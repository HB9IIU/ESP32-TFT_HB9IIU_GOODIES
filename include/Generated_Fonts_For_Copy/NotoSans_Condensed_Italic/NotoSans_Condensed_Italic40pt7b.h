#ifndef _NOTOSANS_CONDENSED_ITALIC40PT7B_H_
#define _NOTOSANS_CONDENSED_ITALIC40PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Italic.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Italic40pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x70, 0x38, 0x3C, 0x1E, 0x0E, 0x07,
  0x03, 0x83, 0xC1, 0xC0, 0xE0, 0x70, 0x38, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x78, 0x3C, 0x1E, 0x0E, 0x00, 0x38, 0xF7,
  0x8E, 0x78, 0xE7, 0x1E, 0x71, 0xC7, 0x1C, 0x71, 0xC6, 0x1C, 0xE1, 0x8E,
  0x18, 0xC3, 0x80, 0x00, 0x38, 0x60, 0x03, 0x0E, 0x00, 0x70, 0xE0, 0x07,
  0x0C, 0x00, 0x60, 0xC0, 0x0E, 0x1C, 0x00, 0xE1, 0x80, 0x0C, 0x18, 0x00,
  0xC3, 0x81, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0x18, 0x70, 0x03, 0x87, 0x00,
  0x38, 0x60, 0x03, 0x0E, 0x00, 0x70, 0xE0, 0x07, 0x0C, 0x00, 0x60, 0xC0,
  0x7F, 0xFF, 0xCF, 0xFF, 0xFC, 0x0C, 0x18, 0x00, 0xC3, 0x80, 0x1C, 0x38,
  0x01, 0x83, 0x00, 0x18, 0x70, 0x03, 0x87, 0x00, 0x38, 0x60, 0x03, 0x0E,
  0x00, 0x70, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x03,
  0xFC, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x73, 0x18, 0x38, 0xC0, 0x0E, 0x30,
  0x03, 0x8C, 0x00, 0xE6, 0x00, 0x39, 0x80, 0x0F, 0x60, 0x01, 0xF8, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0D, 0xE0, 0x06,
  0x38, 0x01, 0x8E, 0x00, 0x63, 0x80, 0x18, 0xE0, 0x06, 0x70, 0x63, 0x3C,
  0x3F, 0xFE, 0x0F, 0xFF, 0x00, 0xFF, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x07, 0x80, 0x18, 0x1F, 0x80, 0x70, 0x7F, 0x81,
  0xC0, 0xC7, 0x03, 0x83, 0x8E, 0x0E, 0x06, 0x1C, 0x18, 0x1C, 0x38, 0x70,
  0x38, 0x70, 0xC0, 0x60, 0xE3, 0x80, 0xC1, 0x8E, 0x03, 0x87, 0x1C, 0x07,
  0x0E, 0x70, 0x8E, 0x1C, 0xC7, 0xDC, 0x73, 0x9F, 0xF8, 0xEE, 0x73, 0xBF,
  0x9D, 0xC3, 0x7E, 0x73, 0x86, 0x78, 0xC6, 0x1C, 0x03, 0x9C, 0x38, 0x0E,
  0x38, 0x70, 0x1C, 0x70, 0xE0, 0x70, 0xC1, 0x80, 0xE1, 0x83, 0x03, 0x83,
  0x0E, 0x06, 0x06, 0x1C, 0x1C, 0x0C, 0x70, 0x70, 0x1C, 0xE0, 0xE0, 0x3F,
  0x83, 0x80, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x1F, 0xC0, 0x07, 0xFC, 0x01,
  0xE3, 0x80, 0x38, 0x70, 0x07, 0x0E, 0x00, 0xE1, 0xC0, 0x1C, 0x38, 0x03,
  0x8F, 0x00, 0x71, 0xC0, 0x0E, 0x70, 0x01, 0xDC, 0x00, 0x3F, 0x00, 0x07,
  0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x07, 0x1E, 0xF0, 0xE7, 0x8E, 0x3D, 0xE1,
  0xE7, 0x38, 0x1C, 0xE7, 0x03, 0xB9, 0xE0, 0x7F, 0x3C, 0x07, 0xC7, 0x00,
  0xF0, 0xF0, 0x1E, 0x1E, 0x0F, 0xE1, 0xF7, 0xDC, 0x3F, 0xF3, 0xC1, 0xFC,
  0x3C, 0x39, 0xDE, 0xF7, 0x39, 0xCC, 0x67, 0x38, 0x00, 0x70, 0x0E, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x38, 0x07, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1C,
  0x03, 0xC0, 0x38, 0x03, 0x80, 0x78, 0x07, 0x00, 0x70, 0x07, 0x00, 0xF0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0,
  0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x1E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xF0, 0x00, 0x02, 0x00, 0x0F, 0x00, 0x38, 0x00,
  0xE0, 0x43, 0x83, 0xCC, 0x0F, 0xF7, 0xC7, 0xFF, 0x07, 0xFC, 0x3E, 0x01,
  0xD8, 0x0E, 0x70, 0x78, 0xE0, 0xC3, 0x82, 0x0C, 0x00, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x0F,
  0x0E, 0x1E, 0x1C, 0x1C, 0x38, 0x38, 0x70, 0x70, 0xE0, 0xFF, 0xFF, 0xFF,
  0xC0, 0x6F, 0xFF, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00,
  0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x01, 0xFE, 0x03, 0xFE, 0x07, 0x8F, 0x07, 0x07, 0x0F,
  0x07, 0x1E, 0x07, 0x1C, 0x07, 0x1C, 0x07, 0x3C, 0x07, 0x38, 0x07, 0x38,
  0x07, 0x78, 0x07, 0x78, 0x0F, 0x70, 0x0F, 0x70, 0x0E, 0x70, 0x0E, 0x70,
  0x0E, 0xF0, 0x1E, 0xF0, 0x1C, 0xF0, 0x1C, 0xE0, 0x3C, 0xE0, 0x38, 0xF0,
  0x78, 0xF0, 0x70, 0x70, 0xF0, 0x7F, 0xE0, 0x3F, 0xC0, 0x1F, 0x80, 0x01,
  0xC0, 0xF0, 0x7C, 0x7F, 0x3F, 0x9E, 0xEF, 0x3B, 0x9E, 0x47, 0x81, 0xC0,
  0x70, 0x1C, 0x0F, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x07, 0x81, 0xC0, 0x70,
  0x1C, 0x0F, 0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x07, 0x81, 0xC0, 0x70, 0x00,
  0x00, 0x7E, 0x00, 0x7F, 0xE0, 0x3F, 0xF8, 0x0E, 0x0F, 0x01, 0x03, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00,
  0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0xFF,
  0xE3, 0xFF, 0xF0, 0xFF, 0xFC, 0x00, 0x00, 0xFC, 0x01, 0xFF, 0x81, 0xFF,
  0xE0, 0xE0, 0xF0, 0x40, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x07, 0xC0, 0x1F, 0xC0,
  0x1F, 0x80, 0x0F, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x40,
  0x3C, 0x3E, 0xFE, 0x1F, 0xFC, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0x80, 0x03,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xB8, 0x01, 0xF8, 0x01, 0xDC, 0x00,
  0xEE, 0x00, 0xE7, 0x00, 0xE7, 0x80, 0x73, 0x80, 0x71, 0xC0, 0x70, 0xE0,
  0x38, 0xF0, 0x38, 0x70, 0x38, 0x38, 0x18, 0x1C, 0x1C, 0x0E, 0x1C, 0x0F,
  0x1C, 0x07, 0x1F, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFC, 0x00, 0xF0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x01, 0xFF,
  0xC0, 0xFF, 0xE0, 0x3F, 0xF8, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x39,
  0x00, 0x1F, 0xF8, 0x07, 0xFF, 0x00, 0xC7, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x20, 0x1E, 0x0F, 0xBF, 0x83, 0xFF,
  0xC0, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x3C,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x0F, 0x00, 0x07, 0x1E, 0x03, 0xBF, 0xC3, 0xFF, 0xE1, 0xF8, 0x78,
  0xF8, 0x3C, 0x78, 0x0E, 0x38, 0x07, 0x1C, 0x03, 0x8E, 0x01, 0xCF, 0x01,
  0xE7, 0x80, 0xE3, 0xC0, 0x70, 0xE0, 0x78, 0x70, 0x38, 0x3C, 0x3C, 0x1F,
  0xFC, 0x07, 0xFC, 0x01, 0xFC, 0x00, 0x3F, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF,
  0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00,
  0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00,
  0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0,
  0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C,
  0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x7F,
  0xC0, 0x3F, 0xF8, 0x1E, 0x1E, 0x07, 0x03, 0xC1, 0xC0, 0x70, 0xF0, 0x1C,
  0x3C, 0x0F, 0x0F, 0x03, 0x81, 0xC1, 0xE0, 0x70, 0x70, 0x1E, 0x78, 0x03,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0xE0, 0x1E, 0x3C, 0x0F, 0x07,
  0x07, 0x81, 0xE1, 0xC0, 0x38, 0x70, 0x0E, 0x3C, 0x03, 0x8F, 0x00, 0xE3,
  0xC0, 0x38, 0xF0, 0x1E, 0x1E, 0x07, 0x07, 0xE7, 0xC0, 0xFF, 0xE0, 0x1F,
  0xE0, 0x00, 0x00, 0xF8, 0x03, 0xFC, 0x07, 0xFE, 0x0F, 0x0E, 0x1E, 0x0F,
  0x1C, 0x07, 0x1C, 0x07, 0x3C, 0x07, 0x38, 0x07, 0x38, 0x07, 0x38, 0x07,
  0x38, 0x0F, 0x38, 0x0F, 0x38, 0x1F, 0x3C, 0x3E, 0x3E, 0xFE, 0x1F, 0xEE,
  0x0F, 0xDE, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xE0, 0xFF, 0xC0, 0xFF, 0x80, 0xFE, 0x00,
  0x02, 0x0F, 0x0F, 0x0F, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x78, 0xF8, 0xF8, 0xF0, 0x00, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x81, 0xE0, 0x78, 0x1C,
  0x0F, 0x03, 0x80, 0xE0, 0x70, 0x1C, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x0F,
  0x00, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x7C, 0x00,
  0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x00, 0x1F, 0x00, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x00,
  0xF8, 0x00, 0xE0, 0x00, 0x80, 0x00, 0x07, 0xE0, 0xFF, 0xC1, 0xFF, 0x86,
  0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00,
  0x70, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x30, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x1E, 0x01, 0xC0, 0x1C, 0x00,
  0x70, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x0C, 0x1C, 0x00, 0x07, 0x0C, 0x07,
  0xC3, 0x8E, 0x0F, 0xF1, 0xC6, 0x0F, 0x38, 0xE7, 0x0E, 0x18, 0x73, 0x86,
  0x1C, 0x39, 0x87, 0x0E, 0x1D, 0xC3, 0x07, 0x0E, 0xE3, 0x83, 0x06, 0x61,
  0xC3, 0x83, 0x30, 0xC1, 0xC3, 0xB8, 0x60, 0xE1, 0x9C, 0x30, 0xE1, 0xCE,
  0x18, 0x70, 0xE7, 0x0C, 0x7C, 0xE3, 0x87, 0xE7, 0xE1, 0xC1, 0xF3, 0xE0,
  0x60, 0x20, 0x40, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xF0, 0x18, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00,
  0xDC, 0x00, 0x3B, 0x80, 0x07, 0x70, 0x01, 0xCE, 0x00, 0x39, 0xC0, 0x0E,
  0x38, 0x01, 0xC7, 0x00, 0x78, 0xE0, 0x0E, 0x1C, 0x01, 0xC3, 0x80, 0x70,
  0x70, 0x0E, 0x0E, 0x03, 0xC1, 0xC0, 0x7F, 0xF8, 0x1F, 0xFF, 0x03, 0xFF,
  0xE0, 0xF0, 0x1C, 0x1C, 0x03, 0x87, 0x80, 0x70, 0xF0, 0x0E, 0x1C, 0x01,
  0xC7, 0x80, 0x38, 0xE0, 0x07, 0xBC, 0x00, 0xFF, 0x00, 0x1E, 0x03, 0xF8,
  0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x01, 0xC3, 0xF0, 0x38, 0x1E, 0x0F, 0x01,
  0xC1, 0xE0, 0x38, 0x38, 0x07, 0x07, 0x00, 0xE0, 0xE0, 0x3C, 0x3C, 0x07,
  0x07, 0x01, 0xE0, 0xE0, 0xF8, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0xF1, 0xF8,
  0x1C, 0x07, 0x03, 0x80, 0xF0, 0x70, 0x0E, 0x1E, 0x01, 0xC3, 0xC0, 0x38,
  0x70, 0x0F, 0x0E, 0x01, 0xE1, 0xC0, 0x38, 0x78, 0x0F, 0x0F, 0x03, 0xC1,
  0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0xF0,
  0x1F, 0xFC, 0x0F, 0x82, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x70,
  0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0x70, 0x00, 0x1E, 0x02, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xC0, 0x38, 0xFE, 0x03,
  0x81, 0xE0, 0x78, 0x0F, 0x07, 0x80, 0xF0, 0x70, 0x0F, 0x07, 0x00, 0x70,
  0x70, 0x07, 0x0F, 0x00, 0x70, 0xF0, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x0F,
  0x0E, 0x00, 0xF1, 0xE0, 0x0F, 0x1C, 0x00, 0xE1, 0xC0, 0x0E, 0x1C, 0x01,
  0xE3, 0xC0, 0x1C, 0x3C, 0x03, 0xC3, 0x80, 0x3C, 0x38, 0x07, 0x83, 0x80,
  0xF0, 0x78, 0x1F, 0x07, 0x87, 0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0x00, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0E, 0x00, 0x03,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0xFF, 0x80, 0xFF, 0xE0,
  0x7F, 0xF0, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0xFF,
  0xF0, 0x3F, 0xFC, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x3E, 0x0E,
  0x07, 0x80, 0x20, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0xF0, 0x1F, 0xCF, 0x01, 0xFC, 0xF0, 0x3F, 0xCE, 0x00, 0x3C, 0xE0,
  0x03, 0x8E, 0x00, 0x38, 0xE0, 0x03, 0x8E, 0x00, 0x78, 0xF0, 0x07, 0x0F,
  0x00, 0x70, 0x78, 0x07, 0x07, 0xC0, 0x70, 0x3F, 0xFF, 0x01, 0xFF, 0xE0,
  0x0F, 0xFC, 0x00, 0x03, 0x80, 0x38, 0x3C, 0x01, 0xC1, 0xC0, 0x0E, 0x0E,
  0x00, 0xF0, 0x70, 0x07, 0x87, 0x80, 0x38, 0x3C, 0x01, 0xC1, 0xC0, 0x0E,
  0x0E, 0x00, 0xF0, 0x70, 0x07, 0x07, 0x80, 0x38, 0x3C, 0x01, 0xC1, 0xC0,
  0x1E, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF8, 0x38, 0x01, 0xC1,
  0xC0, 0x1E, 0x0E, 0x00, 0xF0, 0x70, 0x07, 0x07, 0x80, 0x38, 0x38, 0x01,
  0xC1, 0xC0, 0x1E, 0x0E, 0x00, 0xE0, 0xF0, 0x07, 0x07, 0x80, 0x38, 0x38,
  0x01, 0xC1, 0xC0, 0x1E, 0x0E, 0x00, 0xE0, 0x00, 0x03, 0xFF, 0x03, 0xFF,
  0x01, 0xFC, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80,
  0x8F, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x38, 0x1E,
  0x03, 0xC0, 0xE0, 0x3C, 0x07, 0x03, 0xC0, 0x38, 0x3C, 0x03, 0xC1, 0xE0,
  0x1E, 0x1E, 0x00, 0xE1, 0xE0, 0x07, 0x1E, 0x00, 0x38, 0xE0, 0x03, 0xCF,
  0x00, 0x1E, 0xF0, 0x00, 0xEF, 0x00, 0x07, 0x70, 0x00, 0x3F, 0xC0, 0x03,
  0xFE, 0x00, 0x1F, 0x70, 0x00, 0xF3, 0xC0, 0x07, 0x1E, 0x00, 0x78, 0x70,
  0x03, 0xC3, 0x80, 0x1C, 0x1E, 0x00, 0xE0, 0xF0, 0x07, 0x03, 0x80, 0x78,
  0x1C, 0x03, 0xC0, 0xF0, 0x1C, 0x07, 0x80, 0xE0, 0x1C, 0x0F, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1E,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0xFE, 0xFF, 0xEF, 0xFF,
  0x00, 0x03, 0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x7C,
  0x07, 0xC0, 0x07, 0xE0, 0x3E, 0x00, 0x3F, 0x03, 0xB0, 0x03, 0xF8, 0x1D,
  0xC0, 0x1F, 0xC0, 0xEE, 0x01, 0xFC, 0x07, 0x70, 0x0E, 0xE0, 0x3B, 0x80,
  0xF7, 0x03, 0xDC, 0x07, 0x78, 0x1C, 0xE0, 0x3B, 0xC0, 0xE7, 0x03, 0x9C,
  0x07, 0x38, 0x1C, 0xE0, 0x39, 0xC1, 0xC7, 0x03, 0x8E, 0x0E, 0x78, 0x1C,
  0x70, 0xE3, 0x80, 0xE3, 0x87, 0x1C, 0x07, 0x1C, 0x70, 0xE0, 0x78, 0xE3,
  0x87, 0x03, 0x87, 0x38, 0x78, 0x1C, 0x19, 0xC3, 0x80, 0xE0, 0xFC, 0x1C,
  0x07, 0x07, 0xE0, 0xE0, 0x78, 0x3E, 0x0F, 0x03, 0x81, 0xF0, 0x78, 0x1C,
  0x0F, 0x03, 0x80, 0xE0, 0x78, 0x1C, 0x0F, 0x03, 0x80, 0xE0, 0x00, 0x03,
  0xC0, 0x0F, 0x03, 0xE0, 0x0E, 0x03, 0xE0, 0x0E, 0x03, 0xE0, 0x0E, 0x03,
  0xE0, 0x1E, 0x07, 0xE0, 0x1C, 0x07, 0x70, 0x1C, 0x07, 0x70, 0x1C, 0x07,
  0x70, 0x1C, 0x07, 0x70, 0x3C, 0x0F, 0x38, 0x38, 0x0E, 0x38, 0x38, 0x0E,
  0x38, 0x38, 0x0E, 0x38, 0x38, 0x0E, 0x3C, 0x78, 0x1E, 0x1C, 0x70, 0x1C,
  0x1C, 0x70, 0x1C, 0x1C, 0x70, 0x1C, 0x1C, 0x70, 0x3C, 0x0E, 0xF0, 0x38,
  0x0E, 0xE0, 0x38, 0x0E, 0xE0, 0x38, 0x0E, 0xE0, 0x38, 0x07, 0xE0, 0x78,
  0x07, 0xC0, 0x70, 0x07, 0xC0, 0x70, 0x07, 0xC0, 0x70, 0x07, 0xC0, 0xF0,
  0x03, 0xC0, 0x00, 0x3E, 0x00, 0x0F, 0xF8, 0x03, 0xFF, 0xC0, 0x7C, 0x3E,
  0x0F, 0x81, 0xE0, 0xF0, 0x0E, 0x1E, 0x00, 0xF1, 0xC0, 0x0F, 0x3C, 0x00,
  0xF3, 0x80, 0x0F, 0x78, 0x00, 0xF7, 0x80, 0x0F, 0x70, 0x00, 0xF7, 0x00,
  0x0E, 0xF0, 0x00, 0xEF, 0x00, 0x0E, 0xF0, 0x01, 0xEE, 0x00, 0x1E, 0xE0,
  0x01, 0xCE, 0x00, 0x3C, 0xE0, 0x03, 0xCE, 0x00, 0x38, 0xE0, 0x07, 0x8F,
  0x00, 0xF0, 0xF0, 0x1F, 0x07, 0x83, 0xE0, 0x7F, 0xFC, 0x03, 0xFF, 0x80,
  0x1F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x01, 0xC7,
  0xE0, 0x38, 0x3C, 0x0F, 0x03, 0x81, 0xE0, 0x78, 0x38, 0x0F, 0x07, 0x01,
  0xE0, 0xE0, 0x38, 0x3C, 0x07, 0x07, 0x81, 0xE0, 0xE0, 0x38, 0x1C, 0x0F,
  0x03, 0x87, 0xC0, 0xFF, 0xF0, 0x1F, 0xFC, 0x03, 0xFC, 0x00, 0x70, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x0F, 0xF8, 0x03, 0xFF, 0xC0, 0x7C, 0x3E, 0x0F, 0x81,
  0xE0, 0xF0, 0x0E, 0x1E, 0x00, 0xF1, 0xC0, 0x0F, 0x3C, 0x00, 0xF3, 0x80,
  0x0F, 0x78, 0x00, 0xF7, 0x80, 0x0F, 0x70, 0x00, 0xF7, 0x00, 0x0E, 0xF0,
  0x00, 0xEF, 0x00, 0x0E, 0xF0, 0x01, 0xEE, 0x00, 0x1E, 0xE0, 0x01, 0xCE,
  0x00, 0x3C, 0xE0, 0x03, 0xCE, 0x00, 0x38, 0xE0, 0x07, 0x8F, 0x00, 0xF0,
  0xF0, 0x0F, 0x07, 0x83, 0xE0, 0x7F, 0xFC, 0x03, 0xFF, 0x80, 0x1F, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x03, 0xF0, 0x00, 0x7F, 0xE0, 0x0F,
  0xFE, 0x01, 0xC7, 0xE0, 0x38, 0x3C, 0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x38,
  0x0F, 0x07, 0x01, 0xE0, 0xE0, 0x38, 0x3C, 0x07, 0x07, 0x81, 0xE0, 0xE0,
  0x78, 0x1C, 0x1F, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xF0, 0x03, 0x8F,
  0x00, 0x70, 0xE0, 0x1E, 0x1C, 0x03, 0xC3, 0x80, 0x70, 0x78, 0x0E, 0x07,
  0x01, 0xC0, 0xE0, 0x78, 0x1C, 0x0F, 0x03, 0xC1, 0xC0, 0x78, 0x38, 0x07,
  0x0F, 0x00, 0xF0, 0x00, 0x7E, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0x0E,
  0x0F, 0x00, 0x83, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3F,
  0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x20,
  0x1E, 0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFE, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x70, 0xE0, 0x07,
  0x0E, 0x00, 0xF0, 0xE0, 0x0F, 0x1E, 0x00, 0xE1, 0xE0, 0x0E, 0x1C, 0x00,
  0xE1, 0xC0, 0x1E, 0x1C, 0x01, 0xC3, 0xC0, 0x1C, 0x38, 0x01, 0xC3, 0x80,
  0x3C, 0x38, 0x03, 0xC3, 0x80, 0x38, 0x78, 0x03, 0x87, 0x00, 0x38, 0x70,
  0x07, 0x87, 0x00, 0x78, 0xF0, 0x07, 0x0F, 0x00, 0x70, 0xE0, 0x07, 0x0E,
  0x00, 0xF0, 0xE0, 0x0E, 0x0E, 0x01, 0xE0, 0xF0, 0x1C, 0x0F, 0x03, 0xC0,
  0x7F, 0xF8, 0x07, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0xE0, 0x03, 0xF0, 0x03,
  0xF8, 0x01, 0xDC, 0x01, 0xEE, 0x00, 0xE7, 0x00, 0xF3, 0x80, 0x79, 0xC0,
  0x38, 0xE0, 0x3C, 0x70, 0x1C, 0x38, 0x1E, 0x1C, 0x0E, 0x0E, 0x0F, 0x07,
  0x07, 0x03, 0x83, 0x81, 0xC3, 0x80, 0xE1, 0xC0, 0x71, 0xE0, 0x38, 0xE0,
  0x1C, 0xF0, 0x0E, 0x70, 0x07, 0x78, 0x03, 0xB8, 0x01, 0xDC, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x0E,
  0x00, 0xFE, 0x00, 0xE0, 0x0E, 0xE0, 0x1E, 0x00, 0xEE, 0x01, 0xE0, 0x1E,
  0xE0, 0x1E, 0x01, 0xCE, 0x03, 0xE0, 0x3C, 0xE0, 0x36, 0x03, 0x8E, 0x07,
  0x60, 0x38, 0xE0, 0x76, 0x07, 0x0E, 0x0E, 0xE0, 0x70, 0xE0, 0xEE, 0x0F,
  0x0E, 0x0E, 0xE0, 0xE0, 0xE1, 0xCE, 0x1E, 0x0E, 0x1C, 0xE1, 0xC0, 0xE3,
  0x8E, 0x1C, 0x0E, 0x38, 0xE3, 0xC0, 0xE3, 0x0E, 0x38, 0x0E, 0x70, 0xE7,
  0x80, 0xE7, 0x0E, 0x70, 0x0E, 0xE0, 0xE7, 0x00, 0xEE, 0x0E, 0xF0, 0x0E,
  0xC0, 0xEE, 0x00, 0xFC, 0x0E, 0xE0, 0x0F, 0xC0, 0xFC, 0x00, 0xF8, 0x0F,
  0xC0, 0x0F, 0x80, 0xF8, 0x00, 0xF0, 0x0F, 0x80, 0x0F, 0x00, 0xF8, 0x00,
  0xF0, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x3C, 0x07, 0x01, 0xE0, 0x1C, 0x07,
  0x00, 0x70, 0x3C, 0x01, 0xE0, 0xE0, 0x07, 0x87, 0x80, 0x0E, 0x3C, 0x00,
  0x38, 0xE0, 0x00, 0xE7, 0x80, 0x03, 0x9C, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0x70, 0x00, 0x3D, 0xC0, 0x00, 0xE7, 0x00, 0x07,
  0x9C, 0x00, 0x3C, 0x70, 0x00, 0xE1, 0xE0, 0x07, 0x83, 0x80, 0x1C, 0x0E,
  0x00, 0xE0, 0x38, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0xC0, 0xF0, 0x0F, 0x00,
  0xF0, 0x07, 0xB8, 0x07, 0x9C, 0x03, 0x8E, 0x03, 0xC7, 0x01, 0xC3, 0xC1,
  0xE1, 0xE0, 0xE0, 0x70, 0xF0, 0x38, 0x70, 0x1C, 0x70, 0x0E, 0x78, 0x07,
  0x38, 0x03, 0xBC, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x82, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x38, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03,
  0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x0E, 0x00, 0x03, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0x80, 0x00,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xFE, 0x03, 0xFC, 0x00, 0xE1, 0xC3, 0x83, 0x07, 0x0E, 0x1C, 0x38,
  0x70, 0xE1, 0xC1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE0, 0xE1, 0xC3,
  0x87, 0x0E, 0x1C, 0x38, 0x38, 0x70, 0xE0, 0x00, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0xFE, 0x03, 0xFC,
  0x00, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03,
  0xB8, 0x07, 0x38, 0x07, 0x38, 0x0E, 0x1C, 0x0E, 0x1C, 0x1C, 0x1C, 0x1C,
  0x0E, 0x38, 0x0E, 0x70, 0x06, 0x70, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0x7F,
  0xFD, 0xFF, 0xFF, 0xFF, 0xC0, 0xF3, 0xC7, 0x1C, 0x38, 0x61, 0xC0, 0x01,
  0xE0, 0x01, 0xFD, 0xC1, 0xFE, 0xE1, 0xE3, 0xF1, 0xE0, 0xF8, 0xE0, 0x78,
  0xF0, 0x1C, 0x70, 0x1E, 0x78, 0x0F, 0x3C, 0x07, 0x9C, 0x03, 0x8E, 0x01,
  0xC7, 0x00, 0xE7, 0x80, 0xF3, 0xC0, 0x71, 0xE0, 0x78, 0xF0, 0x3C, 0x78,
  0x3E, 0x1C, 0x1F, 0x0F, 0x3F, 0x07, 0xFB, 0x81, 0xF9, 0xC0, 0x01, 0xC0,
  0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0E, 0x00, 0x07, 0x1E, 0x03, 0xBF, 0x83, 0xFF, 0xE1, 0xF8, 0xF0,
  0xF8, 0x38, 0x78, 0x1C, 0x3C, 0x0E, 0x3C, 0x07, 0x1E, 0x03, 0x8E, 0x01,
  0xC7, 0x00, 0xE3, 0x80, 0x73, 0x80, 0x79, 0xC0, 0x38, 0xE0, 0x1C, 0x70,
  0x1E, 0x78, 0x0E, 0x3C, 0x0F, 0x1F, 0x0F, 0x0F, 0xCF, 0x86, 0x7F, 0x87,
  0x3F, 0x00, 0x00, 0xF8, 0x0F, 0xF0, 0x7F, 0xC3, 0xC2, 0x1E, 0x00, 0x70,
  0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x02, 0x1F,
  0x38, 0x3F, 0xE0, 0x7F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07,
  0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E,
  0x01, 0xE3, 0x80, 0x7F, 0x70, 0x1F, 0xEE, 0x07, 0x87, 0xC1, 0xE0, 0xF8,
  0x38, 0x1E, 0x0F, 0x01, 0xC1, 0xC0, 0x78, 0x78, 0x0F, 0x0F, 0x01, 0xC1,
  0xC0, 0x38, 0x38, 0x07, 0x0F, 0x00, 0xE1, 0xE0, 0x3C, 0x3C, 0x07, 0x07,
  0x81, 0xE0, 0xF0, 0x3C, 0x1E, 0x0F, 0x83, 0xC3, 0xF0, 0x3C, 0xFC, 0x07,
  0xFB, 0x80, 0x7E, 0x70, 0x00, 0x00, 0xF0, 0x07, 0xF8, 0x1F, 0xF0, 0x78,
  0xF1, 0xE0, 0xE3, 0x81, 0xCE, 0x03, 0x9C, 0x0E, 0x78, 0x3C, 0xE1, 0xF1,
  0xFF, 0xC3, 0xFE, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xF0,
  0x01, 0xE0, 0x01, 0xC0, 0x43, 0xE3, 0x83, 0xFF, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xF2, 0x00, 0x1E, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80,
  0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x09, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xC0, 0x00, 0x60, 0x00, 0x00, 0x00, 0x70, 0x00, 0x7F, 0x70, 0x3F,
  0xDC, 0x1E, 0x3F, 0x0F, 0x07, 0xC3, 0x81, 0xE1, 0xE0, 0x78, 0x70, 0x1E,
  0x3C, 0x07, 0x8F, 0x01, 0xC3, 0x80, 0x70, 0xE0, 0x1C, 0x38, 0x0F, 0x1E,
  0x03, 0xC7, 0x80, 0xE1, 0xE0, 0x78, 0x78, 0x1E, 0x1E, 0x0F, 0x87, 0x87,
  0xE0, 0xF3, 0xF0, 0x3F, 0xDC, 0x07, 0xE7, 0x00, 0x01, 0xC0, 0x00, 0xF0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x82, 0x03, 0xC0, 0xE1, 0xE0, 0x3F,
  0xF8, 0x0F, 0xF8, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07,
  0x1E, 0x03, 0xBF, 0x83, 0xFF, 0xE1, 0xF8, 0xF0, 0xF8, 0x38, 0x78, 0x1C,
  0x38, 0x0E, 0x3C, 0x0F, 0x1E, 0x07, 0x0E, 0x03, 0x87, 0x01, 0xC3, 0x80,
  0xE3, 0xC0, 0xF1, 0xC0, 0x70, 0xE0, 0x38, 0x70, 0x1C, 0x78, 0x0E, 0x3C,
  0x0F, 0x1C, 0x07, 0x0E, 0x03, 0x87, 0x01, 0xC7, 0x81, 0xE0, 0x03, 0xC0,
  0xF0, 0x38, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x03, 0xC0, 0xE0,
  0x38, 0x0E, 0x03, 0x81, 0xE0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0xF0, 0x38,
  0x0E, 0x03, 0x81, 0xE0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x1E, 0x00, 0x38, 0x04, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x18, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x41, 0xC1, 0xE0,
  0xF0, 0xF0, 0x38, 0x38, 0x0E, 0x1C, 0x03, 0x8F, 0x00, 0xE7, 0x80, 0x7B,
  0xC0, 0x1C, 0xE0, 0x07, 0x70, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3E, 0xE0,
  0x0F, 0x38, 0x03, 0x8F, 0x00, 0xE1, 0xC0, 0x78, 0x70, 0x1E, 0x1E, 0x07,
  0x07, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x3C, 0x0F, 0x00, 0x01, 0xC0, 0xF0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x78, 0x1C, 0x07, 0x01, 0xC0, 0xF0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x78, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x3C, 0x0E,
  0x03, 0x80, 0xE0, 0x78, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x3C, 0x00, 0x00,
  0x1C, 0x0F, 0x01, 0x9F, 0xCF, 0xE0, 0xEF, 0xF7, 0xFC, 0x3F, 0x1F, 0x8F,
  0x0F, 0x87, 0xC1, 0xC3, 0xC1, 0xE0, 0x70, 0xE0, 0x78, 0x1C, 0x78, 0x1C,
  0x07, 0x1E, 0x07, 0x03, 0xC7, 0x01, 0xC0, 0xE1, 0xC0, 0xF0, 0x38, 0x70,
  0x38, 0x0E, 0x3C, 0x0E, 0x03, 0x8E, 0x03, 0x81, 0xE3, 0x80, 0xE0, 0x70,
  0xE0, 0x78, 0x1C, 0x78, 0x1C, 0x07, 0x1E, 0x07, 0x01, 0xC7, 0x01, 0xC0,
  0xF1, 0xC0, 0x70, 0x38, 0x70, 0x3C, 0x0E, 0x3C, 0x0E, 0x03, 0x80, 0x01,
  0x1C, 0x03, 0x3F, 0x83, 0xBF, 0xE1, 0xF8, 0xF0, 0xF8, 0x38, 0x78, 0x1C,
  0x38, 0x0E, 0x3C, 0x0F, 0x1E, 0x07, 0x8E, 0x03, 0x87, 0x01, 0xC7, 0x80,
  0xE3, 0xC0, 0xF1, 0xC0, 0x70, 0xE0, 0x38, 0x70, 0x1C, 0x78, 0x1E, 0x3C,
  0x0F, 0x1C, 0x07, 0x0E, 0x03, 0x87, 0x01, 0xC7, 0x81, 0xE0, 0x00, 0xF0,
  0x03, 0xFC, 0x07, 0xFE, 0x0F, 0x1E, 0x1E, 0x0F, 0x1C, 0x0F, 0x38, 0x07,
  0x38, 0x07, 0x78, 0x07, 0x70, 0x0F, 0x70, 0x0F, 0x70, 0x0E, 0xF0, 0x0E,
  0xF0, 0x0E, 0xF0, 0x1E, 0xF0, 0x1C, 0xF0, 0x3C, 0xF0, 0x38, 0x70, 0x78,
  0x7D, 0xF0, 0x3F, 0xE0, 0x1F, 0xC0, 0x00, 0x47, 0x80, 0x33, 0xF8, 0x0E,
  0xFF, 0x81, 0xD8, 0xF0, 0x3E, 0x0E, 0x07, 0x81, 0xC0, 0xF0, 0x38, 0x3C,
  0x07, 0x07, 0x80, 0xE0, 0xE0, 0x1C, 0x1C, 0x03, 0x83, 0x80, 0x70, 0xF0,
  0x1E, 0x1C, 0x03, 0x83, 0x80, 0x70, 0x70, 0x1E, 0x0E, 0x03, 0x83, 0xC0,
  0xF0, 0x7C, 0x3C, 0x0F, 0xCF, 0x81, 0xDF, 0xE0, 0x79, 0xF0, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x01, 0xFD,
  0xC1, 0xFE, 0xE1, 0xE3, 0xF1, 0xE0, 0xF8, 0xE0, 0x78, 0xF0, 0x3C, 0x70,
  0x1E, 0x78, 0x0F, 0x3C, 0x07, 0x1C, 0x03, 0x8E, 0x01, 0xCF, 0x00, 0xE7,
  0x80, 0xF3, 0xC0, 0x71, 0xE0, 0x78, 0xF0, 0x3C, 0x78, 0x3E, 0x3C, 0x3F,
  0x0F, 0x3F, 0x07, 0xFB, 0x81, 0xF9, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0x1C, 0x19, 0xF0, 0xEF, 0xC3, 0xBA, 0x0F,
  0x80, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x1F, 0xF0, 0xFF,
  0xC7, 0x82, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0x88, 0x1E, 0x3D, 0xF8, 0xFF, 0xC3, 0xFE, 0x00, 0x03, 0x00,
  0xE0, 0x1C, 0x07, 0x00, 0xE0, 0xFF, 0xDF, 0xF0, 0xF0, 0x1C, 0x03, 0x80,
  0x70, 0x1E, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x78, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0xD0, 0x7E, 0x0F, 0xC0, 0x0E, 0x03,
  0x8F, 0x03, 0xC7, 0x01, 0xC3, 0x80, 0xE1, 0xC0, 0x71, 0xE0, 0x38, 0xF0,
  0x3C, 0x70, 0x1C, 0x38, 0x0E, 0x1C, 0x07, 0x1E, 0x07, 0x8E, 0x03, 0xC7,
  0x01, 0xC3, 0x80, 0xE1, 0xC0, 0xF1, 0xE0, 0x78, 0xF0, 0x78, 0x78, 0x7C,
  0x1E, 0xFE, 0x0F, 0xF7, 0x03, 0xF3, 0x80, 0xE0, 0x1F, 0xC0, 0x3B, 0xC0,
  0xF7, 0x81, 0xCF, 0x07, 0x8E, 0x0E, 0x1C, 0x3C, 0x38, 0x70, 0x70, 0xE0,
  0xE3, 0x81, 0xC7, 0x03, 0x9C, 0x07, 0x38, 0x0E, 0xE0, 0x1D, 0xC0, 0x3F,
  0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x00, 0xF0,
  0x3C, 0x0F, 0xF0, 0x7C, 0x0E, 0xF0, 0x7C, 0x1C, 0xF0, 0x7C, 0x1C, 0xF0,
  0xFC, 0x3C, 0xF0, 0xDC, 0x38, 0xE1, 0xDC, 0x38, 0xE1, 0xDC, 0x70, 0xE1,
  0x9C, 0x70, 0xE3, 0x9C, 0xF0, 0xE3, 0x1C, 0xE0, 0xE7, 0x1C, 0xE0, 0xE7,
  0x1D, 0xC0, 0xEE, 0x1D, 0xC0, 0xEE, 0x1F, 0x80, 0xEC, 0x1F, 0x80, 0xFC,
  0x1F, 0x80, 0xFC, 0x1F, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x1E, 0x00, 0xF0,
  0x1E, 0x00, 0x07, 0x81, 0xE0, 0x70, 0x70, 0x0E, 0x1E, 0x01, 0xC3, 0x80,
  0x3C, 0xE0, 0x03, 0xBC, 0x00, 0x77, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01,
  0xCE, 0x00, 0x71, 0xC0, 0x1E, 0x38, 0x03, 0x87, 0x80, 0xE0, 0x70, 0x3C,
  0x0E, 0x0F, 0x01, 0xE0, 0x03, 0xC0, 0x78, 0x1E, 0x03, 0x80, 0x70, 0x3C,
  0x03, 0x81, 0xC0, 0x1C, 0x0E, 0x00, 0xE0, 0xE0, 0x07, 0x07, 0x00, 0x38,
  0x70, 0x01, 0xC3, 0x80, 0x0E, 0x38, 0x00, 0x71, 0xC0, 0x03, 0x9E, 0x00,
  0x1C, 0xE0, 0x00, 0xEF, 0x00, 0x07, 0x70, 0x00, 0x3B, 0x80, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x01, 0x1E, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0xFE, 0x1F, 0xFC, 0x00, 0x70, 0x01, 0xE0, 0x07, 0x80,
  0x0E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x03,
  0xFF, 0x87, 0xFF, 0x0F, 0xFE, 0x00, 0x00, 0x06, 0x00, 0xF8, 0x03, 0xF0,
  0x07, 0x80, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00,
  0xFE, 0x01, 0xF0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x3C, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0x80, 0x03, 0xC0, 0x0F, 0xC0, 0x07, 0x80,
  0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x7A,
  0x00, 0x78, 0x01, 0xF0, 0x07, 0x80, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0,
  0x03, 0x80, 0x0F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0x18, 0x01,
  0x7F, 0x01, 0xFF, 0xE7, 0xC3, 0xFF, 0x80, 0xFE,
};

const GFXglyph NotoSans_Condensed_Italic40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 9, 29, 10, 1, -29 },
  { 34, 12, 11, 14, 4, -29 },
  { 51, 20, 29, 20, 0, -29 },
  { 124, 18, 32, 18, 0, -30 },
  { 196, 23, 29, 27, 2, -29 },
  { 280, 19, 29, 20, 0, -29 },
  { 349, 5, 11, 8, 4, -29 },
  { 356, 12, 35, 11, 1, -29 },
  { 409, 12, 35, 11, -3, -29 },
  { 462, 14, 15, 17, 4, -31 },
  { 489, 16, 19, 19, 2, -24 },
  { 527, 8, 10, 9, -2, -5 },
  { 537, 9, 3, 11, 1, -12 },
  { 541, 4, 5, 9, 1, -5 },
  { 544, 19, 29, 14, -2, -29 },
  { 613, 16, 29, 18, 1, -29 },
  { 671, 10, 29, 18, 5, -29 },
  { 708, 18, 29, 18, -1, -29 },
  { 774, 17, 29, 18, 0, -29 },
  { 836, 17, 29, 18, 0, -29 },
  { 898, 18, 29, 18, 0, -29 },
  { 964, 17, 29, 18, 1, -29 },
  { 1026, 17, 29, 18, 2, -29 },
  { 1088, 18, 29, 18, 0, -29 },
  { 1154, 16, 29, 18, 1, -29 },
  { 1212, 8, 22, 9, 0, -22 },
  { 1234, 10, 27, 9, -2, -22 },
  { 1268, 16, 18, 19, 2, -23 },
  { 1304, 16, 11, 19, 2, -20 },
  { 1326, 16, 18, 19, 2, -23 },
  { 1362, 14, 29, 13, 1, -29 },
  { 1413, 25, 32, 27, 1, -29 },
  { 1513, 19, 29, 18, -3, -29 },
  { 1582, 19, 29, 19, 0, -29 },
  { 1651, 18, 29, 18, 2, -29 },
  { 1717, 20, 29, 21, 0, -29 },
  { 1790, 18, 29, 16, 0, -29 },
  { 1856, 18, 29, 15, 0, -29 },
  { 1922, 20, 29, 22, 2, -29 },
  { 1995, 21, 29, 22, 1, -29 },
  { 2072, 16, 29, 11, -2, -29 },
  { 2130, 16, 37, 9, -6, -29 },
  { 2204, 21, 29, 18, 0, -29 },
  { 2281, 13, 29, 15, 0, -29 },
  { 2329, 29, 29, 28, 0, -29 },
  { 2435, 24, 29, 23, 0, -29 },
  { 2522, 20, 29, 23, 2, -29 },
  { 2595, 19, 29, 18, 0, -29 },
  { 2664, 20, 36, 23, 2, -29 },
  { 2754, 19, 29, 19, 0, -29 },
  { 2823, 18, 29, 17, 0, -29 },
  { 2889, 16, 29, 16, 3, -29 },
  { 2947, 20, 29, 21, 2, -29 },
  { 3020, 17, 29, 18, 4, -29 },
  { 3082, 28, 29, 29, 4, -29 },
  { 3184, 22, 29, 17, -2, -29 },
  { 3264, 17, 29, 16, 3, -29 },
  { 3326, 19, 29, 16, -1, -29 },
  { 3395, 15, 35, 11, -1, -29 },
  { 3461, 7, 29, 14, 4, -29 },
  { 3487, 15, 35, 11, -3, -29 },
  { 3553, 16, 17, 18, 1, -29 },
  { 3587, 14, 3, 13, -4, 3 },
  { 3593, 6, 7, 10, 6, -31 },
  { 3599, 17, 22, 19, 1, -22 },
  { 3646, 17, 30, 19, 0, -30 },
  { 3710, 14, 22, 14, 1, -22 },
  { 3749, 19, 30, 19, 1, -30 },
  { 3821, 15, 22, 17, 1, -22 },
  { 3863, 20, 41, 10, -5, -31 },
  { 3966, 18, 32, 19, 0, -22 },
  { 4038, 17, 30, 18, 0, -30 },
  { 4102, 10, 29, 8, 0, -29 },
  { 4139, 15, 39, 8, -5, -29 },
  { 4213, 18, 30, 16, 0, -30 },
  { 4281, 10, 30, 8, 0, -30 },
  { 4319, 26, 22, 28, 0, -22 },
  { 4391, 17, 22, 18, 0, -22 },
  { 4438, 16, 22, 18, 1, -22 },
  { 4482, 19, 31, 19, -2, -22 },
  { 4556, 17, 32, 19, 1, -22 },
  { 4624, 14, 22, 13, 0, -22 },
  { 4663, 14, 22, 14, 0, -22 },
  { 4702, 11, 26, 11, 1, -26 },
  { 4738, 17, 21, 19, 1, -21 },
  { 4783, 15, 21, 15, 2, -21 },
  { 4823, 24, 21, 24, 2, -21 },
  { 4886, 19, 21, 15, -2, -21 },
  { 4936, 21, 31, 15, -4, -21 },
  { 5018, 15, 21, 13, -1, -21 },
  { 5058, 15, 35, 13, 1, -29 },
  { 5124, 3, 41, 17, 7, -31 },
  { 5140, 15, 35, 13, -2, -29 },
  { 5206, 16, 5, 19, 2, -17 },
};

const GFXfont NotoSans_Condensed_Italic40pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Italic40pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Italic40pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _NOTOSANS_CONDENSED_ITALIC40PT7B_H_
