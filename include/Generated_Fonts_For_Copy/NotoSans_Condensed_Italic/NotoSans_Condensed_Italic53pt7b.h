#ifndef _NOTOSANS_CONDENSED_ITALIC53PT7B_H_
#define _NOTOSANS_CONDENSED_ITALIC53PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Italic.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Italic53pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x07, 0xC0, 0x3F, 0x01, 0xF0, 0x0F,
  0x80, 0x78, 0x00, 0x80, 0x00, 0x3E, 0x1F, 0x3E, 0x1E, 0x3E, 0x3E, 0x3C,
  0x3E, 0x3C, 0x3C, 0x3C, 0x3C, 0x78, 0x3C, 0x78, 0x3C, 0x78, 0x38, 0x78,
  0x78, 0x70, 0x78, 0x70, 0x70, 0x70, 0x70, 0xF0, 0x70, 0x00, 0x07, 0x83,
  0xC0, 0x00, 0xE0, 0x70, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0xE0, 0x70, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xE0, 0x70,
  0x00, 0x1C, 0x0E, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xE0, 0x70, 0x07, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC0, 0x1C, 0x0E, 0x00,
  0x03, 0x83, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0xF0, 0x78, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x81, 0xC0, 0x00,
  0xF0, 0x78, 0x03, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xF8, 0x03, 0x81, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x1E,
  0x0F, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x1E, 0x0F, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC1,
  0xC0, 0x00, 0x70, 0x38, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0x00,
  0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xE6, 0x38, 0x0F, 0x1C, 0x10, 0x3E,
  0x38, 0x00, 0x78, 0x70, 0x00, 0xF0, 0xC0, 0x01, 0xE1, 0x80, 0x03, 0xC7,
  0x00, 0x07, 0xCE, 0x00, 0x0F, 0x9C, 0x00, 0x0F, 0xB0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x77, 0xC0, 0x00, 0xE7, 0xC0, 0x01, 0x87, 0x80,
  0x03, 0x0F, 0x00, 0x0E, 0x1E, 0x00, 0x1C, 0x3C, 0x00, 0x30, 0xF0, 0x40,
  0x61, 0xE0, 0xC0, 0xC7, 0xC1, 0xF3, 0xFF, 0x03, 0xFF, 0xFC, 0x07, 0xFF,
  0xF0, 0x07, 0xFF, 0x80, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0xF0, 0x1F, 0xE0, 0x03, 0x80, 0xFF, 0xC0, 0x1E, 0x07, 0x8F, 0x00,
  0xF0, 0x1C, 0x1C, 0x03, 0x80, 0xF0, 0x70, 0x1E, 0x03, 0xC1, 0xC0, 0x70,
  0x0E, 0x07, 0x03, 0xC0, 0x78, 0x1C, 0x0E, 0x01, 0xE0, 0xF0, 0x78, 0x07,
  0x03, 0xC3, 0xC0, 0x1C, 0x0F, 0x0E, 0x00, 0xF0, 0x38, 0x78, 0x03, 0xC0,
  0xE1, 0xC0, 0x0F, 0x07, 0x8F, 0x00, 0x3C, 0x1E, 0x78, 0x7C, 0xE0, 0x71,
  0xC7, 0xFB, 0x83, 0xCF, 0x3F, 0xFF, 0x0E, 0x38, 0xF3, 0xFC, 0x79, 0xE7,
  0x87, 0x7F, 0xCF, 0x1C, 0x1D, 0xFE, 0x3C, 0xF0, 0x73, 0xF1, 0xE3, 0x81,
  0xC0, 0x07, 0x0E, 0x07, 0x00, 0x3C, 0x78, 0x1C, 0x00, 0xE1, 0xE0, 0xF0,
  0x07, 0x87, 0x03, 0xC0, 0x3C, 0x1C, 0x0F, 0x00, 0xE0, 0xF0, 0x38, 0x07,
  0x83, 0xC1, 0xE0, 0x1C, 0x0F, 0x07, 0x80, 0xF0, 0x3C, 0x1C, 0x07, 0x80,
  0xF0, 0xF0, 0x1C, 0x03, 0xC3, 0x80, 0xF0, 0x0F, 0x1E, 0x03, 0x80, 0x1F,
  0xF0, 0x1E, 0x00, 0x7F, 0x80, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x01,
  0xF1, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x03, 0xC0,
  0x07, 0xC0, 0xF0, 0x01, 0xE0, 0x78, 0x00, 0x78, 0x1E, 0x00, 0x1E, 0x07,
  0x80, 0x07, 0xC3, 0xC0, 0x00, 0xF1, 0xF0, 0x00, 0x3C, 0xF8, 0x00, 0x0F,
  0x7C, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x07, 0xC3, 0xE7, 0xC1,
  0xE1, 0xF1, 0xF0, 0x78, 0xF8, 0x3C, 0x3C, 0x3C, 0x0F, 0x8F, 0x1F, 0x01,
  0xE7, 0x87, 0x80, 0x7D, 0xE1, 0xE0, 0x0F, 0xF0, 0xF8, 0x03, 0xFC, 0x3E,
  0x00, 0xFE, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x07, 0xF8,
  0x1F, 0x03, 0xFE, 0x07, 0xE3, 0xF7, 0xC1, 0xFF, 0xF9, 0xF0, 0x3F, 0xFC,
  0x3E, 0x03, 0xFC, 0x0F, 0x80, 0x18, 0x00, 0x00, 0x3D, 0xF7, 0xDE, 0x79,
  0xE7, 0xBC, 0xF3, 0xCF, 0x38, 0xE3, 0x80, 0x00, 0x0F, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1C, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00,
  0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03,
  0xC0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x38, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x38, 0x06, 0x07, 0x00, 0xF1, 0xE0, 0x1F, 0xB8, 0x07, 0xFF, 0x3F,
  0x1F, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xCF, 0x83, 0xF8, 0x00, 0xFF, 0x80,
  0x3E, 0x70, 0x0F, 0x8F, 0x03, 0xE1, 0xE0, 0x3C, 0x1E, 0x01, 0x03, 0xC0,
  0x00, 0x60, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x87, 0xC3,
  0xC3, 0xE1, 0xF0, 0xF0, 0xF8, 0x78, 0x78, 0x3C, 0x1C, 0x1E, 0x0E, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7B, 0xFF, 0xFF, 0xFB, 0xC2, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3E, 0x0F,
  0x03, 0xE0, 0x7C, 0x1E, 0x03, 0xE1, 0xF0, 0x0F, 0x0F, 0x00, 0x78, 0xF8,
  0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x00, 0xF3, 0xE0, 0x07, 0x9E, 0x00, 0x7C,
  0xF0, 0x03, 0xEF, 0x80, 0x1F, 0x7C, 0x00, 0xF3, 0xC0, 0x07, 0x9E, 0x00,
  0x3C, 0xF0, 0x01, 0xEF, 0x80, 0x1F, 0x7C, 0x00, 0xFB, 0xC0, 0x07, 0x9E,
  0x00, 0x3C, 0xF0, 0x03, 0xE7, 0x80, 0x1E, 0x3C, 0x00, 0xF1, 0xE0, 0x0F,
  0x8F, 0x00, 0x78, 0x78, 0x07, 0xC3, 0xC0, 0x3E, 0x1E, 0x03, 0xE0, 0xF0,
  0x1E, 0x07, 0xC1, 0xF0, 0x1F, 0xBF, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x3C, 0x01, 0xF0, 0x1F, 0xC0,
  0xFE, 0x07, 0xF8, 0x3F, 0xE3, 0xF7, 0x9F, 0xBE, 0xFC, 0xF1, 0xC3, 0xC2,
  0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xE0,
  0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xF0,
  0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x01, 0xFE,
  0xFE, 0x00, 0xF0, 0x3F, 0x00, 0xC0, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF0, 0x1F, 0xCF, 0xE0, 0x1C, 0x07, 0xE0, 0x20, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC1, 0x00, 0x1F, 0x83, 0xE1, 0xFE, 0x07,
  0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xDE, 0x00, 0x03, 0xDE,
  0x00, 0x07, 0xBC, 0x00, 0x07, 0x3C, 0x00, 0x0F, 0x3C, 0x00, 0x1E, 0x7C,
  0x00, 0x1C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x78, 0x78, 0x00, 0xF0, 0x78,
  0x00, 0xF0, 0xF8, 0x01, 0xE0, 0xF0, 0x03, 0xC0, 0xF0, 0x03, 0xC0, 0xF0,
  0x07, 0x80, 0xF0, 0x0F, 0x01, 0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x3C, 0x01, 0xE0, 0x38, 0x03, 0xE0, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC,
  0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x1F, 0x7F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC1, 0x80, 0x1F, 0x83, 0xE1, 0xFE, 0x07, 0xFF,
  0xF8, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xE6, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC1, 0xE0, 0x0F, 0x3F, 0xE0, 0x3D, 0xFF, 0xC1, 0xFF, 0xFF,
  0x07, 0xF8, 0x7E, 0x1F, 0x80, 0xF8, 0x7C, 0x01, 0xE3, 0xF0, 0x07, 0x8F,
  0x80, 0x1E, 0x3E, 0x00, 0x78, 0xF8, 0x01, 0xE3, 0xC0, 0x07, 0x8F, 0x00,
  0x3E, 0x3C, 0x00, 0xF8, 0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x0F, 0x00, 0x7C,
  0x3C, 0x01, 0xE0, 0xF8, 0x0F, 0x81, 0xE0, 0x7C, 0x07, 0xE7, 0xF0, 0x0F,
  0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x10, 0x00, 0x00, 0x0F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0xFC,
  0xFE, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x1E, 0x03, 0xC0, 0x1F, 0x03, 0xC0,
  0x1F, 0x03, 0xC0, 0x1E, 0x03, 0xC0, 0x1E, 0x03, 0xC0, 0x1E, 0x03, 0xC0,
  0x3E, 0x03, 0xC0, 0x3C, 0x03, 0xE0, 0x78, 0x01, 0xF0, 0xF8, 0x01, 0xF3,
  0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x07, 0xFF, 0xC0, 0x0F, 0xC7, 0xC0, 0x1F, 0x03, 0xE0, 0x3E, 0x01,
  0xF0, 0x3C, 0x01, 0xF0, 0x7C, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0x78, 0x00,
  0xF0, 0x78, 0x00, 0xF0, 0xF8, 0x00, 0xF0, 0xF8, 0x00, 0xF0, 0x78, 0x01,
  0xF0, 0x78, 0x01, 0xE0, 0x7C, 0x03, 0xE0, 0x3F, 0x0F, 0xC0, 0x3F, 0xFF,
  0x80, 0x1F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x00, 0x3F,
  0xC0, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFE, 0xFC, 0x07, 0xE0, 0xF8,
  0x1F, 0x01, 0xE0, 0xF8, 0x07, 0x83, 0xC0, 0x1F, 0x0F, 0x00, 0x7C, 0x7C,
  0x01, 0xF1, 0xE0, 0x07, 0xC7, 0x80, 0x1F, 0x1E, 0x00, 0x7C, 0xF8, 0x01,
  0xE3, 0xE0, 0x07, 0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xF8, 0x78, 0x07, 0xE1,
  0xF0, 0x3F, 0x87, 0xC1, 0xFE, 0x1F, 0xFF, 0xF0, 0x3F, 0xFB, 0xC0, 0x7F,
  0xCF, 0x00, 0xFC, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x0C, 0x1F, 0xC0, 0x3F, 0xFC,
  0x00, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x7C, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0x80, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x7C, 0x0F, 0x83, 0xF0, 0x7E,
  0x07, 0x80, 0x40, 0x00, 0x00, 0x38, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xE0, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x07, 0xC0,
  0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00,
  0x3C, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x00, 0x08, 0x00, 0x01,
  0xC0, 0x00, 0x3E, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x01,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0x80, 0x00, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x80, 0x00, 0x07, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0x80, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x7C, 0x00, 0x03,
  0x80, 0x00, 0x10, 0x00, 0x00, 0x03, 0xFC, 0x03, 0xFF, 0xC1, 0xFF, 0xF0,
  0x7E, 0xFE, 0x1C, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0x80,
  0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0x1E, 0x01, 0xF0, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0x07, 0x0F, 0x00, 0x78, 0x07, 0x0E, 0x01, 0xFF, 0x87, 0x1E, 0x03, 0xFF,
  0x07, 0x1C, 0x07, 0x8F, 0x07, 0x3C, 0x0F, 0x0F, 0x07, 0x3C, 0x1E, 0x0F,
  0x07, 0x38, 0x1C, 0x0E, 0x07, 0x78, 0x3C, 0x0E, 0x07, 0x70, 0x38, 0x1E,
  0x07, 0x70, 0x78, 0x1E, 0x0F, 0x70, 0x70, 0x1C, 0x0E, 0xF0, 0x70, 0x3C,
  0x0E, 0xF0, 0xF0, 0x3C, 0x0E, 0xE0, 0xF0, 0x3C, 0x1E, 0xE0, 0xF0, 0x78,
  0x1C, 0xE0, 0xF0, 0x78, 0x3C, 0xE0, 0xF0, 0x78, 0x38, 0xE0, 0xF0, 0xF8,
  0x78, 0xE0, 0xF1, 0xF8, 0xF0, 0xE0, 0x7F, 0x9F, 0xE0, 0xE0, 0x7F, 0x1F,
  0xC0, 0xE0, 0x3E, 0x0F, 0x80, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x18, 0x00, 0x0F, 0xF7, 0xF8,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xDC, 0x00, 0x03, 0xDC, 0x00, 0x03,
  0x9E, 0x00, 0x07, 0x9E, 0x00, 0x07, 0x9E, 0x00, 0x0F, 0x1E, 0x00, 0x0F,
  0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x3E, 0x1E, 0x00, 0x3C,
  0x1E, 0x00, 0x7C, 0x1E, 0x00, 0x78, 0x1E, 0x00, 0x78, 0x1E, 0x00, 0xF0,
  0x1E, 0x00, 0xF0, 0x1E, 0x01, 0xF0, 0x1E, 0x01, 0xFF, 0xFE, 0x03, 0xFF,
  0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xC0, 0x1E, 0x0F, 0x80,
  0x1E, 0x0F, 0x80, 0x1E, 0x0F, 0x00, 0x1E, 0x1F, 0x00, 0x1E, 0x1E, 0x00,
  0x1E, 0x3E, 0x00, 0x1F, 0x3C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1E, 0x03, 0xF0, 0x1F,
  0x00, 0xF8, 0x0F, 0x80, 0x3C, 0x07, 0xC0, 0x1F, 0x03, 0xC0, 0x0F, 0x81,
  0xE0, 0x07, 0xC1, 0xF0, 0x03, 0xC0, 0xF8, 0x03, 0xE0, 0x78, 0x01, 0xF0,
  0x3C, 0x01, 0xF0, 0x1E, 0x00, 0xF8, 0x1F, 0x01, 0xF8, 0x0F, 0xFF, 0xF8,
  0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x01, 0xF0, 0x3F,
  0x00, 0xF8, 0x07, 0xC0, 0x78, 0x03, 0xE0, 0x3C, 0x00, 0xF8, 0x3E, 0x00,
  0x7C, 0x1F, 0x00, 0x3E, 0x0F, 0x00, 0x1F, 0x07, 0x80, 0x0F, 0x83, 0xC0,
  0x07, 0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x03, 0xE0, 0xF0, 0x03, 0xE0, 0x78,
  0x03, 0xF0, 0x3C, 0x03, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x0F, 0xC0, 0x20, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x80, 0x20, 0x07, 0xF3, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0xFF,
  0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x01, 0xE0, 0x7F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x0F, 0x80, 0x3E, 0x03, 0xC0,
  0x07, 0x80, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x07,
  0x80, 0x07, 0xC1, 0xE0, 0x01, 0xF0, 0x78, 0x00, 0x7C, 0x3E, 0x00, 0x1F,
  0x0F, 0x80, 0x07, 0xC3, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0x3C, 0x00,
  0x3E, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xE1, 0xE0, 0x00, 0xF0, 0x78,
  0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0x83, 0xC0, 0x03, 0xE0,
  0xF0, 0x00, 0xF8, 0x3C, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x07, 0xC0, 0x1F,
  0x81, 0xE0, 0x0F, 0xC0, 0x78, 0x07, 0xE0, 0x1E, 0x07, 0xF0, 0x0F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0,
  0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F,
  0xFF, 0xE0, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x7F, 0xFE, 0x01,
  0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0xFC, 0x01, 0xC0, 0x1F, 0x80,
  0x04, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x01, 0xFF, 0x87, 0xC0,
  0x1F, 0xF8, 0x78, 0x03, 0xFF, 0x07, 0x80, 0x3F, 0xF0, 0x78, 0x00, 0x0F,
  0x07, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xE0, 0xF8,
  0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x3E, 0x07, 0x80, 0x03,
  0xC0, 0x7C, 0x00, 0x3C, 0x07, 0xC0, 0x03, 0xC0, 0x3E, 0x00, 0x7C, 0x03,
  0xF0, 0x07, 0xC0, 0x1F, 0xE3, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0xF8, 0x0F, 0x80, 0x07, 0x80, 0x7C, 0x00, 0x3C, 0x03, 0xC0, 0x01, 0xE0,
  0x1E, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0xF0, 0x0F, 0x80, 0x07, 0x80, 0x78,
  0x00, 0x3C, 0x03, 0xC0, 0x03, 0xE0, 0x1E, 0x00, 0x1F, 0x01, 0xF0, 0x00,
  0xF0, 0x0F, 0x80, 0x07, 0x80, 0x78, 0x00, 0x3C, 0x03, 0xC0, 0x03, 0xE0,
  0x1E, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x01, 0xF0, 0x00,
  0xF0, 0x0F, 0x80, 0x07, 0x80, 0x78, 0x00, 0x7C, 0x03, 0xC0, 0x03, 0xE0,
  0x1E, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0xF0, 0x0F, 0x00, 0x07, 0x80, 0x78,
  0x00, 0x7C, 0x03, 0xC0, 0x03, 0xE0, 0x3E, 0x00, 0x1E, 0x01, 0xF0, 0x00,
  0xF0, 0x0F, 0x00, 0x07, 0x80, 0x78, 0x00, 0x7C, 0x03, 0xC0, 0x03, 0xE0,
  0x3E, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0xF0, 0x0F, 0x00, 0x07, 0x80, 0x78,
  0x00, 0x7C, 0x00, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x01,
  0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x07, 0xFF, 0x80, 0xFF, 0xF8, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x07, 0xFE, 0x00,
  0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xF0, 0x03, 0xE0,
  0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x01,
  0xF0, 0x07, 0xC0, 0x7C, 0x00, 0xF8, 0x1F, 0x00, 0x1E, 0x03, 0xE0, 0x03,
  0xC0, 0xF8, 0x00, 0x78, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE1, 0xF0,
  0x00, 0x78, 0x7C, 0x00, 0x0F, 0x1F, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x7D,
  0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0x3C, 0x00, 0x07, 0xC7,
  0xC0, 0x00, 0xF0, 0xF8, 0x00, 0x3E, 0x0F, 0x00, 0x07, 0xC1, 0xE0, 0x00,
  0xF0, 0x3E, 0x00, 0x1E, 0x07, 0xC0, 0x03, 0xC0, 0x78, 0x00, 0xF8, 0x0F,
  0x00, 0x1F, 0x01, 0xF0, 0x03, 0xC0, 0x3E, 0x00, 0x78, 0x03, 0xC0, 0x0F,
  0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0x00, 0x1E,
  0x01, 0xE0, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x00, 0xFC, 0x00,
  0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x01, 0xFE, 0x03,
  0xF8, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x07,
  0xF8, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x03, 0xFE, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x01, 0xEF, 0x01, 0xF7, 0x00, 0x0F, 0x78,
  0x0F, 0x38, 0x00, 0xF3, 0xC0, 0x79, 0xE0, 0x07, 0xBE, 0x03, 0xCF, 0x00,
  0x79, 0xE0, 0x1E, 0x78, 0x03, 0xCF, 0x01, 0xF3, 0xC0, 0x3C, 0x78, 0x0F,
  0x1E, 0x01, 0xE7, 0xC0, 0x78, 0xF0, 0x1E, 0x3E, 0x03, 0xC7, 0x80, 0xF1,
  0xE0, 0x1E, 0x3C, 0x0F, 0x0F, 0x01, 0xF1, 0xE0, 0x78, 0x78, 0x0F, 0x0F,
  0x07, 0x87, 0xC0, 0x78, 0x78, 0x3C, 0x3E, 0x03, 0xC3, 0xC3, 0xC1, 0xE0,
  0x3E, 0x1E, 0x1E, 0x0F, 0x01, 0xE0, 0xF1, 0xE0, 0x78, 0x0F, 0x03, 0x8F,
  0x07, 0xC0, 0x78, 0x1C, 0x78, 0x3C, 0x03, 0xC0, 0xF7, 0x81, 0xE0, 0x3E,
  0x07, 0xBC, 0x0F, 0x01, 0xE0, 0x3F, 0xC0, 0xF8, 0x0F, 0x01, 0xFE, 0x07,
  0xC0, 0x78, 0x0F, 0xE0, 0x3C, 0x03, 0xC0, 0x7F, 0x01, 0xE0, 0x3E, 0x03,
  0xF0, 0x0F, 0x01, 0xE0, 0x1F, 0x80, 0xF8, 0x0F, 0x00, 0xF8, 0x07, 0xC0,
  0x78, 0x07, 0xC0, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x3C, 0x07, 0xE0, 0x00,
  0xF0, 0x1F, 0x80, 0x07, 0xC0, 0x7E, 0x00, 0x1F, 0x01, 0xFC, 0x00, 0x78,
  0x0F, 0xF0, 0x01, 0xE0, 0x3F, 0xC0, 0x07, 0x80, 0xFF, 0x00, 0x3E, 0x03,
  0xFE, 0x00, 0xF0, 0x0F, 0x78, 0x03, 0xC0, 0x7D, 0xE0, 0x0F, 0x01, 0xE7,
  0x80, 0x3C, 0x07, 0x9E, 0x01, 0xF0, 0x1E, 0x3C, 0x07, 0x80, 0x78, 0xF0,
  0x1E, 0x03, 0xE3, 0xC0, 0x78, 0x0F, 0x0F, 0x03, 0xE0, 0x3C, 0x1E, 0x0F,
  0x80, 0xF0, 0x78, 0x3C, 0x03, 0xC1, 0xE0, 0xF0, 0x1F, 0x07, 0x83, 0xC0,
  0x78, 0x1F, 0x1F, 0x01, 0xE0, 0x3C, 0x78, 0x07, 0x80, 0xF1, 0xE0, 0x3E,
  0x03, 0xC7, 0x80, 0xF0, 0x0F, 0x1E, 0x03, 0xC0, 0x1E, 0xF8, 0x0F, 0x00,
  0x7B, 0xC0, 0x3C, 0x01, 0xEF, 0x01, 0xF0, 0x07, 0xBC, 0x07, 0x80, 0x0F,
  0xF0, 0x1E, 0x00, 0x3F, 0xC0, 0x78, 0x00, 0xFE, 0x01, 0xE0, 0x03, 0xF8,
  0x0F, 0x80, 0x0F, 0xE0, 0x3C, 0x00, 0x1F, 0x80, 0xF0, 0x00, 0x7C, 0x03,
  0xC0, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x01,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0x80, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x1E, 0x07, 0xC0, 0x03, 0xE1, 0xF0,
  0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF1, 0xF0, 0x00, 0x3E,
  0x7C, 0x00, 0x07, 0xCF, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x1F, 0x3C, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0x79, 0xF0, 0x00, 0x0F, 0x3E, 0x00, 0x03, 0xE7,
  0xC0, 0x00, 0x7C, 0xF0, 0x00, 0x0F, 0x9E, 0x00, 0x01, 0xE3, 0xC0, 0x00,
  0x7C, 0xF8, 0x00, 0x0F, 0x9F, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x7C, 0x7C,
  0x00, 0x0F, 0x87, 0x80, 0x03, 0xE0, 0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x1F,
  0x03, 0xE0, 0x07, 0xE0, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x7E, 0x00, 0xFF,
  0x7F, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x01, 0xFF,
  0xF8, 0x01, 0xFF, 0xFC, 0x01, 0xE0, 0xFE, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x1E, 0x03, 0xE0, 0x1F, 0x03, 0xC0, 0x1F, 0x03, 0xC0, 0x1F, 0x07, 0xC0,
  0x1F, 0x07, 0xC0, 0x1E, 0x07, 0x80, 0x1E, 0x07, 0x80, 0x1E, 0x07, 0x80,
  0x3E, 0x0F, 0x80, 0x3C, 0x0F, 0x80, 0x7C, 0x0F, 0x00, 0xF8, 0x0F, 0x03,
  0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x1F, 0xFE,
  0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0,
  0x1F, 0x80, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0xF8, 0x01, 0xF0, 0x3E, 0x00,
  0x1E, 0x07, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x8F,
  0x80, 0x01, 0xF1, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x07, 0xCF, 0x80, 0x00,
  0xF9, 0xF0, 0x00, 0x1F, 0x3C, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x79, 0xF0,
  0x00, 0x0F, 0x3E, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x7C, 0xF0, 0x00, 0x0F,
  0x9E, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x7C, 0xF8, 0x00, 0x0F, 0x9F, 0x00,
  0x01, 0xE3, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x87, 0x80, 0x03, 0xE0,
  0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x07, 0xE0, 0x7E, 0x01,
  0xF8, 0x07, 0xC0, 0x7E, 0x00, 0xFF, 0x7F, 0x80, 0x0F, 0xFF, 0xE0, 0x00,
  0xFF, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x01, 0xFF,
  0xFC, 0x01, 0xE0, 0xFE, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x1F, 0x03, 0xE0,
  0x1F, 0x03, 0xC0, 0x1F, 0x03, 0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0xC0,
  0x1F, 0x07, 0x80, 0x1E, 0x07, 0x80, 0x3E, 0x07, 0x80, 0x3E, 0x0F, 0x80,
  0x7C, 0x0F, 0x80, 0xFC, 0x0F, 0x01, 0xF8, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x1E, 0x1F, 0x00, 0x1E, 0x0F,
  0x00, 0x3E, 0x0F, 0x00, 0x3E, 0x0F, 0x80, 0x3C, 0x0F, 0x80, 0x3C, 0x07,
  0x80, 0x3C, 0x07, 0x80, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x07,
  0xC0, 0x78, 0x03, 0xC0, 0x78, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x03,
  0xE0, 0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x1F, 0x80, 0xE0, 0x1F,
  0x80, 0x10, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x40,
  0x03, 0xE0, 0x30, 0x07, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x0A, 0x00, 0x00, 0x7F, 0xFF, 0xFB,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFD, 0xFF, 0xFF, 0xE0, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xE0, 0x01, 0xE0, 0x78, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x81,
  0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0x81, 0xE0, 0x00,
  0xF0, 0x3C, 0x00, 0x3E, 0x07, 0x80, 0x07, 0xC1, 0xF0, 0x00, 0xF0, 0x3E,
  0x00, 0x1E, 0x07, 0x80, 0x03, 0xC0, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x1F,
  0x07, 0xC0, 0x03, 0xC0, 0xF0, 0x00, 0x78, 0x1E, 0x00, 0x0F, 0x03, 0xC0,
  0x03, 0xE0, 0xF8, 0x00, 0x78, 0x1F, 0x00, 0x0F, 0x03, 0xC0, 0x01, 0xE0,
  0x78, 0x00, 0x7C, 0x0F, 0x00, 0x0F, 0x83, 0xE0, 0x01, 0xE0, 0x7C, 0x00,
  0x3C, 0x0F, 0x00, 0x07, 0x81, 0xE0, 0x01, 0xF0, 0x3C, 0x00, 0x3E, 0x07,
  0x80, 0x07, 0x81, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x3E, 0x03, 0xC0, 0x0F,
  0x80, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x01, 0xFE, 0xFF, 0x00, 0x1F,
  0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x10, 0x00,
  0x00, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xF7, 0x80, 0x03,
  0xEF, 0x00, 0x07, 0x9E, 0x00, 0x1F, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0xF8,
  0xF0, 0x01, 0xE1, 0xE0, 0x07, 0xC3, 0xC0, 0x0F, 0x87, 0x80, 0x3E, 0x0F,
  0x00, 0x7C, 0x1E, 0x00, 0xF0, 0x3C, 0x03, 0xE0, 0x78, 0x07, 0x80, 0xF0,
  0x1F, 0x01, 0xE0, 0x3C, 0x03, 0xE0, 0xF8, 0x07, 0xC1, 0xE0, 0x0F, 0x83,
  0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x1E, 0x00, 0x3C, 0x7C, 0x00, 0x78, 0xF0,
  0x00, 0xF3, 0xE0, 0x01, 0xE7, 0x80, 0x03, 0xDF, 0x00, 0x07, 0xBC, 0x00,
  0x0F, 0x78, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xC0, 0x07,
  0xFC, 0x00, 0x7E, 0x00, 0x3D, 0xE0, 0x03, 0xF0, 0x03, 0xEF, 0x00, 0x1F,
  0x80, 0x1E, 0x78, 0x01, 0xFC, 0x01, 0xF3, 0xC0, 0x0F, 0xE0, 0x0F, 0x9E,
  0x00, 0xFF, 0x00, 0x78, 0xF0, 0x07, 0xF8, 0x07, 0xC7, 0x80, 0x3B, 0xC0,
  0x3C, 0x3C, 0x03, 0xDE, 0x03, 0xE1, 0xE0, 0x1E, 0xF0, 0x1E, 0x0F, 0x01,
  0xE7, 0x80, 0xF0, 0x78, 0x0F, 0x38, 0x0F, 0x83, 0xC0, 0x71, 0xC0, 0x78,
  0x1E, 0x07, 0x8E, 0x07, 0xC0, 0xF0, 0x3C, 0x70, 0x3C, 0x07, 0x83, 0xC3,
  0x81, 0xE0, 0x3C, 0x1E, 0x1C, 0x1F, 0x01, 0xE1, 0xE0, 0xE0, 0xF0, 0x0F,
  0x0F, 0x07, 0x0F, 0x80, 0x78, 0x70, 0x38, 0x78, 0x03, 0xC7, 0x81, 0xC3,
  0xC0, 0x1E, 0x3C, 0x0E, 0x3E, 0x00, 0xF3, 0xC0, 0x71, 0xE0, 0x07, 0x9E,
  0x03, 0x9F, 0x00, 0x3C, 0xE0, 0x1C, 0xF0, 0x01, 0xEF, 0x00, 0xE7, 0x80,
  0x0F, 0x78, 0x07, 0x78, 0x00, 0x7F, 0x80, 0x3B, 0xC0, 0x03, 0xFC, 0x01,
  0xDE, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8,
  0x07, 0xC0, 0x03, 0xC0, 0x3C, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0xF0, 0x1E,
  0x00, 0x07, 0xC1, 0xE0, 0x00, 0x1E, 0x1F, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x07, 0x8F, 0x80, 0x00, 0x3C, 0x78, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x7C, 0x78,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x00,
  0x1E, 0x03, 0xC0, 0x01, 0xF0, 0x1E, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0xF0,
  0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x07, 0xC0, 0x07,
  0x80, 0x7C, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xBC, 0x00,
  0x7D, 0xF0, 0x07, 0xCF, 0x80, 0x3C, 0x7C, 0x03, 0xE1, 0xE0, 0x1E, 0x0F,
  0x01, 0xF0, 0x78, 0x0F, 0x03, 0xC0, 0xF8, 0x1E, 0x07, 0x80, 0xF8, 0x78,
  0x07, 0xC7, 0xC0, 0x1E, 0x3C, 0x00, 0xF3, 0xE0, 0x07, 0x9E, 0x00, 0x3D,
  0xF0, 0x01, 0xEF, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xF0, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x38, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x1C, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00,
  0x01, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFE, 0x00, 0x0F, 0x78, 0x00, 0x3D, 0xE0, 0x01, 0xE3, 0xC0, 0x07,
  0x8F, 0x00, 0x3C, 0x3C, 0x00, 0xE0, 0x78, 0x07, 0x81, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x0F, 0x07, 0x80, 0x3C, 0x1E, 0x00, 0x70, 0xF0, 0x01, 0xE3,
  0xC0, 0x07, 0x9E, 0x00, 0x0E, 0xF8, 0x00, 0x3C, 0x7F, 0xFF, 0xEF, 0xFF,
  0xF9, 0xFF, 0xFF, 0x7F, 0xFF, 0xE0, 0xF9, 0xF3, 0xE3, 0xC3, 0xC7, 0x87,
  0x87, 0x0E, 0x00, 0x7C, 0x00, 0x07, 0xFC, 0xF0, 0x3F, 0xF3, 0xC1, 0xFF,
  0xEF, 0x0F, 0xC3, 0xFC, 0x3E, 0x07, 0xE1, 0xF0, 0x0F, 0x87, 0x80, 0x3E,
  0x3E, 0x00, 0xF8, 0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0x1F, 0x00, 0x3C, 0x78,
  0x00, 0xF1, 0xE0, 0x07, 0xCF, 0x80, 0x1E, 0x3E, 0x00, 0x78, 0xF0, 0x01,
  0xE3, 0xC0, 0x0F, 0x8F, 0x00, 0x3E, 0x3C, 0x00, 0xF0, 0xF0, 0x07, 0xC3,
  0xC0, 0x1F, 0x0F, 0x00, 0xFC, 0x3C, 0x07, 0xF0, 0xF8, 0x1F, 0x83, 0xF1,
  0xFE, 0x07, 0xFF, 0x78, 0x1F, 0xF9, 0xE0, 0x3F, 0x87, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x0F, 0x00,
  0x3C, 0x7F, 0x80, 0x79, 0xFF, 0x80, 0xF7, 0xFF, 0x01, 0xFC, 0x3F, 0x07,
  0xF0, 0x3E, 0x0F, 0xC0, 0x3C, 0x1F, 0x00, 0x78, 0x3E, 0x00, 0xF0, 0x78,
  0x01, 0xE1, 0xF0, 0x03, 0xC3, 0xE0, 0x07, 0x87, 0x80, 0x1F, 0x0F, 0x00,
  0x3E, 0x3E, 0x00, 0x78, 0x78, 0x00, 0xF0, 0xF0, 0x01, 0xE1, 0xE0, 0x07,
  0xC3, 0xC0, 0x0F, 0x0F, 0x80, 0x1E, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF0,
  0x7C, 0x03, 0xE0, 0xF8, 0x0F, 0x83, 0xF8, 0x1F, 0x07, 0xF8, 0xFC, 0x0F,
  0x7F, 0xF0, 0x1C, 0xFF, 0xC0, 0x78, 0x7F, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x3F, 0x00, 0x3F, 0xF0, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xC0, 0x83, 0xE0,
  0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x04, 0x1F, 0x8E, 0x07, 0xFF, 0x80,
  0xFF, 0xE0, 0x1F, 0xF0, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0x87, 0x80, 0x1F, 0xF3, 0xC0,
  0x1F, 0xF9, 0xE0, 0x1F, 0xFE, 0xF0, 0x1F, 0x83, 0xF0, 0x0F, 0x81, 0xF8,
  0x0F, 0x80, 0x7C, 0x07, 0x80, 0x3E, 0x07, 0xC0, 0x1F, 0x03, 0xC0, 0x0F,
  0x03, 0xE0, 0x07, 0x81, 0xF0, 0x03, 0xC0, 0xF0, 0x01, 0xE0, 0x78, 0x01,
  0xF0, 0x7C, 0x00, 0xF0, 0x3E, 0x00, 0x78, 0x1E, 0x00, 0x3C, 0x0F, 0x00,
  0x3E, 0x07, 0x80, 0x1F, 0x03, 0xC0, 0x0F, 0x01, 0xE0, 0x0F, 0x80, 0xF0,
  0x07, 0xC0, 0x78, 0x07, 0xE0, 0x3C, 0x07, 0xE0, 0x1F, 0x07, 0xF0, 0x0F,
  0xC7, 0xF8, 0x03, 0xFF, 0xBC, 0x01, 0xFF, 0x9E, 0x00, 0x7F, 0x0E, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0xF0, 0x0F, 0xFF, 0x03,
  0xFF, 0xF0, 0xFC, 0x3E, 0x1F, 0x03, 0xC7, 0xC0, 0x79, 0xF0, 0x0F, 0x3E,
  0x01, 0xE7, 0x80, 0x79, 0xF0, 0x1F, 0x3C, 0x07, 0xC7, 0x83, 0xF9, 0xFF,
  0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x02, 0x0F, 0xC1, 0xC1, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0xFF,
  0x80, 0x02, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xF0, 0x80, 0x00, 0x78, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0xFF, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x7F, 0xC7, 0x00, 0xFF, 0xEF, 0x01, 0xFF, 0xEF,
  0x03, 0xF0, 0x7F, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0x3E, 0x07, 0x80, 0x3E,
  0x0F, 0x80, 0x3E, 0x0F, 0x00, 0x3C, 0x1F, 0x00, 0x3C, 0x1F, 0x00, 0x3C,
  0x1E, 0x00, 0x7C, 0x1E, 0x00, 0x7C, 0x3E, 0x00, 0x78, 0x3E, 0x00, 0x78,
  0x3C, 0x00, 0x78, 0x3C, 0x00, 0xF8, 0x3C, 0x00, 0xF8, 0x3C, 0x01, 0xF0,
  0x3C, 0x01, 0xF0, 0x3C, 0x03, 0xF0, 0x3C, 0x03, 0xF0, 0x3C, 0x07, 0xF0,
  0x3E, 0x0F, 0xE0, 0x3F, 0x1F, 0xE0, 0x1F, 0xFD, 0xE0, 0x1F, 0xFB, 0xE0,
  0x0F, 0xE3, 0xC0, 0x01, 0x83, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00,
  0x80, 0x1F, 0x00, 0xE0, 0x7E, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00,
  0xFF, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x1F, 0x1F, 0x00, 0x3C, 0x7F, 0x80, 0x7B, 0xFF, 0x80, 0xF7,
  0xFF, 0x01, 0xFC, 0x3E, 0x07, 0xF0, 0x3E, 0x0F, 0xC0, 0x7C, 0x1F, 0x00,
  0xF0, 0x3E, 0x01, 0xE0, 0x78, 0x03, 0xC1, 0xF0, 0x07, 0x83, 0xE0, 0x1F,
  0x07, 0x80, 0x3E, 0x0F, 0x00, 0x78, 0x3E, 0x00, 0xF0, 0x7C, 0x01, 0xE0,
  0xF0, 0x07, 0xC1, 0xE0, 0x0F, 0x03, 0xC0, 0x1E, 0x0F, 0x80, 0x3C, 0x1F,
  0x00, 0x78, 0x3C, 0x01, 0xF0, 0x78, 0x03, 0xC0, 0xF0, 0x07, 0x83, 0xE0,
  0x0F, 0x07, 0x80, 0x3E, 0x0F, 0x00, 0x7C, 0x1E, 0x00, 0xF0, 0x7C, 0x01,
  0xE0, 0x00, 0x70, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x03, 0xE0, 0x78, 0x0F, 0x80, 0xF0, 0x3E, 0x01, 0xE0,
  0xF8, 0x07, 0xC1, 0xE0, 0x0F, 0x07, 0xC0, 0x1E, 0x1F, 0x00, 0x3C, 0x7C,
  0x00, 0x79, 0xF0, 0x01, 0xF3, 0xC0, 0x03, 0xCF, 0x00, 0x07, 0xBE, 0x00,
  0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0xFD, 0xF0, 0x01,
  0xF1, 0xE0, 0x03, 0xC3, 0xC0, 0x0F, 0x87, 0xC0, 0x1E, 0x0F, 0x80, 0x3C,
  0x0F, 0x00, 0x78, 0x1E, 0x00, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0x80,
  0x78, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0x00, 0x78,
  0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF8,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x79, 0xFF, 0x0F, 0xF0,
  0x0F, 0x7F, 0xE3, 0xFF, 0x01, 0xFF, 0xFE, 0xFF, 0xE0, 0x3B, 0x87, 0xF8,
  0x3E, 0x0F, 0xE0, 0x7E, 0x07, 0xC1, 0xF8, 0x0F, 0x80, 0xF8, 0x3E, 0x01,
  0xF0, 0x1F, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0xF0, 0x0F, 0x80, 0x78, 0x3E,
  0x01, 0xF0, 0x0F, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0xF0, 0x07, 0x80, 0x7C,
  0x1E, 0x00, 0xF0, 0x0F, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0xF8, 0x07, 0x80,
  0x3C, 0x1E, 0x00, 0xF0, 0x07, 0x83, 0xC0, 0x1E, 0x01, 0xF0, 0x78, 0x03,
  0xC0, 0x3C, 0x1F, 0x00, 0xF8, 0x07, 0x83, 0xE0, 0x1E, 0x00, 0xF0, 0x78,
  0x03, 0xC0, 0x1E, 0x0F, 0x00, 0x78, 0x07, 0xC1, 0xE0, 0x1F, 0x00, 0xF0,
  0x7C, 0x03, 0xE0, 0x1E, 0x0F, 0x00, 0x78, 0x03, 0xC1, 0xE0, 0x0F, 0x00,
  0xF8, 0x3C, 0x01, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x00, 0x03,
  0xE0, 0x07, 0x9F, 0xF0, 0x0F, 0x7F, 0xF0, 0x1F, 0xFF, 0xE0, 0x3B, 0x87,
  0xC0, 0xFE, 0x07, 0xC1, 0xF8, 0x0F, 0x83, 0xE0, 0x1E, 0x07, 0xC0, 0x3C,
  0x1F, 0x00, 0x78, 0x3E, 0x00, 0xF0, 0x7C, 0x03, 0xE0, 0xF0, 0x07, 0xC1,
  0xE0, 0x0F, 0x07, 0xC0, 0x1E, 0x0F, 0x80, 0x3C, 0x1E, 0x00, 0xF8, 0x3C,
  0x01, 0xF0, 0x78, 0x03, 0xC1, 0xF0, 0x07, 0x83, 0xE0, 0x1F, 0x07, 0x80,
  0x3E, 0x0F, 0x00, 0x78, 0x3E, 0x00, 0xF0, 0x7C, 0x01, 0xE0, 0xF0, 0x07,
  0xC1, 0xE0, 0x0F, 0x83, 0xC0, 0x1E, 0x0F, 0x80, 0x3C, 0x00, 0x00, 0x3E,
  0x00, 0x0F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0xC3, 0xE0, 0xF8,
  0x1F, 0x1F, 0x00, 0xF1, 0xE0, 0x0F, 0x3E, 0x00, 0xF3, 0xC0, 0x0F, 0x7C,
  0x00, 0xF7, 0x80, 0x0F, 0x78, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x3E,
  0xF0, 0x03, 0xCF, 0x00, 0x7C, 0xF0, 0x07, 0x8F, 0x80, 0xF8, 0xF8, 0x1F,
  0x07, 0xE3, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x78, 0xFF, 0x00, 0x3C, 0xFF, 0xC0, 0x1E, 0xFF, 0xE0,
  0x0F, 0xE0, 0xF8, 0x0F, 0xE0, 0x7C, 0x07, 0xE0, 0x1E, 0x03, 0xF0, 0x0F,
  0x01, 0xF0, 0x07, 0x80, 0xF0, 0x03, 0xC0, 0xF8, 0x01, 0xE0, 0x7C, 0x00,
  0xF0, 0x3C, 0x00, 0xF8, 0x1E, 0x00, 0x7C, 0x0F, 0x00, 0x3E, 0x0F, 0x80,
  0x1E, 0x07, 0x80, 0x0F, 0x03, 0xC0, 0x0F, 0x81, 0xE0, 0x07, 0xC1, 0xF0,
  0x03, 0xC0, 0xF8, 0x03, 0xE0, 0x7C, 0x01, 0xE0, 0x3E, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0xC0, 0xF8, 0x0F, 0x71, 0xF8, 0x07, 0xBF, 0xF8, 0x03,
  0xCF, 0xF8, 0x01, 0xE3, 0xF8, 0x01, 0xF0, 0x40, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x07,
  0xFC, 0xF0, 0x3F, 0xFB, 0xC1, 0xFF, 0xEF, 0x0F, 0xC3, 0xFC, 0x3E, 0x07,
  0xE1, 0xF0, 0x0F, 0x87, 0x80, 0x3E, 0x3E, 0x00, 0xF8, 0xF0, 0x03, 0xC7,
  0xC0, 0x0F, 0x1F, 0x00, 0x3C, 0x78, 0x00, 0xF1, 0xE0, 0x07, 0xCF, 0x80,
  0x1E, 0x3E, 0x00, 0x78, 0xF0, 0x01, 0xE3, 0xC0, 0x0F, 0x8F, 0x00, 0x3E,
  0x3C, 0x01, 0xF0, 0xF0, 0x07, 0xC3, 0xC0, 0x1F, 0x0F, 0x00, 0xFC, 0x3C,
  0x07, 0xF0, 0xF8, 0x3F, 0x83, 0xF1, 0xFE, 0x07, 0xFF, 0x78, 0x1F, 0xFB,
  0xE0, 0x3F, 0x8F, 0x00, 0x18, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x79, 0xF8, 0x0F, 0x7F, 0x01,
  0xCF, 0xE0, 0x3B, 0xE4, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x7F, 0xF8, 0x1F, 0xFF, 0x87, 0xFF, 0xE0, 0xF8,
  0x1C, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x80, 0x3E,
  0x1E, 0x1F, 0x83, 0xFF, 0xF0, 0x7F, 0xFC, 0x07, 0xFE, 0x00, 0x04, 0x00,
  0x00, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x0F, 0xFF, 0x7F, 0xF9, 0xFF, 0xE0, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x20, 0xFF, 0x83, 0xFE,
  0x07, 0xF8, 0x03, 0x00, 0x0F, 0x80, 0x7C, 0x3C, 0x01, 0xF0, 0xF0, 0x07,
  0x87, 0xC0, 0x1E, 0x1F, 0x00, 0x78, 0x78, 0x03, 0xE1, 0xE0, 0x0F, 0x07,
  0x80, 0x3C, 0x3E, 0x00, 0xF0, 0xF8, 0x03, 0xC3, 0xC0, 0x1F, 0x0F, 0x00,
  0x78, 0x3C, 0x01, 0xE1, 0xF0, 0x07, 0x87, 0x80, 0x3E, 0x1E, 0x00, 0xF8,
  0x78, 0x03, 0xC3, 0xE0, 0x0F, 0x0F, 0x80, 0x7C, 0x3C, 0x01, 0xF0, 0xF0,
  0x0F, 0x83, 0xC0, 0x3E, 0x0F, 0x01, 0xF8, 0x3E, 0x0F, 0xE0, 0xFC, 0xF7,
  0x83, 0xFF, 0x9C, 0x07, 0xFC, 0x70, 0x0F, 0xE3, 0xC0, 0x0C, 0x00, 0x00,
  0xF0, 0x01, 0xFF, 0x00, 0x3E, 0xF0, 0x03, 0xCF, 0x00, 0x7C, 0xF0, 0x07,
  0x8F, 0x00, 0xF8, 0xF0, 0x0F, 0x0F, 0x01, 0xF0, 0xF0, 0x1E, 0x0F, 0x01,
  0xE0, 0xF8, 0x3C, 0x07, 0x83, 0xC0, 0x78, 0x7C, 0x07, 0x87, 0x80, 0x78,
  0xF8, 0x07, 0x8F, 0x00, 0x79, 0xF0, 0x07, 0x9E, 0x00, 0x79, 0xE0, 0x07,
  0xBC, 0x00, 0x7B, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x07,
  0xC0, 0x3F, 0xE0, 0x1F, 0x80, 0x7B, 0xC0, 0x3F, 0x01, 0xF7, 0x80, 0x7E,
  0x03, 0xCF, 0x01, 0xFC, 0x07, 0x9E, 0x03, 0xF8, 0x1F, 0x3C, 0x0F, 0xF0,
  0x3C, 0x78, 0x1D, 0xE0, 0xF8, 0xF0, 0x7B, 0xC1, 0xE1, 0xE0, 0xF7, 0x83,
  0xC3, 0xC1, 0xCF, 0x0F, 0x07, 0x87, 0x9E, 0x1E, 0x0F, 0x0E, 0x3C, 0x7C,
  0x1E, 0x3C, 0x78, 0xF0, 0x3C, 0x78, 0xF1, 0xE0, 0x78, 0xE1, 0xE7, 0x80,
  0xF3, 0xC3, 0xCF, 0x01, 0xE7, 0x07, 0xBE, 0x03, 0xDE, 0x0F, 0x78, 0x07,
  0xBC, 0x1E, 0xF0, 0x0F, 0x70, 0x3F, 0xC0, 0x1F, 0xE0, 0x7F, 0x80, 0x3F,
  0x80, 0xFE, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x01, 0xF8,
  0x07, 0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x1F, 0x01, 0xE0, 0x3E, 0x01, 0xE0, 0x3C, 0x01, 0xE0, 0x7C, 0x01,
  0xF0, 0xF8, 0x00, 0xF0, 0xF0, 0x00, 0xF1, 0xF0, 0x00, 0xF3, 0xE0, 0x00,
  0xFB, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xEF, 0x00, 0x03, 0xEF, 0x00, 0x03, 0xCF, 0x00, 0x07,
  0x8F, 0x80, 0x0F, 0x87, 0x80, 0x1F, 0x07, 0x80, 0x1E, 0x07, 0x80, 0x3E,
  0x07, 0xC0, 0x7C, 0x03, 0xC0, 0x78, 0x03, 0xC0, 0xF8, 0x03, 0xE0, 0x00,
  0xF0, 0x01, 0xF0, 0x0F, 0x00, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x80,
  0x7C, 0x00, 0xF8, 0x07, 0x80, 0x07, 0x80, 0x78, 0x00, 0x78, 0x0F, 0x80,
  0x07, 0x80, 0xF0, 0x00, 0x78, 0x1F, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x78,
  0x3E, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x78, 0x7C, 0x00, 0x07, 0x87, 0x80,
  0x00, 0x78, 0xF8, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x07,
  0x9E, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x7B, 0xC0,
  0x00, 0x03, 0xB8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07,
  0xC0, 0x00, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0x81, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00,
  0x3F, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x07, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x00, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x80,
  0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x78, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x3E, 0x00, 0x1F, 0xE0, 0x03, 0xF0, 0x00, 0x7C, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C,
  0x00, 0x3F, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x0B, 0xFF, 0x00, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0x40, 0x1F, 0xF2, 0x00, 0x1E, 0x00,
};

const GFXglyph NotoSans_Condensed_Italic53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 13, 39, 13, 1, -38 },
  { 65, 16, 14, 19, 5, -38 },
  { 93, 27, 38, 26, 0, -38 },
  { 222, 23, 43, 23, 1, -40 },
  { 346, 30, 39, 35, 3, -38 },
  { 493, 26, 39, 27, 0, -38 },
  { 620, 6, 14, 10, 6, -38 },
  { 631, 17, 46, 14, 1, -38 },
  { 729, 16, 46, 14, -4, -38 },
  { 821, 19, 19, 22, 5, -40 },
  { 867, 21, 25, 25, 3, -31 },
  { 933, 9, 13, 12, -2, -6 },
  { 948, 12, 4, 15, 1, -16 },
  { 954, 6, 7, 12, 1, -6 },
  { 960, 25, 38, 18, -3, -38 },
  { 1079, 21, 39, 23, 2, -38 },
  { 1182, 14, 38, 23, 6, -38 },
  { 1249, 24, 38, 23, -1, -38 },
  { 1363, 23, 39, 23, 0, -38 },
  { 1476, 24, 38, 23, -1, -38 },
  { 1590, 23, 39, 23, 0, -38 },
  { 1703, 22, 39, 23, 2, -38 },
  { 1811, 23, 38, 23, 2, -38 },
  { 1921, 24, 39, 23, 0, -38 },
  { 2038, 22, 39, 23, 1, -38 },
  { 2146, 11, 30, 12, 0, -29 },
  { 2188, 14, 36, 12, -3, -29 },
  { 2251, 21, 24, 25, 3, -31 },
  { 2314, 21, 15, 25, 3, -26 },
  { 2354, 21, 24, 25, 3, -31 },
  { 2417, 18, 39, 18, 2, -38 },
  { 2505, 32, 43, 35, 2, -38 },
  { 2677, 24, 38, 24, -3, -38 },
  { 2791, 25, 38, 26, 1, -38 },
  { 2910, 25, 39, 24, 2, -38 },
  { 3032, 26, 38, 28, 1, -38 },
  { 3156, 23, 38, 22, 1, -38 },
  { 3266, 23, 38, 20, 1, -38 },
  { 3376, 28, 39, 29, 2, -38 },
  { 3513, 29, 38, 29, 1, -38 },
  { 3651, 20, 38, 15, -2, -38 },
  { 3746, 21, 48, 12, -8, -38 },
  { 3872, 27, 38, 24, 1, -38 },
  { 4001, 16, 38, 20, 1, -38 },
  { 4077, 37, 38, 37, 1, -38 },
  { 4253, 30, 38, 30, 1, -38 },
  { 4396, 27, 39, 30, 2, -38 },
  { 4528, 24, 38, 24, 1, -38 },
  { 4642, 27, 47, 30, 2, -38 },
  { 4801, 24, 38, 25, 1, -38 },
  { 4915, 25, 39, 22, -1, -38 },
  { 5037, 21, 38, 21, 4, -38 },
  { 5137, 27, 39, 28, 2, -38 },
  { 5269, 23, 38, 24, 5, -38 },
  { 5379, 37, 38, 38, 5, -38 },
  { 5555, 29, 38, 22, -3, -38 },
  { 5693, 21, 38, 21, 5, -38 },
  { 5793, 26, 38, 21, -2, -38 },
  { 5917, 20, 46, 15, -1, -38 },
  { 6032, 9, 38, 18, 5, -38 },
  { 6075, 20, 46, 15, -4, -38 },
  { 6190, 22, 21, 24, 1, -38 },
  { 6248, 19, 4, 18, -5, 4 },
  { 6258, 7, 9, 14, 8, -41 },
  { 6266, 22, 30, 25, 2, -29 },
  { 6349, 23, 41, 25, 0, -40 },
  { 6467, 18, 30, 19, 2, -29 },
  { 6535, 25, 41, 25, 2, -40 },
  { 6664, 19, 30, 22, 2, -29 },
  { 6736, 26, 54, 14, -6, -41 },
  { 6912, 24, 42, 25, 0, -29 },
  { 7038, 23, 40, 24, 0, -40 },
  { 7153, 13, 39, 11, 0, -39 },
  { 7217, 20, 52, 11, -7, -39 },
  { 7347, 23, 40, 21, 0, -40 },
  { 7462, 13, 40, 11, 0, -40 },
  { 7527, 35, 29, 37, 0, -29 },
  { 7654, 23, 29, 24, 0, -29 },
  { 7738, 20, 29, 24, 2, -29 },
  { 7811, 25, 41, 25, -2, -29 },
  { 7940, 22, 42, 25, 2, -29 },
  { 8056, 19, 29, 17, 0, -29 },
  { 8125, 19, 30, 19, 0, -29 },
  { 8197, 14, 36, 14, 2, -35 },
  { 8260, 22, 29, 25, 2, -28 },
  { 8340, 20, 28, 20, 3, -28 },
  { 8410, 31, 28, 32, 3, -28 },
  { 8519, 24, 28, 20, -2, -28 },
  { 8603, 28, 41, 20, -5, -28 },
  { 8747, 21, 28, 18, -2, -28 },
  { 8821, 20, 46, 18, 1, -38 },
  { 8936, 3, 53, 22, 10, -40 },
  { 8956, 20, 46, 18, -3, -38 },
  { 9071, 21, 7, 25, 3, -22 },
};

const GFXfont NotoSans_Condensed_Italic53pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Italic53pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Italic53pt7bGlyphs,
  0x20, 0x7E, 72
};

#endif // _NOTOSANS_CONDENSED_ITALIC53PT7B_H_
