#ifndef _NOTOSANS_CONDENSED_ITALIC54PT7B_H_
#define _NOTOSANS_CONDENSED_ITALIC54PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Italic.ttf
// Size: 54pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Italic54pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xE0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7C, 0x03, 0xE0, 0x0C, 0x00, 0x3C, 0x3E, 0xF8, 0x7D, 0xF0, 0xF3,
  0xE1, 0xE7, 0x83, 0xCF, 0x0F, 0x9E, 0x1E, 0x3C, 0x3C, 0xF0, 0x79, 0xE0,
  0xE3, 0xC1, 0xC7, 0x07, 0x8E, 0x0F, 0x1C, 0x1C, 0x00, 0x00, 0x07, 0x81,
  0xC0, 0x00, 0x78, 0x3C, 0x00, 0x07, 0x03, 0x80, 0x00, 0x70, 0x38, 0x00,
  0x0F, 0x07, 0x80, 0x00, 0xE0, 0x78, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x1C, 0x0F, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x3C, 0x0E, 0x00,
  0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xE0, 0x07, 0x03, 0x80, 0x00, 0x70, 0x38, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0xE0, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1C,
  0x0F, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x3C, 0x0E, 0x00, 0x7F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x08, 0x78, 0x3C, 0x00, 0x07,
  0x03, 0x80, 0x00, 0x70, 0x38, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xE0, 0x78,
  0x00, 0x0E, 0x07, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x01,
  0xC0, 0xE0, 0x00, 0x3C, 0x0E, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x38, 0x1C,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xFF,
  0xFE, 0x03, 0xF7, 0x7C, 0x0F, 0x8C, 0x10, 0x1E, 0x18, 0x00, 0x78, 0x70,
  0x00, 0xF0, 0xE0, 0x01, 0xE1, 0xC0, 0x03, 0xC3, 0x00, 0x07, 0x86, 0x00,
  0x0F, 0x9C, 0x00, 0x0F, 0xB8, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x37, 0xC0, 0x00, 0xE7, 0xC0, 0x01, 0xC7, 0x80, 0x03, 0x8F, 0x00, 0x06,
  0x1E, 0x00, 0x1C, 0x3C, 0x00, 0x38, 0x78, 0x00, 0x70, 0xF0, 0x80, 0xC3,
  0xC1, 0x81, 0x8F, 0x83, 0xF7, 0xFE, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x78, 0x0F, 0xF0, 0x01, 0xE0, 0x1F, 0xF0, 0x03, 0x80, 0x79, 0xE0, 0x0F,
  0x01, 0xE1, 0xC0, 0x1C, 0x03, 0x83, 0x80, 0x78, 0x0F, 0x07, 0x01, 0xE0,
  0x1C, 0x0E, 0x03, 0x80, 0x38, 0x1C, 0x0F, 0x00, 0xF0, 0x38, 0x1C, 0x01,
  0xE0, 0x70, 0x78, 0x03, 0x81, 0xE1, 0xE0, 0x07, 0x03, 0xC3, 0xC0, 0x1E,
  0x07, 0x8F, 0x00, 0x3C, 0x0E, 0x1C, 0x00, 0x78, 0x3C, 0x78, 0x30, 0xF0,
  0x78, 0xE3, 0xF9, 0xE0, 0xE3, 0xCF, 0xFB, 0xC3, 0xCF, 0x1F, 0xF7, 0x87,
  0x1C, 0x78, 0xFF, 0x9E, 0x79, 0xE1, 0xEF, 0xF8, 0xE3, 0x83, 0xDF, 0xE3,
  0xCF, 0x07, 0x8F, 0x8F, 0x1E, 0x0F, 0x00, 0x1E, 0x38, 0x1E, 0x00, 0x78,
  0x70, 0x3C, 0x00, 0xE1, 0xE0, 0x70, 0x03, 0xC3, 0xC0, 0xE0, 0x0F, 0x07,
  0x81, 0xC0, 0x1E, 0x0E, 0x07, 0x80, 0x78, 0x1C, 0x0F, 0x00, 0xE0, 0x38,
  0x1C, 0x03, 0xC0, 0x70, 0x78, 0x07, 0x00, 0xE0, 0xE0, 0x1E, 0x01, 0xC3,
  0xC0, 0x78, 0x03, 0xC7, 0x00, 0xF0, 0x07, 0xFE, 0x03, 0xC0, 0x07, 0xF8,
  0x0F, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFB, 0xF0, 0x00, 0x78, 0x3C,
  0x00, 0x3E, 0x0F, 0x00, 0x0F, 0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x00, 0xF0,
  0x3C, 0x00, 0x7C, 0x0F, 0x00, 0x1F, 0x07, 0x80, 0x07, 0xC1, 0xE0, 0x00,
  0xF0, 0xF0, 0x00, 0x3C, 0x7C, 0x00, 0x0F, 0x3E, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xF7, 0xC0, 0xF0, 0xF9, 0xF0, 0x7C, 0x7C,
  0x3C, 0x1E, 0x3E, 0x0F, 0x8F, 0x8F, 0x01, 0xE3, 0xC7, 0xC0, 0x7D, 0xF1,
  0xE0, 0x1F, 0x78, 0x78, 0x03, 0xFE, 0x3E, 0x00, 0xFF, 0x0F, 0x80, 0x1F,
  0x83, 0xE0, 0x07, 0xE0, 0xF8, 0x01, 0xF8, 0x3E, 0x00, 0xFE, 0x07, 0xC0,
  0xFF, 0x81, 0xF8, 0xFF, 0xF0, 0x3F, 0xFF, 0x3C, 0x0F, 0xFF, 0x0F, 0x80,
  0xFF, 0x83, 0xF0, 0x04, 0x00, 0x00, 0x3E, 0x79, 0xF3, 0xE7, 0x8F, 0x1E,
  0x3C, 0x71, 0xE3, 0xC7, 0x8E, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07,
  0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x0E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x04, 0x07, 0x00, 0xE0, 0xE0, 0x1F, 0x1C, 0x07,
  0xFB, 0x87, 0x7F, 0xFF, 0xE0, 0xFF, 0xFC, 0x07, 0xFF, 0x81, 0xF8, 0x00,
  0x7F, 0x80, 0x1E, 0x70, 0x07, 0xCF, 0x03, 0xF1, 0xE0, 0x3C, 0x1E, 0x03,
  0x03, 0xE0, 0x20, 0x78, 0x00, 0x04, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x0F, 0x87, 0xC3, 0xE3, 0xE1, 0xF0, 0xF0, 0xF8,
  0x78, 0x7C, 0x3C, 0x1C, 0x1E, 0x0E, 0x00, 0x7F, 0xFB, 0xFF, 0xBF, 0xFD,
  0xFF, 0xEF, 0xFF, 0x00, 0x7B, 0xFF, 0xFF, 0xFB, 0xE2, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0x00, 0x3F,
  0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0x0F, 0x81, 0xF0, 0x7C, 0x1F, 0x01, 0xE0,
  0xF0, 0x0F, 0x0F, 0x80, 0x78, 0x78, 0x03, 0xC7, 0xC0, 0x1E, 0x3C, 0x00,
  0xF1, 0xE0, 0x07, 0x9F, 0x00, 0x3C, 0xF8, 0x01, 0xE7, 0x80, 0x0F, 0x7C,
  0x00, 0xFB, 0xE0, 0x07, 0xDE, 0x00, 0x3E, 0xF0, 0x01, 0xE7, 0x80, 0x0F,
  0x7C, 0x00, 0x7B, 0xE0, 0x07, 0xDF, 0x00, 0x3E, 0xF0, 0x01, 0xE7, 0x80,
  0x0F, 0x3C, 0x00, 0xF9, 0xE0, 0x07, 0x8F, 0x00, 0x3C, 0x78, 0x03, 0xE3,
  0xC0, 0x1E, 0x1E, 0x01, 0xF0, 0xF0, 0x0F, 0x07, 0xC0, 0xF8, 0x3E, 0x0F,
  0x80, 0xFD, 0xF8, 0x07, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x7F, 0x80, 0x00,
  0x40, 0x00, 0x00, 0x3E, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x7F, 0xC1,
  0xFF, 0x87, 0xFE, 0x1F, 0xBC, 0xFC, 0xF8, 0xF1, 0xF1, 0xC3, 0xC1, 0x07,
  0x80, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xFE, 0x01, 0xFF, 0xFE, 0x00, 0xF8, 0x3F, 0x00, 0xE0, 0x1F, 0x00, 0x40,
  0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x1F, 0xFF,
  0xE0, 0x1E, 0x07, 0xE0, 0x30, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE1,
  0x00, 0x0F, 0x83, 0x00, 0x3F, 0x07, 0xC3, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xBC, 0x00, 0x03, 0xDE,
  0x00, 0x03, 0xDF, 0x00, 0x01, 0xCF, 0x00, 0x01, 0xE7, 0x80, 0x01, 0xE3,
  0xC0, 0x01, 0xE3, 0xE0, 0x00, 0xF1, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xF0,
  0x78, 0x00, 0x78, 0x3C, 0x00, 0x78, 0x3E, 0x00, 0x78, 0x1E, 0x00, 0x3C,
  0x0F, 0x00, 0x3C, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x1E, 0x00, 0x78, 0x0F, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF2, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF,
  0xFE, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0xBC, 0x00, 0x07, 0xFF,
  0x80, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x06, 0x07, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x80, 0x07, 0xE0, 0xC0, 0x0F, 0xC0, 0xF8, 0x7F, 0x80, 0xFF, 0xFF,
  0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x3F, 0x80, 0x3C, 0xFF, 0x80, 0x7B,
  0xFF, 0x81, 0xFF, 0xFF, 0x83, 0xF8, 0x1F, 0x07, 0xE0, 0x1E, 0x0F, 0x80,
  0x3E, 0x3F, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x03,
  0xE3, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x7C,
  0x3C, 0x00, 0xF0, 0x78, 0x03, 0xE0, 0xF8, 0x07, 0xC1, 0xF0, 0x1F, 0x01,
  0xF0, 0x7E, 0x03, 0xFB, 0xF8, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x03,
  0xFC, 0x00, 0x00, 0x80, 0x00, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFE, 0x01, 0xF8,
  0x3F, 0x01, 0xE0, 0x1F, 0x03, 0xE0, 0x1F, 0x03, 0xC0, 0x0F, 0x03, 0xC0,
  0x0F, 0x03, 0xC0, 0x0F, 0x03, 0xC0, 0x1F, 0x03, 0xC0, 0x1E, 0x03, 0xC0,
  0x3E, 0x03, 0xE0, 0x3C, 0x01, 0xE0, 0x7C, 0x01, 0xF1, 0xF8, 0x00, 0xFB,
  0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x80, 0x03, 0xFF,
  0x80, 0x07, 0xE7, 0xC0, 0x0F, 0x83, 0xE0, 0x1F, 0x01, 0xF0, 0x3E, 0x01,
  0xF0, 0x3C, 0x00, 0xF0, 0x7C, 0x00, 0xF8, 0x78, 0x00, 0xF8, 0x78, 0x00,
  0xF8, 0x78, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF0, 0x78, 0x01,
  0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0x3F, 0x0F, 0xC0, 0x3F, 0xFF,
  0xC0, 0x1F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x40, 0x00, 0x00, 0x1F,
  0x80, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xE0, 0xF8,
  0x1F, 0x01, 0xE0, 0x78, 0x07, 0xC3, 0xE0, 0x0F, 0x0F, 0x00, 0x3C, 0x7C,
  0x00, 0xF1, 0xF0, 0x03, 0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x3C, 0x78, 0x01,
  0xF1, 0xE0, 0x07, 0xC7, 0x80, 0x1F, 0x1E, 0x00, 0x7C, 0x78, 0x03, 0xE1,
  0xE0, 0x1F, 0x87, 0xC0, 0xFE, 0x1F, 0x87, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF,
  0xEF, 0x01, 0xFE, 0x3C, 0x01, 0xE0, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x38, 0xFF,
  0x00, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x02, 0x00, 0x00,
  0x03, 0xE0, 0x7C, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0x80, 0x40, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x7C, 0x0F, 0x83,
  0xF0, 0x7E, 0x07, 0x80, 0x40, 0x00, 0x00, 0x3C, 0x01, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x01, 0xE0, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0,
  0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0xC0, 0x00, 0x1E, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x3C, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x03, 0xE0, 0x00, 0x1C, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x01, 0xFC, 0x03, 0xFF, 0xC1, 0xFF, 0xF8, 0x7F, 0xFE,
  0x1E, 0x0F, 0xC2, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x03,
  0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x00, 0x80, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFE,
  0x7F, 0x80, 0x03, 0xF0, 0x03, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x03, 0xC0,
  0x00, 0x3C, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x07, 0x03, 0xC0,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0x01, 0xE1, 0xE0, 0x1F, 0xE0, 0x70, 0xE0,
  0x1F, 0xF8, 0x38, 0xF0, 0x3F, 0xFC, 0x1C, 0x70, 0x3E, 0x1C, 0x0E, 0x78,
  0x1E, 0x0E, 0x07, 0x38, 0x1E, 0x0F, 0x03, 0x9C, 0x0E, 0x07, 0x83, 0xDE,
  0x0F, 0x03, 0x81, 0xEF, 0x07, 0x01, 0xC0, 0xE7, 0x07, 0x81, 0xE0, 0x73,
  0x83, 0xC0, 0xF0, 0x3B, 0xC1, 0xC0, 0x70, 0x3D, 0xE0, 0xE0, 0x78, 0x1C,
  0xE0, 0xF0, 0x3C, 0x0E, 0x70, 0x78, 0x1E, 0x0F, 0x38, 0x3C, 0x1F, 0x07,
  0x1C, 0x1E, 0x0F, 0x07, 0x8E, 0x0F, 0x0F, 0xC3, 0x87, 0x07, 0xCE, 0xE3,
  0x83, 0x81, 0xFE, 0x7F, 0xC1, 0xC0, 0xFE, 0x1F, 0xC0, 0xE0, 0x1E, 0x07,
  0x80, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x30, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xDE, 0x00, 0x03, 0xDE, 0x00,
  0x07, 0xDE, 0x00, 0x07, 0x9E, 0x00, 0x07, 0x9E, 0x00, 0x0F, 0x1E, 0x00,
  0x0F, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x3E, 0x1E, 0x00,
  0x3C, 0x1E, 0x00, 0x7C, 0x1E, 0x00, 0x78, 0x1E, 0x00, 0xF8, 0x1E, 0x00,
  0xF8, 0x1E, 0x00, 0xF0, 0x1E, 0x01, 0xF0, 0x1E, 0x01, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xC0, 0x1F, 0x0F,
  0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x1E,
  0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x1E, 0x0F, 0xF0,
  0x0F, 0x00, 0xFC, 0x07, 0x80, 0x3E, 0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x0F,
  0x81, 0xE0, 0x07, 0xC0, 0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x7C, 0x00,
  0xF0, 0x3E, 0x00, 0xF8, 0x1E, 0x00, 0xF8, 0x0F, 0x00, 0xFC, 0x0F, 0x80,
  0xFC, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x00, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x3C, 0x00, 0xF8, 0x1E,
  0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x83,
  0xC0, 0x07, 0xC1, 0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0x01, 0xF0,
  0x7C, 0x01, 0xF8, 0x3C, 0x01, 0xF8, 0x1E, 0x01, 0xFC, 0x1F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x1F,
  0xC0, 0x60, 0x1F, 0x80, 0x10, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x20, 0x07,
  0xFB, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF,
  0xC0, 0x07, 0xFF, 0xF8, 0x01, 0xE1, 0xFF, 0x00, 0x78, 0x0F, 0xE0, 0x1E,
  0x00, 0xF8, 0x0F, 0x80, 0x3F, 0x03, 0xE0, 0x07, 0xC0, 0xF0, 0x01, 0xF0,
  0x3C, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xC1, 0xF0, 0x00,
  0xF0, 0x78, 0x00, 0x3C, 0x1E, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC3, 0xE0,
  0x01, 0xF0, 0xF0, 0x00, 0x7C, 0x3C, 0x00, 0x1F, 0x0F, 0x00, 0x07, 0xC7,
  0xC0, 0x01, 0xE1, 0xF0, 0x00, 0xF8, 0x78, 0x00, 0x3E, 0x1E, 0x00, 0x0F,
  0x8F, 0x80, 0x07, 0xC3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x3C, 0x00,
  0x3E, 0x0F, 0x00, 0x1F, 0x07, 0xC0, 0x0F, 0xC1, 0xF0, 0x07, 0xE0, 0x78,
  0x03, 0xF0, 0x1E, 0x01, 0xFC, 0x07, 0x81, 0xFE, 0x03, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xFE, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFE,
  0x01, 0xFF, 0xFE, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x1F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xF0, 0x1F, 0xE0, 0x3C, 0x07, 0xF0, 0x01, 0x00, 0xFC, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x01, 0xFF, 0x8F, 0x80, 0x3F, 0xF1, 0xF0,
  0x07, 0xFE, 0x3C, 0x00, 0xFF, 0xC7, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x1E,
  0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF8, 0x78, 0x00, 0x1F, 0x0F, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x78, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE0,
  0xFC, 0x00, 0x78, 0x0F, 0x80, 0x0F, 0x01, 0xF8, 0x01, 0xE0, 0x1F, 0xF7,
  0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00,
  0x02, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x78, 0x07, 0x80, 0x07, 0xC0, 0x7C,
  0x00, 0x3E, 0x03, 0xE0, 0x01, 0xF0, 0x1E, 0x00, 0x0F, 0x00, 0xF0, 0x00,
  0x78, 0x07, 0x80, 0x07, 0xC0, 0x7C, 0x00, 0x3E, 0x03, 0xE0, 0x01, 0xE0,
  0x1E, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x78, 0x07, 0x80, 0x07, 0xC0, 0x7C,
  0x00, 0x3E, 0x03, 0xE0, 0x01, 0xE0, 0x1E, 0x00, 0x0F, 0x00, 0xF0, 0x00,
  0x78, 0x0F, 0x80, 0x07, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0x80, 0x07, 0xC0, 0x7C,
  0x00, 0x3E, 0x03, 0xC0, 0x01, 0xE0, 0x1E, 0x00, 0x0F, 0x00, 0xF0, 0x00,
  0xF8, 0x0F, 0x80, 0x07, 0xC0, 0x7C, 0x00, 0x3C, 0x03, 0xC0, 0x01, 0xE0,
  0x1E, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0xF8, 0x0F, 0x80, 0x07, 0xC0, 0x7C,
  0x00, 0x3C, 0x03, 0xC0, 0x01, 0xE0, 0x1E, 0x00, 0x1F, 0x01, 0xF0, 0x00,
  0xF8, 0x0F, 0x80, 0x07, 0xC0, 0x78, 0x00, 0x3C, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x7F, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x0F,
  0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xF0, 0x01, 0xF0, 0x0F, 0x00, 0x3E,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x01, 0xE0, 0x0F, 0x80, 0x1E,
  0x01, 0xF0, 0x01, 0xE0, 0x3E, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0x7C,
  0x00, 0x3C, 0x0F, 0x80, 0x03, 0xC1, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x07,
  0xC7, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x07, 0x8F, 0x80, 0x00, 0x79, 0xF0,
  0x00, 0x0F, 0xBE, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x0F, 0x7E, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFD, 0xE0, 0x00, 0x1F, 0x9F,
  0x00, 0x01, 0xF1, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xE0, 0xF0, 0x00,
  0x3E, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x3C, 0x07, 0x80, 0x03, 0xC0,
  0x7C, 0x00, 0x7C, 0x07, 0xC0, 0x07, 0xC0, 0x7C, 0x00, 0x7C, 0x03, 0xC0,
  0x07, 0x80, 0x3E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x01, 0xF0, 0x0F, 0x00, 0x1F, 0x00, 0xF0, 0x01, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x03, 0xF0, 0x00,
  0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x00, 0xFE, 0x01,
  0xFC, 0x00, 0x07, 0xF8, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x00,
  0xFF, 0x80, 0xF7, 0x80, 0x03, 0xFC, 0x03, 0xDE, 0x00, 0x1F, 0xF0, 0x0F,
  0x78, 0x00, 0x7B, 0xC0, 0x3D, 0xE0, 0x03, 0xFF, 0x01, 0xF7, 0x80, 0x0F,
  0x7C, 0x07, 0x9E, 0x00, 0x7D, 0xE0, 0x1E, 0x78, 0x01, 0xE7, 0x80, 0x79,
  0xE0, 0x0F, 0x9E, 0x01, 0xE7, 0x80, 0x3C, 0xF8, 0x0F, 0x9E, 0x00, 0xF3,
  0xE0, 0x3C, 0x78, 0x07, 0x8F, 0x00, 0xF1, 0xE0, 0x1E, 0x3C, 0x03, 0xC7,
  0x80, 0xF1, 0xF0, 0x0F, 0x1E, 0x03, 0xC7, 0xC0, 0x7C, 0x78, 0x1E, 0x1F,
  0x01, 0xE1, 0xE0, 0x78, 0x78, 0x07, 0x83, 0x83, 0xC1, 0xE0, 0x1E, 0x0F,
  0x0F, 0x0F, 0x80, 0xF8, 0x3C, 0x78, 0x3E, 0x03, 0xE0, 0xF1, 0xE0, 0xF0,
  0x0F, 0x03, 0xCF, 0x03, 0xC0, 0x3C, 0x0F, 0x3C, 0x0F, 0x00, 0xF0, 0x3D,
  0xE0, 0x7C, 0x07, 0xC0, 0xF7, 0x81, 0xF0, 0x1E, 0x03, 0xFC, 0x07, 0x80,
  0x78, 0x0F, 0xF0, 0x1E, 0x01, 0xE0, 0x3F, 0x80, 0x78, 0x07, 0x80, 0xFE,
  0x03, 0xE0, 0x3E, 0x03, 0xF0, 0x0F, 0x80, 0xF0, 0x0F, 0xC0, 0x3C, 0x03,
  0xC0, 0x3F, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x3E, 0x01, 0xF0, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0xF0, 0x0F, 0xE0,
  0x01, 0xE0, 0x1F, 0xC0, 0x03, 0xC0, 0x3F, 0x80, 0x0F, 0x80, 0x7F, 0x00,
  0x1F, 0x01, 0xFF, 0x00, 0x3C, 0x03, 0xDE, 0x00, 0x78, 0x07, 0xBC, 0x00,
  0xF0, 0x0F, 0x78, 0x03, 0xE0, 0x3E, 0xF0, 0x07, 0x80, 0x78, 0xF0, 0x0F,
  0x00, 0xF1, 0xE0, 0x1E, 0x01, 0xE3, 0xC0, 0x7C, 0x03, 0xC7, 0x80, 0xF8,
  0x0F, 0x8F, 0x81, 0xE0, 0x1E, 0x0F, 0x03, 0xC0, 0x3C, 0x1E, 0x07, 0x80,
  0x78, 0x3C, 0x1F, 0x00, 0xF0, 0x7C, 0x3E, 0x03, 0xE0, 0x78, 0x78, 0x07,
  0x80, 0xF0, 0xF0, 0x0F, 0x01, 0xE1, 0xE0, 0x1E, 0x03, 0xC7, 0xC0, 0x7C,
  0x07, 0xCF, 0x00, 0xF8, 0x07, 0x9E, 0x01, 0xE0, 0x0F, 0x3C, 0x03, 0xC0,
  0x1E, 0x78, 0x07, 0x80, 0x3F, 0xF0, 0x1F, 0x00, 0x3F, 0xC0, 0x3E, 0x00,
  0x7F, 0x80, 0x78, 0x00, 0xFF, 0x00, 0xF0, 0x01, 0xFE, 0x01, 0xE0, 0x01,
  0xFC, 0x07, 0xC0, 0x03, 0xF0, 0x0F, 0x00, 0x07, 0xE0, 0x1E, 0x00, 0x0F,
  0xC0, 0x3C, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xC0, 0xFC, 0x03,
  0xF0, 0x0F, 0x80, 0xFC, 0x00, 0xF8, 0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x03,
  0xE1, 0xF0, 0x00, 0x3C, 0x3E, 0x00, 0x07, 0x87, 0x80, 0x00, 0xF1, 0xF0,
  0x00, 0x1E, 0x3E, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x79, 0xF0, 0x00, 0x0F,
  0x3E, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x7D, 0xF0, 0x00, 0x0F, 0xBE, 0x00,
  0x01, 0xF7, 0xC0, 0x00, 0x3C, 0xF8, 0x00, 0x07, 0x9F, 0x00, 0x01, 0xF3,
  0xC0, 0x00, 0x3E, 0x78, 0x00, 0x07, 0xDF, 0x00, 0x01, 0xF3, 0xE0, 0x00,
  0x3E, 0x7C, 0x00, 0x07, 0x87, 0x80, 0x01, 0xF0, 0xF0, 0x00, 0x3E, 0x1E,
  0x00, 0x0F, 0x83, 0xE0, 0x03, 0xF0, 0x7C, 0x00, 0x7C, 0x0F, 0xC0, 0x1F,
  0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x01, 0xE1, 0xFE,
  0x01, 0xE0, 0x3E, 0x01, 0xE0, 0x1F, 0x03, 0xE0, 0x1F, 0x03, 0xE0, 0x1F,
  0x03, 0xC0, 0x0F, 0x03, 0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1F,
  0x07, 0xC0, 0x1F, 0x07, 0x80, 0x1E, 0x07, 0x80, 0x3E, 0x0F, 0x80, 0x3E,
  0x0F, 0x80, 0x7C, 0x0F, 0x00, 0xFC, 0x0F, 0x03, 0xF8, 0x0F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x1E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xC0, 0xFC, 0x03,
  0xF0, 0x0F, 0x80, 0xFC, 0x00, 0xF8, 0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x03,
  0xE1, 0xF0, 0x00, 0x3C, 0x3E, 0x00, 0x07, 0x87, 0x80, 0x00, 0xF1, 0xF0,
  0x00, 0x1E, 0x3E, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x79, 0xF0, 0x00, 0x0F,
  0x3E, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x7D, 0xF0, 0x00, 0x0F, 0xBE, 0x00,
  0x01, 0xF7, 0xC0, 0x00, 0x3C, 0xF8, 0x00, 0x07, 0x9F, 0x00, 0x01, 0xF3,
  0xC0, 0x00, 0x3E, 0x78, 0x00, 0x07, 0xDF, 0x00, 0x01, 0xF3, 0xE0, 0x00,
  0x3E, 0x7C, 0x00, 0x07, 0xC7, 0x80, 0x01, 0xF0, 0xF0, 0x00, 0x3E, 0x1E,
  0x00, 0x0F, 0x83, 0xE0, 0x03, 0xF0, 0x7C, 0x00, 0x7C, 0x0F, 0xC0, 0x1F,
  0x00, 0xFC, 0x0F, 0xE0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFC,
  0x01, 0xE1, 0xFE, 0x01, 0xE0, 0x3F, 0x01, 0xE0, 0x1F, 0x03, 0xE0, 0x1F,
  0x03, 0xE0, 0x1F, 0x03, 0xC0, 0x0F, 0x03, 0xC0, 0x1F, 0x07, 0xC0, 0x1F,
  0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0x80, 0x1E, 0x07, 0x80, 0x3E,
  0x0F, 0x80, 0x7E, 0x0F, 0x80, 0xFC, 0x0F, 0x01, 0xF8, 0x0F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x1E, 0x0F, 0x00,
  0x1E, 0x0F, 0x00, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x07, 0x80,
  0x3C, 0x07, 0x80, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0x7C, 0x03, 0xC0, 0x78, 0x03, 0xE0, 0x78, 0x03, 0xE0, 0xF8, 0x03, 0xE0,
  0xF8, 0x01, 0xE0, 0xF0, 0x01, 0xF0, 0xF0, 0x01, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xC0,
  0xF0, 0x0F, 0x80, 0x10, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x20, 0x01, 0xF0, 0x18, 0x03, 0xF8, 0x0F, 0xFF,
  0xF8, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x05,
  0x00, 0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x03,
  0xE0, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x83, 0xC0, 0x01, 0xE0, 0x78,
  0x00, 0x3C, 0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x01, 0xF0, 0x78, 0x00, 0x3C,
  0x0F, 0x00, 0x07, 0x81, 0xE0, 0x00, 0xF0, 0x7C, 0x00, 0x3E, 0x0F, 0x80,
  0x07, 0xC1, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x1E, 0x07, 0x80, 0x07, 0xC1,
  0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x07, 0x80, 0x03, 0xC0, 0xF0, 0x00,
  0x78, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x78, 0x1E,
  0x00, 0x0F, 0x03, 0xC0, 0x01, 0xE0, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x0F,
  0x83, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x81, 0xE0,
  0x01, 0xF0, 0x3C, 0x00, 0x3C, 0x07, 0x80, 0x0F, 0x80, 0xF0, 0x01, 0xE0,
  0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x1F, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF,
  0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x04, 0x00, 0x00,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x3C,
  0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0xF8, 0xF0, 0x00, 0xF8,
  0xF0, 0x01, 0xF0, 0xF0, 0x01, 0xF0, 0xF8, 0x03, 0xE0, 0xF8, 0x03, 0xE0,
  0xF8, 0x03, 0xC0, 0xF8, 0x07, 0xC0, 0xF8, 0x07, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x1E, 0x00,
  0xF8, 0x3E, 0x00, 0x78, 0x3C, 0x00, 0x78, 0x7C, 0x00, 0x78, 0x78, 0x00,
  0x78, 0xF8, 0x00, 0x78, 0xF0, 0x00, 0x79, 0xF0, 0x00, 0x79, 0xE0, 0x00,
  0x79, 0xE0, 0x00, 0x7B, 0xE0, 0x00, 0x7B, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x7F, 0xC0, 0x03, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0x80, 0x0F, 0xBC,
  0x00, 0x3E, 0x00, 0x3E, 0xF0, 0x01, 0xF8, 0x00, 0xF3, 0xC0, 0x07, 0xE0,
  0x07, 0xCF, 0x00, 0x3F, 0x80, 0x1E, 0x3C, 0x00, 0xFE, 0x00, 0xF8, 0xF0,
  0x03, 0xF8, 0x03, 0xE3, 0xC0, 0x1F, 0xE0, 0x0F, 0x0F, 0x00, 0x7F, 0x80,
  0x7C, 0x3C, 0x03, 0xDE, 0x01, 0xE0, 0xF0, 0x0F, 0x78, 0x0F, 0x83, 0xC0,
  0x79, 0xE0, 0x3E, 0x0F, 0x01, 0xE7, 0x80, 0xF0, 0x3C, 0x07, 0x9E, 0x07,
  0xC0, 0xF0, 0x3C, 0x78, 0x1E, 0x03, 0xC0, 0xF1, 0xE0, 0xF8, 0x0F, 0x07,
  0x87, 0x83, 0xC0, 0x3C, 0x1E, 0x1E, 0x0F, 0x00, 0xF0, 0x70, 0x78, 0x7C,
  0x03, 0xC3, 0xC1, 0xE1, 0xE0, 0x0F, 0x0F, 0x07, 0x8F, 0x80, 0x3C, 0x78,
  0x1E, 0x3C, 0x00, 0xF1, 0xE0, 0x78, 0xF0, 0x03, 0xCF, 0x01, 0xE7, 0xC0,
  0x0F, 0x3C, 0x07, 0x9E, 0x00, 0x3C, 0xF0, 0x1E, 0xF8, 0x00, 0xF7, 0x80,
  0x7B, 0xC0, 0x03, 0xDE, 0x01, 0xEF, 0x00, 0x0F, 0x70, 0x07, 0xFC, 0x00,
  0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0xF0,
  0x0F, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x1E, 0x0F,
  0x80, 0x00, 0x78, 0x7C, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x07, 0xCF, 0x80,
  0x00, 0x1F, 0x3C, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x7D, 0xE0,
  0x00, 0x03, 0xE7, 0x80, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x7C, 0x7C, 0x00,
  0x01, 0xE1, 0xF0, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x7C, 0x0F, 0x00, 0x01,
  0xE0, 0x3C, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x7C, 0x03, 0xE0, 0x01, 0xF0,
  0x0F, 0x80, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0x78, 0x01, 0xF0, 0x01,
  0xF0, 0x0F, 0x80, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xFE,
  0x00, 0x7D, 0xF0, 0x03, 0xEF, 0x80, 0x3E, 0x7C, 0x01, 0xF1, 0xE0, 0x1F,
  0x0F, 0x00, 0xF0, 0x78, 0x0F, 0x83, 0xC0, 0x78, 0x1F, 0x07, 0xC0, 0xF8,
  0x3C, 0x03, 0xC3, 0xE0, 0x1E, 0x3E, 0x00, 0xF1, 0xE0, 0x07, 0x9F, 0x00,
  0x3C, 0xF0, 0x01, 0xEF, 0x80, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x03,
  0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xFF, 0xE0,
  0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x1E, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7B, 0xC0, 0x00, 0xF3, 0xC0,
  0x03, 0xC7, 0x80, 0x07, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0x78, 0x1E, 0x00,
  0xF0, 0x1E, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x1E, 0x00, 0x78, 0x3C,
  0x00, 0xF0, 0xF0, 0x01, 0xE3, 0xE0, 0x01, 0xE7, 0x80, 0x03, 0xDF, 0x00,
  0x07, 0xC0, 0x7F, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFF, 0x00, 0xF8, 0xF8,
  0x7C, 0x3C, 0x3C, 0x1E, 0x0E, 0x0F, 0x00, 0xFE, 0x1E, 0x03, 0xFE, 0x3C,
  0x0F, 0xFE, 0xF0, 0x3F, 0x9F, 0xE0, 0xFC, 0x1F, 0xC1, 0xF0, 0x1F, 0x87,
  0xC0, 0x3E, 0x0F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x78, 0x01, 0xF1, 0xF0,
  0x03, 0xE3, 0xE0, 0x07, 0x87, 0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x3E, 0x00,
  0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xE1, 0xE0, 0x03, 0xC3, 0xC0, 0x0F,
  0x87, 0x80, 0x1F, 0x0F, 0x00, 0x7E, 0x1E, 0x00, 0xF8, 0x3C, 0x03, 0xF0,
  0x7C, 0x07, 0xE0, 0xF8, 0x1F, 0xC1, 0xF8, 0xFF, 0x01, 0xFF, 0xDE, 0x01,
  0xFF, 0x3C, 0x01, 0xFC, 0x78, 0x00, 0x40, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE3, 0xF8,
  0x03, 0xEF, 0xFC, 0x03, 0xDF, 0xFC, 0x03, 0xFE, 0x7E, 0x03, 0xF8, 0x3E,
  0x07, 0xF0, 0x1E, 0x07, 0xE0, 0x1E, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1F,
  0x07, 0x80, 0x1F, 0x0F, 0x80, 0x1E, 0x0F, 0x80, 0x1E, 0x0F, 0x00, 0x1E,
  0x0F, 0x00, 0x1E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x1E, 0x00, 0x3C,
  0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0xF8,
  0x3E, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x3E, 0x01, 0xF0, 0x7F, 0x03, 0xE0,
  0x7B, 0x8F, 0xC0, 0x7B, 0xFF, 0x80, 0x71, 0xFF, 0x00, 0xF0, 0xFE, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x7F, 0xE0, 0x3F, 0xF8, 0x0F, 0xFF, 0x03, 0xF9,
  0xC0, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x04, 0x0F, 0xC7, 0x81, 0xFF, 0xF0, 0x1F, 0xFE, 0x01, 0xFF, 0x80,
  0x02, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x0F, 0xE3, 0xE0, 0x0F, 0xF9, 0xE0, 0x0F,
  0xFE, 0xF0, 0x0F, 0xC7, 0xF8, 0x0F, 0xC1, 0xFC, 0x07, 0xC0, 0x7E, 0x07,
  0xC0, 0x3E, 0x03, 0xC0, 0x1F, 0x03, 0xE0, 0x0F, 0x81, 0xE0, 0x07, 0xC1,
  0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xE0, 0x78, 0x00, 0xF0, 0x3C, 0x00, 0x78,
  0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x1E, 0x07, 0x80, 0x0F,
  0x03, 0xC0, 0x0F, 0x81, 0xE0, 0x07, 0xC0, 0xF0, 0x07, 0xC0, 0x78, 0x03,
  0xE0, 0x3C, 0x03, 0xF0, 0x1F, 0x03, 0xF8, 0x0F, 0x81, 0xFC, 0x07, 0xE3,
  0xFC, 0x01, 0xFF, 0xDE, 0x00, 0xFF, 0xCF, 0x00, 0x1F, 0xC7, 0x80, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0xF8, 0x0F, 0xFF, 0x83, 0xF1,
  0xF0, 0xF8, 0x1E, 0x3E, 0x03, 0xC7, 0xC0, 0x79, 0xF0, 0x0F, 0x3C, 0x01,
  0xE7, 0x80, 0x7D, 0xF0, 0x1F, 0x3C, 0x07, 0xE7, 0x8F, 0xF9, 0xFF, 0xFC,
  0x3F, 0xFF, 0x07, 0xFF, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x02, 0x0F, 0xC1, 0xC1, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0xFF, 0xC0,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xF6, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFF,
  0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xC7, 0x80, 0x3F, 0xF3, 0x80, 0x3F, 0xFB, 0xC0, 0x3F, 0x1F, 0xE0,
  0x3F, 0x07, 0xF0, 0x1F, 0x01, 0xF8, 0x1F, 0x00, 0xF8, 0x0F, 0x00, 0x7C,
  0x0F, 0x80, 0x3E, 0x07, 0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x07,
  0x81, 0xE0, 0x03, 0xC0, 0xF0, 0x01, 0xE0, 0xF8, 0x01, 0xF0, 0x7C, 0x00,
  0xF8, 0x3E, 0x00, 0x78, 0x1E, 0x00, 0x7C, 0x0F, 0x00, 0x3E, 0x07, 0x80,
  0x1F, 0x03, 0xC0, 0x1F, 0x01, 0xE0, 0x0F, 0x80, 0xF0, 0x0F, 0xC0, 0x7C,
  0x0F, 0xE0, 0x3E, 0x0F, 0xF0, 0x1F, 0x8F, 0xF0, 0x07, 0xFF, 0x78, 0x03,
  0xFF, 0x3C, 0x00, 0xFF, 0x3E, 0x00, 0x08, 0x1F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xF0, 0x08, 0x01, 0xF0, 0x07, 0x01, 0xF8, 0x03, 0xFF, 0xF8,
  0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x3F,
  0x80, 0x79, 0xFF, 0x80, 0xF7, 0xFF, 0x01, 0xFF, 0x7F, 0x03, 0xF8, 0x3E,
  0x0F, 0xC0, 0x7C, 0x1F, 0x80, 0xF8, 0x3E, 0x01, 0xF0, 0x7C, 0x03, 0xE0,
  0xF0, 0x07, 0x83, 0xE0, 0x0F, 0x07, 0xC0, 0x1E, 0x0F, 0x00, 0x7C, 0x1E,
  0x00, 0xF8, 0x7C, 0x01, 0xE0, 0xF8, 0x03, 0xC1, 0xE0, 0x07, 0x83, 0xC0,
  0x1F, 0x07, 0x80, 0x3E, 0x1F, 0x00, 0x78, 0x3E, 0x00, 0xF0, 0x78, 0x01,
  0xE0, 0xF0, 0x07, 0xC1, 0xE0, 0x0F, 0x87, 0xC0, 0x1E, 0x0F, 0x80, 0x3C,
  0x1E, 0x00, 0x78, 0x3C, 0x01, 0xF0, 0xF8, 0x03, 0xC0, 0x00, 0x30, 0x03,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07,
  0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07,
  0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0,
  0x1F, 0x00, 0x00, 0x00, 0x60, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x1F, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x7C,
  0x03, 0xC0, 0xF8, 0x03, 0xC1, 0xF0, 0x07, 0xC1, 0xE0, 0x07, 0xC3, 0xE0,
  0x07, 0x87, 0xC0, 0x07, 0x8F, 0x80, 0x07, 0x9F, 0x00, 0x0F, 0xBE, 0x00,
  0x0F, 0x3C, 0x00, 0x0F, 0x7C, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x00,
  0x1F, 0xFE, 0x00, 0x1F, 0x9E, 0x00, 0x1F, 0x1E, 0x00, 0x1E, 0x1F, 0x00,
  0x3E, 0x1F, 0x00, 0x3E, 0x0F, 0x00, 0x3C, 0x0F, 0x00, 0x3C, 0x0F, 0x80,
  0x3C, 0x0F, 0x80, 0x7C, 0x07, 0x80, 0x7C, 0x07, 0xC0, 0x78, 0x07, 0xC0,
  0x78, 0x07, 0xC0, 0xF8, 0x03, 0xC0, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0x80, 0x1E, 0x00, 0xF8, 0x00, 0x03, 0xC7, 0xF0, 0x3F, 0x80, 0x79,
  0xFF, 0x0F, 0xF8, 0x0F, 0x7F, 0xF3, 0xFF, 0x81, 0xFE, 0x7E, 0xF3, 0xF0,
  0x3F, 0x03, 0xF8, 0x3E, 0x0F, 0xC0, 0x7E, 0x03, 0xC1, 0xF8, 0x0F, 0xC0,
  0x78, 0x3E, 0x01, 0xF0, 0x0F, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0xF0, 0x07,
  0x80, 0x3C, 0x3E, 0x01, 0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x01, 0xE0, 0xF0,
  0x07, 0x80, 0x3C, 0x1E, 0x00, 0xF0, 0x07, 0x83, 0xC0, 0x1E, 0x01, 0xF0,
  0xF8, 0x07, 0xC0, 0x3E, 0x1E, 0x00, 0xF8, 0x07, 0x83, 0xC0, 0x1E, 0x00,
  0xF0, 0x78, 0x03, 0xC0, 0x1E, 0x1F, 0x00, 0x78, 0x07, 0xC3, 0xE0, 0x1F,
  0x00, 0xF8, 0x78, 0x03, 0xC0, 0x1E, 0x0F, 0x00, 0x78, 0x03, 0xC1, 0xE0,
  0x0F, 0x00, 0x78, 0x7C, 0x03, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x03, 0xE1,
  0xE0, 0x0F, 0x00, 0x78, 0x3C, 0x01, 0xE0, 0x0F, 0x0F, 0x80, 0x3C, 0x03,
  0xE0, 0x00, 0x00, 0x40, 0x07, 0x8F, 0xF0, 0x0F, 0x3F, 0xF0, 0x1E, 0xFF,
  0xE0, 0x3F, 0xEF, 0xE0, 0x7F, 0x07, 0xC1, 0xFC, 0x0F, 0x83, 0xF0, 0x1F,
  0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x01, 0xE0,
  0xF8, 0x03, 0xC1, 0xE0, 0x0F, 0x83, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x1F,
  0x00, 0x78, 0x3C, 0x00, 0xF0, 0x78, 0x03, 0xE0, 0xF0, 0x07, 0xC3, 0xE0,
  0x0F, 0x07, 0xC0, 0x1E, 0x0F, 0x00, 0x3C, 0x1E, 0x00, 0xF8, 0x7C, 0x01,
  0xF0, 0xF8, 0x03, 0xC1, 0xF0, 0x07, 0x83, 0xC0, 0x1F, 0x07, 0x80, 0x3E,
  0x1F, 0x00, 0x78, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFE, 0x00, 0xFF, 0xF8,
  0x0F, 0xC7, 0xE0, 0xF8, 0x1F, 0x07, 0x80, 0x78, 0x7C, 0x03, 0xE7, 0xC0,
  0x1F, 0x3E, 0x00, 0xF9, 0xE0, 0x07, 0xDF, 0x00, 0x3E, 0xF0, 0x01, 0xF7,
  0x80, 0x0F, 0xFC, 0x00, 0x7B, 0xE0, 0x03, 0xDF, 0x00, 0x1E, 0xF0, 0x01,
  0xF7, 0x80, 0x0F, 0xBC, 0x00, 0x79, 0xE0, 0x07, 0xCF, 0x00, 0x3E, 0x78,
  0x03, 0xE3, 0xC0, 0x1F, 0x1F, 0x01, 0xF0, 0xF8, 0x1F, 0x83, 0xF1, 0xF8,
  0x1F, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xF0, 0xFE,
  0x00, 0x3C, 0xFF, 0xC0, 0x0F, 0x7F, 0xF0, 0x03, 0xDC, 0x7E, 0x00, 0xFE,
  0x0F, 0x80, 0x7F, 0x01, 0xE0, 0x1F, 0x80, 0x78, 0x07, 0xE0, 0x1F, 0x01,
  0xF0, 0x07, 0xC0, 0x7C, 0x01, 0xF0, 0x3E, 0x00, 0x78, 0x0F, 0x80, 0x1E,
  0x03, 0xC0, 0x07, 0x80, 0xF0, 0x01, 0xE0, 0x3C, 0x00, 0xF8, 0x1F, 0x00,
  0x3E, 0x07, 0x80, 0x0F, 0x01, 0xE0, 0x03, 0xC0, 0x78, 0x01, 0xF0, 0x3E,
  0x00, 0x7C, 0x0F, 0x80, 0x3E, 0x03, 0xE0, 0x0F, 0x80, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x1F, 0xC0, 0xF8, 0x07, 0xB8, 0xFC, 0x01, 0xEF, 0xFF,
  0x00, 0x79, 0xFF, 0x00, 0x1E, 0x3F, 0x80, 0x0F, 0x81, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x1E, 0x03, 0xFF, 0x38, 0x0F, 0xFE, 0xF0, 0x3F,
  0x1F, 0xE0, 0xFC, 0x1F, 0xC1, 0xF0, 0x1F, 0x87, 0xC0, 0x3E, 0x0F, 0x00,
  0x7C, 0x3E, 0x00, 0xF8, 0x78, 0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x07,
  0x87, 0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF8,
  0xF8, 0x01, 0xE1, 0xE0, 0x03, 0xC3, 0xC0, 0x0F, 0x87, 0x80, 0x1F, 0x0F,
  0x00, 0x7C, 0x1E, 0x00, 0xF8, 0x3C, 0x03, 0xF0, 0x78, 0x0F, 0xE0, 0xF8,
  0x3F, 0xC1, 0xF8, 0xFF, 0x01, 0xFF, 0xDE, 0x03, 0xFF, 0x3C, 0x03, 0xFC,
  0xF8, 0x00, 0x81, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC7, 0xE0, 0x79, 0xFC, 0x0F, 0x7F, 0x01, 0xFF,
  0xE0, 0x3B, 0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xFF, 0x80, 0x7F, 0xFC, 0x1F, 0xFF, 0x87, 0xE1, 0xE0, 0xF8, 0x04,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x80, 0x3E, 0x1E,
  0x1F, 0x83, 0xFF, 0xF0, 0x7F, 0xFC, 0x07, 0xFE, 0x00, 0x06, 0x00, 0x00,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78,
  0x07, 0xFF, 0x7F, 0xFD, 0xFF, 0xF7, 0xFF, 0x83, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3E,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF8, 0x83, 0xFE, 0x07,
  0xF8, 0x1F, 0xE0, 0x08, 0x00, 0x0F, 0x80, 0x3C, 0x3E, 0x00, 0xF0, 0xF0,
  0x03, 0xC3, 0xC0, 0x1F, 0x1F, 0x00, 0x78, 0x7C, 0x01, 0xE1, 0xE0, 0x07,
  0x87, 0x80, 0x3E, 0x1E, 0x00, 0xF8, 0xF8, 0x03, 0xC3, 0xE0, 0x0F, 0x0F,
  0x00, 0x3C, 0x3C, 0x01, 0xF0, 0xF0, 0x07, 0xC7, 0xC0, 0x1E, 0x1F, 0x00,
  0x78, 0x78, 0x03, 0xE1, 0xE0, 0x0F, 0x8F, 0x80, 0x3C, 0x3E, 0x01, 0xF0,
  0xF0, 0x07, 0xC3, 0xC0, 0x1F, 0x0F, 0x00, 0xFC, 0x3C, 0x07, 0xE0, 0xF8,
  0x3F, 0x83, 0xF3, 0xDE, 0x0F, 0xFF, 0x78, 0x1F, 0xF9, 0xE0, 0x3F, 0x87,
  0x00, 0x38, 0x00, 0x00, 0xF0, 0x01, 0xFF, 0x00, 0x1E, 0xF0, 0x03, 0xEF,
  0x00, 0x3C, 0xF0, 0x07, 0xCF, 0x00, 0x78, 0xF8, 0x0F, 0x8F, 0x80, 0xF0,
  0xF8, 0x0F, 0x0F, 0x81, 0xF0, 0xF8, 0x1E, 0x07, 0x83, 0xE0, 0x78, 0x3C,
  0x07, 0x87, 0xC0, 0x78, 0x78, 0x07, 0x8F, 0x80, 0x78, 0xF0, 0x07, 0x8F,
  0x00, 0x79, 0xE0, 0x07, 0x9E, 0x00, 0x7B, 0xC0, 0x07, 0xBC, 0x00, 0x7F,
  0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0xF8, 0x07, 0xC0,
  0x1E, 0xF0, 0x0F, 0xC0, 0x3E, 0xF0, 0x0F, 0xC0, 0x3C, 0xF0, 0x0F, 0xC0,
  0x7C, 0xF0, 0x1F, 0xC0, 0x78, 0xF0, 0x1D, 0xC0, 0x78, 0xF0, 0x3D, 0xC0,
  0xF8, 0xF0, 0x3D, 0xC0, 0xF0, 0xF0, 0x39, 0xC1, 0xF0, 0xF0, 0x79, 0xC1,
  0xE0, 0xF0, 0x71, 0xC1, 0xE0, 0xF0, 0xF1, 0xC3, 0xC0, 0xF0, 0xF1, 0xC3,
  0xC0, 0xF1, 0xE1, 0xC7, 0xC0, 0xF1, 0xE1, 0xC7, 0x80, 0xF1, 0xC1, 0xC7,
  0x80, 0xF3, 0xC1, 0xCF, 0x00, 0xF3, 0xC1, 0xCF, 0x00, 0xF7, 0x81, 0xDF,
  0x00, 0xF7, 0x83, 0xDE, 0x00, 0xF7, 0x03, 0xDE, 0x00, 0xFF, 0x03, 0xFC,
  0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x03, 0xF8,
  0x00, 0xFC, 0x03, 0xF8, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0xFC, 0x03, 0xF0,
  0x00, 0x03, 0xE0, 0x0F, 0x81, 0xF0, 0x0F, 0x80, 0x78, 0x0F, 0x80, 0x3C,
  0x07, 0x80, 0x1F, 0x07, 0xC0, 0x07, 0x87, 0xC0, 0x03, 0xC3, 0xC0, 0x01,
  0xE3, 0xE0, 0x00, 0xFB, 0xE0, 0x00, 0x3D, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7B, 0xC0,
  0x00, 0x7D, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x3C, 0x3C, 0x00, 0x3E, 0x1E,
  0x00, 0x3E, 0x0F, 0x00, 0x1E, 0x07, 0xC0, 0x1F, 0x01, 0xE0, 0x1F, 0x00,
  0xF0, 0x0F, 0x00, 0x7C, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0xF8, 0x01, 0xF0,
  0x0F, 0x80, 0x1F, 0x00, 0xF8, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xC0, 0x07, 0x80, 0x7C, 0x00, 0x78, 0x07, 0x80, 0x07, 0x80, 0xF8,
  0x00, 0x78, 0x0F, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x78, 0x1E, 0x00, 0x07,
  0x83, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x78, 0x78,
  0x00, 0x07, 0x87, 0x80, 0x00, 0x78, 0xF0, 0x00, 0x07, 0x8F, 0x00, 0x00,
  0x79, 0xF0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x03, 0xBC,
  0x00, 0x00, 0x3B, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0x78, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03,
  0xC0, 0x00, 0x3E, 0x00, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x10, 0x00, 0x3F, 0x00, 0x0F, 0xF0,
  0x01, 0xFF, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x7F,
  0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07,
  0xE0, 0x00, 0x02, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x30, 0x00, 0x07, 0xE0,
  0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xF0, 0x00, 0xFC, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x09, 0xFE, 0x00,
  0x7F, 0xFC, 0x07, 0xFF, 0xFC, 0xFF, 0x3F, 0xFF, 0xE0, 0x3F, 0xFA, 0x00,
  0x7F, 0x80,
};

const GFXglyph NotoSans_Condensed_Italic54pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 13, 40, 13, 1, -39 },
  { 66, 15, 14, 19, 6, -39 },
  { 93, 28, 39, 26, 0, -39 },
  { 230, 23, 44, 24, 1, -41 },
  { 357, 31, 40, 36, 3, -39 },
  { 512, 26, 40, 27, 0, -39 },
  { 642, 7, 14, 11, 6, -39 },
  { 655, 17, 48, 14, 1, -39 },
  { 757, 17, 48, 14, -4, -39 },
  { 859, 19, 20, 23, 5, -41 },
  { 907, 21, 26, 26, 3, -32 },
  { 976, 9, 13, 12, -2, -6 },
  { 991, 13, 5, 15, 1, -17 },
  { 1000, 6, 7, 12, 1, -6 },
  { 1006, 26, 39, 18, -3, -39 },
  { 1133, 21, 40, 24, 2, -39 },
  { 1238, 15, 39, 24, 6, -39 },
  { 1312, 24, 39, 24, -1, -39 },
  { 1429, 23, 40, 24, 0, -39 },
  { 1544, 25, 39, 24, -1, -39 },
  { 1666, 24, 40, 24, 0, -39 },
  { 1786, 23, 40, 24, 2, -39 },
  { 1901, 23, 39, 24, 2, -39 },
  { 2014, 24, 40, 24, 0, -39 },
  { 2134, 22, 40, 24, 1, -39 },
  { 2244, 11, 30, 12, 0, -29 },
  { 2286, 14, 36, 12, -3, -29 },
  { 2349, 21, 25, 26, 3, -32 },
  { 2415, 21, 16, 26, 3, -27 },
  { 2457, 21, 25, 26, 3, -32 },
  { 2523, 18, 40, 18, 2, -39 },
  { 2613, 33, 44, 36, 2, -39 },
  { 2795, 24, 39, 24, -3, -39 },
  { 2912, 25, 39, 26, 1, -39 },
  { 3034, 25, 40, 24, 3, -39 },
  { 3159, 26, 39, 28, 1, -39 },
  { 3286, 23, 39, 22, 1, -39 },
  { 3399, 24, 39, 21, 1, -39 },
  { 3516, 27, 40, 30, 3, -39 },
  { 3651, 29, 39, 29, 1, -39 },
  { 3793, 21, 39, 15, -2, -39 },
  { 3896, 21, 49, 12, -8, -39 },
  { 4025, 28, 39, 24, 1, -39 },
  { 4162, 16, 39, 20, 1, -39 },
  { 4240, 38, 39, 38, 1, -39 },
  { 4426, 31, 39, 31, 1, -39 },
  { 4578, 27, 40, 30, 2, -39 },
  { 4713, 24, 39, 24, 1, -39 },
  { 4830, 27, 48, 30, 2, -39 },
  { 4992, 24, 39, 25, 1, -39 },
  { 5109, 25, 40, 22, -1, -39 },
  { 5234, 21, 39, 21, 4, -39 },
  { 5337, 27, 40, 29, 3, -39 },
  { 5472, 24, 39, 24, 5, -39 },
  { 5589, 38, 39, 39, 5, -39 },
  { 5775, 30, 39, 23, -3, -39 },
  { 5922, 21, 39, 22, 5, -39 },
  { 6025, 26, 39, 21, -2, -39 },
  { 6152, 20, 48, 15, -1, -39 },
  { 6272, 9, 39, 19, 6, -39 },
  { 6316, 21, 48, 15, -4, -39 },
  { 6442, 23, 22, 24, 1, -39 },
  { 6506, 19, 3, 18, -5, 5 },
  { 6514, 8, 8, 14, 8, -41 },
  { 6522, 23, 30, 25, 2, -29 },
  { 6609, 24, 42, 25, 0, -41 },
  { 6735, 19, 30, 19, 2, -29 },
  { 6807, 25, 42, 25, 2, -41 },
  { 6939, 19, 30, 23, 2, -29 },
  { 7011, 26, 54, 14, -6, -41 },
  { 7187, 25, 42, 25, 0, -29 },
  { 7319, 23, 41, 25, 0, -41 },
  { 7437, 13, 40, 11, 0, -40 },
  { 7502, 20, 53, 11, -7, -40 },
  { 7635, 24, 41, 22, 0, -41 },
  { 7758, 14, 41, 11, 0, -41 },
  { 7830, 35, 29, 37, 0, -29 },
  { 7957, 23, 30, 25, 0, -30 },
  { 8044, 21, 29, 25, 2, -29 },
  { 8121, 26, 42, 25, -2, -29 },
  { 8258, 23, 42, 25, 2, -29 },
  { 8379, 19, 29, 17, 0, -29 },
  { 8448, 19, 30, 19, 0, -29 },
  { 8520, 14, 37, 14, 2, -36 },
  { 8585, 22, 30, 25, 2, -29 },
  { 8668, 20, 29, 20, 3, -29 },
  { 8741, 32, 29, 32, 3, -29 },
  { 8857, 25, 29, 21, -2, -29 },
  { 8948, 28, 42, 20, -5, -29 },
  { 9095, 21, 29, 18, -2, -29 },
  { 9172, 20, 48, 18, 1, -39 },
  { 9292, 4, 54, 23, 10, -41 },
  { 9319, 20, 48, 18, -3, -39 },
  { 9439, 21, 7, 26, 3, -23 },
};

const GFXfont NotoSans_Condensed_Italic54pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Italic54pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Italic54pt7bGlyphs,
  0x20, 0x7E, 74
};

#endif // _NOTOSANS_CONDENSED_ITALIC54PT7B_H_
