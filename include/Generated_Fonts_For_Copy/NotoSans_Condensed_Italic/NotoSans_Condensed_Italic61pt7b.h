#ifndef _NOTOSANS_CONDENSED_ITALIC61PT7B_H_
#define _NOTOSANS_CONDENSED_ITALIC61PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Italic.ttf
// Size: 61pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Italic61pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x1F, 0x00, 0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x03,
  0x00, 0x00, 0x1F, 0x0F, 0xCF, 0xC3, 0xE3, 0xE0, 0xF8, 0xF8, 0x3E, 0x3E,
  0x0F, 0x8F, 0x87, 0xC3, 0xC1, 0xF0, 0xF0, 0x7C, 0x7C, 0x1E, 0x1F, 0x07,
  0x87, 0x81, 0xE1, 0xE0, 0x78, 0x78, 0x3C, 0x1E, 0x0F, 0x0F, 0x03, 0xC3,
  0xC0, 0xF0, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x38,
  0x0F, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0xF0, 0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x78, 0x0F, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x1C, 0x07, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xE0, 0x78, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x1E, 0x03, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0x01, 0xE0, 0x78, 0x00,
  0x07, 0x01, 0xE0, 0x00, 0x3C, 0x07, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xE0,
  0x78, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF0, 0x3C,
  0x00, 0x03, 0x80, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x78, 0x1E, 0x00,
  0x01, 0xC0, 0x78, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x00,
  0xF0, 0x3C, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFE, 0x71, 0xE0, 0x3E, 0x18, 0x10, 0x1F,
  0x0E, 0x00, 0x07, 0xC3, 0x80, 0x01, 0xE0, 0xE0, 0x00, 0x78, 0x38, 0x00,
  0x1E, 0x1C, 0x00, 0x07, 0x87, 0x00, 0x01, 0xF1, 0xC0, 0x00, 0x7C, 0x70,
  0x00, 0x0F, 0x9C, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x77, 0xE0, 0x00, 0x1C, 0xF8, 0x00, 0x0E, 0x3F,
  0x00, 0x03, 0x87, 0xC0, 0x00, 0xE1, 0xF0, 0x00, 0x38, 0x7C, 0x00, 0x0E,
  0x1F, 0x00, 0x07, 0x07, 0xC0, 0x01, 0xC3, 0xE0, 0x80, 0x70, 0xF8, 0x38,
  0x1C, 0x7C, 0x0F, 0xC6, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x00, 0xFF,
  0x00, 0x07, 0x80, 0x7F, 0xE0, 0x03, 0xE0, 0x3F, 0xF8, 0x00, 0xF0, 0x1F,
  0x1E, 0x00, 0x78, 0x07, 0x83, 0xC0, 0x1E, 0x03, 0xC0, 0xF0, 0x0F, 0x00,
  0xF0, 0x3C, 0x07, 0xC0, 0x7C, 0x0F, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0xF0,
  0x07, 0x80, 0xE0, 0x3C, 0x01, 0xE0, 0x78, 0x1E, 0x00, 0xF0, 0x1E, 0x0F,
  0x80, 0x3C, 0x07, 0x83, 0xC0, 0x0F, 0x01, 0xE1, 0xE0, 0x03, 0xC0, 0x78,
  0x78, 0x00, 0xF0, 0x3C, 0x3C, 0x00, 0x3C, 0x0F, 0x0F, 0x07, 0x0E, 0x03,
  0xC7, 0x87, 0xF3, 0x81, 0xE3, 0xE3, 0xFE, 0xE0, 0x78, 0xF1, 0xFF, 0xFC,
  0x3C, 0x78, 0xF8, 0xFF, 0x1F, 0x1E, 0x3C, 0x3F, 0xFF, 0x8F, 0x1E, 0x0F,
  0xFF, 0xC7, 0xC7, 0x83, 0xDF, 0xE1, 0xE3, 0xC0, 0xF3, 0xF0, 0xF0, 0xF0,
  0x3C, 0x00, 0x3C, 0x3C, 0x0F, 0x00, 0x1E, 0x1E, 0x03, 0xC0, 0x0F, 0x87,
  0x80, 0xF0, 0x03, 0xC1, 0xE0, 0x3C, 0x01, 0xF0, 0x78, 0x1F, 0x00, 0x78,
  0x3C, 0x07, 0x80, 0x3C, 0x0F, 0x01, 0xE0, 0x0F, 0x03, 0xC0, 0x78, 0x07,
  0x80, 0xF0, 0x3C, 0x03, 0xE0, 0x3C, 0x0F, 0x00, 0xF0, 0x0F, 0x03, 0xC0,
  0x78, 0x03, 0xC1, 0xE0, 0x1E, 0x00, 0xF0, 0xF8, 0x0F, 0x00, 0x1E, 0x7C,
  0x07, 0xC0, 0x07, 0xFE, 0x01, 0xE0, 0x01, 0xFF, 0x80, 0xF0, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3E, 0x1F,
  0x80, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x03, 0xE0,
  0x00, 0x78, 0x0F, 0x80, 0x01, 0xE0, 0x3E, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0x3E, 0x07, 0xC0, 0x00, 0xF8, 0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07,
  0x83, 0xE0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x01, 0xF7,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x1F,
  0x07, 0xEF, 0xC0, 0xF8, 0x3F, 0x1F, 0x03, 0xE1, 0xF8, 0x7E, 0x0F, 0x07,
  0xC0, 0xF8, 0x7C, 0x3E, 0x03, 0xE1, 0xF1, 0xF8, 0x07, 0xCF, 0x87, 0xC0,
  0x1F, 0x3E, 0x1F, 0x00, 0x7F, 0xF0, 0x7C, 0x00, 0xFF, 0x83, 0xE0, 0x03,
  0xFE, 0x0F, 0x80, 0x07, 0xF0, 0x3E, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x7E,
  0x03, 0xF0, 0x03, 0xFC, 0x07, 0xC0, 0x1F, 0xF0, 0x1F, 0x81, 0xFF, 0xE0,
  0x7F, 0xFF, 0xDF, 0x80, 0xFF, 0xFE, 0x3F, 0x01, 0xFF, 0xF0, 0xFC, 0x03,
  0xFF, 0x01, 0xF8, 0x01, 0xC0, 0x00, 0x00, 0x1F, 0x1F, 0x3F, 0x3E, 0x3E,
  0x3E, 0x3E, 0x3C, 0x3C, 0x7C, 0x78, 0x78, 0x78, 0x78, 0x70, 0xF0, 0x00,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F,
  0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x01, 0xC0, 0xE0, 0x0F, 0x87, 0x00, 0x7F, 0x78, 0x07, 0xFF, 0xCF,
  0xCF, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0xF3, 0x80, 0x0F, 0x9E, 0x00, 0xF8, 0xF0, 0x1F, 0x83, 0xC0,
  0x78, 0x1F, 0x01, 0xC0, 0xF8, 0x04, 0x07, 0xC0, 0x00, 0x18, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x03, 0xE0, 0x7C, 0x1F, 0x83, 0xE0, 0xFC, 0x1F, 0x03, 0xE0,
  0xF8, 0x1F, 0x03, 0xC0, 0xF8, 0x1E, 0x07, 0xC0, 0xF0, 0x3C, 0x00, 0x7F,
  0xFD, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3C, 0xFB, 0xFF, 0xFF,
  0xDF, 0xBE, 0x10, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0xFE, 0x7E, 0x01, 0xF8,
  0x3F, 0x01, 0xF0, 0x1F, 0x03, 0xE0, 0x1F, 0x07, 0xE0, 0x1F, 0x07, 0xC0,
  0x1F, 0x0F, 0xC0, 0x0F, 0x0F, 0x80, 0x0F, 0x0F, 0x80, 0x1F, 0x1F, 0x00,
  0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x3F, 0x00, 0x1F, 0x3E, 0x00,
  0x1F, 0x3E, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x7E, 0x00, 0x1F, 0x7C, 0x00,
  0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00,
  0x3E, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00,
  0xFC, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x01, 0xF8, 0xF8, 0x01,
  0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x03, 0xE0, 0xF8, 0x07, 0xE0, 0xF8, 0x07,
  0xC0, 0x7C, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0x7F, 0xFF, 0x00, 0x3F, 0xFE,
  0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x3F, 0x00, 0x7F, 0x00, 0xFF, 0x01, 0xFE, 0x07, 0xFE, 0x0F, 0xFE,
  0x1F, 0xBE, 0x3F, 0x3E, 0xFE, 0x7C, 0x7C, 0x7C, 0x70, 0x7C, 0x20, 0x7C,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xF1, 0xFE, 0x00, 0xF0, 0x0F, 0xC0, 0x1C,
  0x00, 0xF8, 0x01, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x01, 0xFC, 0x3F, 0xC0,
  0x38, 0x03, 0xF0, 0x0C, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0xE0,
  0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x08, 0x00,
  0x3F, 0x03, 0x80, 0x3F, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xBC, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x0F, 0x7C, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x78, 0xF8, 0x00,
  0x0F, 0x8F, 0x80, 0x01, 0xF0, 0xF0, 0x00, 0x1E, 0x1F, 0x00, 0x03, 0xC1,
  0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x07, 0x81, 0xF0, 0x00, 0xF0, 0x3E, 0x00,
  0x1F, 0x03, 0xE0, 0x01, 0xE0, 0x3E, 0x00, 0x3C, 0x03, 0xE0, 0x07, 0xC0,
  0x3C, 0x00, 0xF8, 0x07, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x3E, 0x00, 0x7C, 0x03, 0xC0, 0x07, 0x80, 0x7F, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF,
  0xFC, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x1F, 0xFF, 0x80,
  0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x20, 0x00, 0xFE, 0x07, 0x80, 0x7F, 0x80, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xC1, 0x80, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0x87, 0xF8, 0x03, 0xE7, 0xFF, 0x00, 0xFB, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8,
  0x0F, 0xF0, 0x7F, 0x07, 0xF8, 0x0F, 0xC1, 0xFC, 0x01, 0xF0, 0x7E, 0x00,
  0x7C, 0x1F, 0x80, 0x1F, 0x07, 0xC0, 0x07, 0xC1, 0xF0, 0x01, 0xF0, 0xFC,
  0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x01, 0xF0,
  0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x07,
  0xE0, 0xF8, 0x01, 0xF0, 0x1F, 0x00, 0xFC, 0x07, 0xC0, 0x7E, 0x01, 0xF8,
  0x3F, 0x80, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF,
  0x80, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0xFC, 0x1F, 0x80, 0x7E,
  0x03, 0xF0, 0x3F, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x07, 0xC0,
  0xF8, 0x01, 0xF0, 0x3C, 0x00, 0x7C, 0x0F, 0x00, 0x1F, 0x03, 0xE0, 0x07,
  0xC0, 0xF8, 0x03, 0xE0, 0x3E, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x01, 0xF0,
  0x3E, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0x80,
  0x0F, 0xE3, 0xF0, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x0F, 0x80, 0xF8, 0x03,
  0xF0, 0x7C, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC3, 0xE0,
  0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x0F, 0x00, 0x07, 0xC3,
  0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x0F, 0xC0, 0x1F,
  0x83, 0xF8, 0x0F, 0xC0, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x1F, 0xC7,
  0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0x80, 0x7C, 0x0F, 0xC0, 0x1F, 0x07, 0xC0,
  0x0F, 0x87, 0xE0, 0x07, 0xC3, 0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0xF8,
  0x00, 0xF8, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x1F,
  0x00, 0x0F, 0x8F, 0x80, 0x0F, 0xC7, 0xC0, 0x07, 0xE3, 0xE0, 0x07, 0xE1,
  0xF0, 0x03, 0xF0, 0xFC, 0x03, 0xF8, 0x3E, 0x03, 0xFC, 0x1F, 0xEF, 0xFE,
  0x0F, 0xFF, 0xDE, 0x03, 0xFF, 0xDF, 0x00, 0xFF, 0x8F, 0x80, 0x1F, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x01, 0x00,
  0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0xFE, 0x07,
  0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0xFC, 0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x1F, 0xC0, 0x7C, 0x01,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7E, 0x00, 0x7C, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0,
  0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00,
  0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x7F, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF,
  0xFE, 0x0F, 0x87, 0xF0, 0xE0, 0x3F, 0x08, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFC, 0x00, 0x0F, 0x80, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xE0, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0xF8,
  0x00, 0x00, 0xF0, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0x00, 0x1E, 0x07, 0xC0, 0x0F, 0xC0, 0x38, 0x1E, 0x00,
  0xFF, 0xE0, 0xF0, 0xF0, 0x0F, 0xFF, 0x03, 0xC3, 0xC0, 0x7F, 0xFC, 0x0F,
  0x1E, 0x03, 0xE0, 0xF0, 0x3C, 0x78, 0x1F, 0x03, 0xC0, 0xF1, 0xC0, 0x78,
  0x1E, 0x03, 0x8F, 0x03, 0xC0, 0x78, 0x0E, 0x3C, 0x0F, 0x01, 0xE0, 0x78,
  0xE0, 0x78, 0x07, 0x81, 0xE7, 0x81, 0xE0, 0x3C, 0x07, 0x9E, 0x07, 0x80,
  0xF0, 0x1E, 0x78, 0x3C, 0x03, 0xC0, 0xF1, 0xE0, 0xF0, 0x1F, 0x03, 0xCF,
  0x03, 0xC0, 0x78, 0x0F, 0x3C, 0x0F, 0x01, 0xE0, 0x38, 0xF0, 0x3C, 0x0F,
  0x81, 0xE3, 0xC0, 0xF0, 0x3E, 0x07, 0x8F, 0x03, 0xC0, 0xF0, 0x3C, 0x3C,
  0x0F, 0x07, 0xC0, 0xF0, 0xF0, 0x3C, 0x3F, 0x87, 0x83, 0xC0, 0xF9, 0xEF,
  0x7C, 0x0F, 0x03, 0xFF, 0x3F, 0xE0, 0x3C, 0x07, 0xF8, 0xFF, 0x00, 0xF0,
  0x0F, 0xC1, 0xF8, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x03, 0x00, 0x00, 0x3F, 0xE0, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xBC, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x0F, 0x3C,
  0x00, 0x01, 0xF3, 0xE0, 0x00, 0x1F, 0x3E, 0x00, 0x03, 0xE3, 0xE0, 0x00,
  0x3E, 0x3E, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0xC3,
  0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0x83, 0xE0, 0x01, 0xF0, 0x3E, 0x00,
  0x1F, 0x03, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x3E, 0x03, 0xE0, 0x07, 0xE0,
  0x3E, 0x00, 0x7C, 0x03, 0xE0, 0x07, 0xC0, 0x3E, 0x00, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x03, 0xF0,
  0x03, 0xE0, 0x3E, 0x00, 0x3E, 0x07, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x3E,
  0x0F, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x3F, 0x0F, 0x80, 0x03, 0xF1, 0xF8,
  0x00, 0x1F, 0x1F, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x01,
  0xF7, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0x80, 0x7F, 0x00, 0xF8, 0x03, 0xF0,
  0x1F, 0x80, 0x1F, 0x01, 0xF0, 0x01, 0xF0, 0x1F, 0x00, 0x1F, 0x01, 0xF0,
  0x01, 0xF0, 0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x1F,
  0x03, 0xE0, 0x03, 0xF0, 0x3E, 0x00, 0x3E, 0x03, 0xE0, 0x07, 0xE0, 0x7C,
  0x00, 0xFC, 0x07, 0xC0, 0x3F, 0x80, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xF8, 0x1F, 0xE0, 0x0F,
  0x80, 0x3F, 0x00, 0xF8, 0x01, 0xF0, 0x1F, 0x80, 0x1F, 0x81, 0xF0, 0x00,
  0xF8, 0x1F, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0xF8, 0x1F, 0x00, 0x0F, 0x83,
  0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0x83, 0xE0, 0x01, 0xF8, 0x3E, 0x00,
  0x1F, 0x03, 0xE0, 0x03, 0xF0, 0x7C, 0x00, 0x3F, 0x07, 0xC0, 0x07, 0xE0,
  0x7C, 0x01, 0xFE, 0x07, 0xC0, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00,
  0x7F, 0xE3, 0xE0, 0x0F, 0xF0, 0x04, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x0E, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xE0, 0x3F, 0xC0, 0x0F, 0x80,
  0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x01, 0xF0, 0x01, 0xF8, 0x07, 0xC0, 0x03,
  0xE0, 0x1F, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0xFC,
  0x0F, 0x80, 0x03, 0xF0, 0x3E, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x3F, 0x03,
  0xE0, 0x00, 0xFC, 0x1F, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x0F, 0xC1, 0xF0,
  0x00, 0x3F, 0x07, 0xC0, 0x00, 0xF8, 0x3F, 0x00, 0x03, 0xE0, 0xF8, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF8, 0x3E, 0x00, 0x07,
  0xC1, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xFC, 0x1F, 0x00, 0x03, 0xF0,
  0x7C, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x7E, 0x0F, 0x80, 0x01, 0xF0, 0x3E,
  0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x7E, 0x03, 0xE0, 0x01, 0xF8, 0x0F, 0x80,
  0x0F, 0xC0, 0x7C, 0x00, 0x7E, 0x01, 0xF0, 0x07, 0xF0, 0x07, 0xC0, 0x3F,
  0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFC, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x40,
  0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF8, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFE,
  0x1F, 0xC0, 0x1F, 0xE0, 0x07, 0x00, 0x7F, 0x00, 0x02, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0xFE, 0x3F, 0x00, 0x3F, 0xFC, 0x7E,
  0x00, 0x7F, 0xF0, 0xF8, 0x00, 0xFF, 0xE1, 0xF0, 0x00, 0x07, 0xC3, 0xE0,
  0x00, 0x0F, 0x87, 0xC0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x7C, 0x1F, 0x00,
  0x00, 0xF8, 0x3E, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0xF8, 0x00,
  0x0F, 0xC1, 0xF0, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x3E, 0x07, 0xE0, 0x00,
  0x7C, 0x07, 0xE0, 0x00, 0xF8, 0x0F, 0xC0, 0x03, 0xE0, 0x0F, 0xC0, 0x07,
  0xC0, 0x1F, 0xE0, 0x1F, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x07, 0xC0, 0x1F, 0x00,
  0x03, 0xE0, 0x1F, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x01, 0xF0, 0x07, 0xC0,
  0x00, 0xF8, 0x03, 0xE0, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x3E, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x3E,
  0x00, 0x07, 0xC0, 0x3E, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x03, 0xE0, 0x0F,
  0x80, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x7C, 0x03,
  0xE0, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0x80, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0xF8,
  0x07, 0xE0, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x0F,
  0x80, 0x3E, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x01,
  0xF0, 0x07, 0xC0, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0xF8, 0x03, 0xE0, 0x00,
  0x7C, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x7C, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x07, 0xC0, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x83, 0xF8, 0x00,
  0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x00,
  0xF8, 0x03, 0xF0, 0x00, 0xF8, 0x07, 0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x01,
  0xF0, 0x0F, 0x80, 0x01, 0xF0, 0x1F, 0x80, 0x01, 0xF0, 0x3F, 0x00, 0x01,
  0xF0, 0x7E, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x03,
  0xE1, 0xF8, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x07,
  0xC7, 0xC0, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x1F,
  0x87, 0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x1F,
  0x03, 0xE0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x3E,
  0x03, 0xF0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x3E,
  0x01, 0xF8, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x0F, 0xE0, 0x00, 0x03,
  0xFC, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x3F,
  0xC0, 0x00, 0x3F, 0xF0, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x07, 0xBE, 0x00, 0x07,
  0xBE, 0x00, 0xF7, 0xC0, 0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x00, 0x3C, 0xF0,
  0x07, 0xDF, 0x00, 0x0F, 0xBE, 0x00, 0xFB, 0xE0, 0x01, 0xE7, 0xC0, 0x1F,
  0x7C, 0x00, 0x7C, 0xF8, 0x03, 0xC7, 0x80, 0x0F, 0x1F, 0x00, 0xF8, 0xF0,
  0x03, 0xE7, 0xC0, 0x1F, 0x1E, 0x00, 0x78, 0xF8, 0x03, 0xE3, 0xC0, 0x1F,
  0x1F, 0x00, 0x7C, 0x78, 0x03, 0xC3, 0xE0, 0x1F, 0x0F, 0x00, 0xF8, 0x7C,
  0x03, 0xE1, 0xE0, 0x1E, 0x1F, 0x00, 0x7C, 0x3C, 0x07, 0xC3, 0xE0, 0x0F,
  0x87, 0xC0, 0xF8, 0x7C, 0x01, 0xE0, 0xF8, 0x3E, 0x0F, 0x80, 0x7C, 0x1F,
  0x07, 0xC3, 0xF0, 0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x3E,
  0x0F, 0x80, 0x3E, 0x0F, 0x8F, 0x81, 0xF0, 0x07, 0x81, 0xF1, 0xF0, 0x3E,
  0x01, 0xF0, 0x1E, 0x3C, 0x0F, 0x80, 0x3E, 0x03, 0xCF, 0x81, 0xF0, 0x07,
  0xC0, 0x79, 0xE0, 0x3E, 0x00, 0xF8, 0x0F, 0x7C, 0x07, 0xC0, 0x1E, 0x01,
  0xEF, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0xE0, 0x3E, 0x00, 0xF8, 0x07, 0xF8,
  0x07, 0xC0, 0x1F, 0x00, 0xFF, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0xC0, 0x1F,
  0x00, 0xF8, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x03, 0xE0, 0x0F, 0xC0, 0x00, 0x7C, 0x03, 0xF8, 0x00, 0x0F,
  0x00, 0x7F, 0x00, 0x03, 0xE0, 0x0F, 0xF0, 0x00, 0x7C, 0x01, 0xFE, 0x00,
  0x0F, 0x80, 0x3F, 0xC0, 0x01, 0xF0, 0x0F, 0xF8, 0x00, 0x3C, 0x01, 0xFF,
  0x80, 0x0F, 0x80, 0x3F, 0xF0, 0x01, 0xF0, 0x07, 0xBE, 0x00, 0x3E, 0x00,
  0xF3, 0xC0, 0x07, 0xC0, 0x3E, 0x78, 0x01, 0xF0, 0x07, 0xCF, 0x80, 0x3E,
  0x00, 0xF9, 0xF0, 0x07, 0xC0, 0x1F, 0x3E, 0x00, 0xF8, 0x03, 0xC3, 0xC0,
  0x1F, 0x00, 0xF8, 0x7C, 0x07, 0xC0, 0x1F, 0x0F, 0x80, 0xF8, 0x03, 0xE1,
  0xF0, 0x1F, 0x00, 0x7C, 0x1E, 0x03, 0xE0, 0x1F, 0x03, 0xE0, 0x78, 0x03,
  0xE0, 0x7C, 0x1F, 0x00, 0x7C, 0x0F, 0x83, 0xE0, 0x0F, 0x80, 0xF0, 0x7C,
  0x01, 0xE0, 0x1E, 0x0F, 0x80, 0x7C, 0x03, 0xE1, 0xE0, 0x0F, 0x80, 0x7C,
  0x7C, 0x01, 0xF0, 0x0F, 0x8F, 0x80, 0x3E, 0x00, 0xF1, 0xF0, 0x07, 0x80,
  0x1F, 0x3E, 0x01, 0xF0, 0x03, 0xE7, 0x80, 0x3E, 0x00, 0x7D, 0xF0, 0x07,
  0xC0, 0x07, 0xBE, 0x00, 0xF8, 0x00, 0xFF, 0xC0, 0x1E, 0x00, 0x1F, 0xF0,
  0x07, 0xC0, 0x03, 0xFE, 0x00, 0xF8, 0x00, 0x7F, 0xC0, 0x1F, 0x00, 0x07,
  0xF8, 0x03, 0xE0, 0x00, 0xFF, 0x00, 0xF8, 0x00, 0x1F, 0xC0, 0x1F, 0x00,
  0x03, 0xF8, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0x8F, 0xF0, 0x03, 0xF8, 0x0F, 0xE0, 0x1F,
  0x80, 0x1F, 0x80, 0xFC, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0xFC, 0x1F, 0x80,
  0x01, 0xF0, 0xFC, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x1F, 0x1F, 0x80, 0x00,
  0x7C, 0x7E, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x1F,
  0x3E, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x07, 0xDF,
  0x80, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x03, 0xEF, 0xC0,
  0x00, 0x0F, 0xBF, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0xFB, 0xE0, 0x00,
  0x07, 0xEF, 0x80, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x03,
  0xF3, 0xE0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x3E, 0x3E, 0x00, 0x01, 0xF8,
  0xF8, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0xF8, 0x3F,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x01, 0xF8, 0x01, 0xF8, 0x07, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x01, 0xF0, 0x3F, 0x80, 0x3E, 0x01,
  0xF8, 0x0F, 0xC0, 0x3F, 0x01, 0xF0, 0x03, 0xE0, 0x3E, 0x00, 0x7C, 0x07,
  0xC0, 0x0F, 0x80, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x3E, 0x07, 0xC0, 0x07,
  0xC0, 0xF8, 0x00, 0xF8, 0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x07, 0xE0, 0xF8,
  0x00, 0xF8, 0x1F, 0x00, 0x3F, 0x03, 0xE0, 0x0F, 0xC0, 0x7C, 0x03, 0xF8,
  0x1F, 0x80, 0xFE, 0x03, 0xE3, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0x8F,
  0xF0, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0x80, 0x1F, 0x80, 0xFC, 0x00, 0x3E,
  0x03, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xF0, 0xFC, 0x00, 0x07, 0xC3,
  0xF0, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x7C, 0x7E, 0x00, 0x01, 0xF1, 0xF0,
  0x00, 0x07, 0xCF, 0xC0, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x7C, 0xF8, 0x00,
  0x01, 0xF7, 0xE0, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x3F, 0x7C, 0x00, 0x00,
  0xFD, 0xF0, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x3E,
  0xFC, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x1F, 0x3E,
  0x00, 0x00, 0x7C, 0xF8, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x0F, 0xCF, 0x80,
  0x00, 0x3E, 0x3E, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x07, 0xC3, 0xE0, 0x00,
  0x3F, 0x0F, 0x80, 0x00, 0xF8, 0x3F, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x3F,
  0x01, 0xF8, 0x01, 0xFC, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0xFF, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xFF, 0x80,
  0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x01, 0xF0,
  0x3F, 0xC0, 0x3E, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x01, 0xF0, 0x03, 0xE0,
  0x3E, 0x00, 0x7C, 0x07, 0xC0, 0x0F, 0x80, 0xF8, 0x01, 0xF0, 0x3E, 0x00,
  0x3E, 0x07, 0xC0, 0x07, 0xC0, 0xF8, 0x00, 0xF8, 0x1F, 0x00, 0x3F, 0x03,
  0xE0, 0x07, 0xE0, 0xF8, 0x00, 0xF8, 0x1F, 0x00, 0x3F, 0x03, 0xE0, 0x0F,
  0xC0, 0x7C, 0x07, 0xF0, 0x1F, 0x8F, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7E, 0x1F, 0x00,
  0x0F, 0x81, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0xC0,
  0xF8, 0x01, 0xF0, 0x1F, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00,
  0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x07, 0xC0, 0x0F, 0x80, 0xF8, 0x01,
  0xF0, 0x1F, 0x00, 0x3E, 0x03, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x1F,
  0x00, 0x0F, 0x83, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xE0, 0x0C, 0x01, 0xFC, 0x00, 0x40, 0x1F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x08, 0x00, 0x0F, 0xC0, 0x60,
  0x03, 0xF8, 0x07, 0xC0, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF0,
  0x1F, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x0F, 0x81,
  0xF0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0xF8, 0x0F,
  0x80, 0x01, 0xF0, 0x3F, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0xC0, 0xF8,
  0x00, 0x1F, 0x01, 0xF0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x80,
  0x00, 0xF8, 0x1F, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x07, 0xC0, 0x7C, 0x00,
  0x0F, 0x80, 0xF8, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7E, 0x07, 0xC0, 0x00,
  0xF8, 0x0F, 0x80, 0x01, 0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x07,
  0xC0, 0xF8, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x7C,
  0x07, 0xC0, 0x00, 0xF8, 0x1F, 0x80, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC0,
  0x7C, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x7E, 0x03,
  0xE0, 0x00, 0xF8, 0x07, 0xC0, 0x01, 0xF0, 0x0F, 0x80, 0x07, 0xC0, 0x1F,
  0x80, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3E, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x0F,
  0xC7, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x87, 0xC0, 0x01, 0xF0, 0x7C,
  0x00, 0x3F, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x07,
  0xC0, 0x7C, 0x00, 0x7C, 0x07, 0xC0, 0x0F, 0xC0, 0x7C, 0x00, 0xF8, 0x07,
  0xC0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03,
  0xE0, 0x07, 0xC0, 0x3E, 0x00, 0x7C, 0x07, 0xC0, 0x07, 0xC0, 0x7C, 0x00,
  0x7C, 0x0F, 0x80, 0x07, 0xC0, 0xF8, 0x00, 0x7C, 0x1F, 0x80, 0x07, 0xC1,
  0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x3E, 0x00,
  0x07, 0xC7, 0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x3C,
  0xF8, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x3D, 0xF0, 0x00, 0x03, 0xDF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xF7, 0xC0,
  0x01, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xE7, 0xC0, 0x03,
  0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x3F, 0x00, 0x07, 0xC7, 0xC0, 0x03, 0xF0,
  0x00, 0xF8, 0x7C, 0x00, 0x7F, 0x00, 0x0F, 0x87, 0xC0, 0x07, 0xF0, 0x01,
  0xF8, 0x7C, 0x00, 0xFF, 0x00, 0x1F, 0x07, 0xC0, 0x0F, 0xF0, 0x01, 0xF0,
  0x7C, 0x00, 0xFF, 0x00, 0x3E, 0x07, 0xC0, 0x1E, 0xF0, 0x03, 0xE0, 0x78,
  0x01, 0xEF, 0x00, 0x7E, 0x07, 0x80, 0x3E, 0xF0, 0x07, 0xC0, 0x78, 0x03,
  0xCF, 0x00, 0x7C, 0x07, 0x80, 0x7C, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0x8F,
  0x00, 0xF8, 0x07, 0x80, 0x78, 0xF0, 0x1F, 0x00, 0x78, 0x0F, 0x8F, 0x01,
  0xF0, 0x07, 0x80, 0xF0, 0xF0, 0x1F, 0x00, 0x78, 0x1F, 0x0F, 0x03, 0xE0,
  0x07, 0x81, 0xE0, 0xF0, 0x3E, 0x00, 0x78, 0x1E, 0x0F, 0x07, 0xC0, 0x07,
  0x83, 0xE0, 0xF0, 0x7C, 0x00, 0x78, 0x3C, 0x0F, 0x07, 0xC0, 0x07, 0x87,
  0xC0, 0xF0, 0xF8, 0x00, 0x78, 0x78, 0x0F, 0x0F, 0x80, 0x07, 0x87, 0x80,
  0xF1, 0xF0, 0x00, 0x78, 0xF8, 0x0F, 0x1F, 0x00, 0x07, 0x8F, 0x00, 0xF1,
  0xF0, 0x00, 0x79, 0xF0, 0x0F, 0x3E, 0x00, 0x07, 0x9E, 0x00, 0xF3, 0xE0,
  0x00, 0x79, 0xE0, 0x0F, 0x7C, 0x00, 0x07, 0xBC, 0x00, 0xF7, 0xC0, 0x00,
  0x7B, 0xC0, 0x0F, 0x78, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x03, 0xF0, 0x07, 0xC0, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x7C, 0x03, 0xE0,
  0x00, 0x3E, 0x03, 0xF0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x07, 0xC1, 0xF0,
  0x00, 0x03, 0xE0, 0xF8, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x00, 0xF8, 0xF8,
  0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0x0F, 0xBE,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07,
  0xDF, 0x00, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x03,
  0xE1, 0xF0, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x01,
  0xF0, 0x3E, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00,
  0xFC, 0x03, 0xE0, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0xF8, 0x00,
  0x7E, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x0F, 0x80,
  0x3F, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F,
  0xFE, 0x00, 0x0F, 0x9F, 0x00, 0x0F, 0xCF, 0x80, 0x07, 0xC7, 0xC0, 0x07,
  0xE3, 0xE0, 0x03, 0xE1, 0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x3E, 0x01,
  0xF0, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0xFC, 0x03, 0xE0,
  0x7C, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0x3C, 0x3E, 0x00, 0x1F,
  0x1F, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xEF, 0x80, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x3F,
  0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xF8, 0x1F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xF0, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x01, 0xFF, 0xC0, 0x07, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x7D,
  0xF0, 0x00, 0x1E, 0x3C, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xC3, 0xE0, 0x01,
  0xF0, 0x78, 0x00, 0x78, 0x1F, 0x00, 0x3E, 0x03, 0xC0, 0x1F, 0x00, 0xF0,
  0x07, 0x80, 0x3E, 0x03, 0xE0, 0x07, 0x80, 0xF0, 0x01, 0xE0, 0x7C, 0x00,
  0x7C, 0x1E, 0x00, 0x0F, 0x0F, 0x80, 0x03, 0xC3, 0xC0, 0x00, 0xF9, 0xF0,
  0x00, 0x1E, 0xF8, 0x00, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xE0, 0xFC, 0x7E, 0x1F, 0x0F, 0x83, 0xE1, 0xF0,
  0x78, 0x1E, 0x0F, 0x03, 0xC0, 0x00, 0x3F, 0x83, 0xC0, 0x1F, 0xF0, 0xF0,
  0x1F, 0xFE, 0x7C, 0x0F, 0xFF, 0xDE, 0x03, 0xF0, 0xF7, 0x81, 0xF8, 0x0F,
  0xE0, 0xFC, 0x03, 0xF8, 0x3E, 0x00, 0xFE, 0x1F, 0x80, 0x1F, 0x07, 0xC0,
  0x07, 0xC3, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x1F,
  0x80, 0x0F, 0x87, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x3E,
  0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x01, 0xF0, 0xF8, 0x00,
  0x7C, 0x3E, 0x00, 0x3F, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x07, 0xE0, 0xF8,
  0x01, 0xF8, 0x3E, 0x00, 0xFE, 0x0F, 0x80, 0x3F, 0x83, 0xF0, 0x1F, 0xC0,
  0x7C, 0x0E, 0xF0, 0x1F, 0xFF, 0x7C, 0x07, 0xFF, 0x9F, 0x00, 0xFF, 0xC7,
  0x80, 0x1F, 0xE1, 0xE0, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xE1, 0xFC, 0x00, 0x7C, 0x7F, 0xC0, 0x0F,
  0xBF, 0xFC, 0x01, 0xEF, 0xFF, 0xC0, 0x3D, 0xE1, 0xF8, 0x0F, 0xF0, 0x1F,
  0x01, 0xFC, 0x03, 0xE0, 0x3F, 0x80, 0x7E, 0x07, 0xE0, 0x0F, 0xC1, 0xF8,
  0x00, 0xF8, 0x3F, 0x00, 0x3F, 0x07, 0xC0, 0x07, 0xE0, 0xF8, 0x00, 0xF8,
  0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x1F, 0x00,
  0x0F, 0x83, 0xE0, 0x01, 0xF0, 0x78, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x83,
  0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x7E, 0x0F, 0x80, 0x0F, 0x83, 0xF0, 0x01,
  0xF0, 0x7E, 0x00, 0x7C, 0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x03, 0xE0, 0x3F,
  0x80, 0xFC, 0x0F, 0xF0, 0x3F, 0x01, 0xFF, 0xFF, 0xC0, 0x3C, 0xFF, 0xF0,
  0x07, 0x8F, 0xFC, 0x01, 0xF0, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0x03,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x30, 0x3F, 0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x0F,
  0xFC, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x1F, 0xC3, 0xE0, 0x01, 0xFF, 0x1F, 0x00,
  0x3F, 0xFC, 0xF8, 0x03, 0xFF, 0xF7, 0x80, 0x1F, 0x83, 0xFC, 0x01, 0xF8,
  0x0F, 0xE0, 0x1F, 0x80, 0x7F, 0x00, 0xF8, 0x01, 0xF0, 0x0F, 0xC0, 0x0F,
  0x80, 0x7C, 0x00, 0x7C, 0x07, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x1F, 0x01,
  0xF0, 0x01, 0xF0, 0x1F, 0x80, 0x0F, 0x80, 0xF8, 0x00, 0x7C, 0x07, 0xC0,
  0x03, 0xE0, 0x3E, 0x00, 0x1F, 0x03, 0xF0, 0x01, 0xF0, 0x1F, 0x00, 0x0F,
  0x80, 0xF8, 0x00, 0x7C, 0x07, 0xC0, 0x07, 0xE0, 0x3E, 0x00, 0x3E, 0x01,
  0xF0, 0x01, 0xF0, 0x0F, 0x80, 0x1F, 0x80, 0x7C, 0x00, 0xFC, 0x03, 0xE0,
  0x0F, 0xE0, 0x1F, 0x00, 0xFE, 0x00, 0xFC, 0x07, 0xF0, 0x07, 0xE0, 0xFF,
  0x80, 0x1F, 0xFF, 0x7C, 0x00, 0xFF, 0xF3, 0xE0, 0x03, 0xFF, 0x1E, 0x00,
  0x0F, 0xF0, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x01,
  0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0xFF, 0xFF, 0x03, 0xF0, 0xFC, 0x1F, 0x81,
  0xF0, 0xFC, 0x07, 0xC3, 0xE0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xF3,
  0xE0, 0x07, 0xCF, 0x80, 0x3E, 0x7E, 0x01, 0xF9, 0xF0, 0x1F, 0xC7, 0xDF,
  0xFE, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x03, 0xFF, 0xE0, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x10, 0x7E, 0x01, 0xC1, 0xFF, 0x7F, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF0,
  0x07, 0xFF, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0xF0, 0x01, 0xFF, 0x8F, 0x00, 0x7F, 0xF9, 0xF0, 0x0F, 0xFF,
  0xDE, 0x00, 0xFC, 0x1D, 0xE0, 0x1F, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xE0,
  0x3E, 0x00, 0xFC, 0x07, 0xE0, 0x07, 0xC0, 0x7C, 0x00, 0x7C, 0x0F, 0xC0,
  0x07, 0xC0, 0xF8, 0x00, 0xFC, 0x0F, 0x80, 0x0F, 0x81, 0xF8, 0x00, 0xF8,
  0x1F, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0xF8, 0x1F, 0x00, 0x0F, 0x83, 0xF0,
  0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x03, 0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x3F,
  0x03, 0xE0, 0x03, 0xF0, 0x3E, 0x00, 0x3E, 0x03, 0xE0, 0x07, 0xE0, 0x3E,
  0x00, 0x7E, 0x03, 0xE0, 0x0F, 0xE0, 0x3E, 0x01, 0xFC, 0x03, 0xF0, 0x3F,
  0xC0, 0x3F, 0x07, 0xFC, 0x01, 0xFF, 0xF7, 0xC0, 0x1F, 0xFF, 0x7C, 0x00,
  0xFF, 0xC7, 0x80, 0x07, 0xF8, 0xF8, 0x00, 0x1C, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x08, 0x00,
  0x7C, 0x00, 0xE0, 0x1F, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x3F, 0x80, 0x1F, 0x3F, 0xF0,
  0x07, 0xDF, 0xFE, 0x01, 0xEF, 0xFF, 0x80, 0x7B, 0xC7, 0xF0, 0x3F, 0xC0,
  0xFC, 0x0F, 0xE0, 0x1F, 0x03, 0xF0, 0x07, 0xC0, 0xFC, 0x01, 0xF0, 0x7E,
  0x00, 0x7C, 0x1F, 0x80, 0x1E, 0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x03, 0xE0,
  0x7C, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x07,
  0xC0, 0xF8, 0x01, 0xF0, 0x3C, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x07, 0xC0,
  0x0F, 0x81, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x0F,
  0x80, 0x0F, 0x83, 0xE0, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x7C,
  0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x07, 0x81, 0xF0, 0x03, 0xE0, 0x7C, 0x00,
  0xF8, 0x3F, 0x00, 0x3E, 0x00, 0x00, 0x1C, 0x00, 0x7C, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x0F, 0xC0, 0x7C,
  0x03, 0xF0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x1F, 0x00, 0x3C, 0x07, 0xC0,
  0x0F, 0x81, 0xF8, 0x01, 0xF0, 0x7E, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC3,
  0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x3F, 0x00, 0x07, 0xCF, 0xC0, 0x00,
  0xFB, 0xF0, 0x00, 0x1E, 0x7C, 0x00, 0x07, 0xDF, 0x80, 0x00, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0x7C, 0x00, 0x1F,
  0xCF, 0x80, 0x03, 0xF1, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x83, 0xE0,
  0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x0F, 0xC0, 0x0F, 0x80, 0xF8, 0x01, 0xF0,
  0x1F, 0x00, 0x3E, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0,
  0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F,
  0x00, 0x00, 0x01, 0xE0, 0xFE, 0x03, 0xF8, 0x01, 0xE3, 0xFF, 0x0F, 0xFC,
  0x01, 0xE7, 0xFF, 0x1F, 0xFE, 0x01, 0xEF, 0xFF, 0xBF, 0xFF, 0x01, 0xFE,
  0x1F, 0xBC, 0x3F, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0x03, 0xF8, 0x0F, 0xE0,
  0x1F, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x0F,
  0x80, 0x3E, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x1F, 0x00, 0x3E,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x0F, 0x80,
  0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x0F, 0x80, 0x3E, 0x00,
  0x7C, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x1F,
  0x00, 0x3E, 0x00, 0xF8, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x01, 0xF0,
  0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x03,
  0xE0, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x01,
  0xE0, 0xFE, 0x00, 0x78, 0xFF, 0xC0, 0x1E, 0x7F, 0xF8, 0x07, 0xBF, 0xFF,
  0x03, 0xFF, 0x1F, 0xC0, 0xFF, 0x03, 0xF0, 0x3F, 0x80, 0x7C, 0x0F, 0xC0,
  0x1F, 0x03, 0xF0, 0x07, 0xC1, 0xF8, 0x01, 0xF0, 0x7E, 0x00, 0xFC, 0x1F,
  0x00, 0x3E, 0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x03, 0xE0, 0xF8, 0x00, 0xF8,
  0x3E, 0x00, 0x7E, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x07, 0xC1, 0xF8, 0x01,
  0xF0, 0x7C, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x07, 0xC0, 0x0F, 0x81, 0xF0,
  0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x03,
  0xE0, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x1F, 0x00, 0x3F,
  0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x03, 0xE0, 0xFC, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x03,
  0xF0, 0xFE, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0x3E, 0x0F, 0x80, 0x3E, 0x1F,
  0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x3E,
  0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C,
  0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x7E, 0xF8,
  0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0xF8, 0xF8,
  0x01, 0xF8, 0xF8, 0x01, 0xF0, 0xF8, 0x03, 0xF0, 0x7C, 0x07, 0xE0, 0x7E,
  0x0F, 0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x40, 0x00, 0x00, 0x7C, 0x3F, 0x80, 0x03, 0xC3, 0xFE,
  0x00, 0x1E, 0x7F, 0xF8, 0x00, 0xF3, 0xFF, 0xE0, 0x07, 0xBC, 0x3F, 0x00,
  0x7F, 0x80, 0xF8, 0x03, 0xF8, 0x07, 0xC0, 0x1F, 0xC0, 0x3F, 0x00, 0xFC,
  0x00, 0xF8, 0x0F, 0xC0, 0x07, 0xC0, 0x7E, 0x00, 0x3E, 0x03, 0xF0, 0x03,
  0xF0, 0x1F, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0xF8, 0x0F, 0x80, 0x07, 0xC0,
  0x7C, 0x00, 0x3E, 0x03, 0xE0, 0x01, 0xF0, 0x1F, 0x00, 0x0F, 0x80, 0xF0,
  0x00, 0xF8, 0x0F, 0x80, 0x07, 0xC0, 0x7C, 0x00, 0x3E, 0x03, 0xE0, 0x03,
  0xF0, 0x1F, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0xF8, 0x0F, 0xC0, 0x0F, 0x80,
  0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0xC0, 0x7E, 0x01, 0xFE,
  0x07, 0xE0, 0x0F, 0xBF, 0xFE, 0x00, 0x7D, 0xFF, 0xF0, 0x03, 0xE7, 0xFE,
  0x00, 0x1F, 0x1F, 0xE0, 0x01, 0xF0, 0x10, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x83, 0xC0,
  0x1F, 0xF8, 0xF0, 0x1F, 0xFE, 0x7C, 0x0F, 0xFF, 0xDE, 0x03, 0xF0, 0xF7,
  0x81, 0xF8, 0x0F, 0xE0, 0xFC, 0x03, 0xF8, 0x3E, 0x00, 0xFC, 0x1F, 0x80,
  0x1F, 0x07, 0xC0, 0x07, 0xC3, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xFC, 0x3E,
  0x00, 0x3E, 0x1F, 0x80, 0x0F, 0x87, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xF8,
  0x7C, 0x00, 0x3E, 0x3F, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x01,
  0xF0, 0xF8, 0x00, 0xFC, 0x3E, 0x00, 0x3F, 0x0F, 0x80, 0x0F, 0x83, 0xE0,
  0x07, 0xE0, 0xF8, 0x01, 0xF8, 0x3E, 0x00, 0xFE, 0x0F, 0x80, 0x7F, 0x03,
  0xF0, 0x3F, 0xC0, 0xFC, 0x1F, 0xF0, 0x1F, 0xFF, 0x7C, 0x07, 0xFF, 0x9F,
  0x00, 0xFF, 0xC7, 0x80, 0x1F, 0xE3, 0xE0, 0x01, 0xC0, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE1, 0xFC, 0x07,
  0x8F, 0xE0, 0x1E, 0x7F, 0x80, 0x7B, 0xFE, 0x01, 0xEF, 0xF0, 0x0F, 0xF8,
  0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81,
  0xFF, 0xFE, 0x07, 0xE0, 0x70, 0x3F, 0x00, 0x40, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xF8, 0x20, 0x07, 0xE0, 0xC0, 0x3F, 0x83, 0xFF,
  0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x07, 0xFF, 0x3F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFE, 0x07,
  0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x3F, 0xC0, 0x06, 0x00, 0x07,
  0xC0, 0x07, 0xC1, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x1F, 0x00, 0x3E,
  0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x3E, 0x00,
  0x7C, 0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x07, 0xC1, 0xF0, 0x03, 0xE0, 0x7C,
  0x00, 0xF8, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x03, 0xE0,
  0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x07,
  0xC1, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x1F, 0x00, 0x3E, 0x07, 0xC0,
  0x1F, 0x83, 0xE0, 0x07, 0xE0, 0xF8, 0x03, 0xF0, 0x3E, 0x00, 0xFC, 0x0F,
  0x80, 0x7F, 0x03, 0xE0, 0x3F, 0xC0, 0xFC, 0x1F, 0xF0, 0x3F, 0xFF, 0x78,
  0x07, 0xFF, 0x9E, 0x01, 0xFF, 0xC7, 0x80, 0x1F, 0xE1, 0xE0, 0x01, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xF9, 0xE0, 0x01, 0xF3, 0xC0,
  0x07, 0xC7, 0x80, 0x0F, 0x8F, 0x00, 0x3F, 0x1E, 0x00, 0x7C, 0x3C, 0x00,
  0xF8, 0x7C, 0x03, 0xE0, 0xF8, 0x07, 0xC1, 0xF0, 0x1F, 0x03, 0xE0, 0x3E,
  0x07, 0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0x07, 0xC0, 0x3E, 0x0F, 0x80,
  0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0xF0, 0x03, 0xE3, 0xE0, 0x07,
  0xC7, 0x80, 0x0F, 0x9F, 0x00, 0x1F, 0x3E, 0x00, 0x3E, 0xF8, 0x00, 0x3D,
  0xF0, 0x00, 0x7B, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0xF0, 0x01, 0xF0, 0x03, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0xC0, 0x0F,
  0xC0, 0x1F, 0x78, 0x03, 0xF8, 0x03, 0xEF, 0x00, 0x7F, 0x00, 0xF9, 0xE0,
  0x1F, 0xE0, 0x1F, 0x3C, 0x03, 0xFC, 0x03, 0xE7, 0x80, 0x7F, 0x80, 0xF8,
  0xF0, 0x1E, 0xF0, 0x1F, 0x1E, 0x03, 0xDE, 0x07, 0xC3, 0xC0, 0xF3, 0xC0,
  0xF8, 0x78, 0x1E, 0x78, 0x1E, 0x0F, 0x03, 0xCF, 0x07, 0xC1, 0xE0, 0xF1,
  0xE0, 0xF8, 0x3C, 0x1E, 0x3C, 0x3E, 0x07, 0x87, 0x87, 0x87, 0xC0, 0xF0,
  0xF0, 0xF0, 0xF0, 0x1E, 0x1E, 0x1E, 0x3E, 0x03, 0xC7, 0x83, 0xC7, 0xC0,
  0x78, 0xF0, 0x79, 0xF0, 0x0F, 0x3C, 0x0F, 0x3E, 0x01, 0xE7, 0x81, 0xE7,
  0x80, 0x3D, 0xF0, 0x3D, 0xF0, 0x07, 0xBC, 0x07, 0xBC, 0x00, 0xF7, 0x80,
  0xF7, 0x80, 0x1F, 0xE0, 0x1F, 0xF0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x7F, 0x80, 0x0F, 0xE0, 0x0F, 0xE0, 0x01, 0xFC, 0x01, 0xFC, 0x00,
  0x3F, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xF8, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00,
  0xF8, 0x00, 0xF8, 0x0F, 0x80, 0x07, 0xC0, 0xFC, 0x00, 0x3E, 0x07, 0xC0,
  0x01, 0xF0, 0x7C, 0x00, 0x07, 0x87, 0xE0, 0x00, 0x3E, 0x3E, 0x00, 0x01,
  0xF3, 0xE0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x3D, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0x3E, 0x3E, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x3F, 0x0F, 0x80,
  0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x01, 0xF0, 0x01, 0xF8, 0x0F, 0x80, 0x0F,
  0x80, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x0F, 0x80, 0xFC, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x3E,
  0x01, 0xF0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3E,
  0x03, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E,
  0x07, 0xC0, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x1E,
  0x1F, 0x00, 0x00, 0x1E, 0x1F, 0x00, 0x00, 0x1E, 0x3E, 0x00, 0x00, 0x1E,
  0x3E, 0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0x1E,
  0x78, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1E,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x02, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x02, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x10, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x01, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0xBF, 0xFC, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xF6, 0x00, 0xFF, 0xF2, 0x00, 0x0F, 0xF0,
};

const GFXglyph NotoSans_Condensed_Italic61pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 15, 45, 15, 1, -44 },
  { 86, 18, 16, 22, 6, -44 },
  { 122, 30, 44, 30, 1, -44 },
  { 287, 26, 50, 27, 1, -46 },
  { 450, 34, 45, 41, 4, -44 },
  { 642, 30, 45, 31, 0, -44 },
  { 811, 8, 16, 12, 6, -44 },
  { 827, 18, 54, 16, 2, -44 },
  { 949, 19, 54, 16, -5, -44 },
  { 1078, 21, 23, 26, 6, -47 },
  { 1139, 24, 29, 29, 3, -36 },
  { 1226, 11, 15, 13, -3, -7 },
  { 1247, 14, 5, 17, 1, -19 },
  { 1256, 7, 8, 13, 1, -7 },
  { 1263, 29, 44, 21, -3, -44 },
  { 1423, 24, 45, 27, 2, -44 },
  { 1558, 16, 44, 27, 7, -44 },
  { 1646, 27, 44, 27, -1, -44 },
  { 1795, 26, 45, 27, 0, -44 },
  { 1942, 28, 44, 27, -1, -44 },
  { 2096, 27, 45, 27, 0, -44 },
  { 2248, 26, 45, 27, 2, -44 },
  { 2395, 26, 44, 27, 3, -44 },
  { 2538, 26, 45, 27, 1, -44 },
  { 2685, 25, 45, 27, 1, -44 },
  { 2826, 13, 34, 13, 0, -33 },
  { 2882, 16, 41, 13, -3, -33 },
  { 2964, 24, 28, 29, 3, -36 },
  { 3048, 24, 17, 29, 3, -30 },
  { 3099, 24, 28, 29, 3, -36 },
  { 3183, 20, 45, 20, 2, -44 },
  { 3296, 38, 49, 41, 2, -44 },
  { 3529, 28, 44, 28, -4, -44 },
  { 3683, 28, 44, 29, 1, -44 },
  { 3837, 28, 45, 27, 3, -44 },
  { 3995, 30, 44, 32, 1, -44 },
  { 4160, 27, 44, 25, 1, -44 },
  { 4309, 27, 44, 23, 1, -44 },
  { 4458, 31, 45, 33, 3, -44 },
  { 4633, 33, 44, 33, 1, -44 },
  { 4815, 24, 44, 17, -3, -44 },
  { 4947, 24, 56, 14, -9, -44 },
  { 5115, 32, 44, 28, 1, -44 },
  { 5291, 18, 44, 23, 1, -44 },
  { 5390, 43, 44, 43, 1, -44 },
  { 5627, 35, 44, 35, 1, -44 },
  { 5820, 30, 45, 34, 3, -44 },
  { 5989, 27, 44, 28, 1, -44 },
  { 6138, 30, 54, 34, 3, -44 },
  { 6341, 27, 44, 28, 1, -44 },
  { 6490, 28, 45, 25, -1, -44 },
  { 6648, 24, 44, 24, 5, -44 },
  { 6780, 31, 45, 33, 3, -44 },
  { 6955, 28, 44, 27, 5, -44 },
  { 7109, 44, 44, 44, 5, -44 },
  { 7351, 33, 44, 26, -3, -44 },
  { 7533, 25, 44, 25, 5, -44 },
  { 7671, 29, 44, 24, -2, -44 },
  { 7831, 23, 54, 17, -1, -44 },
  { 7987, 11, 44, 21, 6, -44 },
  { 8048, 23, 54, 17, -4, -44 },
  { 8204, 26, 25, 27, 1, -44 },
  { 8286, 21, 4, 20, -5, 5 },
  { 8297, 9, 10, 16, 9, -47 },
  { 8309, 26, 34, 28, 2, -33 },
  { 8420, 27, 47, 28, 0, -46 },
  { 8579, 21, 34, 22, 2, -33 },
  { 8669, 29, 47, 29, 2, -46 },
  { 8840, 22, 34, 25, 2, -33 },
  { 8934, 30, 62, 16, -7, -47 },
  { 9167, 28, 48, 29, 0, -33 },
  { 9335, 26, 46, 28, 0, -46 },
  { 9485, 15, 45, 13, 0, -45 },
  { 9570, 23, 60, 13, -8, -45 },
  { 9743, 27, 46, 24, 0, -46 },
  { 9899, 15, 46, 13, 0, -46 },
  { 9986, 40, 33, 42, 0, -33 },
  { 10151, 26, 33, 28, 0, -33 },
  { 10259, 24, 34, 28, 2, -33 },
  { 10361, 29, 47, 28, -2, -33 },
  { 10532, 26, 48, 29, 2, -33 },
  { 10688, 22, 33, 19, 0, -33 },
  { 10779, 22, 34, 21, 0, -33 },
  { 10873, 16, 41, 16, 2, -40 },
  { 10955, 26, 34, 28, 2, -33 },
  { 11066, 23, 33, 23, 3, -33 },
  { 11161, 35, 33, 36, 4, -33 },
  { 11306, 29, 33, 24, -3, -33 },
  { 11426, 32, 48, 23, -6, -33 },
  { 11618, 23, 33, 20, -2, -33 },
  { 11713, 23, 54, 20, 1, -44 },
  { 11869, 4, 62, 26, 11, -47 },
  { 11900, 22, 54, 20, -3, -44 },
  { 12049, 25, 7, 29, 3, -25 },
};

const GFXfont NotoSans_Condensed_Italic61pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Italic61pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Italic61pt7bGlyphs,
  0x20, 0x7E, 83
};

#endif // _NOTOSANS_CONDENSED_ITALIC61PT7B_H_
