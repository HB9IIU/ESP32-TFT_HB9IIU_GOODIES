#ifndef _NOTOSANS_CONDENSED_ITALIC8PT7B_H_
#define _NOTOSANS_CONDENSED_ITALIC8PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Italic.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Italic8pt7bBitmaps[] PROGMEM = {
  0x00, 0x56, 0x20, 0xF0, 0x35, 0x67, 0xAC, 0x34, 0x42, 0x6C, 0x4D, 0xAA,
  0xF5, 0xAC, 0x26, 0x6D, 0xAF, 0xC0, 0x29, 0x49, 0x20, 0x24, 0x92, 0xB0,
  0x5F, 0x00, 0x44, 0xF4, 0xC0, 0xC0, 0x80, 0x25, 0x29, 0x00, 0x2E, 0xDB,
  0x80, 0x75, 0xA0, 0x64, 0x95, 0xC0, 0x64, 0xB3, 0xC0, 0x25, 0xDE, 0x40,
  0x74, 0x42, 0x2E, 0x34, 0xEA, 0xAE, 0x72, 0x24, 0x48, 0x65, 0x66, 0xAE,
  0x6E, 0xB3, 0x80, 0x42, 0x42, 0x80, 0x16, 0xC3, 0xFF, 0x86, 0x3C, 0x64,
  0xA1, 0x00, 0x32, 0x6F, 0xBF, 0xC1, 0x80, 0x11, 0x37, 0x5D, 0x65, 0x5A,
  0x9E, 0x34, 0x88, 0x86, 0x65, 0x59, 0x9E, 0x74, 0x4A, 0x8E, 0x74, 0x46,
  0x88, 0x34, 0x8B, 0x97, 0x55, 0x5B, 0x99, 0x69, 0x29, 0x80, 0x24, 0xA4,
  0x94, 0x56, 0x64, 0xAA, 0x49, 0x49, 0xC0, 0x45, 0x34, 0xAE, 0xAA, 0xA0,
  0x4A, 0x5D, 0x6B, 0x48, 0x35, 0x99, 0x96, 0x65, 0x56, 0x88, 0x35, 0x99,
  0x96, 0x20, 0x65, 0x56, 0xAA, 0x74, 0x42, 0x2E, 0xEA, 0x49, 0x00, 0x55,
  0x59, 0x96, 0xB7, 0x69, 0x00, 0xAD, 0x7B, 0x6B, 0x50, 0x56, 0x64, 0xAA,
  0xBB, 0x49, 0x00, 0x72, 0x24, 0x8E, 0x69, 0x49, 0x20, 0xFC, 0x24, 0x92,
  0x70, 0x26, 0x69, 0xE0, 0x80, 0x7A, 0xAE, 0x49, 0xDB, 0xC0, 0x72, 0x70,
  0x11, 0x7A, 0xAE, 0x7E, 0x70, 0x32, 0x64, 0x44, 0x48, 0x7A, 0xAE, 0x2C,
  0x49, 0xDB, 0x40, 0x46, 0xA0, 0x20, 0xA4, 0x94, 0x45, 0x64, 0xCA, 0x56,
  0xA0, 0x7D, 0x6B, 0x50, 0x76, 0xD0, 0x76, 0xF0, 0x76, 0xF9, 0x00, 0x7A,
  0xAE, 0x22, 0x72, 0x40, 0xE9, 0x60, 0x7A, 0xC0, 0x5A, 0xAE, 0xB5, 0x20,
  0xAF, 0x75, 0x20, 0x69, 0x50, 0x55, 0x22, 0x4C, 0x6A, 0x60, 0x29, 0x65,
  0x30, 0xFF, 0x49, 0x35, 0x20, 0xF0,
};

const GFXglyph NotoSans_Condensed_Italic8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 6, 2, 0, -6 },
  { 3, 2, 2, 3, 1, -6 },
  { 4, 4, 6, 4, 0, -6 },
  { 7, 4, 6, 4, 0, -6 },
  { 10, 5, 6, 5, 0, -6 },
  { 14, 4, 6, 4, 0, -6 },
  { 17, 1, 2, 2, 1, -6 },
  { 18, 3, 7, 2, 0, -6 },
  { 21, 3, 7, 2, -1, -6 },
  { 24, 3, 3, 3, 1, -6 },
  { 26, 4, 4, 4, 0, -5 },
  { 28, 1, 2, 2, 0, -1 },
  { 29, 2, 1, 2, 0, -3 },
  { 30, 1, 1, 2, 0, -1 },
  { 31, 3, 6, 3, 0, -6 },
  { 34, 3, 6, 4, 0, -6 },
  { 37, 2, 6, 4, 1, -6 },
  { 39, 3, 6, 4, 0, -6 },
  { 42, 3, 6, 4, 0, -6 },
  { 45, 3, 6, 4, 0, -6 },
  { 48, 4, 6, 4, 0, -6 },
  { 51, 4, 6, 4, 0, -6 },
  { 54, 4, 6, 4, 0, -6 },
  { 57, 4, 6, 4, 0, -6 },
  { 60, 3, 6, 4, 0, -6 },
  { 63, 2, 4, 2, 0, -4 },
  { 64, 2, 5, 2, 0, -4 },
  { 66, 4, 4, 4, 0, -5 },
  { 68, 4, 2, 4, 0, -4 },
  { 69, 4, 4, 4, 0, -5 },
  { 71, 3, 6, 3, 0, -6 },
  { 74, 5, 7, 5, 0, -6 },
  { 79, 4, 6, 4, -1, -6 },
  { 82, 4, 6, 4, 0, -6 },
  { 85, 4, 6, 4, 0, -6 },
  { 88, 4, 6, 4, 0, -6 },
  { 91, 4, 6, 3, 0, -6 },
  { 94, 4, 6, 3, 0, -6 },
  { 97, 4, 6, 4, 0, -6 },
  { 100, 4, 6, 4, 0, -6 },
  { 103, 3, 6, 2, 0, -6 },
  { 106, 3, 8, 2, -1, -6 },
  { 109, 4, 6, 4, 0, -6 },
  { 112, 3, 6, 3, 0, -6 },
  { 115, 6, 6, 6, 0, -6 },
  { 120, 5, 6, 5, 0, -6 },
  { 124, 4, 6, 5, 0, -6 },
  { 127, 4, 6, 4, 0, -6 },
  { 130, 4, 7, 5, 0, -6 },
  { 134, 4, 6, 4, 0, -6 },
  { 137, 4, 6, 3, 0, -6 },
  { 140, 3, 6, 3, 1, -6 },
  { 143, 4, 6, 4, 0, -6 },
  { 146, 3, 6, 4, 1, -6 },
  { 149, 5, 6, 6, 1, -6 },
  { 153, 4, 6, 3, 0, -6 },
  { 156, 3, 6, 3, 1, -6 },
  { 159, 4, 6, 3, 0, -6 },
  { 162, 3, 7, 2, 0, -6 },
  { 165, 1, 6, 3, 1, -6 },
  { 166, 3, 7, 2, -1, -6 },
  { 169, 4, 4, 4, 0, -6 },
  { 171, 3, 1, 3, -1, 0 },
  { 172, 1, 1, 2, 1, -6 },
  { 173, 4, 4, 4, 0, -4 },
  { 175, 3, 6, 4, 0, -6 },
  { 178, 3, 4, 3, 0, -4 },
  { 180, 4, 6, 4, 0, -6 },
  { 183, 3, 4, 3, 0, -4 },
  { 185, 4, 8, 2, -1, -6 },
  { 189, 4, 6, 4, 0, -4 },
  { 192, 3, 6, 4, 0, -6 },
  { 195, 2, 6, 2, 0, -6 },
  { 197, 3, 8, 2, -1, -6 },
  { 200, 4, 6, 3, 0, -6 },
  { 203, 2, 6, 2, 0, -6 },
  { 205, 5, 4, 6, 0, -4 },
  { 208, 3, 4, 4, 0, -4 },
  { 210, 3, 4, 4, 0, -4 },
  { 212, 3, 6, 4, 0, -4 },
  { 215, 4, 6, 4, 0, -4 },
  { 218, 3, 4, 3, 0, -4 },
  { 220, 3, 4, 3, 0, -4 },
  { 222, 2, 5, 2, 0, -5 },
  { 224, 4, 4, 4, 0, -4 },
  { 226, 3, 4, 3, 0, -4 },
  { 228, 5, 4, 5, 0, -4 },
  { 231, 3, 4, 3, 0, -4 },
  { 233, 4, 6, 3, -1, -4 },
  { 236, 3, 4, 3, 0, -4 },
  { 238, 3, 7, 3, 0, -6 },
  { 241, 1, 8, 3, 1, -6 },
  { 242, 3, 7, 3, 0, -6 },
  { 245, 4, 1, 4, 0, -3 },
};

const GFXfont NotoSans_Condensed_Italic8pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Italic8pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Italic8pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _NOTOSANS_CONDENSED_ITALIC8PT7B_H_
