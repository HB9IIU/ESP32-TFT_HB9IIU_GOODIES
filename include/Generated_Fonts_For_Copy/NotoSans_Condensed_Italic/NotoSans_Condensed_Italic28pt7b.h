#ifndef _NOTOSANS_CONDENSED_ITALIC28PT7B_H_
#define _NOTOSANS_CONDENSED_ITALIC28PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Italic.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Italic28pt7bBitmaps[] PROGMEM = {
  0x00, 0x0E, 0x1C, 0x38, 0x60, 0xC3, 0x87, 0x0C, 0x18, 0x30, 0x61, 0x83,
  0x06, 0x00, 0x00, 0x00, 0xC3, 0x87, 0x00, 0x67, 0x66, 0x66, 0xE6, 0xC6,
  0xCC, 0xCC, 0x01, 0x8C, 0x04, 0x60, 0x31, 0x80, 0xC4, 0x02, 0x30, 0x18,
  0xC3, 0xFF, 0xC1, 0x98, 0x0C, 0x60, 0x31, 0x80, 0xC4, 0x06, 0x30, 0xFF,
  0xF3, 0xFF, 0xC1, 0x18, 0x0C, 0x60, 0x31, 0x00, 0x8C, 0x06, 0x30, 0x18,
  0xC0, 0x00, 0xC0, 0x08, 0x03, 0xE0, 0xFF, 0x1D, 0x91, 0x90, 0x19, 0x01,
  0x90, 0x1B, 0x01, 0xE0, 0x0F, 0x00, 0x38, 0x07, 0xC0, 0x6C, 0x04, 0xC0,
  0x4C, 0x84, 0xCE, 0xFC, 0xFF, 0x81, 0xC0, 0x08, 0x00, 0x80, 0x18, 0x00,
  0x3C, 0x0C, 0x3E, 0x0C, 0x66, 0x18, 0x46, 0x30, 0xC6, 0x30, 0xC6, 0x60,
  0xC6, 0x60, 0xC4, 0xC0, 0x8D, 0x9E, 0x8D, 0xBE, 0xDB, 0x23, 0xF3, 0x63,
  0x06, 0x63, 0x04, 0x42, 0x0C, 0xC6, 0x18, 0xC6, 0x18, 0xC6, 0x30, 0xCC,
  0x30, 0xFC, 0x60, 0x78, 0x03, 0xE0, 0x1F, 0x80, 0xE7, 0x03, 0x1C, 0x0C,
  0x60, 0x31, 0x80, 0xCC, 0x03, 0x70, 0x07, 0x80, 0x38, 0x01, 0xF0, 0x4C,
  0xC6, 0x73, 0x99, 0x86, 0xCE, 0x1F, 0x30, 0x38, 0xC0, 0xE3, 0x87, 0x87,
  0xF7, 0x0F, 0x9C, 0x76, 0x6E, 0xCC, 0xC0, 0x03, 0x06, 0x0C, 0x0C, 0x18,
  0x38, 0x30, 0x70, 0x60, 0x60, 0x60, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x60, 0x60, 0x06, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0E, 0x07, 0x03, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x1C,
  0x0C, 0x06, 0x06, 0x03, 0x03, 0x01, 0x81, 0x81, 0xC1, 0xC0, 0x0E, 0x03,
  0x0C, 0xC3, 0xF1, 0x3F, 0x87, 0x33, 0x41, 0x98, 0xE7, 0x00, 0x80, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x39, 0x9C, 0xC6, 0x63,
  0x00, 0x7E, 0xFF, 0xF8, 0x6F, 0xE0, 0x00, 0x38, 0x01, 0x80, 0x18, 0x00,
  0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0x80,
  0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0x00, 0x38,
  0x01, 0x80, 0x00, 0x07, 0xC1, 0xF8, 0x73, 0x8C, 0x33, 0x06, 0x60, 0xDC,
  0x1B, 0x03, 0x60, 0x6C, 0x1F, 0x83, 0xE0, 0x6C, 0x0D, 0x83, 0xB0, 0x66,
  0x0C, 0xC3, 0x9C, 0xE1, 0xF8, 0x3E, 0x00, 0x07, 0x0E, 0x3E, 0x76, 0xEE,
  0x4E, 0x0C, 0x0C, 0x0C, 0x1C, 0x18, 0x18, 0x18, 0x38, 0x38, 0x30, 0x30,
  0x30, 0x70, 0x70, 0x03, 0xF0, 0x7F, 0xC1, 0x0E, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x30, 0x03, 0x00, 0x38,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x1F, 0xF9, 0xFF, 0x80,
  0x07, 0xE1, 0xFF, 0x08, 0x70, 0x03, 0x00, 0x30, 0x03, 0x00, 0x70, 0x0E,
  0x03, 0xC0, 0xF0, 0x0F, 0x80, 0x1C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x01, 0xC8, 0x38, 0xFF, 0x8F, 0xE0, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x1E,
  0x03, 0x60, 0x36, 0x06, 0x60, 0xCE, 0x0C, 0xC1, 0x8C, 0x30, 0xC3, 0x0C,
  0x61, 0xCC, 0x19, 0xFF, 0xEF, 0xFE, 0x03, 0x80, 0x30, 0x03, 0x00, 0x30,
  0x07, 0xF0, 0xFF, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x3F, 0x83, 0xFC, 0x00, 0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C,
  0x01, 0xC8, 0x38, 0xFF, 0x8F, 0xE0, 0x03, 0xF0, 0x7E, 0x0E, 0x01, 0xC0,
  0x18, 0x03, 0x00, 0x30, 0x06, 0x20, 0x6F, 0x87, 0x9C, 0xF0, 0xCE, 0x0C,
  0xE0, 0xCC, 0x0C, 0xC0, 0xCC, 0x1C, 0xC1, 0x8E, 0x38, 0x7F, 0x03, 0xE0,
  0x3F, 0xF3, 0xFF, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x18,
  0x03, 0x80, 0x30, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x18, 0x01, 0x80,
  0x30, 0x03, 0x00, 0x60, 0x0E, 0x00, 0x07, 0xE0, 0xFF, 0x0C, 0x31, 0x83,
  0x18, 0x31, 0x83, 0x1C, 0x70, 0xCE, 0x0F, 0xC0, 0x70, 0x1F, 0x83, 0x9C,
  0x70, 0xC6, 0x0E, 0xE0, 0xEE, 0x0E, 0xE0, 0xC6, 0x1C, 0x7F, 0x83, 0xF0,
  0x07, 0xC0, 0xFE, 0x1C, 0x71, 0x83, 0x38, 0x33, 0x03, 0x30, 0x33, 0x07,
  0x30, 0x73, 0x0F, 0x3D, 0xE1, 0xF6, 0x0C, 0x60, 0x0C, 0x00, 0xC0, 0x1C,
  0x01, 0x80, 0x30, 0xFE, 0x0F, 0xC0, 0x1C, 0x71, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x63, 0x8E, 0x00, 0x0E, 0x1C, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x86, 0x1C, 0x30, 0x61, 0x82, 0x00, 0x00,
  0x30, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x0C, 0x00, 0x3F, 0x3F,
  0xC8, 0x60, 0x30, 0x18, 0x0C, 0x0C, 0x0E, 0x0E, 0x0E, 0x06, 0x06, 0x03,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x70, 0x38, 0x1C, 0x00, 0x00, 0xFC, 0x01,
  0xFF, 0x01, 0x80, 0xC1, 0x80, 0x31, 0x80, 0x19, 0x83, 0x0C, 0xC7, 0xE6,
  0xC6, 0x33, 0x63, 0x11, 0xA3, 0x18, 0xF1, 0x8C, 0x78, 0x86, 0x2C, 0xC6,
  0x36, 0x63, 0x1B, 0x33, 0x99, 0x8F, 0x78, 0xC7, 0x18, 0x60, 0x00, 0x10,
  0x00, 0x0C, 0x00, 0x03, 0x86, 0x00, 0xFF, 0x00, 0x00, 0x70, 0x03, 0x80,
  0x3C, 0x01, 0xE0, 0x1B, 0x00, 0xD8, 0x0E, 0xC0, 0x66, 0x07, 0x30, 0x31,
  0xC1, 0x8E, 0x18, 0x70, 0xFF, 0x8F, 0xFC, 0x60, 0xE7, 0x07, 0x30, 0x3B,
  0x80, 0xD8, 0x07, 0xC0, 0x30, 0x0F, 0xE0, 0x3F, 0xE0, 0xC3, 0x83, 0x06,
  0x0C, 0x1C, 0x70, 0x61, 0xC1, 0x86, 0x0E, 0x18, 0xF0, 0x7F, 0x03, 0xFE,
  0x0C, 0x1C, 0x30, 0x30, 0xC0, 0xC7, 0x07, 0x1C, 0x1C, 0x60, 0x61, 0x87,
  0x87, 0xFC, 0x3F, 0xC0, 0x03, 0xF8, 0x3F, 0xC3, 0x82, 0x38, 0x01, 0x80,
  0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x60, 0x03, 0x82, 0x0F, 0xE0, 0x3F,
  0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0xC3, 0x83, 0x07, 0x0C, 0x1C, 0x70, 0x31,
  0xC0, 0xC6, 0x03, 0x18, 0x0C, 0x60, 0x73, 0x81, 0xCC, 0x07, 0x30, 0x18,
  0xC0, 0xE7, 0x03, 0x1C, 0x1C, 0x60, 0xE1, 0x87, 0x07, 0xF8, 0x3F, 0x80,
  0x0F, 0xF8, 0x7F, 0x83, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x00, 0x18, 0x20, 0xFE, 0x0F, 0xF0, 0x60, 0x03, 0x00, 0x18, 0x01, 0xC0,
  0x0E, 0x00, 0x60, 0x03, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x0F, 0xF8, 0x7F,
  0x83, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00,
  0xFE, 0x0F, 0xF0, 0x60, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x01, 0xC0, 0x00, 0x01, 0xFC, 0x0F, 0xFC, 0x38, 0x10,
  0xE0, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC1,
  0xF1, 0x83, 0xE7, 0x01, 0xCE, 0x03, 0x9C, 0x06, 0x38, 0x0C, 0x70, 0x18,
  0x60, 0x70, 0xE0, 0xE0, 0xFF, 0x80, 0xFF, 0x00, 0x0E, 0x07, 0x0E, 0x06,
  0x0C, 0x06, 0x0C, 0x06, 0x0C, 0x0E, 0x1C, 0x0C, 0x1C, 0x0C, 0x18, 0x0C,
  0x1F, 0xFC, 0x1F, 0xFC, 0x3F, 0xF8, 0x30, 0x18, 0x30, 0x18, 0x30, 0x38,
  0x30, 0x38, 0x70, 0x30, 0x60, 0x30, 0x60, 0x30, 0x60, 0x70, 0xE0, 0x70,
  0x0F, 0xE0, 0xF0, 0x0C, 0x03, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x0E,
  0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x01, 0xF0, 0x7F, 0x00, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x03,
  0x80, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x0E, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xE0, 0x18, 0x07, 0x07,
  0xC0, 0xF0, 0x00, 0x0E, 0x0E, 0x1C, 0x38, 0x30, 0xE0, 0x61, 0x80, 0xC7,
  0x03, 0x9C, 0x07, 0x70, 0x0C, 0xC0, 0x1B, 0x00, 0x3E, 0x00, 0xFC, 0x01,
  0xDC, 0x03, 0x18, 0x06, 0x30, 0x1C, 0x60, 0x38, 0xE0, 0x60, 0xC0, 0xC1,
  0x81, 0x83, 0x87, 0x07, 0x00, 0x0E, 0x07, 0x03, 0x01, 0x80, 0xC0, 0xE0,
  0x70, 0x30, 0x18, 0x0C, 0x0E, 0x06, 0x03, 0x01, 0x81, 0xC0, 0xE0, 0x60,
  0x30, 0x1F, 0xFF, 0xF0, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x0F, 0x01, 0xF0,
  0xF0, 0x1E, 0x0F, 0x01, 0xE1, 0xF0, 0x36, 0x1B, 0x03, 0x61, 0xB0, 0x6E,
  0x1B, 0x06, 0xC1, 0xB0, 0xCC, 0x3B, 0x0C, 0xC3, 0x39, 0x9C, 0x31, 0x99,
  0xC3, 0x1B, 0x18, 0x71, 0xB1, 0x86, 0x1E, 0x18, 0x61, 0xE3, 0x86, 0x1C,
  0x38, 0x61, 0xC3, 0x0E, 0x18, 0x30, 0x0E, 0x03, 0x0F, 0x03, 0x0F, 0x03,
  0x0F, 0x03, 0x0F, 0x07, 0x1F, 0x06, 0x19, 0x86, 0x19, 0x86, 0x19, 0x8E,
  0x19, 0x8C, 0x39, 0xCC, 0x30, 0xCC, 0x30, 0xCC, 0x30, 0xDC, 0x70, 0xF8,
  0x70, 0x78, 0x60, 0x78, 0x60, 0x78, 0x60, 0x78, 0xE0, 0x30, 0x03, 0xF0,
  0x1F, 0xE0, 0xE1, 0xC7, 0x07, 0x38, 0x0C, 0xE0, 0x33, 0x00, 0xDC, 0x03,
  0x60, 0x0D, 0x80, 0x76, 0x01, 0xF8, 0x07, 0xE0, 0x1B, 0x80, 0xEE, 0x03,
  0xB8, 0x1C, 0x60, 0x61, 0xC3, 0x87, 0xFC, 0x07, 0xE0, 0x0F, 0xE0, 0x7F,
  0x83, 0x0E, 0x18, 0x70, 0xC1, 0x8E, 0x0C, 0x70, 0xE3, 0x07, 0x18, 0x30,
  0xC7, 0x8F, 0xF8, 0x7F, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x01, 0xC0, 0x00, 0x03, 0xF0, 0x1F, 0xE0, 0xE1, 0xC7,
  0x07, 0x38, 0x0C, 0xE0, 0x33, 0x00, 0xDC, 0x03, 0x60, 0x0D, 0x80, 0x76,
  0x01, 0xF8, 0x07, 0xE0, 0x1B, 0x80, 0xEE, 0x03, 0xB8, 0x1C, 0x60, 0x71,
  0xC3, 0x87, 0xFC, 0x07, 0xE0, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70,
  0x01, 0xC0, 0x0F, 0xE0, 0x7F, 0x83, 0x0E, 0x18, 0x70, 0xC1, 0x8E, 0x0C,
  0x70, 0xE3, 0x07, 0x18, 0x70, 0xCF, 0x0F, 0xF0, 0x7F, 0x03, 0x18, 0x18,
  0xC1, 0xC7, 0x0E, 0x38, 0x60, 0xC3, 0x06, 0x18, 0x39, 0xC1, 0xC0, 0x07,
  0xF0, 0xFF, 0x1C, 0x11, 0x80, 0x38, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xC0, 0x1C, 0x01,
  0xC8, 0x38, 0xFF, 0x8F, 0xE0, 0x7F, 0xFF, 0xFC, 0x38, 0x06, 0x00, 0xC0,
  0x18, 0x07, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x60,
  0x0C, 0x01, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x00, 0x1C, 0x0E, 0x30,
  0x18, 0x60, 0x30, 0xC0, 0xE3, 0x81, 0xC7, 0x03, 0x0C, 0x06, 0x18, 0x0C,
  0x30, 0x38, 0xE0, 0x71, 0xC0, 0xC3, 0x01, 0x86, 0x03, 0x0C, 0x0E, 0x38,
  0x18, 0x70, 0x30, 0xE0, 0xE0, 0xC3, 0x81, 0xFE, 0x01, 0xF8, 0x00, 0xE0,
  0x3B, 0x01, 0x98, 0x1C, 0xC0, 0xC6, 0x0E, 0x30, 0x61, 0x83, 0x0C, 0x38,
  0x61, 0x83, 0x1C, 0x18, 0xC0, 0xCE, 0x06, 0x60, 0x37, 0x01, 0xB0, 0x0D,
  0x80, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x00, 0xC0, 0xE0, 0x78, 0x1C,
  0x1F, 0x07, 0x83, 0x60, 0xF0, 0xEC, 0x36, 0x19, 0x86, 0x83, 0x30, 0xD0,
  0xE6, 0x36, 0x18, 0xC6, 0xC7, 0x19, 0x98, 0xC3, 0x33, 0x18, 0x66, 0x67,
  0x0D, 0x8C, 0xC1, 0xB1, 0xB8, 0x3C, 0x36, 0x07, 0x86, 0xC0, 0xF0, 0xF0,
  0x1C, 0x1E, 0x03, 0x83, 0xC0, 0x60, 0x70, 0x00, 0x07, 0x07, 0x07, 0x0E,
  0x03, 0x0C, 0x03, 0x1C, 0x03, 0x18, 0x03, 0x30, 0x03, 0xF0, 0x01, 0xE0,
  0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x06, 0xC0, 0x0E, 0xC0,
  0x0C, 0xE0, 0x1C, 0x60, 0x18, 0x60, 0x30, 0x60, 0x70, 0x60, 0xE0, 0x70,
  0xE0, 0x76, 0x0E, 0x60, 0xC6, 0x1C, 0x61, 0x87, 0x38, 0x73, 0x03, 0x60,
  0x36, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0x0F, 0xFC, 0x3F, 0xE0, 0x03, 0x80,
  0x0C, 0x00, 0x70, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x03, 0x80, 0x0C, 0x00,
  0x70, 0x01, 0x80, 0x0E, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x01,
  0x80, 0x0F, 0xFC, 0x3F, 0xF0, 0x07, 0xE0, 0xFC, 0x18, 0x03, 0x00, 0x60,
  0x1C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x0E, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x18,
  0x07, 0xE0, 0xC6, 0x31, 0x8E, 0x31, 0x8C, 0x63, 0x18, 0xC3, 0x18, 0xC6,
  0x31, 0x8C, 0x70, 0x07, 0xE0, 0xF8, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0xC0,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x07, 0xE0,
  0x02, 0x00, 0xE0, 0x3C, 0x07, 0xC1, 0x98, 0x33, 0x0C, 0x31, 0x86, 0x60,
  0xDC, 0x0F, 0x01, 0x80, 0xFF, 0xFF, 0xC0, 0xE6, 0x33, 0x0F, 0x31, 0xFF,
  0x38, 0xE3, 0x0E, 0x70, 0xE6, 0x0E, 0xE0, 0xEE, 0x0C, 0xC0, 0xCC, 0x1C,
  0xC1, 0xCC, 0x38, 0xE3, 0x8F, 0xD8, 0x79, 0x80, 0x06, 0x00, 0xE0, 0x0C,
  0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x1D, 0xE1, 0xBF, 0x1C, 0x31, 0xC3, 0x38,
  0x33, 0x83, 0x30, 0x33, 0x07, 0x30, 0x77, 0x06, 0x70, 0x67, 0x0E, 0x71,
  0xC7, 0xF8, 0xCF, 0x00, 0x0F, 0xC7, 0xE3, 0x81, 0xC0, 0x60, 0x18, 0x0E,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xE0, 0x1F, 0x87, 0xE0, 0x00,
  0x18, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x18, 0x3C, 0xC3, 0xFE,
  0x38, 0xE1, 0x87, 0x1C, 0x38, 0xC1, 0xCE, 0x0C, 0x70, 0x63, 0x03, 0x18,
  0x38, 0xC1, 0xC6, 0x1C, 0x38, 0xE1, 0xFB, 0x07, 0x98, 0x00, 0x0F, 0x87,
  0xF3, 0x8D, 0xC3, 0x60, 0xD8, 0x6F, 0xFB, 0xF8, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xE1, 0x1F, 0xC3, 0xF0, 0x00, 0x7C, 0x03, 0xE0, 0x0C, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x7E, 0x03, 0xF8, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0xC0, 0x0F, 0x00, 0x30, 0x00, 0x07, 0x98, 0x7F, 0xC7, 0x1C, 0x30,
  0xE3, 0x87, 0x18, 0x39, 0xC1, 0x8E, 0x0C, 0x60, 0x63, 0x07, 0x18, 0x38,
  0xC3, 0x87, 0x1C, 0x3F, 0x60, 0xF3, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00,
  0xE1, 0x8E, 0x0F, 0xE0, 0x3C, 0x00, 0x06, 0x00, 0xE0, 0x0C, 0x00, 0xC0,
  0x0C, 0x01, 0xC0, 0x1D, 0xE1, 0xBF, 0x1C, 0x71, 0x83, 0x38, 0x73, 0x87,
  0x30, 0x63, 0x06, 0x30, 0x67, 0x0E, 0x60, 0xC6, 0x0C, 0x60, 0xC6, 0x0C,
  0xE1, 0xC0, 0x04, 0x1C, 0x38, 0x00, 0x00, 0x07, 0x0C, 0x18, 0x30, 0xE1,
  0xC3, 0x06, 0x0C, 0x38, 0x60, 0xC1, 0x83, 0x0E, 0x00, 0x00, 0x40, 0x1C,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x0E,
  0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x07, 0x03, 0xE0, 0x70, 0x00,
  0x06, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x1C, 0x71, 0x86,
  0x18, 0xC1, 0x98, 0x3B, 0x83, 0x70, 0x36, 0x03, 0xF0, 0x3B, 0x07, 0x30,
  0x63, 0x06, 0x38, 0x61, 0x86, 0x18, 0xE1, 0xC0, 0x06, 0x1C, 0x30, 0x60,
  0xC1, 0x87, 0x0C, 0x18, 0x30, 0xE1, 0xC3, 0x06, 0x0C, 0x38, 0x60, 0xC1,
  0x83, 0x0E, 0x00, 0x19, 0xE7, 0xC6, 0xFB, 0xF1, 0xC7, 0x8C, 0x61, 0xC3,
  0x38, 0x70, 0xCE, 0x18, 0x33, 0x06, 0x1C, 0xC1, 0x87, 0x30, 0xE1, 0x9C,
  0x30, 0x66, 0x0C, 0x19, 0x83, 0x0E, 0x60, 0xC3, 0x18, 0x70, 0xCE, 0x18,
  0x30, 0x19, 0xE1, 0xBF, 0x1C, 0x71, 0xC3, 0x38, 0x73, 0x87, 0x30, 0x63,
  0x06, 0x30, 0x67, 0x0E, 0x60, 0xE6, 0x0C, 0x60, 0xCE, 0x0C, 0xE1, 0xC0,
  0x0F, 0x83, 0xF8, 0xE3, 0xB8, 0x76, 0x06, 0xC1, 0xF8, 0x3E, 0x07, 0xC0,
  0xD8, 0x1B, 0x07, 0x60, 0xCE, 0x38, 0xFE, 0x0F, 0x80, 0x0C, 0xF0, 0x6F,
  0xC3, 0x86, 0x1C, 0x31, 0xC1, 0x8E, 0x0C, 0x60, 0x63, 0x03, 0x18, 0x39,
  0xC1, 0x8E, 0x0C, 0x70, 0xE3, 0x8E, 0x1F, 0xE1, 0xDE, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x00, 0x0F, 0x31, 0xFF,
  0x38, 0xE3, 0x0E, 0x70, 0xE6, 0x0E, 0xE0, 0xCE, 0x0C, 0xC0, 0xCC, 0x1C,
  0xC1, 0xCC, 0x38, 0xE3, 0x8F, 0xD8, 0x79, 0x80, 0x38, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x70, 0x07, 0x00, 0x60, 0x1B, 0xC6, 0xE1, 0xE0, 0x70, 0x38,
  0x0E, 0x03, 0x00, 0xC0, 0x30, 0x1C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0E,
  0x00, 0x1F, 0x8F, 0xF3, 0x04, 0xC0, 0x30, 0x0E, 0x03, 0xC0, 0x78, 0x07,
  0x01, 0xC0, 0x30, 0x0C, 0x87, 0x3F, 0x8F, 0xC0, 0x08, 0x30, 0x63, 0xFF,
  0xE6, 0x0C, 0x38, 0x70, 0xC1, 0x83, 0x0E, 0x18, 0x30, 0x60, 0xF8, 0xF0,
  0x38, 0x73, 0x06, 0x30, 0x63, 0x06, 0x70, 0xE6, 0x0C, 0x60, 0xC6, 0x0C,
  0x60, 0xCE, 0x1C, 0xC1, 0x8C, 0x38, 0xC3, 0x8F, 0xD8, 0x79, 0x80, 0xC1,
  0xF0, 0x6C, 0x3B, 0x0C, 0xC7, 0x31, 0x8C, 0x63, 0x30, 0xCC, 0x36, 0x0D,
  0x83, 0xE0, 0xF0, 0x3C, 0x0E, 0x00, 0xC3, 0x87, 0xC3, 0x86, 0xC7, 0x86,
  0xC7, 0x8E, 0xC7, 0x8C, 0xCD, 0x9C, 0xCD, 0x98, 0xD9, 0x98, 0xD9, 0xB0,
  0xD9, 0xB0, 0xF1, 0xF0, 0xF1, 0xE0, 0xE1, 0xE0, 0xE1, 0xC0, 0xE1, 0xC0,
  0x1C, 0x38, 0x63, 0x83, 0x18, 0x19, 0x80, 0xFC, 0x03, 0xC0, 0x1C, 0x00,
  0xE0, 0x0F, 0x00, 0x78, 0x06, 0xE0, 0x73, 0x07, 0x18, 0x30, 0xC3, 0x87,
  0x00, 0x06, 0x0E, 0x0C, 0x18, 0x18, 0x70, 0x30, 0xC0, 0x61, 0x80, 0xC6,
  0x01, 0x8C, 0x03, 0x30, 0x06, 0x60, 0x0D, 0xC0, 0x1B, 0x00, 0x36, 0x00,
  0x78, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x30,
  0x00, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x00, 0x0F, 0xE3, 0xFC, 0x07, 0x00,
  0xC0, 0x38, 0x06, 0x01, 0x80, 0x70, 0x0C, 0x03, 0x00, 0xE0, 0x18, 0x07,
  0x01, 0xFE, 0x3F, 0xC0, 0x01, 0xC1, 0xF0, 0x60, 0x18, 0x0E, 0x03, 0x00,
  0xC0, 0x30, 0x1C, 0x06, 0x03, 0x83, 0xC0, 0xE0, 0x1C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x07, 0x01, 0x80, 0x60, 0x18, 0x07, 0x80, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0E, 0x03, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x1C, 0x06, 0x01, 0x80, 0x70, 0x0F, 0x03, 0xC1, 0xC0, 0xC0,
  0x30, 0x0C, 0x07, 0x01, 0x80, 0x60, 0x18, 0x0E, 0x0F, 0x03, 0x80, 0x10,
  0x17, 0xE3, 0xCF, 0xF8, 0x1C,
};

const GFXglyph NotoSans_Condensed_Italic28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 7, 20, 7, 0, -20 },
  { 19, 8, 7, 10, 3, -20 },
  { 26, 14, 20, 14, 0, -20 },
  { 61, 12, 23, 12, 0, -21 },
  { 96, 16, 20, 19, 2, -20 },
  { 136, 14, 20, 14, 0, -20 },
  { 171, 4, 7, 6, 3, -20 },
  { 175, 8, 24, 7, 1, -20 },
  { 199, 9, 24, 7, -2, -20 },
  { 226, 10, 10, 12, 3, -21 },
  { 239, 12, 14, 13, 1, -17 },
  { 260, 5, 7, 6, -1, -3 },
  { 265, 7, 3, 8, 0, -9 },
  { 268, 4, 3, 6, 0, -3 },
  { 270, 13, 20, 10, -1, -20 },
  { 303, 11, 20, 12, 1, -20 },
  { 331, 8, 20, 12, 3, -20 },
  { 351, 13, 20, 12, -1, -20 },
  { 384, 12, 20, 12, 0, -20 },
  { 414, 12, 20, 12, 0, -20 },
  { 444, 12, 20, 12, 0, -20 },
  { 474, 12, 20, 12, 1, -20 },
  { 504, 12, 20, 12, 1, -20 },
  { 534, 12, 20, 12, 0, -20 },
  { 564, 12, 20, 12, 0, -20 },
  { 594, 6, 15, 6, 0, -15 },
  { 606, 7, 19, 6, -1, -15 },
  { 623, 12, 12, 13, 1, -16 },
  { 641, 11, 8, 13, 1, -14 },
  { 652, 12, 12, 13, 1, -16 },
  { 670, 9, 20, 9, 1, -20 },
  { 693, 17, 22, 19, 1, -20 },
  { 740, 13, 20, 13, -2, -20 },
  { 773, 14, 20, 13, 0, -20 },
  { 808, 13, 20, 12, 1, -20 },
  { 841, 14, 20, 15, 0, -20 },
  { 876, 13, 20, 11, 0, -20 },
  { 909, 13, 20, 11, 0, -20 },
  { 942, 15, 20, 15, 1, -20 },
  { 980, 16, 20, 15, 0, -20 },
  { 1020, 11, 20, 8, -1, -20 },
  { 1048, 11, 25, 6, -4, -20 },
  { 1083, 15, 20, 13, 0, -20 },
  { 1121, 9, 20, 11, 0, -20 },
  { 1144, 20, 20, 20, 0, -20 },
  { 1194, 16, 20, 16, 0, -20 },
  { 1234, 14, 20, 16, 1, -20 },
  { 1269, 13, 20, 13, 0, -20 },
  { 1302, 14, 25, 16, 1, -20 },
  { 1346, 13, 20, 13, 0, -20 },
  { 1379, 12, 20, 12, 0, -20 },
  { 1409, 11, 20, 11, 2, -20 },
  { 1437, 15, 20, 15, 1, -20 },
  { 1475, 13, 20, 13, 2, -20 },
  { 1508, 19, 20, 20, 3, -20 },
  { 1556, 16, 20, 12, -2, -20 },
  { 1596, 12, 20, 11, 2, -20 },
  { 1626, 14, 20, 11, -1, -20 },
  { 1661, 11, 24, 8, -1, -20 },
  { 1694, 5, 20, 10, 3, -20 },
  { 1707, 11, 24, 8, -2, -20 },
  { 1740, 11, 11, 13, 1, -20 },
  { 1756, 9, 2, 9, -2, 2 },
  { 1759, 4, 4, 7, 4, -21 },
  { 1761, 12, 15, 13, 1, -15 },
  { 1784, 12, 21, 13, 0, -21 },
  { 1816, 10, 15, 10, 1, -15 },
  { 1835, 13, 21, 13, 1, -21 },
  { 1870, 10, 15, 12, 1, -15 },
  { 1889, 14, 28, 7, -3, -21 },
  { 1938, 13, 22, 13, 0, -15 },
  { 1974, 12, 21, 13, 0, -21 },
  { 2006, 7, 21, 6, 0, -21 },
  { 2025, 11, 28, 6, -4, -21 },
  { 2064, 12, 21, 11, 0, -21 },
  { 2096, 7, 21, 6, 0, -21 },
  { 2115, 18, 15, 19, 0, -15 },
  { 2149, 12, 15, 13, 0, -15 },
  { 2172, 11, 15, 13, 1, -15 },
  { 2193, 13, 22, 13, -1, -15 },
  { 2229, 12, 22, 13, 1, -15 },
  { 2262, 10, 15, 9, 0, -15 },
  { 2281, 10, 15, 10, 0, -15 },
  { 2300, 7, 18, 7, 1, -18 },
  { 2316, 12, 15, 13, 1, -15 },
  { 2339, 10, 15, 11, 2, -15 },
  { 2358, 16, 15, 17, 2, -15 },
  { 2388, 13, 15, 11, -1, -15 },
  { 2413, 15, 22, 11, -3, -15 },
  { 2455, 11, 15, 9, -1, -15 },
  { 2476, 10, 24, 9, 1, -20 },
  { 2506, 2, 28, 12, 5, -21 },
  { 2513, 10, 24, 9, -1, -20 },
  { 2543, 12, 4, 13, 1, -12 },
};

const GFXfont NotoSans_Condensed_Italic28pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Italic28pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Italic28pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _NOTOSANS_CONDENSED_ITALIC28PT7B_H_
