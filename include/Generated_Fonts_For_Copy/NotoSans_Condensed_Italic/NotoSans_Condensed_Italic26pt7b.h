#ifndef _NOTOSANS_CONDENSED_ITALIC26PT7B_H_
#define _NOTOSANS_CONDENSED_ITALIC26PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Italic.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Italic26pt7bBitmaps[] PROGMEM = {
  0x00, 0x0E, 0x18, 0x30, 0x61, 0xC3, 0x06, 0x0C, 0x18, 0x20, 0xC1, 0x83,
  0x04, 0x00, 0x00, 0x61, 0xC3, 0x80, 0x67, 0xCF, 0x3E, 0x6C, 0xD9, 0xA2,
  0x00, 0x03, 0x18, 0x18, 0x80, 0xCC, 0x04, 0x60, 0x62, 0x03, 0x30, 0xFF,
  0xE1, 0x88, 0x0C, 0xC0, 0x46, 0x06, 0x20, 0x31, 0x2F, 0xFE, 0x18, 0xC0,
  0xC4, 0x06, 0x60, 0x23, 0x03, 0x10, 0x19, 0x80, 0x00, 0x80, 0x18, 0x01,
  0x80, 0xFF, 0x1D, 0x61, 0xB0, 0x33, 0x03, 0x20, 0x1A, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x05, 0x80, 0x4C, 0x04, 0xC0, 0xDC, 0xCB, 0x8F, 0xF0, 0x3C,
  0x01, 0x80, 0x18, 0x01, 0x00, 0x18, 0x18, 0xF0, 0x66, 0x43, 0x31, 0x08,
  0xC4, 0x63, 0x33, 0x08, 0xCC, 0x23, 0x60, 0x89, 0xBE, 0x6D, 0xBF, 0x24,
  0x59, 0xB1, 0x0C, 0xCC, 0x32, 0x31, 0x88, 0xC4, 0x62, 0x31, 0x99, 0x83,
  0x66, 0x0F, 0x00, 0x03, 0x80, 0x3E, 0x03, 0x18, 0x18, 0xC0, 0xC6, 0x06,
  0x60, 0x37, 0x01, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x8E, 0xE6, 0x66, 0x33,
  0x71, 0xF3, 0x07, 0x98, 0x38, 0xE3, 0xC3, 0xFF, 0x1F, 0x18, 0x6F, 0xED,
  0xA0, 0x03, 0x06, 0x0C, 0x18, 0x18, 0x30, 0x30, 0x60, 0x60, 0x60, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x60,
  0x06, 0x06, 0x02, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x07, 0x06, 0x06, 0x06, 0x0C, 0x0C, 0x18, 0x18, 0x30, 0x60, 0xC0, 0x0C,
  0x06, 0x22, 0x1D, 0x07, 0xF8, 0xFC, 0xF1, 0xD8, 0x46, 0x02, 0x00, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x41, 0xFF, 0xFF, 0xF8, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x39, 0x9C, 0xC6, 0x60, 0x7F, 0xF8, 0x7F, 0x80,
  0x00, 0x30, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x30,
  0x07, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00,
  0x60, 0x06, 0x00, 0xC0, 0x00, 0x07, 0x03, 0xE1, 0xCC, 0xE3, 0x30, 0xDC,
  0x36, 0x0D, 0x83, 0x60, 0xF8, 0x3C, 0x1F, 0x06, 0xC1, 0xB0, 0x6C, 0x33,
  0x0C, 0xC6, 0x3F, 0x87, 0xC0, 0x06, 0x1C, 0xF3, 0xEE, 0xC9, 0x87, 0x0C,
  0x18, 0x30, 0x61, 0xC3, 0x06, 0x0C, 0x18, 0x60, 0xC1, 0x80, 0x03, 0xC0,
  0x7E, 0x0C, 0x70, 0x83, 0x00, 0x30, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x07,
  0xFC, 0xFF, 0xC0, 0x07, 0x83, 0xFC, 0x63, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x38, 0x06, 0x0F, 0x83, 0xC0, 0x1E, 0x00, 0xC0, 0x1C, 0x03, 0x80, 0x70,
  0x0C, 0x83, 0x9F, 0xE3, 0xF8, 0x00, 0x00, 0x60, 0x1C, 0x07, 0x80, 0xB0,
  0x3C, 0x0D, 0x81, 0xB0, 0x66, 0x18, 0xC3, 0x30, 0xC6, 0x30, 0xC4, 0x19,
  0xFF, 0xFF, 0xF0, 0x18, 0x03, 0x00, 0x60, 0x18, 0x00, 0x0F, 0xE1, 0xFC,
  0x30, 0x06, 0x01, 0x80, 0x30, 0x06, 0x01, 0x80, 0x3F, 0x86, 0x70, 0x07,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x70, 0x0C, 0x83, 0x9F, 0xE3, 0xF8, 0x00,
  0x01, 0xE0, 0xFC, 0x38, 0x0C, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x30, 0x7F,
  0x9E, 0x73, 0x86, 0x60, 0xCC, 0x19, 0x83, 0x30, 0x66, 0x1C, 0xC3, 0x0F,
  0xC1, 0xF0, 0x00, 0x3F, 0xE7, 0xFC, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00,
  0x60, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x0E, 0x01,
  0x80, 0x70, 0x0C, 0x03, 0x80, 0x00, 0x03, 0x80, 0xFE, 0x1C, 0x61, 0x87,
  0x18, 0x71, 0x86, 0x18, 0x61, 0xCC, 0x0F, 0x80, 0xF0, 0x3B, 0x87, 0x18,
  0x60, 0xCE, 0x0C, 0xC0, 0xCC, 0x0C, 0xE1, 0x87, 0xF8, 0x3F, 0x00, 0x03,
  0x81, 0xF8, 0x73, 0x8C, 0x33, 0x06, 0x60, 0xCC, 0x19, 0x83, 0x30, 0xE6,
  0x1C, 0xFF, 0x0F, 0x60, 0x0C, 0x03, 0x80, 0x60, 0x18, 0x07, 0x1F, 0xC3,
  0xF0, 0x00, 0x19, 0xC6, 0x00, 0x00, 0x00, 0x00, 0x00, 0xCE, 0x70, 0x0C,
  0x30, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x31, 0x86, 0x30, 0xC0,
  0x00, 0x60, 0x3C, 0x1E, 0x0F, 0x03, 0x81, 0xC0, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0x80, 0x10, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0,
  0x78, 0x3C, 0x1E, 0x0F, 0x03, 0x80, 0x40, 0x00, 0x1E, 0x3F, 0x88, 0xC0,
  0x70, 0x30, 0x18, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x06, 0x06, 0x03, 0x00,
  0x00, 0x00, 0xE0, 0x70, 0x30, 0x00, 0x00, 0x70, 0x03, 0xFC, 0x06, 0x0E,
  0x0C, 0x06, 0x18, 0x03, 0x30, 0xE3, 0x21, 0xF3, 0x63, 0x33, 0x66, 0x23,
  0xC4, 0x63, 0xCC, 0x62, 0xCC, 0x66, 0xCC, 0x46, 0xCC, 0xC4, 0xCD, 0xEC,
  0xC7, 0x78, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0xC0, 0x1F, 0xC0,
  0x00, 0x60, 0x0E, 0x00, 0xF0, 0x1B, 0x01, 0xB0, 0x1B, 0x03, 0x30, 0x33,
  0x06, 0x30, 0x63, 0x0C, 0x30, 0xFF, 0x1F, 0xF1, 0x83, 0x38, 0x33, 0x03,
  0x70, 0x36, 0x03, 0xE0, 0x30, 0x0F, 0x00, 0x7F, 0x03, 0x1C, 0x18, 0x61,
  0xC3, 0x8C, 0x18, 0x60, 0xC3, 0x0E, 0x1F, 0xE1, 0xFC, 0x0C, 0x30, 0x60,
  0xC3, 0x06, 0x38, 0x31, 0x81, 0x8C, 0x1C, 0x61, 0xC3, 0xFC, 0x3F, 0xC0,
  0x01, 0xE0, 0x7F, 0x0E, 0x11, 0xC0, 0x38, 0x03, 0x00, 0x70, 0x06, 0x00,
  0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xE0, 0x0E, 0x00,
  0x60, 0x07, 0xF8, 0x3F, 0x80, 0x0F, 0x00, 0x7F, 0x03, 0x3C, 0x18, 0x71,
  0xC1, 0x8C, 0x0C, 0x60, 0x63, 0x03, 0x18, 0x19, 0x80, 0xCC, 0x0E, 0x60,
  0x63, 0x03, 0x38, 0x39, 0x81, 0x8C, 0x1C, 0x63, 0xC3, 0xFC, 0x3F, 0x80,
  0x0F, 0xF0, 0xFF, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x1F, 0xC3, 0xFC, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x07, 0xF0, 0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x0C, 0x00, 0xC0, 0x1C,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x03, 0xFC, 0x3F, 0x83, 0x00, 0x30,
  0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x00, 0x01, 0xF0,
  0x1F, 0xF0, 0xE1, 0x87, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00,
  0x60, 0x03, 0x87, 0xCE, 0x1F, 0x38, 0x0C, 0xC0, 0x73, 0x01, 0x8E, 0x06,
  0x38, 0x18, 0x70, 0xE1, 0xFF, 0x01, 0xFC, 0x00, 0x0C, 0x0E, 0x18, 0x18,
  0x30, 0x30, 0x60, 0x61, 0xC0, 0xC3, 0x03, 0x06, 0x06, 0x0C, 0x0C, 0x1F,
  0xF8, 0x7F, 0xF0, 0xC0, 0xC1, 0x81, 0x83, 0x03, 0x0E, 0x06, 0x18, 0x1C,
  0x30, 0x30, 0x60, 0x60, 0xC0, 0xC3, 0x83, 0x80, 0x0F, 0xC3, 0xF0, 0x70,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x38, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x38, 0x0E, 0x0F, 0xC0, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x30, 0x0C, 0x03,
  0x01, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x30, 0x0C, 0x07, 0x0F,
  0x83, 0xC0, 0x0C, 0x1C, 0x30, 0x60, 0xC3, 0x03, 0x1C, 0x1C, 0xE0, 0x63,
  0x01, 0x98, 0x06, 0xC0, 0x1F, 0x00, 0xDC, 0x03, 0xB0, 0x0C, 0xC0, 0x33,
  0x01, 0xCE, 0x06, 0x18, 0x18, 0x60, 0x61, 0xC1, 0x87, 0x0E, 0x0C, 0x00,
  0x0C, 0x0C, 0x0C, 0x0C, 0x1C, 0x18, 0x18, 0x18, 0x18, 0x30, 0x30, 0x30,
  0x30, 0x70, 0x60, 0x60, 0x60, 0x7F, 0xFF, 0x0E, 0x01, 0xE1, 0xC0, 0x3C,
  0x38, 0x07, 0x07, 0x01, 0xE1, 0xA0, 0x3C, 0x36, 0x0D, 0x86, 0xC1, 0xE0,
  0xD8, 0x6C, 0x1B, 0x0D, 0x86, 0x63, 0x30, 0xCC, 0x6E, 0x19, 0x99, 0x83,
  0x33, 0x30, 0xE6, 0xC6, 0x18, 0xD8, 0xC3, 0x1E, 0x38, 0x63, 0xC6, 0x0C,
  0x70, 0xC3, 0x0E, 0x18, 0x00, 0x0E, 0x06, 0x1C, 0x0C, 0x38, 0x18, 0x70,
  0x31, 0xB0, 0xC3, 0x61, 0x86, 0xC3, 0x0D, 0x86, 0x19, 0x8C, 0x63, 0x30,
  0xC6, 0x61, 0x8C, 0xC3, 0x19, 0x8E, 0x1F, 0x18, 0x3C, 0x30, 0x78, 0x60,
  0xF0, 0xC0, 0xE3, 0x01, 0x80, 0x03, 0xC0, 0x3F, 0x83, 0x8C, 0x30, 0x73,
  0x81, 0x98, 0x0D, 0xC0, 0x6C, 0x03, 0x60, 0x1B, 0x00, 0xF8, 0x0F, 0xC0,
  0x6C, 0x03, 0x60, 0x3B, 0x81, 0x9C, 0x1C, 0x61, 0xC3, 0xFC, 0x0F, 0xC0,
  0x0F, 0x00, 0xFE, 0x0C, 0xF0, 0xC3, 0x1C, 0x31, 0x83, 0x18, 0x31, 0x87,
  0x18, 0x63, 0x1E, 0x3F, 0xC3, 0xE0, 0x30, 0x07, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x3F, 0x83, 0x8C, 0x30, 0x73,
  0x81, 0x98, 0x0D, 0xC0, 0x6C, 0x03, 0x60, 0x1B, 0x00, 0xF8, 0x0F, 0xC0,
  0x6C, 0x03, 0x60, 0x3B, 0x81, 0x9C, 0x1C, 0x61, 0xC3, 0xFC, 0x0F, 0xC0,
  0x0E, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x0F, 0x80, 0xFE, 0x0C, 0xF0,
  0xC3, 0x1C, 0x31, 0x83, 0x18, 0x31, 0x87, 0x18, 0xE3, 0xFC, 0x3F, 0x83,
  0x30, 0x33, 0x07, 0x18, 0x61, 0x86, 0x18, 0x61, 0xC6, 0x1C, 0xE0, 0xC0,
  0x03, 0xC0, 0xFF, 0x1C, 0x61, 0x80, 0x38, 0x03, 0x00, 0x38, 0x01, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x83, 0x8F, 0xF0, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0xC0, 0x30, 0x1C, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x07, 0x01,
  0x80, 0x60, 0x18, 0x0E, 0x00, 0x18, 0x18, 0xC0, 0xC6, 0x06, 0x70, 0x33,
  0x03, 0x98, 0x18, 0xC0, 0xC6, 0x06, 0x70, 0x33, 0x03, 0x18, 0x18, 0xC0,
  0xC6, 0x06, 0x70, 0x73, 0x03, 0x18, 0x18, 0xE1, 0x83, 0xFC, 0x0F, 0xC0,
  0xC0, 0x7C, 0x06, 0xE0, 0x6E, 0x0C, 0xE0, 0xCE, 0x1C, 0x61, 0x86, 0x38,
  0x63, 0x06, 0x30, 0x66, 0x06, 0x60, 0x6C, 0x06, 0xC0, 0x78, 0x07, 0x80,
  0x78, 0x07, 0x00, 0x70, 0x00, 0xE0, 0xE0, 0xFC, 0x1C, 0x1B, 0x83, 0x83,
  0x70, 0xF0, 0xCC, 0x1E, 0x19, 0x86, 0xC7, 0x30, 0xD8, 0xC6, 0x13, 0x18,
  0xC6, 0x46, 0x18, 0xC8, 0xC3, 0x31, 0x38, 0x66, 0x26, 0x0C, 0x84, 0xC1,
  0xB0, 0xB0, 0x36, 0x16, 0x07, 0x83, 0x80, 0xF0, 0x70, 0x1C, 0x0E, 0x03,
  0x81, 0x80, 0x00, 0x0C, 0x1C, 0x30, 0x60, 0xC3, 0x83, 0x8C, 0x06, 0x60,
  0x1B, 0x80, 0x6C, 0x01, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x60,
  0x0D, 0x80, 0x66, 0x03, 0x98, 0x0C, 0x60, 0x61, 0xC3, 0x83, 0x0C, 0x0C,
  0x00, 0xC0, 0xFC, 0x19, 0x87, 0x30, 0xC6, 0x30, 0xC6, 0x19, 0x83, 0x30,
  0x7C, 0x07, 0x80, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x00, 0x60,
  0x0C, 0x03, 0x80, 0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x0C, 0x00, 0xE0, 0x0E,
  0x00, 0x60, 0x07, 0x00, 0x30, 0x03, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00,
  0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x07, 0xFC, 0x3F, 0xE0, 0x07,
  0xC1, 0xF0, 0x60, 0x18, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x06, 0x01, 0x80,
  0x60, 0x1F, 0x0F, 0xC0, 0xCC, 0xCC, 0xCC, 0xC6, 0x66, 0x66, 0x66, 0x23,
  0x33, 0x30, 0x07, 0xC1, 0xF0, 0x0C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x1F, 0x0F, 0x80, 0x03, 0x00, 0x60, 0x1C, 0x02,
  0xC0, 0xD8, 0x31, 0x06, 0x31, 0x86, 0x30, 0x6C, 0x0F, 0x81, 0x80, 0xFF,
  0xFF, 0x80, 0xCE, 0x63, 0x0F, 0x63, 0xEC, 0xC7, 0x38, 0x66, 0x0C, 0xC1,
  0xB0, 0x76, 0x0C, 0xC1, 0x98, 0x33, 0x0E, 0x63, 0xCF, 0xF0, 0xF6, 0x00,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0xC0, 0x30, 0x06, 0xF0, 0xFF, 0x1C,
  0x67, 0x0C, 0xE1, 0x98, 0x33, 0x06, 0x60, 0xD8, 0x3B, 0x06, 0x60, 0xCE,
  0x31, 0x7E, 0x6F, 0x80, 0x0F, 0x8F, 0x8C, 0x0C, 0x06, 0x07, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0F, 0xE3, 0xF0, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x06, 0x00, 0x60, 0x06, 0x0F, 0x61, 0xF6, 0x30, 0xC7, 0x0C, 0x60,
  0xCE, 0x0C, 0xC1, 0xCC, 0x18, 0xC1, 0x8C, 0x18, 0xC3, 0x8C, 0x78, 0xFF,
  0x07, 0xB0, 0x0F, 0x0F, 0xCC, 0x6C, 0x36, 0x1F, 0x1B, 0xF9, 0xF0, 0xC0,
  0x60, 0x30, 0x18, 0x0F, 0xE3, 0xF0, 0x00, 0x78, 0x07, 0x80, 0x70, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x1F, 0x81, 0xF8, 0x03, 0x00, 0x18, 0x01, 0xC0,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x00, 0xF0, 0x07, 0x00,
  0x00, 0x07, 0xB0, 0xFB, 0x18, 0x63, 0x86, 0x30, 0x67, 0x06, 0x60, 0xE6,
  0x0C, 0x60, 0xC6, 0x0C, 0x61, 0xC6, 0x3C, 0x7F, 0x83, 0xD8, 0x01, 0x80,
  0x18, 0x03, 0x08, 0x70, 0xFE, 0x0F, 0xC0, 0x0E, 0x01, 0x80, 0x30, 0x06,
  0x01, 0xC0, 0x30, 0x06, 0xF0, 0xFF, 0x1C, 0x67, 0x0C, 0xE1, 0x98, 0x33,
  0x0C, 0x61, 0x98, 0x33, 0x06, 0x61, 0xCC, 0x31, 0x86, 0x60, 0xC0, 0x0C,
  0x30, 0xC0, 0x00, 0x61, 0x86, 0x38, 0xC3, 0x0C, 0x31, 0x86, 0x18, 0x61,
  0x8C, 0x00, 0x01, 0x80, 0xC0, 0x60, 0x00, 0x00, 0x18, 0x0C, 0x06, 0x07,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0xC1, 0xE0, 0xE0, 0x00, 0x0E, 0x01, 0x80, 0x30, 0x06,
  0x01, 0xC0, 0x30, 0x06, 0x18, 0xC6, 0x19, 0x87, 0x70, 0xDC, 0x1B, 0x03,
  0xE0, 0x7C, 0x1D, 0x83, 0x18, 0x63, 0x0C, 0x61, 0x8E, 0x60, 0xC0, 0x0E,
  0x18, 0x30, 0x61, 0xC3, 0x06, 0x0C, 0x18, 0x70, 0xC1, 0x83, 0x06, 0x18,
  0x30, 0x60, 0xC1, 0x86, 0x00, 0x1B, 0xCF, 0x0F, 0xFF, 0xC7, 0x1C, 0x67,
  0x0C, 0x33, 0x06, 0x19, 0x86, 0x0C, 0xC3, 0x0C, 0x61, 0x86, 0x60, 0xC3,
  0x30, 0xE1, 0x98, 0x61, 0xCC, 0x30, 0xC6, 0x18, 0x66, 0x0C, 0x30, 0x1B,
  0xC3, 0xFC, 0x71, 0x9C, 0x33, 0x86, 0x61, 0xCC, 0x31, 0x86, 0x70, 0xCC,
  0x19, 0x87, 0x30, 0xCE, 0x19, 0x83, 0x00, 0x0F, 0x0F, 0xE3, 0x1D, 0x83,
  0x60, 0xF8, 0x3C, 0x0F, 0x07, 0xC1, 0xB0, 0x6C, 0x3B, 0x0C, 0xFE, 0x1F,
  0x00, 0x0D, 0xE0, 0xFF, 0x0E, 0x31, 0xC3, 0x1C, 0x31, 0x83, 0x18, 0x31,
  0x83, 0x30, 0x73, 0x06, 0x30, 0x63, 0x8C, 0x3F, 0xC6, 0xF8, 0x60, 0x06,
  0x00, 0x60, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0x0F, 0x63, 0xEC, 0xC7, 0x38,
  0x66, 0x0D, 0xC1, 0xB0, 0x76, 0x0C, 0xC1, 0x98, 0x33, 0x0E, 0x63, 0xCF,
  0xF0, 0xF6, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x1B,
  0x8F, 0xC7, 0x07, 0x03, 0x81, 0x80, 0xC0, 0x60, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x06, 0x00, 0x1F, 0x9F, 0xCC, 0x06, 0x03, 0x01, 0xC0, 0x70, 0x1C,
  0x06, 0x03, 0x81, 0xD0, 0xCF, 0xE7, 0xE0, 0x18, 0x30, 0xC3, 0xFF, 0xC6,
  0x1C, 0x30, 0x60, 0xC1, 0x86, 0x0C, 0x18, 0x30, 0x78, 0xF0, 0x30, 0x66,
  0x18, 0xC3, 0x30, 0x66, 0x0C, 0xC3, 0x98, 0x67, 0x0C, 0xC1, 0x98, 0x73,
  0x0E, 0x63, 0x8F, 0xF0, 0xF6, 0x00, 0xE0, 0xD8, 0x66, 0x19, 0x8C, 0x63,
  0x19, 0xC6, 0x61, 0xB8, 0x6C, 0x1B, 0x07, 0x81, 0xE0, 0x70, 0x1C, 0x00,
  0xC3, 0x0F, 0x8E, 0x1B, 0x1C, 0x36, 0x28, 0xCC, 0xD1, 0x99, 0x66, 0x36,
  0xCC, 0x6D, 0x98, 0xF3, 0x61, 0x66, 0xC2, 0x8F, 0x07, 0x1E, 0x0E, 0x38,
  0x18, 0x70, 0x00, 0x18, 0x71, 0xC6, 0x0C, 0xC0, 0xDC, 0x0D, 0x80, 0xF0,
  0x06, 0x00, 0xE0, 0x0F, 0x01, 0xB0, 0x33, 0x03, 0x30, 0x61, 0x8E, 0x18,
  0x0C, 0x18, 0x61, 0x83, 0x0C, 0x18, 0xE0, 0xC6, 0x06, 0x70, 0x33, 0x01,
  0x98, 0x0D, 0x80, 0x6C, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x30,
  0x01, 0x80, 0x18, 0x00, 0xC0, 0x3C, 0x01, 0xC0, 0x00, 0x1F, 0xC7, 0xF0,
  0x18, 0x0E, 0x03, 0x01, 0x80, 0xE0, 0x30, 0x18, 0x0E, 0x03, 0x01, 0x80,
  0x7F, 0x3F, 0xC0, 0x00, 0x40, 0xF0, 0x30, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x30, 0x0C, 0x03, 0x01, 0x81, 0xC0, 0xF0, 0x06, 0x01, 0x80, 0x60, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0F, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x08, 0x07, 0x01, 0xC0, 0x60, 0x30, 0x18, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0x70, 0x78, 0x60, 0x30, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x03, 0x07, 0x83, 0x80, 0x38, 0x3F, 0xCE, 0x1F, 0x40, 0x00,
};

const GFXglyph NotoSans_Condensed_Italic26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 7, 19, 6, 0, -19 },
  { 18, 7, 7, 9, 3, -19 },
  { 25, 13, 19, 13, 0, -19 },
  { 56, 12, 22, 11, 0, -20 },
  { 89, 14, 19, 17, 2, -19 },
  { 123, 13, 19, 13, 0, -19 },
  { 154, 3, 7, 5, 3, -19 },
  { 157, 8, 23, 7, 1, -19 },
  { 180, 8, 23, 7, -2, -19 },
  { 203, 9, 10, 11, 3, -20 },
  { 215, 11, 12, 12, 1, -15 },
  { 232, 5, 6, 6, -1, -3 },
  { 236, 7, 2, 7, 0, -8 },
  { 238, 3, 3, 6, 0, -3 },
  { 240, 12, 19, 9, -1, -19 },
  { 269, 10, 19, 11, 1, -19 },
  { 293, 7, 19, 11, 3, -19 },
  { 310, 12, 19, 11, -1, -19 },
  { 339, 11, 19, 11, 0, -19 },
  { 366, 11, 19, 11, 0, -19 },
  { 393, 11, 19, 11, 0, -19 },
  { 420, 11, 19, 11, 1, -19 },
  { 447, 11, 19, 11, 1, -19 },
  { 474, 12, 19, 11, 0, -19 },
  { 503, 11, 19, 11, 0, -19 },
  { 530, 5, 14, 6, 0, -14 },
  { 539, 6, 17, 6, -1, -14 },
  { 552, 11, 12, 12, 1, -15 },
  { 569, 11, 7, 12, 1, -13 },
  { 579, 11, 12, 12, 1, -15 },
  { 596, 9, 19, 9, 1, -19 },
  { 618, 16, 21, 17, 1, -19 },
  { 660, 12, 19, 12, -2, -19 },
  { 689, 13, 19, 13, 0, -19 },
  { 720, 12, 19, 12, 1, -19 },
  { 749, 13, 19, 14, 0, -19 },
  { 780, 12, 19, 11, 0, -19 },
  { 809, 12, 19, 10, 0, -19 },
  { 838, 14, 19, 14, 1, -19 },
  { 872, 15, 19, 14, 0, -19 },
  { 908, 10, 19, 7, -1, -19 },
  { 932, 10, 24, 6, -4, -19 },
  { 962, 14, 19, 12, 0, -19 },
  { 996, 8, 19, 10, 0, -19 },
  { 1015, 19, 19, 18, 0, -19 },
  { 1061, 15, 19, 15, 0, -19 },
  { 1097, 13, 19, 15, 1, -19 },
  { 1128, 12, 19, 12, 0, -19 },
  { 1157, 13, 23, 15, 1, -19 },
  { 1195, 12, 19, 12, 0, -19 },
  { 1224, 12, 19, 11, 0, -19 },
  { 1253, 10, 19, 10, 2, -19 },
  { 1277, 13, 19, 14, 1, -19 },
  { 1308, 12, 19, 12, 2, -19 },
  { 1337, 19, 19, 19, 2, -19 },
  { 1383, 14, 19, 11, -1, -19 },
  { 1417, 11, 19, 10, 2, -19 },
  { 1444, 13, 19, 10, -1, -19 },
  { 1475, 10, 23, 7, -1, -19 },
  { 1504, 4, 19, 9, 3, -19 },
  { 1514, 10, 23, 7, -2, -19 },
  { 1543, 11, 11, 12, 0, -19 },
  { 1559, 9, 2, 9, -2, 2 },
  { 1562, 4, 4, 7, 4, -20 },
  { 1564, 11, 14, 12, 1, -14 },
  { 1584, 11, 20, 12, 0, -20 },
  { 1612, 9, 14, 9, 1, -14 },
  { 1628, 12, 20, 12, 1, -20 },
  { 1658, 9, 14, 11, 1, -14 },
  { 1674, 13, 26, 7, -3, -20 },
  { 1717, 12, 20, 12, 0, -14 },
  { 1747, 11, 20, 12, 0, -20 },
  { 1775, 6, 19, 6, 0, -19 },
  { 1790, 9, 25, 6, -3, -19 },
  { 1819, 11, 20, 10, 0, -20 },
  { 1847, 7, 20, 5, 0, -20 },
  { 1865, 17, 14, 18, 0, -14 },
  { 1895, 11, 14, 12, 0, -14 },
  { 1915, 10, 14, 12, 1, -14 },
  { 1933, 12, 20, 12, -1, -14 },
  { 1963, 11, 20, 12, 1, -14 },
  { 1991, 9, 14, 8, 0, -14 },
  { 2007, 9, 14, 9, 0, -14 },
  { 2023, 7, 17, 7, 1, -17 },
  { 2038, 11, 14, 12, 1, -14 },
  { 2058, 10, 14, 10, 1, -14 },
  { 2076, 15, 14, 16, 2, -14 },
  { 2103, 12, 14, 10, -1, -14 },
  { 2124, 13, 20, 10, -2, -14 },
  { 2157, 10, 14, 9, -1, -14 },
  { 2175, 10, 23, 9, 0, -19 },
  { 2204, 2, 26, 11, 5, -20 },
  { 2211, 9, 23, 9, -1, -19 },
  { 2237, 11, 4, 12, 1, -11 },
};

const GFXfont NotoSans_Condensed_Italic26pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Italic26pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Italic26pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _NOTOSANS_CONDENSED_ITALIC26PT7B_H_
