#ifndef _NOTOSANS_CONDENSED_ITALIC52PT7B_H_
#define _NOTOSANS_CONDENSED_ITALIC52PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Italic.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Italic52pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x07, 0x80,
  0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1C, 0x01, 0xC0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x02, 0x00, 0x3E, 0x3E,
  0x7C, 0x7C, 0xF0, 0xF1, 0xE1, 0xE3, 0xC3, 0xCF, 0x07, 0x9E, 0x0E, 0x3C,
  0x3C, 0x78, 0x78, 0xE0, 0xF1, 0xC1, 0xC3, 0x83, 0x8F, 0x0F, 0x00, 0x00,
  0x07, 0x03, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x38, 0x1C, 0x00, 0x07, 0x03,
  0x80, 0x00, 0xE0, 0xF0, 0x00, 0x3C, 0x1C, 0x00, 0x07, 0x03, 0x80, 0x00,
  0xE0, 0xF0, 0x00, 0x3C, 0x1C, 0x00, 0x07, 0x03, 0x80, 0x3F, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x80, 0x3C,
  0x1E, 0x00, 0x07, 0x83, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x1C, 0x1E, 0x00,
  0x07, 0x83, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x1C, 0x1E, 0x00, 0x07, 0x83,
  0x80, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0xC0, 0x1C, 0x0E, 0x00, 0x03, 0x83, 0xC0, 0x00, 0xF0, 0x70,
  0x00, 0x1C, 0x0E, 0x00, 0x03, 0x83, 0xC0, 0x00, 0xF0, 0x70, 0x00, 0x1C,
  0x0E, 0x00, 0x03, 0x83, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x1C, 0x0E, 0x00,
  0x03, 0x83, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x01, 0xC0, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0,
  0xFF, 0xFE, 0x07, 0xCE, 0x18, 0x1E, 0x38, 0x00, 0xF0, 0xC0, 0x03, 0xC3,
  0x00, 0x0F, 0x1C, 0x00, 0x3C, 0x70, 0x00, 0xF1, 0xC0, 0x03, 0xE6, 0x00,
  0x07, 0xD8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1D, 0xF0, 0x00, 0x63,
  0xC0, 0x01, 0x8F, 0x00, 0x0E, 0x3C, 0x00, 0x38, 0x70, 0x00, 0xE3, 0xC0,
  0x03, 0x0F, 0x00, 0x0C, 0x3C, 0x30, 0x71, 0xE0, 0xF1, 0xDF, 0x83, 0xFF,
  0xFC, 0x0F, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x03, 0x80, 0x7F, 0x80, 0x1C, 0x03,
  0xFE, 0x00, 0xF0, 0x1E, 0x3C, 0x03, 0x80, 0x70, 0xF0, 0x1E, 0x03, 0xC3,
  0xC0, 0x70, 0x0E, 0x0F, 0x03, 0xC0, 0x78, 0x3C, 0x1E, 0x01, 0xE0, 0xF0,
  0x70, 0x07, 0x03, 0x83, 0xC0, 0x1C, 0x0E, 0x0E, 0x00, 0xF0, 0x38, 0x78,
  0x03, 0xC1, 0xE3, 0xC0, 0x0F, 0x07, 0x8E, 0x00, 0x38, 0x1C, 0x78, 0x70,
  0xE0, 0x71, 0xC7, 0xF3, 0x83, 0xCF, 0x3F, 0xEE, 0x0E, 0x38, 0xF7, 0xBC,
  0x79, 0xE7, 0x8F, 0xFF, 0xCF, 0x3C, 0x3D, 0xFE, 0x38, 0xE0, 0xF3, 0xF1,
  0xE3, 0x83, 0xC7, 0x07, 0x1E, 0x0F, 0x00, 0x3C, 0x70, 0x38, 0x01, 0xE1,
  0xC0, 0xE0, 0x07, 0x0F, 0x03, 0x80, 0x3C, 0x3C, 0x1E, 0x00, 0xE0, 0xF0,
  0x78, 0x07, 0x83, 0x81, 0xC0, 0x3C, 0x0E, 0x07, 0x00, 0xF0, 0x38, 0x3C,
  0x07, 0x80, 0xE0, 0xE0, 0x1C, 0x03, 0x87, 0x80, 0xF0, 0x0F, 0x1C, 0x03,
  0x80, 0x3F, 0xF0, 0x1E, 0x00, 0x7F, 0x80, 0xF0, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x07, 0x87, 0x80, 0x07, 0x83, 0xC0, 0x03, 0xC1,
  0xE0, 0x03, 0xC0, 0xF0, 0x01, 0xE0, 0x78, 0x00, 0xF0, 0x3C, 0x00, 0x78,
  0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x1F, 0x00, 0x0F, 0x9F, 0x00, 0x03,
  0xDF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xE0, 0x78, 0x7C, 0xF0, 0x3C,
  0x7C, 0x7C, 0x3C, 0x7C, 0x3E, 0x1E, 0x3C, 0x0F, 0x1F, 0x3E, 0x07, 0xCF,
  0x1E, 0x01, 0xEF, 0x8F, 0x00, 0xFF, 0x8F, 0x80, 0x3F, 0x87, 0xC0, 0x1F,
  0xC3, 0xE0, 0x07, 0xC1, 0xF0, 0x07, 0xE0, 0xF8, 0x07, 0xF0, 0x3C, 0x07,
  0xFC, 0x1F, 0x8F, 0xFE, 0x0F, 0xFF, 0xCF, 0x83, 0xFF, 0xC7, 0xC0, 0x7F,
  0x81, 0xF0, 0x04, 0x00, 0x00, 0x3E, 0x7C, 0xF1, 0xE3, 0xC7, 0x9E, 0x3C,
  0x78, 0xF1, 0xC3, 0x8F, 0x00, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x38, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x03,
  0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0x78, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x38, 0x00, 0xF0, 0x00, 0x00, 0x40, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x18, 0x3C, 0x07, 0x8E, 0x03, 0xFB, 0x81, 0x7F,
  0xFF, 0xC3, 0xFF, 0xF0, 0x1F, 0xFC, 0x0F, 0x80, 0x07, 0xF0, 0x03, 0xDE,
  0x01, 0xE3, 0x81, 0xF0, 0xF0, 0x3C, 0x3C, 0x06, 0x07, 0x80, 0x81, 0xC0,
  0x00, 0x40, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x87, 0xC3, 0xC3, 0xE1, 0xE0, 0xF0,
  0xF0, 0x78, 0x78, 0x3C, 0x1C, 0x1E, 0x0E, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x7B, 0xEF, 0xFE, 0xFB, 0xC2, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x06, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xF8,
  0x03, 0xFF, 0xC0, 0x3F, 0x1F, 0x01, 0xF0, 0x78, 0x1F, 0x03, 0xC1, 0xF0,
  0x1E, 0x0F, 0x00, 0xF0, 0x78, 0x07, 0xC7, 0xC0, 0x3E, 0x3C, 0x01, 0xE3,
  0xE0, 0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x03, 0xCF, 0x80, 0x1E, 0x7C, 0x00,
  0xF3, 0xC0, 0x07, 0x9E, 0x00, 0x7C, 0xF0, 0x03, 0xEF, 0x80, 0x1E, 0x7C,
  0x00, 0xF3, 0xC0, 0x07, 0x9E, 0x00, 0x7C, 0xF0, 0x03, 0xC7, 0x80, 0x1E,
  0x3C, 0x01, 0xF1, 0xE0, 0x0F, 0x0F, 0x00, 0x78, 0x78, 0x07, 0xC3, 0xC0,
  0x3C, 0x1E, 0x03, 0xE0, 0xF0, 0x1E, 0x07, 0xC1, 0xF0, 0x1F, 0x3F, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x7C, 0x03, 0xE0, 0x1F, 0x81, 0xFE, 0x0F, 0xF8, 0x7D, 0xE3, 0xEF, 0x3F,
  0x3C, 0xF8, 0xF1, 0xC7, 0xC2, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xF8, 0x01, 0xFF, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0xE0, 0x3E, 0x00, 0x80,
  0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3E, 0x0F,
  0xC0, 0x30, 0x0F, 0x80, 0x40, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x03,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC1, 0x00, 0x1F, 0x03,
  0xC1, 0xFE, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xDC, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xBC, 0x00, 0x07, 0x3C, 0x00, 0x0F, 0x3C, 0x00, 0x1E, 0x78,
  0x00, 0x1C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x78, 0x78, 0x00, 0x70, 0xF8,
  0x00, 0xF0, 0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xC0, 0xF0, 0x03, 0xC0, 0xF0,
  0x07, 0x81, 0xF0, 0x0F, 0x01, 0xE0, 0x0F, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x3C, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xFC,
  0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x10, 0x1F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0xC0, 0x0F, 0x81, 0xE0, 0xFF, 0x03, 0xFF, 0xFC, 0x07, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFC, 0x08, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x1F, 0xC0, 0x3D, 0xFF, 0x81, 0xFF, 0xFF, 0x07, 0xF8, 0xFC,
  0x1F, 0x80, 0xF0, 0x7C, 0x03, 0xE3, 0xF0, 0x0F, 0x8F, 0x80, 0x3E, 0x3E,
  0x00, 0x78, 0xF0, 0x03, 0xE3, 0xC0, 0x0F, 0x8F, 0x00, 0x3E, 0x3C, 0x00,
  0xF0, 0xF0, 0x03, 0xC3, 0xC0, 0x1F, 0x0F, 0x00, 0x78, 0x3C, 0x01, 0xE0,
  0xF8, 0x0F, 0x81, 0xE0, 0x7C, 0x07, 0xE7, 0xE0, 0x0F, 0xFF, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x10, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0x87, 0xE0, 0x3C, 0x07,
  0xC0, 0xF8, 0x07, 0x81, 0xE0, 0x0F, 0x03, 0xC0, 0x1E, 0x07, 0x80, 0x3C,
  0x0F, 0x00, 0x78, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x7C, 0x0F, 0x00,
  0x78, 0x3E, 0x00, 0xF8, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF8, 0x01, 0xF8, 0xF8, 0x07, 0xE0,
  0xF8, 0x1F, 0x01, 0xF0, 0x3C, 0x01, 0xE0, 0xF8, 0x03, 0xE1, 0xE0, 0x03,
  0xC3, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x1F, 0x00, 0x1E, 0x3E, 0x00, 0x7C,
  0x3C, 0x00, 0xF0, 0x78, 0x03, 0xE0, 0xF8, 0x07, 0x81, 0xF8, 0x3F, 0x01,
  0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F,
  0x1F, 0x03, 0xE0, 0x7C, 0x1E, 0x01, 0xE1, 0xF0, 0x0F, 0x0F, 0x00, 0x78,
  0xF8, 0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x00, 0xF1, 0xE0, 0x07, 0x9F, 0x00,
  0x3C, 0xF8, 0x01, 0xE7, 0xC0, 0x1F, 0x3E, 0x00, 0xF9, 0xF0, 0x0F, 0xC7,
  0x80, 0xFC, 0x3E, 0x0F, 0xE1, 0xFD, 0xFF, 0x07, 0xFF, 0x78, 0x3F, 0xF7,
  0xC0, 0x7E, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x30, 0x7E, 0x01, 0xFF, 0xE0, 0x0F, 0xFE,
  0x00, 0x7F, 0xC0, 0x00, 0x60, 0x00, 0x00, 0x03, 0xC0, 0x7C, 0x1F, 0x83,
  0xF0, 0x7C, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x03, 0xE0, 0x7C, 0x1F, 0x83, 0xF0, 0x3C, 0x02, 0x00, 0x00,
  0x38, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0,
  0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7C, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0x80,
  0x00, 0xE0, 0x00, 0x08, 0x00, 0x00, 0x00, 0xE0, 0x03, 0xFE, 0x07, 0xFF,
  0xC3, 0xFF, 0xE1, 0xE1, 0xF8, 0xC0, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0x80, 0x00, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0xF0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00,
  0x0E, 0x07, 0x80, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x0E, 0x0F, 0x01, 0xFE,
  0x0F, 0x0E, 0x03, 0xFF, 0x0F, 0x1C, 0x07, 0xFF, 0x07, 0x1C, 0x0F, 0x0E,
  0x0F, 0x3C, 0x1E, 0x0E, 0x0F, 0x38, 0x1C, 0x1E, 0x0F, 0x78, 0x38, 0x1E,
  0x0E, 0x70, 0x38, 0x1C, 0x0E, 0x70, 0x70, 0x1C, 0x0E, 0x70, 0x70, 0x3C,
  0x0E, 0xF0, 0xF0, 0x3C, 0x1E, 0xF0, 0xF0, 0x38, 0x1C, 0xE0, 0xE0, 0x38,
  0x1C, 0xE0, 0xE0, 0x78, 0x3C, 0xE0, 0xE0, 0x78, 0x38, 0xE0, 0xE0, 0xF8,
  0x78, 0xE0, 0xE0, 0xF8, 0x70, 0xE0, 0xF1, 0xF8, 0xF0, 0xE0, 0xFF, 0xBF,
  0xE0, 0xE0, 0x7F, 0x1F, 0xC0, 0xE0, 0x3E, 0x1F, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x30,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xEF, 0x00, 0x03, 0xDE,
  0x00, 0x07, 0xBC, 0x00, 0x1E, 0x78, 0x00, 0x3C, 0xF0, 0x00, 0xF1, 0xE0,
  0x01, 0xE3, 0xC0, 0x07, 0xC7, 0x80, 0x0F, 0x0F, 0x00, 0x3E, 0x1E, 0x00,
  0x78, 0x3E, 0x00, 0xF0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0xF0, 0x1F,
  0x01, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x07, 0xFF,
  0xFE, 0x0F, 0x80, 0x3C, 0x3E, 0x00, 0x78, 0x7C, 0x00, 0xF0, 0xF0, 0x01,
  0xE3, 0xE0, 0x03, 0xC7, 0x80, 0x07, 0x9F, 0x00, 0x0F, 0x3C, 0x00, 0x1E,
  0xF8, 0x00, 0x3D, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xE0,
  0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFE,
  0x03, 0xE0, 0x3F, 0x03, 0xE0, 0x1F, 0x03, 0xC0, 0x1F, 0x03, 0xC0, 0x0F,
  0x03, 0xC0, 0x0F, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0x80, 0x1E,
  0x07, 0x80, 0x3E, 0x07, 0x80, 0x3E, 0x0F, 0x80, 0x7C, 0x0F, 0x03, 0xF8,
  0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x1F, 0x0F, 0xE0,
  0x1E, 0x01, 0xF0, 0x1E, 0x00, 0xF8, 0x1E, 0x00, 0xF8, 0x3E, 0x00, 0x78,
  0x3E, 0x00, 0x78, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0xF8,
  0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x78, 0x01, 0xF0, 0x78, 0x03, 0xF0,
  0x78, 0x07, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF,
  0xE0, 0x0F, 0xFF, 0xE0, 0x0F, 0xF1, 0xE0, 0x0F, 0xC0, 0x10, 0x0F, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00,
  0x40, 0x0F, 0xF3, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x3E, 0x07, 0xF0, 0x1F, 0x00, 0xF8,
  0x0F, 0x00, 0x7E, 0x07, 0x80, 0x1F, 0x03, 0xC0, 0x0F, 0x83, 0xE0, 0x03,
  0xC1, 0xF0, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0x78, 0x00, 0x78, 0x3C, 0x00,
  0x3C, 0x3E, 0x00, 0x1E, 0x1F, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x87, 0x80,
  0x07, 0xC3, 0xC0, 0x03, 0xE3, 0xE0, 0x01, 0xF1, 0xE0, 0x00, 0xF0, 0xF0,
  0x00, 0xF8, 0x78, 0x00, 0x7C, 0x7C, 0x00, 0x3C, 0x3E, 0x00, 0x3E, 0x1E,
  0x00, 0x1F, 0x0F, 0x00, 0x1F, 0x07, 0x80, 0x0F, 0x87, 0xC0, 0x0F, 0x83,
  0xE0, 0x0F, 0x81, 0xE0, 0x0F, 0xC0, 0xF0, 0x0F, 0xC0, 0x78, 0x1F, 0xC0,
  0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF,
  0xE0, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x10, 0x0F,
  0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF,
  0xF0, 0x0F, 0xF0, 0x7C, 0x03, 0xF8, 0x01, 0x80, 0xFC, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x07, 0xFC, 0x3E, 0x01, 0xFF, 0x87, 0x80, 0x3F, 0xF0, 0xF0, 0x07,
  0xFE, 0x1E, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xF0, 0xF8, 0x00, 0x1E, 0x1F,
  0x00, 0x03, 0xC3, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x1E, 0x07, 0x80, 0x03,
  0xC0, 0xF0, 0x00, 0x78, 0x1F, 0x00, 0x0F, 0x03, 0xE0, 0x03, 0xE0, 0x3E,
  0x00, 0x78, 0x07, 0xE0, 0x0F, 0x00, 0x7F, 0x8F, 0xE0, 0x0F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0xF0, 0x1E, 0x00, 0x1F, 0x01, 0xE0, 0x01, 0xF0, 0x1E, 0x00,
  0x1E, 0x01, 0xE0, 0x01, 0xE0, 0x3E, 0x00, 0x1E, 0x03, 0xC0, 0x03, 0xE0,
  0x3C, 0x00, 0x3C, 0x03, 0xC0, 0x03, 0xC0, 0x7C, 0x00, 0x3C, 0x07, 0xC0,
  0x07, 0xC0, 0x78, 0x00, 0x7C, 0x07, 0x80, 0x07, 0x80, 0x78, 0x00, 0x78,
  0x0F, 0x80, 0x07, 0x80, 0xF8, 0x00, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x1E, 0x00, 0x1F,
  0x01, 0xE0, 0x01, 0xE0, 0x1E, 0x00, 0x1E, 0x01, 0xE0, 0x01, 0xE0, 0x3E,
  0x00, 0x1E, 0x03, 0xC0, 0x03, 0xE0, 0x3C, 0x00, 0x3C, 0x03, 0xC0, 0x03,
  0xC0, 0x7C, 0x00, 0x3C, 0x07, 0xC0, 0x07, 0xC0, 0x78, 0x00, 0x7C, 0x07,
  0x80, 0x07, 0x80, 0x78, 0x00, 0x78, 0x0F, 0x80, 0x07, 0x80, 0xF0, 0x00,
  0xF8, 0x0F, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xF0,
  0x1F, 0xFF, 0x00, 0xFF, 0xC0, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F,
  0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01,
  0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x7F, 0xF8,
  0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0xFF,
  0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x07, 0xE0, 0x3C, 0x00, 0xF8, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x0F, 0x80,
  0x3E, 0x03, 0xE0, 0x07, 0xC0, 0x78, 0x00, 0xF0, 0x1F, 0x00, 0x1E, 0x07,
  0xC0, 0x03, 0xC1, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x03,
  0xC3, 0xE0, 0x00, 0x78, 0xF8, 0x00, 0x0F, 0x3E, 0x00, 0x03, 0xE7, 0xC0,
  0x00, 0x79, 0xF0, 0x00, 0x0F, 0x7C, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x3E, 0x3C, 0x00,
  0x07, 0x87, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0xF0, 0x3E, 0x00, 0x1E, 0x07, 0xC0, 0x07, 0xC0, 0x78, 0x00,
  0xF8, 0x0F, 0x00, 0x1E, 0x01, 0xF0, 0x03, 0xC0, 0x3E, 0x00, 0x78, 0x03,
  0xC0, 0x1F, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x80, 0x78, 0x01, 0xF0, 0x0F,
  0x00, 0x1E, 0x00, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x00, 0x7F, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x3F, 0xC0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x03,
  0xDE, 0x03, 0xFC, 0x00, 0x3D, 0xE0, 0x7B, 0xC0, 0x07, 0xBC, 0x07, 0xBC,
  0x00, 0x7B, 0xC0, 0x7B, 0xC0, 0x0F, 0x3C, 0x07, 0xBC, 0x00, 0xF3, 0xC0,
  0x79, 0xC0, 0x1F, 0x7C, 0x0F, 0x1C, 0x01, 0xE7, 0x80, 0xF1, 0xC0, 0x3E,
  0x78, 0x0F, 0x1E, 0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0x78, 0x0F, 0x1E,
  0x07, 0x8F, 0x81, 0xE1, 0xE0, 0x78, 0xF0, 0x1E, 0x1E, 0x0F, 0x0F, 0x01,
  0xE1, 0xE0, 0xF0, 0xF0, 0x1E, 0x1E, 0x1E, 0x1F, 0x03, 0xE1, 0xE1, 0xE1,
  0xF0, 0x3C, 0x1E, 0x3C, 0x1E, 0x03, 0xC1, 0xE3, 0xC1, 0xE0, 0x3C, 0x1E,
  0x78, 0x1E, 0x03, 0xC1, 0xE7, 0x83, 0xE0, 0x7C, 0x0E, 0xF0, 0x3C, 0x07,
  0x80, 0xEF, 0x03, 0xC0, 0x78, 0x0F, 0xE0, 0x3C, 0x07, 0x80, 0xFE, 0x03,
  0xC0, 0x78, 0x0F, 0xC0, 0x7C, 0x0F, 0x00, 0xFC, 0x07, 0x80, 0xF0, 0x0F,
  0x80, 0x78, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0xF0, 0x0F, 0x00, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x7C, 0x07, 0xE0, 0x01, 0xE0, 0x1F, 0x80, 0x07, 0x80,
  0x7E, 0x00, 0x1E, 0x03, 0xF8, 0x00, 0xF8, 0x0F, 0xF0, 0x03, 0xC0, 0x3F,
  0xC0, 0x0F, 0x00, 0xFF, 0x00, 0x3C, 0x03, 0xFC, 0x00, 0xF0, 0x1E, 0x78,
  0x07, 0xC0, 0x79, 0xE0, 0x1E, 0x01, 0xE7, 0x80, 0x78, 0x07, 0x9E, 0x01,
  0xE0, 0x1E, 0x3C, 0x07, 0x80, 0xF0, 0xF0, 0x3E, 0x03, 0xC3, 0xC0, 0xF0,
  0x0F, 0x0F, 0x03, 0xC0, 0x3C, 0x3C, 0x0F, 0x00, 0xF0, 0x78, 0x3C, 0x07,
  0x81, 0xE1, 0xE0, 0x1E, 0x07, 0x87, 0x80, 0x78, 0x1E, 0x1E, 0x01, 0xE0,
  0x3C, 0x78, 0x0F, 0x80, 0xF3, 0xE0, 0x3C, 0x03, 0xCF, 0x00, 0xF0, 0x0F,
  0x3C, 0x03, 0xC0, 0x3C, 0xF0, 0x0F, 0x00, 0x7B, 0xC0, 0x7C, 0x01, 0xEF,
  0x01, 0xE0, 0x07, 0xF8, 0x07, 0x80, 0x1F, 0xE0, 0x1E, 0x00, 0x3F, 0x80,
  0x78, 0x00, 0xFE, 0x03, 0xC0, 0x03, 0xF0, 0x0F, 0x00, 0x0F, 0xC0, 0x3C,
  0x00, 0x1F, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0xFC, 0x3F, 0x80,
  0x7C, 0x03, 0xE0, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x07,
  0xC3, 0xE0, 0x00, 0xF0, 0xF8, 0x00, 0x3C, 0x7C, 0x00, 0x0F, 0x1F, 0x00,
  0x03, 0xC7, 0x80, 0x00, 0xF3, 0xE0, 0x00, 0x3C, 0xF8, 0x00, 0x0F, 0x3C,
  0x00, 0x07, 0xDF, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x7D, 0xF0, 0x00, 0x1F,
  0x78, 0x00, 0x07, 0x9E, 0x00, 0x01, 0xE7, 0x80, 0x00, 0xFB, 0xE0, 0x00,
  0x3E, 0xF8, 0x00, 0x0F, 0x3E, 0x00, 0x07, 0xCF, 0x80, 0x01, 0xF3, 0xE0,
  0x00, 0x78, 0xF8, 0x00, 0x3E, 0x1E, 0x00, 0x1F, 0x07, 0x80, 0x07, 0xC1,
  0xF0, 0x03, 0xE0, 0x7C, 0x01, 0xF8, 0x0F, 0x80, 0xFC, 0x03, 0xFD, 0xFE,
  0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x0F,
  0xFF, 0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0xF0, 0x0F, 0x81, 0xE0,
  0x0F, 0x03, 0xC0, 0x1E, 0x0F, 0x80, 0x3C, 0x1F, 0x00, 0x78, 0x3C, 0x00,
  0xF0, 0x78, 0x03, 0xE0, 0xF0, 0x07, 0xC3, 0xE0, 0x1F, 0x07, 0x80, 0x3E,
  0x0F, 0x00, 0xF8, 0x1E, 0x03, 0xF0, 0x3C, 0x3F, 0xC0, 0xFF, 0xFF, 0x01,
  0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x01,
  0xFF, 0xFC, 0x00, 0xFC, 0x3F, 0x80, 0x7C, 0x03, 0xE0, 0x3E, 0x00, 0x7C,
  0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x07, 0xC3, 0xE0, 0x00, 0xF0, 0xF8, 0x00,
  0x3C, 0x7C, 0x00, 0x0F, 0x1F, 0x00, 0x03, 0xC7, 0x80, 0x00, 0xF3, 0xE0,
  0x00, 0x3C, 0xF8, 0x00, 0x0F, 0x3C, 0x00, 0x03, 0xDF, 0x00, 0x01, 0xF7,
  0xC0, 0x00, 0x7D, 0xF0, 0x00, 0x1F, 0x78, 0x00, 0x07, 0x9E, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0x3E, 0x00,
  0x07, 0xCF, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0x78, 0xF8, 0x00, 0x3E, 0x1E,
  0x00, 0x1F, 0x07, 0x80, 0x07, 0xC1, 0xF0, 0x03, 0xE0, 0x7C, 0x01, 0xF8,
  0x0F, 0x80, 0xFC, 0x03, 0xFD, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3E, 0x07,
  0xE0, 0x7C, 0x07, 0xC0, 0xF0, 0x0F, 0x81, 0xE0, 0x0F, 0x03, 0xC0, 0x1E,
  0x0F, 0x80, 0x3C, 0x1F, 0x00, 0x78, 0x3C, 0x01, 0xF0, 0x78, 0x03, 0xE0,
  0xF0, 0x07, 0x83, 0xE0, 0x1F, 0x07, 0xC0, 0x3E, 0x0F, 0x01, 0xF8, 0x1E,
  0x0F, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x07, 0x87, 0xC0, 0x1F, 0x07, 0x80, 0x3E, 0x0F, 0x00, 0x78, 0x1E,
  0x00, 0xF0, 0x3E, 0x01, 0xE0, 0x7C, 0x07, 0xC0, 0x78, 0x0F, 0x80, 0xF0,
  0x1E, 0x01, 0xF0, 0x3C, 0x03, 0xE0, 0x78, 0x03, 0xC1, 0xF0, 0x07, 0x83,
  0xC0, 0x0F, 0x87, 0x80, 0x1F, 0x0F, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFE, 0x3E,
  0x01, 0xF0, 0x06, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x80, 0x07, 0xE0,
  0x60, 0x0F, 0xC0, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x80, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x03, 0xE0, 0x78, 0x00, 0x7C, 0x0F, 0x00,
  0x0F, 0x03, 0xE0, 0x01, 0xE0, 0x7C, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x81,
  0xE0, 0x01, 0xE0, 0x3C, 0x00, 0x3C, 0x0F, 0x80, 0x07, 0x81, 0xE0, 0x01,
  0xF0, 0x3C, 0x00, 0x3E, 0x07, 0x80, 0x07, 0x80, 0xF0, 0x00, 0xF0, 0x3E,
  0x00, 0x1E, 0x07, 0x80, 0x07, 0xC0, 0xF0, 0x00, 0xF8, 0x1E, 0x00, 0x1E,
  0x07, 0xC0, 0x03, 0xC0, 0xF8, 0x00, 0x78, 0x1E, 0x00, 0x1F, 0x03, 0xC0,
  0x03, 0xC0, 0x78, 0x00, 0x78, 0x1F, 0x00, 0x0F, 0x03, 0xE0, 0x03, 0xE0,
  0x78, 0x00, 0x7C, 0x0F, 0x00, 0x0F, 0x01, 0xE0, 0x01, 0xE0, 0x7C, 0x00,
  0x7C, 0x0F, 0x80, 0x0F, 0x81, 0xF0, 0x01, 0xE0, 0x1E, 0x00, 0x7C, 0x03,
  0xC0, 0x1F, 0x00, 0x7C, 0x07, 0xE0, 0x0F, 0xF3, 0xF8, 0x00, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFB, 0xC0, 0x01, 0xF7, 0x80, 0x07, 0xCF,
  0x00, 0x0F, 0x9E, 0x00, 0x1E, 0x3C, 0x00, 0x7C, 0x78, 0x00, 0xF0, 0xF0,
  0x03, 0xE1, 0xE0, 0x07, 0x83, 0xC0, 0x1F, 0x07, 0x80, 0x3C, 0x0F, 0x00,
  0xF8, 0x1E, 0x01, 0xF0, 0x3C, 0x03, 0xC0, 0x78, 0x0F, 0x80, 0xF0, 0x1E,
  0x01, 0xE0, 0x7C, 0x03, 0xC0, 0xF0, 0x07, 0x83, 0xE0, 0x0F, 0x07, 0x80,
  0x1E, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x78, 0x00, 0xF1, 0xE0, 0x00,
  0xF3, 0xC0, 0x01, 0xEF, 0x80, 0x03, 0xDE, 0x00, 0x07, 0xBC, 0x00, 0x0E,
  0xF0, 0x00, 0x1D, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0x00, 0x1F, 0xF0, 0x01, 0xF0, 0x01,
  0xEF, 0x00, 0x1F, 0x00, 0x3E, 0xF0, 0x03, 0xF0, 0x03, 0xCF, 0x00, 0x3F,
  0x00, 0x3C, 0xF0, 0x07, 0xF0, 0x07, 0xCF, 0x00, 0x77, 0x00, 0x78, 0xF0,
  0x0F, 0x70, 0x0F, 0x8F, 0x00, 0xFF, 0x00, 0xF0, 0xF0, 0x0E, 0xF0, 0x0F,
  0x0F, 0x01, 0xEF, 0x01, 0xF0, 0xF0, 0x1E, 0xF0, 0x1E, 0x0F, 0x03, 0xCF,
  0x03, 0xE0, 0xF0, 0x3C, 0xF0, 0x3C, 0x0F, 0x03, 0x8F, 0x03, 0xC0, 0xF0,
  0x78, 0xF0, 0x78, 0x0F, 0x07, 0x8F, 0x07, 0x80, 0xF0, 0xF0, 0xF0, 0xF8,
  0x0F, 0x0F, 0x0F, 0x0F, 0x00, 0xF0, 0xE0, 0xF0, 0xF0, 0x0F, 0x1E, 0x0F,
  0x1E, 0x00, 0xF1, 0xC0, 0xF1, 0xE0, 0x0F, 0x3C, 0x0F, 0x3E, 0x00, 0xF3,
  0xC0, 0xF3, 0xC0, 0x0F, 0x78, 0x0F, 0x3C, 0x00, 0xF7, 0x80, 0xF7, 0x80,
  0x0F, 0x70, 0x0F, 0x78, 0x00, 0xFF, 0x00, 0xF7, 0x80, 0x0F, 0xF0, 0x0F,
  0xF0, 0x00, 0xEE, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0xFC,
  0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0x0F, 0x80, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x78,
  0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0xF8, 0x00, 0xF8, 0x07,
  0x80, 0x03, 0xC0, 0x7C, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0xF0, 0x3C, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x1E, 0x00, 0x00, 0xF1, 0xF0, 0x00, 0x07,
  0x8F, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0x78,
  0x00, 0x00, 0xF1, 0xE0, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0x78, 0x78, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0x7C, 0x1E, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x3E,
  0x03, 0xC0, 0x03, 0xE0, 0x1E, 0x00, 0x1E, 0x00, 0xF0, 0x01, 0xF0, 0x07,
  0x80, 0x0F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x0F, 0x80, 0x07, 0x80,
  0x00, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xEF, 0x00, 0x3C, 0xF8,
  0x07, 0xCF, 0x80, 0x78, 0x78, 0x0F, 0x87, 0x80, 0xF0, 0x78, 0x1F, 0x07,
  0x81, 0xE0, 0x78, 0x3C, 0x07, 0x87, 0xC0, 0x7C, 0x78, 0x03, 0xCF, 0x80,
  0x3C, 0xF0, 0x03, 0xDF, 0x00, 0x3D, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00,
  0x7F, 0xE0, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x82, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0xF0,
  0x38, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x38, 0x1C, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x1C, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x0E, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x0E, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00,
  0x03, 0xDC, 0x00, 0x0F, 0x78, 0x00, 0x79, 0xE0, 0x01, 0xE3, 0x80, 0x0F,
  0x0F, 0x00, 0x3C, 0x3C, 0x01, 0xE0, 0x70, 0x07, 0x01, 0xE0, 0x3C, 0x07,
  0x81, 0xE0, 0x0F, 0x07, 0x80, 0x3C, 0x3C, 0x00, 0xF0, 0xF0, 0x01, 0xE7,
  0x80, 0x07, 0x9E, 0x00, 0x1E, 0xF0, 0x00, 0x3C, 0x7F, 0xFF, 0xDF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xF3, 0xE3, 0xC3, 0xC7, 0x87, 0x07,
  0x00, 0xFE, 0x3C, 0x07, 0xFC, 0xF0, 0x7F, 0xF3, 0x81, 0xF9, 0xFE, 0x0F,
  0x81, 0xF8, 0x7C, 0x07, 0xE1, 0xF0, 0x0F, 0x8F, 0x80, 0x3C, 0x3C, 0x00,
  0xF0, 0xF0, 0x03, 0xC7, 0xC0, 0x1F, 0x1E, 0x00, 0x7C, 0x78, 0x01, 0xE3,
  0xE0, 0x07, 0x8F, 0x80, 0x1E, 0x3C, 0x00, 0xF8, 0xF0, 0x03, 0xC3, 0xC0,
  0x0F, 0x0F, 0x00, 0x7C, 0x3C, 0x01, 0xF0, 0xF0, 0x07, 0xC3, 0xC0, 0x3E,
  0x0F, 0x01, 0xF8, 0x3E, 0x0F, 0xE0, 0xFC, 0x77, 0x81, 0xFF, 0x9E, 0x07,
  0xFE, 0x70, 0x0F, 0xE1, 0xC0, 0x04, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x7F, 0x00, 0x79, 0xFF,
  0x00, 0xF7, 0xFF, 0x01, 0xFE, 0x7E, 0x07, 0xF0, 0x3C, 0x0F, 0xC0, 0x7C,
  0x1F, 0x80, 0xF8, 0x3E, 0x01, 0xF0, 0x78, 0x03, 0xE1, 0xF0, 0x07, 0xC3,
  0xE0, 0x0F, 0x87, 0x80, 0x1E, 0x0F, 0x00, 0x3C, 0x3E, 0x00, 0x78, 0x78,
  0x00, 0xF0, 0xF0, 0x03, 0xE1, 0xE0, 0x07, 0x83, 0xC0, 0x0F, 0x0F, 0x80,
  0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0xF8, 0x0F,
  0x83, 0xF0, 0x3E, 0x07, 0xF8, 0xFC, 0x0F, 0x7F, 0xF0, 0x1C, 0xFF, 0xC0,
  0x78, 0xFF, 0x00, 0x00, 0x20, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x3F,
  0xF8, 0x1F, 0x8E, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00,
  0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x10,
  0x7C, 0x18, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xC0, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0xFE, 0x3C, 0x01, 0xFF, 0x7C, 0x07, 0xFF, 0x78, 0x07, 0xE7, 0xF8,
  0x0F, 0x81, 0xF8, 0x1F, 0x01, 0xF8, 0x1E, 0x00, 0xF8, 0x3E, 0x00, 0xF0,
  0x3C, 0x00, 0xF0, 0x7C, 0x00, 0xF0, 0x7C, 0x01, 0xF0, 0x78, 0x01, 0xE0,
  0x78, 0x01, 0xE0, 0xF8, 0x01, 0xE0, 0xF8, 0x01, 0xE0, 0xF0, 0x03, 0xE0,
  0xF0, 0x03, 0xC0, 0xF0, 0x03, 0xC0, 0xF0, 0x07, 0xC0, 0xF0, 0x07, 0xC0,
  0xF0, 0x0F, 0xC0, 0xF0, 0x0F, 0x80, 0xF0, 0x1F, 0x80, 0xF8, 0x3F, 0x80,
  0xFC, 0x77, 0x80, 0x7F, 0xE7, 0x00, 0x7F, 0xC7, 0x00, 0x3F, 0x87, 0x00,
  0x04, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x03, 0xE3,
  0xE0, 0xF8, 0x3E, 0x3E, 0x03, 0xC7, 0x80, 0x79, 0xF0, 0x1E, 0x3C, 0x03,
  0xCF, 0x80, 0xF9, 0xE0, 0x3E, 0x3C, 0x1F, 0x8F, 0xFF, 0xF1, 0xFF, 0xF8,
  0x3F, 0xFC, 0x07, 0xF8, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x10,
  0x7C, 0x0E, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFC, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF,
  0x80, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x8F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x8F, 0x00, 0x7F, 0xCF, 0x00, 0xFF, 0xCE, 0x01, 0xF9,
  0xFE, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0x7E, 0x07, 0x80, 0x7E, 0x0F, 0x80,
  0x3C, 0x0F, 0x00, 0x3C, 0x0F, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x1E, 0x00,
  0x78, 0x1E, 0x00, 0x78, 0x3E, 0x00, 0x78, 0x3E, 0x00, 0x78, 0x3C, 0x00,
  0xF8, 0x3C, 0x00, 0xF0, 0x3C, 0x00, 0xF0, 0x3C, 0x01, 0xF0, 0x3C, 0x01,
  0xF0, 0x3C, 0x03, 0xF0, 0x3C, 0x03, 0xE0, 0x3C, 0x07, 0xE0, 0x3E, 0x0F,
  0xE0, 0x3F, 0x1D, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFB, 0xC0, 0x0F, 0xE3,
  0xC0, 0x01, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x80, 0x3F,
  0x00, 0xF0, 0x7E, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC7,
  0xF0, 0x0F, 0x3F, 0xE0, 0x3D, 0xFF, 0xC0, 0xFF, 0x3F, 0x07, 0xF0, 0x7C,
  0x1F, 0x80, 0xF0, 0x7C, 0x03, 0xC1, 0xF0, 0x0F, 0x07, 0x80, 0x3C, 0x3E,
  0x01, 0xF0, 0xF0, 0x07, 0x83, 0xC0, 0x1E, 0x0F, 0x00, 0x78, 0x7C, 0x01,
  0xE1, 0xE0, 0x0F, 0x87, 0x80, 0x3C, 0x1E, 0x00, 0xF0, 0x78, 0x03, 0xC3,
  0xE0, 0x1F, 0x0F, 0x00, 0x7C, 0x3C, 0x01, 0xE0, 0xF0, 0x07, 0x83, 0xC0,
  0x1E, 0x1F, 0x00, 0xF8, 0x78, 0x03, 0xC1, 0xE0, 0x0F, 0x07, 0x80, 0x3C,
  0x3E, 0x01, 0xF0, 0x00, 0x70, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x7C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00,
  0x8F, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x03, 0xE0,
  0x78, 0x0F, 0x80, 0xF0, 0x3E, 0x01, 0xE0, 0xF8, 0x07, 0xC1, 0xE0, 0x0F,
  0x07, 0xC0, 0x1E, 0x1F, 0x00, 0x3C, 0x7C, 0x00, 0x79, 0xF0, 0x01, 0xE3,
  0xC0, 0x03, 0xCF, 0x00, 0x07, 0xBE, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF8,
  0x00, 0x7F, 0xF0, 0x00, 0xFD, 0xE0, 0x01, 0xF3, 0xE0, 0x03, 0xC3, 0xC0,
  0x0F, 0x87, 0x80, 0x1E, 0x0F, 0x80, 0x3C, 0x1F, 0x00, 0x78, 0x1E, 0x00,
  0xF0, 0x3C, 0x03, 0xE0, 0x7C, 0x07, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x1E,
  0x01, 0xE0, 0x7C, 0x03, 0xE0, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07,
  0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0x03, 0xC7,
  0xF0, 0x7F, 0x00, 0xF3, 0xFE, 0x3F, 0xE0, 0x39, 0xFF, 0x9F, 0xFC, 0x0E,
  0xF3, 0xEF, 0x3F, 0x07, 0xF0, 0x7F, 0x07, 0xC1, 0xF8, 0x1F, 0x80, 0xF0,
  0x7C, 0x07, 0xE0, 0x3C, 0x1F, 0x01, 0xF0, 0x0F, 0x07, 0x80, 0x7C, 0x03,
  0xC3, 0xE0, 0x1E, 0x01, 0xF0, 0xF0, 0x07, 0x80, 0x78, 0x3C, 0x01, 0xE0,
  0x1E, 0x0F, 0x00, 0xF8, 0x07, 0x87, 0xC0, 0x3C, 0x01, 0xE1, 0xE0, 0x0F,
  0x00, 0xF8, 0x78, 0x03, 0xC0, 0x3C, 0x1E, 0x01, 0xF0, 0x0F, 0x07, 0x80,
  0x78, 0x03, 0xC3, 0xE0, 0x1E, 0x01, 0xF0, 0xF0, 0x07, 0x80, 0x78, 0x3C,
  0x01, 0xE0, 0x1E, 0x0F, 0x00, 0xF8, 0x07, 0x83, 0xC0, 0x3C, 0x01, 0xE1,
  0xF0, 0x0F, 0x00, 0xF8, 0x78, 0x03, 0xC0, 0x3C, 0x1E, 0x00, 0xF0, 0x0F,
  0x07, 0x80, 0x7C, 0x03, 0xC3, 0xE0, 0x1E, 0x01, 0xF0, 0x03, 0xC7, 0xF0,
  0x0F, 0x3F, 0xE0, 0x39, 0xFF, 0xC0, 0xEF, 0xBF, 0x07, 0xF0, 0x7C, 0x1F,
  0x80, 0xF0, 0x7C, 0x03, 0xC1, 0xF0, 0x0F, 0x0F, 0x80, 0x3C, 0x3E, 0x01,
  0xF0, 0xF8, 0x07, 0x83, 0xC0, 0x1E, 0x0F, 0x00, 0x78, 0x7C, 0x03, 0xE1,
  0xF0, 0x0F, 0x87, 0x80, 0x3C, 0x1E, 0x00, 0xF0, 0x78, 0x03, 0xC3, 0xE0,
  0x1F, 0x0F, 0x00, 0x7C, 0x3C, 0x01, 0xE0, 0xF0, 0x07, 0x87, 0xC0, 0x1E,
  0x1F, 0x00, 0xF8, 0x78, 0x03, 0xC1, 0xE0, 0x0F, 0x07, 0x80, 0x3C, 0x3E,
  0x01, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x7C, 0x7E,
  0x0F, 0x81, 0xE1, 0xF0, 0x1F, 0x1E, 0x01, 0xF3, 0xE0, 0x0F, 0x3C, 0x00,
  0xF7, 0xC0, 0x0F, 0x78, 0x00, 0xF7, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x3E, 0xF0,
  0x03, 0xCF, 0x00, 0x7C, 0xF0, 0x07, 0xCF, 0x00, 0xF8, 0xF0, 0x0F, 0x8F,
  0x81, 0xF0, 0x7C, 0x7E, 0x07, 0xFF, 0xC0, 0x3F, 0xF8, 0x01, 0xFF, 0x00,
  0x00, 0xF1, 0xFC, 0x00, 0x79, 0xFF, 0x00, 0x3D, 0xFF, 0xC0, 0x1D, 0xE3,
  0xE0, 0x1F, 0xC0, 0xF0, 0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x3E, 0x03, 0xE0,
  0x1F, 0x01, 0xE0, 0x0F, 0x81, 0xF0, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0x78,
  0x01, 0xE0, 0x3C, 0x00, 0xF0, 0x1E, 0x00, 0x78, 0x1E, 0x00, 0x3C, 0x0F,
  0x00, 0x3E, 0x07, 0x80, 0x1E, 0x03, 0xC0, 0x0F, 0x03, 0xE0, 0x0F, 0x81,
  0xF0, 0x07, 0xC0, 0xF8, 0x03, 0xC0, 0x7C, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3F, 0x03, 0xE0, 0x1F, 0xE3, 0xF0, 0x0F, 0x7F, 0xF0, 0x07, 0xBF, 0xF0,
  0x03, 0xC7, 0xF0, 0x03, 0xE0, 0x80, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x3C, 0x07, 0xFC, 0xF0, 0x7F,
  0xF3, 0x81, 0xF9, 0xFE, 0x0F, 0x81, 0xF8, 0x7C, 0x07, 0xE1, 0xE0, 0x1F,
  0x8F, 0x80, 0x3C, 0x3C, 0x00, 0xF0, 0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x1E,
  0x00, 0x78, 0x78, 0x01, 0xE3, 0xE0, 0x07, 0x8F, 0x80, 0x1E, 0x3C, 0x00,
  0xF8, 0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x0F, 0x00, 0x7C, 0x3C, 0x01, 0xF0,
  0xF0, 0x0F, 0xC3, 0xC0, 0x3E, 0x0F, 0x01, 0xF8, 0x3E, 0x0F, 0xE0, 0xFC,
  0x77, 0x81, 0xFF, 0xFE, 0x07, 0xFE, 0xF0, 0x0F, 0xE3, 0xC0, 0x04, 0x0F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x03, 0xC7, 0xC0, 0xE3, 0xF0,
  0x39, 0xFC, 0x0E, 0xFE, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F,
  0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03,
  0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0xFF, 0xF0, 0x7F, 0xFC, 0x3F, 0x0E, 0x0F, 0x00, 0x87, 0xC0, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x03, 0xE2, 0x00, 0xF0, 0xE0, 0xFC, 0x3F, 0xFE, 0x0F, 0xFF, 0x01, 0xFF,
  0x80, 0x02, 0x00, 0x00, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x78,
  0x03, 0xC0, 0x7F, 0xEF, 0xFF, 0x7F, 0xFB, 0xFF, 0xC7, 0xC0, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xE2, 0x1F, 0xF0, 0xFF, 0x83, 0xFC, 0x02,
  0x00, 0x0F, 0x00, 0x78, 0x78, 0x03, 0xC3, 0xC0, 0x1E, 0x3E, 0x00, 0xF1,
  0xE0, 0x0F, 0x8F, 0x00, 0x78, 0x78, 0x03, 0xC3, 0xC0, 0x1E, 0x3E, 0x01,
  0xF1, 0xE0, 0x0F, 0x0F, 0x00, 0x78, 0x78, 0x03, 0xC3, 0xC0, 0x1E, 0x3E,
  0x01, 0xF1, 0xE0, 0x0F, 0x0F, 0x00, 0x78, 0x78, 0x03, 0xC7, 0xC0, 0x3E,
  0x3C, 0x01, 0xF1, 0xE0, 0x0F, 0x0F, 0x00, 0xF8, 0x78, 0x07, 0xC3, 0xC0,
  0x7E, 0x1E, 0x07, 0xF0, 0xF8, 0xFF, 0x07, 0xFF, 0x78, 0x1F, 0xF3, 0xC0,
  0x7F, 0x1E, 0x00, 0x40, 0x00, 0x00, 0xF0, 0x01, 0xFE, 0x00, 0x7B, 0xC0,
  0x0F, 0x78, 0x03, 0xEF, 0x00, 0x79, 0xE0, 0x1F, 0x3C, 0x03, 0xC7, 0x80,
  0xF8, 0xF0, 0x1E, 0x1E, 0x07, 0xC3, 0xC0, 0xF0, 0x78, 0x1E, 0x0F, 0x07,
  0x80, 0xE0, 0xF0, 0x1C, 0x3C, 0x03, 0x87, 0x80, 0x71, 0xE0, 0x0F, 0x3C,
  0x01, 0xEF, 0x80, 0x3D, 0xE0, 0x07, 0xBC, 0x00, 0xFF, 0x00, 0x1D, 0xE0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00,
  0x00, 0xF0, 0x07, 0xC0, 0x3F, 0xC0, 0x3F, 0x00, 0xFF, 0x00, 0xFC, 0x07,
  0xBC, 0x07, 0xF0, 0x1E, 0xF0, 0x1F, 0xC0, 0xFB, 0xC0, 0x7F, 0x03, 0xCF,
  0x03, 0xFC, 0x0F, 0x3C, 0x0E, 0xF0, 0x78, 0xF0, 0x7B, 0xC1, 0xE3, 0xC1,
  0xCE, 0x0F, 0x0F, 0x07, 0x38, 0x3C, 0x3C, 0x3C, 0xE0, 0xF0, 0xF0, 0xE3,
  0x87, 0x83, 0xC7, 0x8E, 0x1E, 0x0F, 0x1C, 0x38, 0xF0, 0x3C, 0x70, 0xE3,
  0xC0, 0xF3, 0xC3, 0x8F, 0x03, 0xCE, 0x0E, 0x78, 0x0F, 0x78, 0x39, 0xE0,
  0x3D, 0xC0, 0xEF, 0x00, 0xF7, 0x03, 0xBC, 0x03, 0xFC, 0x0E, 0xE0, 0x0F,
  0xE0, 0x3F, 0x80, 0x3F, 0x80, 0xFE, 0x00, 0xFC, 0x03, 0xF0, 0x03, 0xF0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x3E, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x03, 0xC0,
  0x1F, 0x03, 0xE0, 0x3E, 0x01, 0xE0, 0x3C, 0x01, 0xE0, 0x7C, 0x01, 0xE0,
  0xF8, 0x01, 0xF0, 0xF0, 0x00, 0xF1, 0xE0, 0x00, 0xF3, 0xE0, 0x00, 0xF3,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xEF, 0x00, 0x03, 0xCF, 0x00, 0x07, 0x8F,
  0x00, 0x0F, 0x8F, 0x80, 0x0F, 0x07, 0x80, 0x1E, 0x07, 0x80, 0x3E, 0x07,
  0x80, 0x7C, 0x07, 0xC0, 0x78, 0x03, 0xC0, 0xF8, 0x03, 0xC0, 0x00, 0xF0,
  0x01, 0xE0, 0x1E, 0x00, 0x7C, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x03, 0xE0,
  0x0F, 0x00, 0x78, 0x01, 0xE0, 0x1F, 0x00, 0x3E, 0x03, 0xC0, 0x03, 0xC0,
  0x78, 0x00, 0x78, 0x1E, 0x00, 0x0F, 0x03, 0xC0, 0x01, 0xE0, 0xF0, 0x00,
  0x3C, 0x1E, 0x00, 0x07, 0x87, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x1E, 0x3E,
  0x00, 0x03, 0xC7, 0x80, 0x00, 0x79, 0xF0, 0x00, 0x0F, 0x3C, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x3D, 0xE0, 0x00, 0x07, 0xBC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x08,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xFF,
  0xF0, 0x3F, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x01, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x1F,
  0xC0, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00,
  0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xF8, 0x00,
  0x7F, 0x00, 0x3F, 0xC0, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0x80, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x00,
  0x0F, 0xC0, 0x00, 0x0E, 0x00, 0x09, 0xFF, 0x00, 0x5F, 0xFE, 0x07, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0x0F, 0xFA, 0x00, 0x1F, 0x00,
};

const GFXglyph NotoSans_Condensed_Italic52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 12, 38, 13, 1, -37 },
  { 58, 15, 13, 18, 5, -37 },
  { 83, 27, 37, 25, 0, -37 },
  { 208, 22, 42, 23, 1, -39 },
  { 324, 30, 39, 35, 3, -38 },
  { 471, 25, 39, 26, 0, -38 },
  { 593, 7, 13, 10, 5, -37 },
  { 605, 16, 45, 14, 1, -37 },
  { 695, 16, 45, 14, -4, -37 },
  { 785, 18, 20, 22, 5, -40 },
  { 830, 20, 25, 25, 3, -31 },
  { 893, 9, 13, 11, -2, -6 },
  { 908, 12, 4, 14, 1, -16 },
  { 914, 6, 7, 11, 1, -6 },
  { 920, 25, 37, 18, -3, -37 },
  { 1036, 21, 39, 23, 2, -38 },
  { 1139, 14, 37, 23, 6, -37 },
  { 1204, 24, 38, 23, -1, -38 },
  { 1318, 23, 39, 23, 0, -38 },
  { 1431, 24, 37, 23, -1, -37 },
  { 1542, 23, 38, 23, 0, -37 },
  { 1652, 22, 39, 23, 2, -38 },
  { 1760, 23, 37, 23, 2, -37 },
  { 1867, 23, 39, 23, 0, -38 },
  { 1980, 21, 39, 23, 1, -38 },
  { 2083, 11, 29, 11, 0, -28 },
  { 2123, 14, 35, 11, -3, -28 },
  { 2185, 21, 24, 25, 2, -31 },
  { 2248, 20, 15, 25, 3, -26 },
  { 2286, 20, 24, 25, 3, -31 },
  { 2346, 17, 39, 17, 2, -38 },
  { 2429, 32, 41, 35, 2, -37 },
  { 2593, 23, 37, 23, -3, -37 },
  { 2700, 24, 37, 25, 1, -37 },
  { 2811, 25, 39, 23, 2, -38 },
  { 2933, 25, 37, 27, 1, -37 },
  { 3049, 23, 37, 21, 1, -37 },
  { 3156, 23, 37, 20, 1, -37 },
  { 3263, 27, 39, 29, 2, -38 },
  { 3395, 28, 37, 28, 1, -37 },
  { 3525, 20, 37, 15, -2, -37 },
  { 3618, 21, 47, 12, -8, -37 },
  { 3742, 27, 37, 24, 1, -37 },
  { 3867, 15, 37, 20, 1, -37 },
  { 3937, 36, 37, 37, 1, -37 },
  { 4104, 30, 37, 30, 1, -37 },
  { 4243, 26, 39, 29, 2, -38 },
  { 4370, 23, 37, 24, 1, -37 },
  { 4477, 26, 47, 29, 2, -38 },
  { 4630, 23, 37, 24, 1, -37 },
  { 4737, 24, 39, 22, -1, -38 },
  { 4854, 20, 37, 20, 4, -37 },
  { 4947, 27, 38, 28, 2, -37 },
  { 5076, 23, 37, 23, 5, -37 },
  { 5183, 36, 37, 37, 5, -37 },
  { 5350, 29, 37, 22, -3, -37 },
  { 5485, 20, 37, 21, 5, -37 },
  { 5578, 25, 37, 20, -2, -37 },
  { 5694, 20, 45, 15, -1, -37 },
  { 5807, 9, 37, 18, 5, -37 },
  { 5849, 20, 45, 15, -4, -37 },
  { 5962, 22, 21, 23, 1, -37 },
  { 6020, 18, 4, 17, -5, 4 },
  { 6029, 7, 8, 13, 8, -40 },
  { 6036, 22, 29, 24, 2, -28 },
  { 6116, 23, 41, 24, 0, -40 },
  { 6234, 18, 29, 19, 2, -28 },
  { 6300, 24, 41, 24, 2, -40 },
  { 6423, 19, 29, 22, 2, -28 },
  { 6492, 26, 52, 13, -6, -40 },
  { 6661, 24, 40, 24, 0, -28 },
  { 6781, 22, 40, 24, 0, -40 },
  { 6891, 13, 38, 11, 0, -38 },
  { 6953, 20, 50, 11, -7, -38 },
  { 7078, 23, 40, 21, 0, -40 },
  { 7193, 13, 40, 11, 0, -40 },
  { 7258, 34, 28, 36, 0, -28 },
  { 7377, 22, 28, 24, 0, -28 },
  { 7454, 20, 28, 24, 2, -28 },
  { 7524, 25, 40, 24, -2, -28 },
  { 7649, 22, 40, 24, 2, -28 },
  { 7759, 18, 28, 16, 0, -28 },
  { 7822, 18, 29, 18, 0, -28 },
  { 7888, 13, 35, 14, 2, -34 },
  { 7945, 21, 29, 24, 2, -28 },
  { 8022, 19, 28, 20, 3, -28 },
  { 8089, 30, 28, 31, 3, -28 },
  { 8194, 24, 28, 20, -2, -28 },
  { 8278, 27, 41, 20, -5, -28 },
  { 8417, 20, 28, 17, -2, -28 },
  { 8487, 19, 45, 17, 1, -37 },
  { 8594, 4, 52, 22, 9, -40 },
  { 8620, 19, 45, 17, -3, -37 },
  { 8727, 21, 7, 25, 2, -22 },
};

const GFXfont NotoSans_Condensed_Italic52pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Italic52pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Italic52pt7bGlyphs,
  0x20, 0x7E, 71
};

#endif // _NOTOSANS_CONDENSED_ITALIC52PT7B_H_
