#ifndef _NOTOSANS_CONDENSED_ITALIC64PT7B_H_
#define _NOTOSANS_CONDENSED_ITALIC64PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Italic.ttf
// Size: 64pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Italic64pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x7E, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xC0, 0x1F, 0x80, 0x08, 0x00, 0x00, 0x3F, 0x0F, 0xCF, 0x83, 0xF3, 0xE0,
  0xF8, 0xF8, 0x3E, 0x7E, 0x1F, 0x9F, 0x07, 0xC7, 0xC1, 0xF1, 0xF0, 0x7C,
  0x78, 0x1F, 0x1E, 0x07, 0x8F, 0x81, 0xE3, 0xE0, 0xF8, 0xF0, 0x3C, 0x3C,
  0x0F, 0x0F, 0x03, 0xC3, 0xC0, 0xF0, 0xE0, 0x38, 0x00, 0x00, 0x01, 0xE0,
  0x3C, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x07, 0x80,
  0xF0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x1E, 0x03,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x7C, 0x0F,
  0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0xF8, 0x1E,
  0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0xF0, 0x3C,
  0x00, 0x01, 0xE0, 0x3C, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x01, 0xE0, 0x78,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0x80, 0xF0, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x01, 0xE0,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0x1E, 0x07, 0xC0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x3C, 0x07, 0x80,
  0x00, 0x3C, 0x07, 0x80, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x78, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xFF,
  0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07,
  0xF3, 0x9F, 0x01, 0xF8, 0xE0, 0x60, 0x3E, 0x1C, 0x00, 0x07, 0x83, 0x80,
  0x01, 0xF0, 0x70, 0x00, 0x3E, 0x0E, 0x00, 0x07, 0xC3, 0x80, 0x00, 0xF8,
  0x70, 0x00, 0x1F, 0x0E, 0x00, 0x03, 0xF1, 0xC0, 0x00, 0x3E, 0x78, 0x00,
  0x07, 0xEE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0x3F, 0x00, 0x00, 0xE3,
  0xF0, 0x00, 0x1C, 0x3E, 0x00, 0x03, 0x87, 0xC0, 0x00, 0xF0, 0xF8, 0x00,
  0x1C, 0x1F, 0x00, 0x03, 0x83, 0xE0, 0x00, 0x70, 0x7C, 0x00, 0x0E, 0x1F,
  0x06, 0x03, 0x87, 0xE0, 0xF0, 0x71, 0xF8, 0x1F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0x80, 0x3F, 0xE0, 0x00, 0xF8, 0x07, 0xFF, 0x00,
  0x0F, 0x00, 0xFF, 0xF0, 0x01, 0xF0, 0x0F, 0x0F, 0x00, 0x1E, 0x01, 0xE0,
  0xF8, 0x03, 0xC0, 0x1E, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x78, 0x07, 0x80,
  0x3C, 0x07, 0x80, 0xF8, 0x07, 0xC0, 0xF8, 0x0F, 0x00, 0x78, 0x0F, 0x01,
  0xE0, 0x07, 0x80, 0xF0, 0x1E, 0x00, 0x78, 0x0F, 0x03, 0xC0, 0x0F, 0x80,
  0xF0, 0x7C, 0x00, 0xF0, 0x0F, 0x07, 0x80, 0x0F, 0x01, 0xF0, 0xF8, 0x00,
  0xF0, 0x1E, 0x0F, 0x00, 0x0F, 0x01, 0xE1, 0xE0, 0x00, 0xF0, 0x1E, 0x3E,
  0x0F, 0x8F, 0x03, 0xC3, 0xC3, 0xFC, 0xF0, 0x3C, 0x7C, 0x7F, 0xEF, 0x07,
  0xC7, 0x8F, 0xFF, 0xF0, 0x78, 0xF1, 0xF1, 0xFF, 0x0F, 0x9F, 0x1E, 0x0F,
  0xFF, 0xF1, 0xE3, 0xE0, 0xF7, 0xFE, 0x3E, 0x3C, 0x0F, 0x7F, 0xC3, 0xC7,
  0xC0, 0xF3, 0xF8, 0x7C, 0x78, 0x0F, 0x00, 0x07, 0x87, 0x80, 0xF0, 0x00,
  0xF0, 0xF8, 0x0F, 0x00, 0x1F, 0x0F, 0x00, 0xF0, 0x01, 0xE0, 0xF0, 0x1F,
  0x00, 0x3E, 0x0F, 0x01, 0xE0, 0x03, 0xC0, 0xF0, 0x1E, 0x00, 0x78, 0x0F,
  0x01, 0xE0, 0x0F, 0x81, 0xF0, 0x3E, 0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x1F,
  0x01, 0xE0, 0x3C, 0x01, 0xE0, 0x1E, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x78,
  0x07, 0xC0, 0x1E, 0x0F, 0x80, 0x78, 0x01, 0xF0, 0xF0, 0x0F, 0x80, 0x0F,
  0xBF, 0x00, 0xF0, 0x00, 0xFF, 0xE0, 0x1F, 0x00, 0x07, 0xFC, 0x03, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x01, 0xF0, 0xFC, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0x3E, 0x03, 0xE0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0xF8, 0x0F, 0x80, 0x01,
  0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F,
  0x81, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x7C,
  0x7E, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x3E, 0x0F, 0xCF, 0x80,
  0xFC, 0x3F, 0x1F, 0x81, 0xF0, 0xFC, 0x1F, 0x03, 0xE1, 0xF0, 0x3F, 0x0F,
  0x87, 0xE0, 0x3E, 0x1F, 0x0F, 0x80, 0x7E, 0x7E, 0x3F, 0x00, 0x7C, 0xF8,
  0x7C, 0x00, 0xFF, 0xE0, 0xF8, 0x01, 0xFF, 0xC3, 0xF0, 0x01, 0xFF, 0x07,
  0xE0, 0x03, 0xFE, 0x0F, 0xC0, 0x03, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0x3F,
  0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x7F, 0xC0, 0x7E, 0x01, 0xFF, 0x80, 0xFE,
  0x0F, 0xFF, 0x80, 0xFF, 0xFF, 0x9F, 0x01, 0xFF, 0xFE, 0x3F, 0x01, 0xFF,
  0xF0, 0x7E, 0x00, 0xFF, 0xC0, 0x7E, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F,
  0x3F, 0x3E, 0x3E, 0x3E, 0x7E, 0x7C, 0x7C, 0x7C, 0x78, 0x78, 0x78, 0xF8,
  0xF0, 0xF0, 0xF0, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xE0, 0x04, 0x07, 0xC0, 0x0C, 0x0F, 0x00, 0x3E, 0x1E, 0x00,
  0x7F, 0x3C, 0x01, 0xFF, 0xF8, 0x7C, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0,
  0x07, 0xFF, 0xE0, 0x1F, 0x83, 0xC0, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x07,
  0xCF, 0x00, 0x3F, 0x1E, 0x00, 0xFC, 0x3E, 0x01, 0xF8, 0x3C, 0x01, 0xE0,
  0x7C, 0x01, 0x80, 0xFC, 0x01, 0x01, 0xE0, 0x00, 0x01, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xF0, 0x3E, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0xFC,
  0x0F, 0x81, 0xF8, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xC0, 0x7C, 0x07, 0x80,
  0xF8, 0x00, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xC0,
  0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0x10, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x01, 0xFF,
  0xFC, 0x00, 0xFF, 0x7F, 0x80, 0x3F, 0x07, 0xE0, 0x1F, 0x80, 0xF8, 0x0F,
  0xC0, 0x3E, 0x03, 0xF0, 0x0F, 0xC1, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0x7C,
  0x1F, 0x00, 0x1F, 0x0F, 0xC0, 0x07, 0xC3, 0xE0, 0x01, 0xF1, 0xF8, 0x00,
  0xFC, 0x7E, 0x00, 0x3F, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xE3, 0xF0,
  0x00, 0xF8, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xE7,
  0xE0, 0x01, 0xF9, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x1F, 0x00, 0x07,
  0xC7, 0xC0, 0x01, 0xF1, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x3E, 0x3F, 0x00,
  0x0F, 0x8F, 0x80, 0x07, 0xE3, 0xE0, 0x01, 0xF8, 0xF8, 0x00, 0x7C, 0x3E,
  0x00, 0x3F, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x03, 0xE0, 0xF8, 0x01, 0xF8,
  0x3E, 0x00, 0x7C, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x1F, 0x80, 0x7C, 0x0F,
  0xC0, 0x1F, 0xC7, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x1F,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x0F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC,
  0x1F, 0xBE, 0x3F, 0x9F, 0x3F, 0x9F, 0x3F, 0x8F, 0x8F, 0x87, 0xC3, 0x03,
  0xE1, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xC0, 0x0F, 0xF9, 0xFF, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0xC0, 0x0F,
  0xC0, 0x04, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC,
  0x00, 0xFE, 0x1F, 0xE0, 0x0F, 0x00, 0x7E, 0x00, 0x40, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xFC, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x08, 0x00, 0x0F, 0xC0, 0xC0, 0x03, 0xF8, 0x0F, 0x00, 0xFF,
  0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xBC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xDF, 0x00, 0x00, 0x3C, 0xF8, 0x00,
  0x03, 0xE7, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x1F,
  0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0xF8, 0x7C,
  0x00, 0x0F, 0x83, 0xE0, 0x00, 0x78, 0x1F, 0x00, 0x07, 0xC0, 0xF8, 0x00,
  0x7C, 0x0F, 0x80, 0x07, 0xC0, 0x7C, 0x00, 0x3C, 0x03, 0xE0, 0x03, 0xE0,
  0x1F, 0x00, 0x3E, 0x01, 0xF8, 0x01, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x00, 0x1F, 0x00, 0xF8, 0x01, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x03,
  0xE3, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x08, 0x00,
  0x0F, 0xC0, 0xC0, 0x03, 0xF8, 0x0F, 0x00, 0xFF, 0x80, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x1F,
  0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x0C, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x7F, 0xC0, 0x1F, 0xBF, 0xFC, 0x03, 0xEF,
  0xFF, 0xC0, 0x7D, 0xFF, 0xFC, 0x0F, 0xF8, 0x3F, 0x83, 0xFC, 0x03, 0xF0,
  0x7F, 0x00, 0x3E, 0x0F, 0xE0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3F, 0x00,
  0x1F, 0x87, 0xC0, 0x03, 0xF0, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0x87,
  0xE0, 0x01, 0xF0, 0xFC, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x01,
  0xF8, 0x7C, 0x00, 0x3E, 0x0F, 0xC0, 0x07, 0xC1, 0xF8, 0x01, 0xF8, 0x1F,
  0x00, 0x3E, 0x03, 0xE0, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x07, 0xE1, 0xFC,
  0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xE0, 0xFE, 0x03,
  0xF0, 0x0F, 0xC0, 0x7C, 0x00, 0xF8, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x03,
  0xE0, 0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x81, 0xF0, 0x01, 0xF0, 0x3E,
  0x00, 0x3E, 0x07, 0xC0, 0x0F, 0xC0, 0xF8, 0x01, 0xF0, 0x1F, 0x80, 0x7E,
  0x01, 0xF0, 0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x7F, 0x07,
  0xF0, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x1F,
  0x00, 0x0F, 0x87, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x07,
  0xE3, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE1, 0xF0,
  0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xE0, 0xFC, 0x00, 0xFC,
  0x0F, 0xE0, 0x7F, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFE,
  0x3F, 0x80, 0x7E, 0x03, 0xE0, 0x3F, 0x00, 0xFC, 0x0F, 0x80, 0x1F, 0x07,
  0xE0, 0x07, 0xC1, 0xF0, 0x01, 0xF0, 0xFC, 0x00, 0x7C, 0x3E, 0x00, 0x1F,
  0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x01, 0xF1, 0xF8, 0x00, 0x7C, 0x7E, 0x00,
  0x1F, 0x1F, 0x00, 0x07, 0xC7, 0xC0, 0x03, 0xF1, 0xF0, 0x00, 0xFC, 0x7C,
  0x00, 0x3F, 0x1F, 0x80, 0x1F, 0xC7, 0xE0, 0x0F, 0xE0, 0xF8, 0x03, 0xF8,
  0x3F, 0x03, 0xFE, 0x0F, 0xFF, 0xEF, 0x81, 0xFF, 0xFB, 0xE0, 0x7F, 0xFD,
  0xF0, 0x0F, 0xFC, 0x7C, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xC0, 0x20, 0x1F,
  0xE0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x0F, 0xC0, 0x7E, 0x07,
  0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xC0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x3F, 0x01, 0xFC, 0x0F, 0xE0, 0xFE, 0x03,
  0xF0, 0x1F, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x1F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F,
  0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F,
  0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xFF,
  0x80, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x0F, 0xC7, 0xF8, 0x18, 0x07, 0xE0,
  0x40, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x00, 0x3C, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x00, 0x1E,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x07, 0xC0,
  0x1F, 0xF8, 0x1E, 0x07, 0x80, 0x3F, 0xFC, 0x1E, 0x0F, 0x80, 0x7F, 0xFC,
  0x0F, 0x0F, 0x00, 0xF8, 0x78, 0x0F, 0x1F, 0x01, 0xE0, 0x78, 0x0F, 0x1E,
  0x03, 0xE0, 0x78, 0x1E, 0x1E, 0x07, 0xC0, 0xF8, 0x1E, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x3C, 0x0F, 0x80, 0xF0, 0x1E, 0x3C, 0x0F, 0x00, 0xF0, 0x1E,
  0x7C, 0x0F, 0x01, 0xF0, 0x1E, 0x78, 0x1E, 0x01, 0xE0, 0x3E, 0x78, 0x1E,
  0x01, 0xE0, 0x3C, 0x78, 0x1E, 0x01, 0xE0, 0x3C, 0x78, 0x3E, 0x03, 0xE0,
  0x3C, 0x78, 0x3E, 0x03, 0xC0, 0x78, 0xF0, 0x3C, 0x03, 0xC0, 0x78, 0xF0,
  0x3C, 0x07, 0xC0, 0x70, 0xF0, 0x3C, 0x07, 0xC0, 0xF0, 0xF0, 0x3C, 0x0F,
  0xC1, 0xF0, 0xF0, 0x3E, 0x0F, 0xC1, 0xE0, 0xF0, 0x3E, 0x1D, 0xC3, 0xC0,
  0xF0, 0x1F, 0xF9, 0xFF, 0xC0, 0xF0, 0x1F, 0xF1, 0xFF, 0x80, 0xF0, 0x0F,
  0xE0, 0xFE, 0x00, 0xF8, 0x07, 0xC0, 0x78, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x01, 0x80, 0x00,
  0x07, 0xF8, 0x1F, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x03,
  0xCF, 0x80, 0x00, 0x3E, 0x7C, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x1F, 0x1F,
  0x00, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7C, 0x3E, 0x00,
  0x07, 0xC1, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xF0, 0x7C, 0x00, 0x1F,
  0x03, 0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x7C, 0x07,
  0xC0, 0x07, 0xE0, 0x3E, 0x00, 0x3E, 0x01, 0xF0, 0x03, 0xF0, 0x0F, 0x80,
  0x1F, 0x00, 0x7C, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x03, 0xF0, 0x01,
  0xF8, 0x1F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x0F, 0x80, 0x03, 0xF0,
  0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x07, 0xE3, 0xF0,
  0x00, 0x3F, 0x3F, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x0F, 0xCF, 0x80, 0x00,
  0x3E, 0xFC, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7C,
  0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xF0, 0x1F, 0xE0, 0x0F,
  0x80, 0x1F, 0x80, 0x3E, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0xFC, 0x07, 0xE0,
  0x03, 0xF0, 0x1F, 0x80, 0x0F, 0xC0, 0x7C, 0x00, 0x3F, 0x01, 0xF0, 0x00,
  0xFC, 0x07, 0xC0, 0x03, 0xE0, 0x3F, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x7E,
  0x03, 0xE0, 0x03, 0xF0, 0x0F, 0x80, 0x0F, 0xC0, 0x3E, 0x00, 0xFE, 0x01,
  0xF8, 0x0F, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xC1, 0xFF, 0x00, 0x3E, 0x00,
  0x7E, 0x00, 0xF8, 0x00, 0xFC, 0x03, 0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x07,
  0xC0, 0x7E, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x7C, 0x07, 0xC0, 0x01, 0xF0,
  0x1F, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0xFC, 0x0F,
  0x80, 0x03, 0xF0, 0x3E, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x7E, 0x07, 0xE0,
  0x03, 0xF8, 0x1F, 0x00, 0x1F, 0xC0, 0x7C, 0x00, 0xFE, 0x01, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xF3, 0xF0,
  0x01, 0xFE, 0x00, 0xC0, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x08, 0x00, 0xFF, 0x83, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0x81,
  0xFF, 0x00, 0x3E, 0x00, 0xFF, 0x00, 0x7C, 0x00, 0xFE, 0x00, 0xF8, 0x00,
  0xFC, 0x03, 0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x01, 0xF8, 0x0F, 0x80, 0x03,
  0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x0F,
  0x81, 0xF8, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x7C,
  0x0F, 0x80, 0x00, 0xF8, 0x3F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xE0,
  0xF8, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x3F, 0x0F,
  0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x03, 0xF0, 0x7C,
  0x00, 0x07, 0xE1, 0xF8, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x3F, 0x07, 0xC0,
  0x00, 0x7E, 0x0F, 0x80, 0x01, 0xF8, 0x1F, 0x00, 0x03, 0xF0, 0x7E, 0x00,
  0x0F, 0xC0, 0xFC, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x7E, 0x03, 0xE0, 0x01,
  0xFC, 0x07, 0xC0, 0x07, 0xF0, 0x1F, 0x80, 0x1F, 0xC0, 0x3E, 0x00, 0x7F,
  0x00, 0x7C, 0x07, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0,
  0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xC0, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0x9F, 0xF0, 0x03, 0xFC, 0x00, 0xF0,
  0x03, 0xF8, 0x00, 0x18, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x21, 0xF0, 0x01, 0xFF, 0xE0, 0xF8, 0x00,
  0xFF, 0xF0, 0xFC, 0x00, 0x7F, 0xF8, 0x7E, 0x00, 0x3F, 0xFC, 0x3F, 0x00,
  0x1F, 0xFE, 0x1F, 0x80, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x1F, 0x07, 0xE0,
  0x00, 0x0F, 0x83, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xC0, 0xFC,
  0x00, 0x03, 0xE0, 0x7E, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x00, 0xF8, 0x1F,
  0x80, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x3E, 0x01,
  0xF8, 0x00, 0x1F, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x0F, 0xC0,
  0x0F, 0xF0, 0x1F, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0xFC, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x7C, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x01, 0xF0, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x01, 0xF0, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x01, 0xF8, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0xF8,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFC, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x03, 0xF0,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x01,
  0xF0, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x1F, 0x00,
  0x01, 0xF0, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x1F,
  0x80, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x0F, 0x80, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x0F, 0x80, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0x0F, 0xC0, 0x0F, 0x80, 0x0F,
  0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x0F, 0xC0, 0x03, 0xE0, 0x0F,
  0xC0, 0x01, 0xF0, 0x07, 0xE0, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0xFC, 0x07,
  0xE0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x3E, 0x07, 0xF0, 0x00, 0x1F, 0x03,
  0xF0, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x07, 0xE3,
  0xF0, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x00, 0xF9,
  0xF8, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x00, 0x3E,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x07, 0xFB, 0xE0, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x01,
  0xF8, 0x7C, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00,
  0x7C, 0x0F, 0xC0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x1F, 0x01, 0xF0, 0x00,
  0x1F, 0x80, 0xFC, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x07, 0xC0, 0x1F, 0x00,
  0x03, 0xE0, 0x0F, 0xC0, 0x01, 0xF0, 0x07, 0xE0, 0x01, 0xF8, 0x03, 0xF0,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x07, 0xC0, 0x0F, 0x80, 0x03,
  0xF0, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xF8, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0xF7, 0x80, 0x00, 0x7F, 0xE0, 0x0F,
  0xBC, 0x00, 0x03, 0xFF, 0x00, 0x7D, 0xE0, 0x00, 0x3E, 0xF8, 0x03, 0xEF,
  0x80, 0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x00, 0x1F, 0x7E, 0x00, 0xFB, 0xE0,
  0x00, 0xFB, 0xE0, 0x0F, 0x9F, 0x00, 0x0F, 0x9F, 0x00, 0x7C, 0xF8, 0x00,
  0x7C, 0xF8, 0x03, 0xE7, 0xC0, 0x07, 0xCF, 0xC0, 0x1F, 0x3E, 0x00, 0x3E,
  0x7E, 0x00, 0xF9, 0xF0, 0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x1F, 0x1F,
  0x00, 0x7C, 0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0xC0,
  0x1F, 0x0F, 0x00, 0x78, 0x7C, 0x00, 0xF8, 0x78, 0x07, 0xC3, 0xE0, 0x0F,
  0x83, 0xC0, 0x3C, 0x1F, 0x00, 0x7C, 0x1E, 0x03, 0xE0, 0xF8, 0x03, 0xE0,
  0xF0, 0x1F, 0x0F, 0xC0, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x01, 0xF8, 0x3E,
  0x0F, 0x83, 0xE0, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x00, 0x7C, 0x0F, 0x87,
  0xC0, 0xF8, 0x03, 0xE0, 0x7C, 0x7C, 0x0F, 0xC0, 0x1F, 0x03, 0xE3, 0xE0,
  0x7C, 0x01, 0xF0, 0x1F, 0x3E, 0x03, 0xE0, 0x0F, 0x80, 0xF9, 0xF0, 0x1F,
  0x00, 0x7C, 0x07, 0xDF, 0x01, 0xF8, 0x03, 0xE0, 0x3E, 0xF8, 0x0F, 0xC0,
  0x1F, 0x00, 0xFF, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xFC, 0x03, 0xE0, 0x0F,
  0x80, 0x3F, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xFE, 0x01, 0xF8, 0x03, 0xE0,
  0x0F, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7F, 0x00, 0x7C, 0x01, 0xF0, 0x03,
  0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xF8, 0x03, 0xF8, 0x00, 0x0F,
  0x80, 0x1F, 0xC0, 0x00, 0x7C, 0x00, 0xFE, 0x00, 0x03, 0xE0, 0x07, 0xF0,
  0x00, 0x1F, 0x00, 0x7F, 0xC0, 0x01, 0xF8, 0x03, 0xFE, 0x00, 0x0F, 0x80,
  0x1F, 0xF0, 0x00, 0x7C, 0x00, 0xFF, 0x80, 0x03, 0xE0, 0x0F, 0xBE, 0x00,
  0x1F, 0x00, 0x7D, 0xF0, 0x01, 0xF8, 0x03, 0xEF, 0x80, 0x0F, 0x80, 0x1F,
  0x7C, 0x00, 0x7C, 0x00, 0xF9, 0xF0, 0x03, 0xE0, 0x0F, 0x8F, 0x80, 0x1F,
  0x00, 0x7C, 0x7C, 0x01, 0xF0, 0x03, 0xE3, 0xE0, 0x0F, 0x80, 0x1F, 0x0F,
  0x00, 0x7C, 0x00, 0xF8, 0x7C, 0x03, 0xE0, 0x0F, 0x83, 0xE0, 0x3F, 0x00,
  0x7C, 0x1F, 0x01, 0xF0, 0x03, 0xE0, 0xF8, 0x0F, 0x80, 0x1F, 0x03, 0xE0,
  0x7C, 0x00, 0xF8, 0x1F, 0x03, 0xE0, 0x0F, 0x80, 0xF8, 0x3F, 0x00, 0x7C,
  0x07, 0xC1, 0xF0, 0x03, 0xE0, 0x1E, 0x0F, 0x80, 0x1F, 0x00, 0xF8, 0x7C,
  0x01, 0xF8, 0x07, 0xC3, 0xE0, 0x0F, 0x80, 0x3E, 0x3E, 0x00, 0x7C, 0x01,
  0xF1, 0xF0, 0x03, 0xE0, 0x07, 0xCF, 0x80, 0x1F, 0x00, 0x3E, 0x7C, 0x01,
  0xF0, 0x01, 0xF3, 0xE0, 0x0F, 0x80, 0x0F, 0xBE, 0x00, 0x7C, 0x00, 0x3F,
  0xF0, 0x03, 0xE0, 0x01, 0xFF, 0x80, 0x1F, 0x00, 0x0F, 0xFC, 0x01, 0xF0,
  0x00, 0x7F, 0xE0, 0x0F, 0x80, 0x01, 0xFE, 0x00, 0x7C, 0x00, 0x0F, 0xF0,
  0x03, 0xE0, 0x00, 0x7F, 0x80, 0x3F, 0x00, 0x03, 0xFC, 0x01, 0xF0, 0x00,
  0x1F, 0xE0, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0xFF, 0x01, 0xFC,
  0x00, 0xFC, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x7E,
  0x03, 0xF0, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3F,
  0x0F, 0xC0, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3F,
  0x1F, 0x80, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x3F,
  0x3F, 0x00, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x3E,
  0x7E, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00, 0x7E,
  0x7C, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x00, 0x7C,
  0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0xF8,
  0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x01, 0xF0,
  0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0x80,
  0x7E, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0xC1, 0xFE, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFE, 0x00, 0x7E, 0x07, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00,
  0x7E, 0x00, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0x7E,
  0x03, 0xE0, 0x03, 0xF0, 0x1F, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0xFC, 0x0F,
  0xC0, 0x07, 0xE0, 0x7E, 0x00, 0x3E, 0x03, 0xE0, 0x01, 0xF0, 0x1F, 0x00,
  0x1F, 0x80, 0xF8, 0x00, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0x7C, 0x00, 0xFC,
  0x03, 0xE0, 0x0F, 0xE0, 0x1F, 0x01, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x7F, 0xEF, 0xFC, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x01,
  0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x3E, 0x07,
  0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x0F,
  0x80, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3F, 0x3F,
  0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x3F, 0x3E,
  0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x3E, 0x7E,
  0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00, 0x7E, 0xFC,
  0x00, 0x00, 0x7C, 0xFC, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x00, 0xFC, 0xFC,
  0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x01, 0xF8, 0xFC,
  0x00, 0x01, 0xF8, 0xFC, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x03, 0xE0, 0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xE0, 0xFC,
  0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x3F, 0x80, 0x7F,
  0x00, 0x7F, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFE, 0x00, 0x7E, 0x07, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7F,
  0x00, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0x7E, 0x03,
  0xE0, 0x03, 0xF0, 0x1F, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0xFC, 0x0F, 0xC0,
  0x07, 0xE0, 0x7E, 0x00, 0x3E, 0x03, 0xE0, 0x03, 0xF0, 0x1F, 0x00, 0x1F,
  0x80, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0xFC, 0x03,
  0xE0, 0x1F, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0x07, 0xC0,
  0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7C, 0x07, 0xC0, 0x03,
  0xE0, 0x3E, 0x00, 0x1F, 0x01, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0,
  0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E,
  0x01, 0xF8, 0x03, 0xF0, 0x0F, 0x80, 0x0F, 0x80, 0x7C, 0x00, 0x7E, 0x03,
  0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x7C, 0x0F, 0x80,
  0x03, 0xF0, 0x7C, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0x00, 0x7F, 0x80, 0x78, 0x03, 0xF0, 0x00, 0x80, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x08, 0x00, 0x1F, 0xC0, 0x70, 0x01, 0xFC, 0x03, 0xF0,
  0x7F, 0xC0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xF0, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x80, 0xF8, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x07, 0xC0, 0x7E, 0x00,
  0x07, 0xE0, 0x3E, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x01, 0xF0, 0x0F, 0x80,
  0x00, 0xF8, 0x07, 0xC0, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x7E, 0x03, 0xE0,
  0x00, 0x3F, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0xFC,
  0x00, 0x07, 0xC0, 0x7E, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x03, 0xE0, 0x1F,
  0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x7C, 0x07,
  0xE0, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x07, 0xE0,
  0x3E, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0xF8,
  0x0F, 0xC0, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x3E,
  0x01, 0xF0, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x0F,
  0xC0, 0x7C, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x03,
  0xF0, 0x0F, 0x80, 0x01, 0xF0, 0x07, 0xC0, 0x01, 0xF8, 0x03, 0xF0, 0x00,
  0xFC, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x3F, 0xC1,
  0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xEF, 0x80, 0x00,
  0x7E, 0xF8, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0xFC, 0xF8, 0x00, 0x0F, 0x8F,
  0x80, 0x01, 0xF8, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xF0, 0xF8, 0x00,
  0x3E, 0x0F, 0x80, 0x07, 0xE0, 0xF8, 0x00, 0x7E, 0x0F, 0x80, 0x07, 0xC0,
  0xF8, 0x00, 0xFC, 0x0F, 0x80, 0x0F, 0x80, 0xF8, 0x01, 0xF8, 0x0F, 0x80,
  0x1F, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xE0,
  0x0F, 0x80, 0x7C, 0x00, 0xF8, 0x07, 0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0x7C,
  0x0F, 0x80, 0x07, 0xC1, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x07, 0xC3, 0xF0,
  0x00, 0x7C, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x07,
  0xC7, 0xC0, 0x00, 0x7C, 0xF8, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x7D, 0xF8,
  0x00, 0x07, 0xDF, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xFF, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xE0, 0x00, 0xFD, 0xF0, 0x00, 0x3F,
  0x00, 0x07, 0xEF, 0x80, 0x03, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0xC0,
  0x03, 0xF3, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0xF0, 0x01,
  0xF8, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xC7, 0xC0, 0x07, 0xFC, 0x00, 0x7C,
  0x3E, 0x00, 0x3D, 0xE0, 0x07, 0xE1, 0xF0, 0x03, 0xFF, 0x00, 0x3E, 0x0F,
  0x80, 0x1E, 0xF8, 0x03, 0xF0, 0x7C, 0x01, 0xF7, 0xC0, 0x1F, 0x03, 0xE0,
  0x0F, 0xBE, 0x00, 0xF8, 0x1F, 0x00, 0x79, 0xF0, 0x0F, 0xC0, 0xF8, 0x07,
  0xCF, 0x80, 0x7C, 0x07, 0xC0, 0x3C, 0x7C, 0x07, 0xE0, 0x3E, 0x03, 0xE3,
  0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0xF0, 0xF8,
  0x1F, 0x80, 0x7C, 0x0F, 0x87, 0xC0, 0xF8, 0x03, 0xE0, 0x78, 0x3E, 0x0F,
  0xC0, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x00, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0x07, 0xC3, 0xE0, 0x7C, 0x3E, 0x00, 0x3E, 0x1F, 0x03, 0xE1, 0xF0, 0x01,
  0xF0, 0xF0, 0x1F, 0x1F, 0x80, 0x0F, 0x8F, 0x80, 0xF8, 0xF8, 0x00, 0x7C,
  0x7C, 0x07, 0xC7, 0xC0, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x00, 0x1F, 0x3E,
  0x01, 0xF3, 0xE0, 0x00, 0xF9, 0xE0, 0x0F, 0xBF, 0x00, 0x07, 0xDF, 0x00,
  0x7D, 0xF0, 0x00, 0x3E, 0xF0, 0x03, 0xEF, 0x80, 0x01, 0xF7, 0x80, 0x1E,
  0xF8, 0x00, 0x0F, 0x7C, 0x00, 0xF7, 0xC0, 0x00, 0x7B, 0xC0, 0x07, 0xBE,
  0x00, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0x1F, 0x00,
  0x3E, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x07,
  0xC0, 0x7C, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0x1F, 0x03, 0xE0, 0x00,
  0x03, 0xF0, 0xF8, 0x00, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0x07, 0xC7, 0xC0,
  0x00, 0x00, 0xF9, 0xF8, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xDF,
  0x00, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x0F,
  0xCF, 0x80, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00,
  0x1F, 0x83, 0xE0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0xF8, 0x0F, 0x80,
  0x00, 0x3F, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x01, 0xF8, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x03, 0xF0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x07,
  0xE0, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xDF, 0x00, 0x07, 0xEF, 0xC0, 0x07,
  0xE7, 0xE0, 0x03, 0xE1, 0xF0, 0x03, 0xF0, 0xF8, 0x01, 0xF0, 0x7C, 0x01,
  0xF8, 0x3E, 0x00, 0xF8, 0x1F, 0x00, 0xFC, 0x0F, 0x80, 0xFC, 0x07, 0xE0,
  0x7C, 0x01, 0xF0, 0x7E, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x3F, 0x00, 0x3E,
  0x1F, 0x00, 0x1F, 0x1F, 0x80, 0x0F, 0x8F, 0x80, 0x07, 0xCF, 0x80, 0x01,
  0xF7, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0xFF,
  0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xF0, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x81, 0xE0, 0x78, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC0, 0xF0, 0x3C, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x81,
  0xE0, 0x78, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC0, 0xF0, 0x3C,
  0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0x78, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC0, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x3E, 0xF8,
  0x00, 0x0F, 0x9F, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x0F,
  0x03, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x78, 0x0F, 0x80, 0x1F, 0x00, 0xF0,
  0x03, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x3E, 0x00, 0x3C, 0x07, 0xC0,
  0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0x0F, 0x80, 0x01, 0xF1,
  0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xDF, 0x00, 0x00, 0x7C, 0x7F, 0xFF,
  0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0x87,
  0xE0, 0xF8, 0x3F, 0x07, 0xC0, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xFC, 0x3C, 0x03, 0xFF, 0xC7, 0x80, 0xFF, 0xFD, 0xF0,
  0x3F, 0xFF, 0xBE, 0x07, 0xE0, 0x7F, 0x81, 0xF8, 0x07, 0xF0, 0x7E, 0x00,
  0xFE, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x3E, 0x0F,
  0x80, 0x07, 0xC3, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x3F, 0x0F, 0x80, 0x07,
  0xE3, 0xF0, 0x00, 0xF8, 0x7E, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE1, 0xF0,
  0x00, 0xFC, 0x3E, 0x00, 0x1F, 0x0F, 0xC0, 0x03, 0xE1, 0xF8, 0x00, 0x7C,
  0x3E, 0x00, 0x1F, 0x87, 0xC0, 0x03, 0xF0, 0xF8, 0x00, 0xFC, 0x1F, 0x00,
  0x1F, 0x83, 0xE0, 0x07, 0xF0, 0x7E, 0x00, 0xFE, 0x0F, 0xC0, 0x3F, 0xC1,
  0xF8, 0x0F, 0xF0, 0x1F, 0x83, 0xFE, 0x03, 0xFF, 0xF7, 0xC0, 0x3F, 0xFC,
  0xF8, 0x07, 0xFF, 0x1E, 0x00, 0x3F, 0xC3, 0xC0, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x1F, 0x00, 0x0F, 0x8F, 0xF8, 0x03, 0xE3, 0xFF, 0x80, 0x7D, 0xFF,
  0xF0, 0x0F, 0xBF, 0xFF, 0x01, 0xFF, 0x07, 0xE0, 0x3F, 0xC0, 0x7E, 0x0F,
  0xF0, 0x0F, 0xC1, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0x07, 0xE0, 0x03,
  0xE1, 0xF8, 0x00, 0x7C, 0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF0, 0xF8,
  0x00, 0x7E, 0x1F, 0x00, 0x0F, 0x87, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x3E,
  0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x01, 0xF8, 0x7C, 0x00, 0x3E, 0x1F, 0x80,
  0x07, 0xC3, 0xE0, 0x01, 0xF8, 0x7C, 0x00, 0x3F, 0x0F, 0x80, 0x07, 0xC1,
  0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x3E, 0x0F, 0xC0, 0x0F, 0xC1, 0xFC, 0x03,
  0xF0, 0x3F, 0x80, 0xFE, 0x0F, 0xF8, 0x3F, 0x81, 0xF7, 0xFF, 0xE0, 0x3E,
  0xFF, 0xF8, 0x07, 0x8F, 0xFE, 0x00, 0xF0, 0xFF, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x7F, 0xFF,
  0x03, 0xFF, 0xF8, 0x0F, 0xC0, 0x20, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x02, 0x07,
  0xF0, 0x38, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x7F,
  0xE0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x3E,
  0x00, 0x0F, 0xF8, 0xF8, 0x00, 0xFF, 0xF3, 0xE0, 0x07, 0xFF, 0xEF, 0x80,
  0x3F, 0xFF, 0xBE, 0x00, 0xFC, 0x0F, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x3F,
  0x00, 0x7F, 0x00, 0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x03, 0xE0, 0x1F, 0x80,
  0x0F, 0x80, 0x7C, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0xF8, 0x0F, 0x80, 0x07,
  0xE0, 0x3E, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x7C, 0x07, 0xC0, 0x01, 0xF0,
  0x1F, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0xF8, 0x0F,
  0xC0, 0x03, 0xE0, 0x3F, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x7E, 0x03, 0xE0,
  0x01, 0xF8, 0x0F, 0x80, 0x0F, 0xC0, 0x3E, 0x00, 0x3F, 0x00, 0xF8, 0x01,
  0xFC, 0x03, 0xE0, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0x3F, 0x01, 0xFE,
  0x00, 0x7E, 0x0F, 0xF8, 0x01, 0xFF, 0xFB, 0xE0, 0x03, 0xFF, 0xCF, 0x80,
  0x0F, 0xFE, 0x3C, 0x00, 0x1F, 0xE0, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0,
  0x3F, 0xCF, 0xE0, 0x7E, 0x07, 0xC1, 0xF8, 0x0F, 0x87, 0xE0, 0x1F, 0x0F,
  0x80, 0x3E, 0x3F, 0x00, 0x7C, 0x7C, 0x00, 0xF9, 0xF8, 0x03, 0xF3, 0xE0,
  0x07, 0xC7, 0xC0, 0x3F, 0x9F, 0x80, 0xFE, 0x3E, 0x3F, 0xF8, 0x7F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x04, 0x1F, 0xC0, 0x38, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x1F, 0xEE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x87, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0xF0, 0x01, 0xFF, 0xE3, 0xC0,
  0x0F, 0xFF, 0xDF, 0x00, 0x7F, 0xFF, 0x7C, 0x01, 0xF8, 0x1F, 0xE0, 0x0F,
  0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xFE, 0x01, 0xF8, 0x01, 0xF8, 0x0F, 0xC0,
  0x07, 0xE0, 0x3F, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x7C, 0x07, 0xE0, 0x03,
  0xF0, 0x1F, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0xF8,
  0x0F, 0x80, 0x03, 0xE0, 0x3E, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x7E, 0x07,
  0xE0, 0x01, 0xF0, 0x1F, 0x80, 0x07, 0xC0, 0x7E, 0x00, 0x3F, 0x01, 0xF0,
  0x00, 0xFC, 0x07, 0xC0, 0x03, 0xF0, 0x1F, 0x00, 0x1F, 0x80, 0x7C, 0x00,
  0x7E, 0x01, 0xF0, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0x80, 0x7F,
  0x80, 0x7E, 0x03, 0xFC, 0x00, 0xFC, 0x1F, 0xF0, 0x03, 0xFF, 0xF7, 0xC0,
  0x07, 0xFF, 0x9F, 0x00, 0x1F, 0xFC, 0xF8, 0x00, 0x3F, 0xE3, 0xE0, 0x00,
  0x1C, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x20, 0x00, 0x7C, 0x00, 0xE0, 0x03, 0xF0,
  0x03, 0xE0, 0x3F, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x07, 0xC0, 0x07, 0xC7, 0xFC,
  0x03, 0xE7, 0xFF, 0x80, 0xFB, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x0F, 0xF8,
  0x3F, 0x03, 0xF8, 0x07, 0xC1, 0xFC, 0x01, 0xF0, 0x7F, 0x00, 0x7C, 0x1F,
  0x80, 0x1F, 0x07, 0xE0, 0x07, 0xC3, 0xF0, 0x01, 0xF0, 0xFC, 0x00, 0xFC,
  0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x03, 0xE1, 0xF8, 0x01,
  0xF8, 0x7C, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x07, 0xC1, 0xF0,
  0x01, 0xF0, 0xFC, 0x00, 0xFC, 0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x83,
  0xE0, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x7E, 0x1F, 0x00, 0x1F,
  0x07, 0xC0, 0x07, 0xC1, 0xF0, 0x01, 0xF0, 0xFC, 0x00, 0x7C, 0x3E, 0x00,
  0x3F, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x00,
  0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x01, 0x1F, 0xC0, 0x03, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0x7C, 0x03, 0xF0, 0x0F,
  0x80, 0xFC, 0x01, 0xF0, 0x1F, 0x00, 0x3E, 0x07, 0xC0, 0x0F, 0xC1, 0xF8,
  0x01, 0xF0, 0x7E, 0x00, 0x3E, 0x1F, 0x80, 0x07, 0xC7, 0xE0, 0x00, 0xF8,
  0xF8, 0x00, 0x3E, 0x3F, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0xFB, 0xF0, 0x00,
  0x1F, 0xFE, 0x00, 0x07, 0xDF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0x3E, 0x00, 0x1F, 0xC7, 0xC0, 0x03,
  0xF0, 0xFC, 0x00, 0x7C, 0x1F, 0x80, 0x0F, 0x81, 0xF0, 0x01, 0xF0, 0x3E,
  0x00, 0x7C, 0x07, 0xE0, 0x0F, 0x80, 0xFC, 0x01, 0xF0, 0x0F, 0x80, 0x3E,
  0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xF0, 0x03, 0xE0, 0x3E, 0x00, 0x7C,
  0x07, 0xC0, 0x0F, 0x80, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x7C,
  0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF1, 0xFF,
  0x81, 0xFF, 0x00, 0xF9, 0xFF, 0xC3, 0xFF, 0xC0, 0x7D, 0xFF, 0xF3, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFB, 0xFF, 0xF8, 0x1E, 0xE0, 0x7F, 0xE0, 0xFC, 0x0F,
  0xE0, 0x3F, 0xC0, 0x7E, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0x07, 0xF0, 0x0F,
  0xE0, 0x0F, 0x83, 0xF0, 0x07, 0xE0, 0x07, 0xC1, 0xF0, 0x03, 0xF0, 0x07,
  0xE0, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0xFC, 0x00, 0xF8, 0x01, 0xF0, 0x7C,
  0x00, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x1F, 0x00, 0x3E,
  0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x80, 0x1F,
  0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xC0, 0x07, 0xC1, 0xF0,
  0x03, 0xE0, 0x07, 0xE1, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0xF8, 0x00, 0xF8,
  0x01, 0xF0, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x00, 0x7C,
  0x1F, 0x00, 0x3E, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x00, 0x3E, 0x0F, 0x80,
  0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xC0,
  0x07, 0xC3, 0xF0, 0x03, 0xE0, 0x07, 0xC1, 0xF0, 0x01, 0xF0, 0x03, 0xE0,
  0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x3E, 0x00,
  0x7C, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x1E, 0x1F, 0xF0, 0x07,
  0xCF, 0xFF, 0x00, 0xFB, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xDE, 0x0F,
  0xC0, 0xFF, 0x00, 0xF8, 0x1F, 0xE0, 0x1F, 0x03, 0xF8, 0x03, 0xE0, 0x7E,
  0x00, 0x7C, 0x0F, 0xC0, 0x0F, 0x83, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x7E,
  0x0F, 0xC0, 0x0F, 0x81, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x3E, 0x0F, 0xC0,
  0x0F, 0xC1, 0xF0, 0x01, 0xF8, 0x3E, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0xC1,
  0xF8, 0x00, 0xF8, 0x3F, 0x00, 0x3F, 0x07, 0xC0, 0x07, 0xC0, 0xF8, 0x00,
  0xF8, 0x1F, 0x00, 0x1F, 0x07, 0xE0, 0x03, 0xE0, 0xFC, 0x00, 0xFC, 0x1F,
  0x00, 0x1F, 0x03, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x1F, 0x80, 0x1F,
  0x83, 0xE0, 0x03, 0xF0, 0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x83, 0xF0,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFF,
  0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0x81, 0xF8, 0x1F, 0x80,
  0x7C, 0x1F, 0x80, 0x3F, 0x0F, 0x80, 0x1F, 0x8F, 0xC0, 0x07, 0xC7, 0xC0,
  0x03, 0xE7, 0xE0, 0x01, 0xF3, 0xE0, 0x00, 0xF9, 0xF0, 0x00, 0x7D, 0xF8,
  0x00, 0x3E, 0xF8, 0x00, 0x3F, 0x7C, 0x00, 0x1F, 0xBE, 0x00, 0x0F, 0x9F,
  0x00, 0x07, 0xDF, 0x80, 0x03, 0xEF, 0x80, 0x03, 0xF7, 0xC0, 0x01, 0xFB,
  0xE0, 0x00, 0xF9, 0xF0, 0x00, 0xFC, 0xF8, 0x00, 0x7E, 0x7C, 0x00, 0x3E,
  0x3E, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x1F,
  0x81, 0xFC, 0x1F, 0x80, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x0F, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x3C, 0x3F, 0xE0, 0x00, 0xF8, 0xFF, 0xE0, 0x01, 0xF3, 0xFF, 0xC0,
  0x03, 0xEF, 0xBF, 0xC0, 0x07, 0xBC, 0x1F, 0x80, 0x0F, 0xF0, 0x1F, 0x80,
  0x3F, 0xC0, 0x3F, 0x00, 0x7F, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x7C, 0x01,
  0xF8, 0x00, 0xF8, 0x03, 0xE0, 0x01, 0xF0, 0x0F, 0xC0, 0x03, 0xE0, 0x1F,
  0x80, 0x0F, 0xC0, 0x3E, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x3F, 0x01, 0xF8,
  0x00, 0x7C, 0x03, 0xE0, 0x00, 0xF8, 0x07, 0xC0, 0x01, 0xF0, 0x0F, 0x80,
  0x07, 0xE0, 0x1F, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0x00, 0xF8, 0x00,
  0x3E, 0x01, 0xF0, 0x00, 0xFC, 0x03, 0xE0, 0x01, 0xF0, 0x07, 0xC0, 0x07,
  0xE0, 0x1F, 0x80, 0x0F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0xFC,
  0x00, 0xFE, 0x03, 0xF8, 0x01, 0xFE, 0x0F, 0xE0, 0x07, 0xDF, 0xFF, 0x80,
  0x0F, 0x9F, 0xFE, 0x00, 0x1F, 0x3F, 0xF8, 0x00, 0x3E, 0x3F, 0xE0, 0x00,
  0xFC, 0x0C, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xFC, 0x3C, 0x03, 0xFF, 0xC7, 0x80, 0xFF, 0xFD, 0xF0,
  0x3F, 0xFF, 0xBE, 0x07, 0xE0, 0x7F, 0x81, 0xF8, 0x07, 0xF0, 0x7E, 0x00,
  0xFE, 0x0F, 0xC0, 0x1F, 0xC3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x3E, 0x0F,
  0x80, 0x07, 0xC3, 0xF0, 0x01, 0xF8, 0x7C, 0x00, 0x3F, 0x0F, 0x80, 0x07,
  0xC3, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE1, 0xF0,
  0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x0F, 0xC0, 0x03, 0xE1, 0xF8, 0x00, 0x7C,
  0x3E, 0x00, 0x1F, 0x87, 0xC0, 0x03, 0xF0, 0xF8, 0x00, 0xFC, 0x1F, 0x00,
  0x1F, 0x83, 0xE0, 0x07, 0xF0, 0x7C, 0x00, 0xFE, 0x0F, 0xC0, 0x3F, 0xC1,
  0xF8, 0x0F, 0xF0, 0x1F, 0x83, 0xFE, 0x03, 0xFF, 0xF7, 0xC0, 0x3F, 0xFC,
  0xF8, 0x07, 0xFF, 0x3E, 0x00, 0x7F, 0xC7, 0xC0, 0x01, 0xC0, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x07, 0x8F, 0xE0, 0x3E, 0x7F, 0x80, 0xFB, 0xFE, 0x03, 0xCF,
  0xF8, 0x0F, 0x7C, 0x20, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0,
  0x7F, 0xDF, 0xC0, 0xFC, 0x03, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x10,
  0x01, 0xF8, 0x38, 0x0F, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x01, 0xFF,
  0xFC, 0x01, 0xFF, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x38,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x1F, 0xFF, 0x9F, 0xFF, 0xDF, 0xFF, 0xCF, 0xFF, 0xE0, 0x7C, 0x00,
  0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xE0, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F,
  0xF0, 0x01, 0x80, 0x00, 0x07, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x1F,
  0x00, 0x1F, 0x03, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x1F, 0x80, 0x1F,
  0x83, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x81, 0xF0,
  0x01, 0xF0, 0x7E, 0x00, 0x7E, 0x0F, 0x80, 0x0F, 0x81, 0xF0, 0x01, 0xF0,
  0x3E, 0x00, 0x3E, 0x0F, 0xC0, 0x07, 0xC1, 0xF0, 0x01, 0xF8, 0x3E, 0x00,
  0x3E, 0x07, 0xC0, 0x07, 0xC0, 0xF8, 0x00, 0xF8, 0x3F, 0x00, 0x3F, 0x07,
  0xC0, 0x07, 0xC0, 0xF8, 0x00, 0xF8, 0x1F, 0x00, 0x3F, 0x03, 0xE0, 0x07,
  0xE0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x03, 0xE0, 0x0F, 0xE0, 0x7E,
  0x01, 0xFC, 0x0F, 0xC0, 0x7F, 0x81, 0xFC, 0x3D, 0xF0, 0x1F, 0xFF, 0xBC,
  0x03, 0xFF, 0xE7, 0x80, 0x3F, 0xF8, 0xF0, 0x03, 0xFC, 0x3E, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xF7,
  0xC0, 0x07, 0xCF, 0x80, 0x0F, 0x9F, 0x00, 0x3F, 0x3E, 0x00, 0x7C, 0x7C,
  0x01, 0xF8, 0xF8, 0x03, 0xE1, 0xF0, 0x0F, 0xC3, 0xE0, 0x1F, 0x07, 0xC0,
  0x7E, 0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x3E, 0x07, 0xC0, 0x7C, 0x0F,
  0x80, 0xF8, 0x3E, 0x01, 0xF0, 0x7C, 0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xE0,
  0x07, 0x8F, 0x80, 0x0F, 0x1F, 0x00, 0x1E, 0x3E, 0x00, 0x3C, 0xF8, 0x00,
  0x79, 0xF0, 0x00, 0xF7, 0xC0, 0x01, 0xEF, 0x80, 0x03, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xFF, 0xC0, 0x0F,
  0xC0, 0x0F, 0xBE, 0x00, 0xFE, 0x00, 0x7D, 0xF0, 0x07, 0xF0, 0x07, 0xEF,
  0x80, 0x3F, 0x80, 0x3E, 0x7C, 0x03, 0xFC, 0x03, 0xF3, 0xE0, 0x1F, 0xE0,
  0x1F, 0x1F, 0x01, 0xFF, 0x00, 0xF8, 0xF8, 0x0F, 0x78, 0x0F, 0x87, 0xC0,
  0xFB, 0xC0, 0x7C, 0x3E, 0x07, 0x9E, 0x07, 0xE1, 0xF0, 0x3C, 0xF0, 0x3E,
  0x0F, 0x83, 0xE7, 0x81, 0xF0, 0x7C, 0x1E, 0x3C, 0x1F, 0x03, 0xE1, 0xF1,
  0xE0, 0xF8, 0x1F, 0x0F, 0x0F, 0x0F, 0x80, 0xF8, 0x78, 0x78, 0x7C, 0x07,
  0xC7, 0xC3, 0xC3, 0xE0, 0x3E, 0x3C, 0x1E, 0x3E, 0x01, 0xF3, 0xE0, 0xF1,
  0xF0, 0x0F, 0x9E, 0x07, 0x8F, 0x00, 0x7C, 0xF0, 0x3C, 0xF8, 0x03, 0xEF,
  0x81, 0xE7, 0xC0, 0x1F, 0x78, 0x0F, 0x7C, 0x00, 0xF7, 0xC0, 0x7B, 0xE0,
  0x07, 0xBC, 0x03, 0xDE, 0x00, 0x3D, 0xE0, 0x1F, 0xF0, 0x01, 0xFF, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0xFC, 0x03,
  0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x3F, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x7C,
  0x07, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x87,
  0xE0, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x01, 0xF7, 0xC0,
  0x00, 0x07, 0xDF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x7E, 0x7C,
  0x00, 0x01, 0xF1, 0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7E, 0x0F, 0x80,
  0x01, 0xF0, 0x3E, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x7E, 0x01, 0xF0, 0x01,
  0xF0, 0x07, 0xC0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x00, 0x7E, 0x03, 0xF0,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x0F, 0xC0,
  0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x01, 0xF0, 0x03, 0xF0, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x7C,
  0x00, 0x03, 0xC0, 0x3E, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x00, 0xF0, 0x1F,
  0x00, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x1F, 0x0F,
  0xC0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x03, 0xE3,
  0xE0, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00, 0x7C,
  0xF8, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x0F,
  0xBC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x08, 0x7F, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x7F, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x47, 0xFC, 0x00, 0x17, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFA, 0x00, 0x0F, 0xF8, 0x80,
  0x00, 0x00, 0x00,
};

const GFXglyph NotoSans_Condensed_Italic64pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 15, 47, 16, 1, -46 },
  { 90, 18, 17, 23, 7, -46 },
  { 129, 32, 46, 31, 1, -46 },
  { 313, 27, 53, 28, 1, -49 },
  { 492, 36, 47, 43, 4, -46 },
  { 704, 31, 47, 32, 0, -46 },
  { 887, 8, 17, 13, 7, -46 },
  { 904, 19, 56, 17, 2, -46 },
  { 1037, 20, 56, 17, -5, -46 },
  { 1177, 23, 24, 27, 6, -49 },
  { 1246, 26, 31, 30, 3, -38 },
  { 1347, 12, 15, 14, -3, -7 },
  { 1370, 15, 5, 18, 1, -20 },
  { 1380, 7, 8, 14, 1, -7 },
  { 1387, 30, 46, 22, -3, -46 },
  { 1560, 26, 47, 28, 2, -46 },
  { 1713, 17, 46, 28, 7, -46 },
  { 1811, 29, 46, 28, -1, -46 },
  { 1978, 28, 47, 28, 0, -46 },
  { 2143, 29, 46, 28, -1, -46 },
  { 2310, 28, 47, 28, 0, -46 },
  { 2475, 27, 47, 28, 2, -46 },
  { 2634, 27, 46, 28, 3, -46 },
  { 2790, 27, 47, 28, 1, -46 },
  { 2949, 26, 47, 28, 1, -46 },
  { 3102, 13, 36, 14, 0, -35 },
  { 3161, 16, 43, 14, -3, -35 },
  { 3247, 26, 30, 30, 3, -38 },
  { 3345, 26, 17, 30, 3, -31 },
  { 3401, 26, 30, 30, 3, -38 },
  { 3499, 22, 47, 21, 2, -46 },
  { 3629, 40, 52, 43, 2, -46 },
  { 3889, 29, 46, 29, -4, -46 },
  { 4056, 30, 46, 31, 1, -46 },
  { 4229, 30, 47, 29, 3, -46 },
  { 4406, 31, 46, 34, 1, -46 },
  { 4585, 28, 46, 26, 1, -46 },
  { 4746, 28, 46, 25, 1, -46 },
  { 4907, 33, 47, 35, 3, -46 },
  { 5101, 35, 46, 35, 1, -46 },
  { 5303, 25, 46, 18, -3, -46 },
  { 5447, 26, 58, 14, -10, -46 },
  { 5636, 33, 46, 29, 1, -46 },
  { 5826, 19, 46, 24, 1, -46 },
  { 5936, 45, 46, 45, 1, -46 },
  { 6195, 37, 46, 37, 1, -46 },
  { 6408, 32, 47, 36, 3, -46 },
  { 6596, 29, 46, 29, 1, -46 },
  { 6763, 32, 57, 36, 3, -46 },
  { 6991, 29, 46, 30, 1, -46 },
  { 7158, 29, 47, 27, -1, -46 },
  { 7329, 25, 46, 25, 5, -46 },
  { 7473, 33, 47, 34, 3, -46 },
  { 7667, 28, 46, 29, 6, -46 },
  { 7828, 45, 46, 46, 6, -46 },
  { 8087, 35, 46, 27, -4, -46 },
  { 8289, 25, 46, 26, 6, -46 },
  { 8433, 31, 46, 25, -2, -46 },
  { 8612, 24, 56, 18, -1, -46 },
  { 8780, 10, 46, 22, 7, -46 },
  { 8838, 24, 56, 18, -4, -46 },
  { 9006, 27, 26, 29, 1, -46 },
  { 9094, 22, 4, 21, -6, 5 },
  { 9105, 10, 10, 17, 9, -49 },
  { 9118, 27, 36, 30, 2, -35 },
  { 9240, 27, 50, 30, 1, -49 },
  { 9409, 22, 36, 23, 2, -35 },
  { 9508, 30, 50, 30, 2, -49 },
  { 9696, 23, 36, 27, 2, -35 },
  { 9800, 32, 64, 16, -8, -49 },
  { 10056, 30, 50, 30, -1, -35 },
  { 10244, 26, 49, 30, 1, -49 },
  { 10404, 14, 47, 14, 1, -47 },
  { 10487, 23, 62, 14, -8, -47 },
  { 10666, 27, 49, 26, 1, -49 },
  { 10832, 15, 49, 13, 1, -49 },
  { 10924, 41, 35, 44, 1, -35 },
  { 11104, 27, 35, 30, 0, -35 },
  { 11223, 25, 36, 29, 2, -35 },
  { 11336, 31, 50, 30, -3, -35 },
  { 11530, 27, 50, 30, 2, -35 },
  { 11699, 22, 35, 20, 1, -35 },
  { 11796, 23, 36, 22, 0, -35 },
  { 11900, 17, 43, 17, 2, -42 },
  { 11992, 27, 35, 30, 2, -34 },
  { 12111, 23, 34, 24, 4, -34 },
  { 12209, 37, 34, 38, 4, -34 },
  { 12367, 30, 34, 25, -3, -34 },
  { 12495, 33, 49, 24, -6, -34 },
  { 12698, 24, 34, 21, -2, -34 },
  { 12800, 24, 56, 21, 1, -46 },
  { 12968, 4, 64, 27, 12, -49 },
  { 13000, 23, 56, 21, -3, -46 },
  { 13161, 26, 9, 30, 3, -27 },
};

const GFXfont NotoSans_Condensed_Italic64pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Italic64pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Italic64pt7bGlyphs,
  0x20, 0x7E, 87
};

#endif // _NOTOSANS_CONDENSED_ITALIC64PT7B_H_
