#ifndef _NOTOSANS_CONDENSED_ITALIC63PT7B_H_
#define _NOTOSANS_CONDENSED_ITALIC63PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Italic.ttf
// Size: 63pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Italic63pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x3F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x0F,
  0x80, 0x04, 0x00, 0x00, 0x1F, 0x07, 0xC7, 0xC1, 0xF3, 0xF0, 0xFC, 0xFC,
  0x3E, 0x3E, 0x0F, 0x8F, 0x83, 0xE3, 0xE0, 0xF8, 0xF0, 0x3C, 0x3C, 0x0F,
  0x1F, 0x07, 0xC7, 0xC1, 0xF1, 0xE0, 0x78, 0x78, 0x1E, 0x1E, 0x07, 0x87,
  0x81, 0xC3, 0xC0, 0xF0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x78, 0x0F, 0x00,
  0x00, 0xF0, 0x1E, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x00,
  0xF0, 0x1E, 0x00, 0x01, 0xE0, 0x3C, 0x01, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xF0,
  0x1E, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x78, 0x1E,
  0x00, 0x01, 0xE0, 0x3C, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x07, 0x81, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xF8, 0x03, 0xC0, 0x78, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x78, 0x0F, 0x00, 0x00,
  0xF0, 0x3C, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x78, 0x0F, 0x00, 0x00, 0xF0,
  0x3C, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x07, 0xE7, 0x0F,
  0x01, 0xF0, 0xE0, 0x40, 0x3E, 0x1C, 0x00, 0x0F, 0x83, 0x80, 0x01, 0xF0,
  0xE0, 0x00, 0x3E, 0x1C, 0x00, 0x07, 0xC3, 0x80, 0x00, 0xF8, 0x70, 0x00,
  0x1F, 0x0E, 0x00, 0x03, 0xF3, 0x80, 0x00, 0x3F, 0x70, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xDF,
  0x80, 0x00, 0x39, 0xF8, 0x00, 0x07, 0x1F, 0x00, 0x00, 0xE3, 0xE0, 0x00,
  0x1C, 0x3E, 0x00, 0x07, 0x07, 0xC0, 0x00, 0xE0, 0xF8, 0x00, 0x1C, 0x1E,
  0x00, 0x03, 0x87, 0xC0, 0x00, 0xE0, 0xF8, 0x20, 0x1C, 0x3E, 0x07, 0x83,
  0x8F, 0xC0, 0xFF, 0x7F, 0xF0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0xF8, 0x03, 0xFE, 0x00, 0x0F, 0x00, 0x7F, 0xF0, 0x01,
  0xE0, 0x0F, 0x9F, 0x00, 0x1E, 0x01, 0xF0, 0xF0, 0x03, 0xC0, 0x1E, 0x0F,
  0x00, 0x7C, 0x03, 0xE0, 0xF0, 0x07, 0x80, 0x3C, 0x0F, 0x00, 0xF0, 0x03,
  0xC0, 0xF0, 0x0F, 0x00, 0x78, 0x0F, 0x01, 0xE0, 0x07, 0x80, 0xF0, 0x3E,
  0x00, 0x78, 0x0F, 0x03, 0xC0, 0x0F, 0x80, 0xF0, 0x7C, 0x00, 0xF0, 0x0F,
  0x07, 0x80, 0x0F, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0x1E, 0x0F, 0x00, 0x0F,
  0x01, 0xE1, 0xE0, 0x00, 0xF0, 0x3E, 0x3E, 0x04, 0x0F, 0x03, 0xC3, 0xC3,
  0xF8, 0xF0, 0x3C, 0x78, 0x7F, 0xCF, 0x07, 0xC7, 0x8F, 0xFE, 0xF0, 0x78,
  0xF1, 0xF3, 0xEF, 0x0F, 0x9F, 0x1E, 0x1E, 0xF9, 0xF1, 0xE3, 0xC1, 0xFF,
  0xFE, 0x3E, 0x3C, 0x0F, 0x7F, 0xC3, 0xC7, 0x81, 0xF3, 0xF8, 0x78, 0x78,
  0x1F, 0x04, 0x0F, 0x8F, 0x81, 0xE0, 0x00, 0xF0, 0xF0, 0x1E, 0x00, 0x1F,
  0x0F, 0x01, 0xE0, 0x01, 0xE0, 0xF0, 0x1E, 0x00, 0x3C, 0x1F, 0x01, 0xE0,
  0x03, 0xC1, 0xE0, 0x3E, 0x00, 0x78, 0x1E, 0x03, 0xC0, 0x0F, 0x81, 0xE0,
  0x3C, 0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x1F, 0x01, 0xE0, 0x7C, 0x01, 0xE0,
  0x1E, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x78, 0x07, 0xC0, 0x1E, 0x0F, 0x00,
  0x78, 0x01, 0xE1, 0xF0, 0x0F, 0x80, 0x1F, 0x3E, 0x00, 0xF0, 0x00, 0xFF,
  0xC0, 0x1E, 0x00, 0x0F, 0xFC, 0x03, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0xFC,
  0x3F, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x7C, 0x07,
  0xC0, 0x01, 0xF0, 0x1F, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x1F, 0x01, 0xE0,
  0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x1F, 0x0F, 0x80, 0x00, 0x7C, 0x7E, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x1F, 0x9F, 0x01, 0xF0, 0xFC, 0x7C, 0x07, 0xC3, 0xE1, 0xF8, 0x3F,
  0x1F, 0x03, 0xE0, 0xF8, 0xFC, 0x0F, 0xC3, 0xE3, 0xE0, 0x1F, 0x1F, 0x1F,
  0x80, 0x7E, 0x7C, 0x7C, 0x00, 0xFB, 0xE1, 0xF0, 0x03, 0xFF, 0x87, 0xC0,
  0x07, 0xFC, 0x3F, 0x00, 0x1F, 0xE0, 0xF8, 0x00, 0x7F, 0x83, 0xF0, 0x00,
  0xFC, 0x0F, 0xC0, 0x07, 0xF0, 0x3F, 0x00, 0x3F, 0xC0, 0x7E, 0x01, 0xFF,
  0x81, 0xFC, 0x1F, 0xFE, 0x07, 0xFF, 0xFE, 0xFC, 0x0F, 0xFF, 0xF1, 0xF0,
  0x1F, 0xFF, 0x07, 0xE0, 0x3F, 0xF8, 0x0F, 0xC0, 0x1C, 0x00, 0x00, 0x00,
  0x3F, 0x3E, 0x3E, 0x3E, 0x7C, 0x7C, 0x7C, 0x7C, 0x78, 0x78, 0xF8, 0xF8,
  0xF0, 0xF0, 0xF0, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x80,
  0xF0, 0x07, 0x83, 0xC0, 0x1F, 0x8F, 0x00, 0x7F, 0xB8, 0x07, 0xFF, 0xE7,
  0xF1, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xF0, 0x00,
  0x3F, 0xC0, 0x01, 0xF7, 0x80, 0x0F, 0x9F, 0x00, 0x7C, 0x3C, 0x07, 0xF0,
  0xF8, 0x0F, 0x83, 0xE0, 0x1C, 0x07, 0xC0, 0x20, 0x1F, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xF0, 0x3E, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x1F,
  0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0xF8, 0x00, 0x7F, 0xFE,
  0xFF, 0xF9, 0xFF, 0xF7, 0xFF, 0xE0, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xBE,
  0x10, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x07, 0xFF,
  0xF0, 0x07, 0xF1, 0xF8, 0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x1F, 0x03, 0xF0,
  0x0F, 0x81, 0xF0, 0x07, 0xC1, 0xF8, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0xFC,
  0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x1F,
  0x00, 0x0F, 0x8F, 0x80, 0x07, 0xCF, 0xC0, 0x03, 0xE7, 0xC0, 0x01, 0xF3,
  0xE0, 0x01, 0xF9, 0xF0, 0x00, 0xF9, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x3E,
  0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x9F, 0x00, 0x0F, 0xCF, 0x80, 0x07,
  0xCF, 0xC0, 0x03, 0xE7, 0xC0, 0x03, 0xF3, 0xE0, 0x01, 0xF9, 0xF0, 0x00,
  0xF8, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x7E, 0x3E, 0x00, 0x3E, 0x1F, 0x00,
  0x3F, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x1F, 0x83, 0xE0, 0x0F, 0x81, 0xF8,
  0x0F, 0xC0, 0x7C, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x1F, 0xFF, 0xE0, 0x07,
  0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x3F,
  0xF8, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xBE, 0x7F, 0x1F, 0x1F, 0x0F, 0x87,
  0x0F, 0xC3, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x03,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xE0, 0xFE, 0x00, 0x78, 0x03,
  0xF0, 0x03, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xF0,
  0x1F, 0xC0, 0x38, 0x01, 0xF8, 0x02, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x80, 0x03, 0xF8, 0x1E,
  0x01, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7B, 0xE0, 0x00, 0x0F, 0x3C, 0x00, 0x01, 0xF7, 0xC0, 0x00,
  0x1E, 0x7C, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x07, 0x8F,
  0x80, 0x00, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00,
  0x3C, 0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x1F, 0x00, 0x0F, 0x01,
  0xF0, 0x01, 0xF0, 0x1F, 0x00, 0x3E, 0x03, 0xE0, 0x03, 0xC0, 0x3E, 0x00,
  0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x03, 0xE0, 0x1E, 0x00,
  0x7C, 0x03, 0xE0, 0x07, 0xC0, 0x7C, 0x00, 0x7C, 0x07, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x60,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xE0, 0x03, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xFC, 0x0C, 0x00, 0x3F, 0x80, 0xF0, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0x80, 0x80,
  0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x7F, 0x80, 0x0F, 0x9F, 0xFC, 0x03, 0xE7,
  0xFF, 0x80, 0x7D, 0xFF, 0xF8, 0x0F, 0xF8, 0x3F, 0x03, 0xFE, 0x03, 0xF0,
  0x7F, 0x00, 0x7E, 0x0F, 0xE0, 0x07, 0xC1, 0xF8, 0x00, 0xF8, 0x3F, 0x00,
  0x1F, 0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x3F, 0x00, 0x0F, 0x87,
  0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0xC3, 0xE0, 0x01,
  0xF0, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0xC1, 0xF8, 0x01, 0xF0, 0x1F,
  0x00, 0x7E, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x03, 0xF0, 0x0F, 0xE1, 0xFC,
  0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x0F, 0x80, 0x3F, 0x03, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x7C,
  0x0F, 0x80, 0x0F, 0x81, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x3E, 0x07, 0xC0,
  0x0F, 0x80, 0xF8, 0x01, 0xF0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x1F, 0x80,
  0x3E, 0x07, 0xE0, 0x07, 0xE1, 0xF8, 0x00, 0x7E, 0xFE, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0xFE, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x00, 0xF8, 0x1F, 0x00, 0x1F, 0x87, 0xE0,
  0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0xF8,
  0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0xFC, 0x3E, 0x00,
  0x1F, 0x07, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0xF8, 0x0F, 0xC0, 0x7F, 0x01,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0x0F,
  0xE0, 0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0x3E, 0x07, 0xE0, 0x0F, 0xC1, 0xF0,
  0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC3,
  0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x1F, 0x00, 0x0F,
  0xC7, 0xC0, 0x03, 0xF1, 0xF0, 0x00, 0xFC, 0x7C, 0x00, 0x3E, 0x1F, 0x00,
  0x1F, 0x87, 0xE0, 0x0F, 0xE1, 0xF8, 0x03, 0xF8, 0x3F, 0x01, 0xFE, 0x0F,
  0xE1, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0x7F, 0xFD, 0xF0, 0x0F, 0xFE, 0x7C,
  0x01, 0xFE, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x20, 0x1F, 0xE0, 0x0F, 0xFF, 0xF0,
  0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xF0, 0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xF8,
  0x0F, 0xC0, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x07,
  0xE0, 0x3F, 0x81, 0xF8, 0x1F, 0xC0, 0xFE, 0x03, 0xE0, 0x04, 0x00, 0x00,
  0x1E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x3E, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07,
  0xC1, 0xFC, 0x10, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x00, 0xFE,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x1F, 0x00, 0x00, 0x00,
  0xF0, 0x3C, 0x00, 0xFE, 0x01, 0xE0, 0xF0, 0x07, 0xFF, 0x83, 0xC3, 0xE0,
  0x1F, 0xFE, 0x07, 0x87, 0x80, 0x7F, 0xFC, 0x0F, 0x0F, 0x01, 0xF0, 0x78,
  0x1E, 0x3C, 0x07, 0xC1, 0xF0, 0x3C, 0x78, 0x1F, 0x03, 0xC0, 0x79, 0xE0,
  0x3C, 0x07, 0x80, 0xF3, 0xC0, 0xF8, 0x0F, 0x01, 0xE7, 0x81, 0xE0, 0x3E,
  0x07, 0x9F, 0x03, 0xC0, 0x78, 0x0F, 0x3C, 0x0F, 0x00, 0xF0, 0x1E, 0x78,
  0x1E, 0x01, 0xE0, 0x3C, 0xF0, 0x3C, 0x07, 0xC0, 0xF1, 0xE0, 0xF0, 0x0F,
  0x01, 0xE7, 0x81, 0xE0, 0x1E, 0x03, 0xCF, 0x03, 0xC0, 0x7C, 0x0F, 0x1E,
  0x07, 0x80, 0xF8, 0x1E, 0x3C, 0x0F, 0x01, 0xE0, 0x3C, 0x78, 0x1E, 0x07,
  0xC0, 0xF0, 0xF0, 0x3C, 0x1F, 0x83, 0xC1, 0xE0, 0x7C, 0x3F, 0x87, 0x83,
  0xC0, 0xFF, 0xEF, 0xFE, 0x07, 0x80, 0xFF, 0x8F, 0xF8, 0x0F, 0x00, 0xFE,
  0x1F, 0xE0, 0x1E, 0x00, 0xF8, 0x0F, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x30, 0x00, 0x03, 0xFE,
  0x07, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F, 0xBC, 0x00,
  0x00, 0x79, 0xE0, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x03,
  0xE3, 0xC0, 0x00, 0x1F, 0x1E, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x0F, 0x87,
  0x80, 0x00, 0xF8, 0x3C, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3E, 0x0F, 0x80,
  0x03, 0xE0, 0x7C, 0x00, 0x1F, 0x03, 0xE0, 0x01, 0xF0, 0x1F, 0x00, 0x0F,
  0x80, 0xF8, 0x00, 0xF8, 0x07, 0xC0, 0x07, 0xC0, 0x3E, 0x00, 0x7E, 0x01,
  0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x7E,
  0x00, 0x3E, 0x03, 0xE0, 0x01, 0xF0, 0x3F, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0x7C, 0x1F, 0x80, 0x03, 0xE0, 0xFC, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0xF8,
  0x7E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x3F, 0x00, 0x01, 0xF1, 0xF0,
  0x00, 0x0F, 0xDF, 0x80, 0x00, 0x7E, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7C, 0x01, 0xFC,
  0x03, 0xE0, 0x07, 0xE0, 0x1F, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0xF8, 0x0F,
  0xC0, 0x07, 0xC0, 0x7C, 0x00, 0x3E, 0x03, 0xE0, 0x01, 0xF0, 0x1F, 0x00,
  0x0F, 0x81, 0xF8, 0x00, 0xFC, 0x0F, 0x80, 0x07, 0xC0, 0x7C, 0x00, 0x7E,
  0x03, 0xE0, 0x03, 0xE0, 0x1F, 0x00, 0x3F, 0x01, 0xF8, 0x07, 0xF0, 0x0F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xFC,
  0x03, 0xE0, 0x03, 0xE0, 0x3F, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0xFC, 0x0F,
  0x80, 0x03, 0xE0, 0x7C, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0xF8, 0x3F, 0x00,
  0x0F, 0xC1, 0xF0, 0x00, 0x7E, 0x0F, 0x80, 0x03, 0xF0, 0x7C, 0x00, 0x3F,
  0x03, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0x81, 0xF0, 0x01, 0xFC, 0x0F,
  0x80, 0x1F, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xE0, 0x78, 0x03, 0xFC, 0x00, 0x80,
  0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x10, 0x01, 0xFE, 0x07, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0x00, 0xFF,
  0x00, 0x3E, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0xFC,
  0x03, 0xF0, 0x00, 0xF8, 0x07, 0xC0, 0x01, 0xF8, 0x0F, 0x80, 0x03, 0xF0,
  0x1F, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x1F, 0x81,
  0xF0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0xFC, 0x1F,
  0x80, 0x01, 0xF8, 0x3E, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x07, 0xC0, 0xF8,
  0x00, 0x0F, 0x83, 0xF0, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x7E, 0x0F, 0x80,
  0x00, 0xFC, 0x1F, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x03, 0xE0, 0xFC, 0x00,
  0x0F, 0xC1, 0xF0, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00,
  0xFC, 0x0F, 0x80, 0x01, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x1F,
  0x80, 0xF8, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0xFC, 0x03, 0xE0, 0x03, 0xF8,
  0x0F, 0xC0, 0x0F, 0xE0, 0x1F, 0x00, 0x7F, 0x80, 0x3E, 0x01, 0xFE, 0x00,
  0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xE0, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xC0, 0x7E,
  0x00, 0xFF, 0x00, 0x0C, 0x00, 0xFE, 0x00, 0x04, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x7F, 0xF8, 0x7C, 0x00, 0x7F, 0xF8,
  0xFC, 0x00, 0x7F, 0xF8, 0xFC, 0x00, 0x7F, 0xF0, 0xFC, 0x00, 0xFF, 0xF0,
  0xFC, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x03, 0xE0,
  0xF8, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x03, 0xE0,
  0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x07, 0xC0,
  0xFC, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x0F, 0xC0,
  0x7F, 0x00, 0x0F, 0x80, 0x3F, 0x80, 0x0F, 0x80, 0x3F, 0xE0, 0x3F, 0x80,
  0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x07,
  0xC0, 0x1F, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0xFC, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x03, 0xE0, 0x0F, 0x80,
  0x00, 0xF8, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x7E,
  0x00, 0x07, 0xC0, 0x1F, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x7C, 0x01,
  0xF0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x03, 0xE0,
  0x0F, 0x80, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x1F,
  0x80, 0x7E, 0x00, 0x07, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xE0, 0x0F, 0x80, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0xF8,
  0x00, 0x1F, 0x80, 0x3E, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x01, 0xF0, 0x07,
  0xC0, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x0F, 0xC0,
  0x3F, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0xF8, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x07, 0xC0, 0x1F, 0x80, 0x01,
  0xF0, 0x07, 0xC0, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x7C, 0x00,
  0x0F, 0xC0, 0x1F, 0x00, 0x03, 0xE0, 0x0F, 0xC0, 0x00, 0xF8, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x0F,
  0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x3E, 0x00, 0x1F,
  0x80, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x1F,
  0x80, 0x07, 0xC0, 0x0F, 0x80, 0x03, 0xE0, 0x0F, 0xC0, 0x01, 0xF0, 0x0F,
  0xC0, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x7C, 0x07,
  0xE0, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x1F, 0x87,
  0xE0, 0x00, 0x0F, 0x87, 0xF0, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x03, 0xE3,
  0xF0, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0xF9,
  0xF8, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xF7, 0xC0, 0x00, 0x07,
  0xF3, 0xE0, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x01,
  0xF0, 0x3E, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x7C, 0x0F, 0xC0, 0x00,
  0x3E, 0x03, 0xE0, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0xFC, 0x00,
  0x0F, 0x80, 0x7E, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x03, 0xE0, 0x0F, 0x80,
  0x03, 0xF0, 0x07, 0xE0, 0x01, 0xF0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x1F, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xF0, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x00, 0xFB, 0xE0, 0x1F,
  0x78, 0x00, 0x0F, 0xFC, 0x01, 0xF7, 0x80, 0x00, 0xF7, 0xC0, 0x1F, 0x78,
  0x00, 0x1F, 0x7C, 0x01, 0xF7, 0x80, 0x01, 0xE7, 0xC0, 0x3E, 0x78, 0x00,
  0x3E, 0xFC, 0x03, 0xE7, 0x80, 0x03, 0xEF, 0x80, 0x3E, 0x7C, 0x00, 0x7C,
  0xF8, 0x03, 0xE7, 0xC0, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x00, 0xF8, 0xF8,
  0x07, 0xC7, 0xC0, 0x0F, 0x9F, 0x80, 0x7C, 0x7C, 0x01, 0xF1, 0xF0, 0x07,
  0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x87,
  0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x0F, 0x87, 0xC0,
  0x7C, 0x3E, 0x00, 0xF8, 0x3C, 0x0F, 0x83, 0xE0, 0x0F, 0x83, 0xC0, 0xF8,
  0x3E, 0x01, 0xF0, 0x3C, 0x1F, 0x07, 0xE0, 0x1F, 0x03, 0xC1, 0xF0, 0x7C,
  0x01, 0xF0, 0x3C, 0x3E, 0x07, 0xC0, 0x1F, 0x03, 0xC3, 0xE0, 0x7C, 0x01,
  0xF0, 0x3E, 0x7C, 0x07, 0xC0, 0x3E, 0x03, 0xE7, 0xC0, 0xFC, 0x03, 0xE0,
  0x3E, 0x78, 0x0F, 0x80, 0x3E, 0x03, 0xEF, 0x80, 0xF8, 0x03, 0xE0, 0x3E,
  0xF0, 0x0F, 0x80, 0x3E, 0x03, 0xFF, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0xE0,
  0x1F, 0x80, 0x7C, 0x03, 0xFE, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xFC, 0x01, 0xF0, 0x0F, 0x80, 0x1F, 0x80, 0x3F, 0x00,
  0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x07, 0xF0,
  0x00, 0x1F, 0x00, 0x7F, 0x00, 0x01, 0xF0, 0x07, 0xF0, 0x00, 0x3E, 0x00,
  0xFF, 0x00, 0x03, 0xE0, 0x0F, 0xF8, 0x00, 0x3E, 0x00, 0xFF, 0x80, 0x03,
  0xE0, 0x0F, 0xF8, 0x00, 0x7E, 0x01, 0xFF, 0x80, 0x07, 0xC0, 0x1F, 0x78,
  0x00, 0x7C, 0x01, 0xF7, 0xC0, 0x07, 0xC0, 0x1F, 0x7C, 0x00, 0x7C, 0x01,
  0xE7, 0xC0, 0x0F, 0x80, 0x3E, 0x7C, 0x00, 0xF8, 0x03, 0xE3, 0xE0, 0x0F,
  0x80, 0x3E, 0x3E, 0x00, 0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x80, 0x3E, 0x3E,
  0x01, 0xF0, 0x07, 0xC1, 0xE0, 0x1F, 0x00, 0x7C, 0x1F, 0x01, 0xF0, 0x07,
  0xC1, 0xF0, 0x1F, 0x00, 0x7C, 0x1F, 0x01, 0xF0, 0x0F, 0xC0, 0xF0, 0x3E,
  0x00, 0xF8, 0x0F, 0x83, 0xE0, 0x0F, 0x80, 0xF8, 0x3E, 0x00, 0xF8, 0x0F,
  0x83, 0xE0, 0x0F, 0x80, 0xF8, 0x7C, 0x01, 0xF0, 0x07, 0xC7, 0xC0, 0x1F,
  0x00, 0x7C, 0x7C, 0x01, 0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x00, 0x7C, 0x7C,
  0x01, 0xF0, 0x03, 0xCF, 0x80, 0x3E, 0x00, 0x3E, 0xF8, 0x03, 0xE0, 0x03,
  0xEF, 0x80, 0x3E, 0x00, 0x3E, 0xF8, 0x03, 0xE0, 0x03, 0xEF, 0x80, 0x3E,
  0x00, 0x1F, 0xF0, 0x07, 0xC0, 0x01, 0xFF, 0x00, 0x7C, 0x00, 0x1F, 0xF0,
  0x07, 0xC0, 0x01, 0xFF, 0x00, 0x7C, 0x00, 0x0F, 0xE0, 0x0F, 0x80, 0x00,
  0xFE, 0x00, 0xF8, 0x00, 0x0F, 0xE0, 0x0F, 0x80, 0x00, 0xFE, 0x00, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80,
  0x0F, 0xF0, 0x7F, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x00, 0x7E, 0x03,
  0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x3E,
  0x00, 0x01, 0xF0, 0xFC, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x07, 0xC7, 0xE0,
  0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0x3E, 0x7E, 0x00,
  0x00, 0x7C, 0xF8, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x01, 0xF7, 0xE0, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x1F, 0xBE, 0x00, 0x00,
  0x3E, 0x7C, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x03,
  0xF7, 0xE0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x3F,
  0x3E, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x03, 0xF1,
  0xF0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x3F, 0x0F,
  0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x03, 0xF0, 0x1F, 0x80, 0x07, 0xE0, 0x3F,
  0x00, 0x1F, 0x80, 0x7F, 0x00, 0xFE, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xE0, 0x0F, 0x80, 0xFE, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0x80, 0x3F, 0x01,
  0xF8, 0x01, 0xF0, 0x1F, 0x80, 0x1F, 0x01, 0xF0, 0x01, 0xF0, 0x1F, 0x00,
  0x1F, 0x01, 0xF0, 0x01, 0xF0, 0x3F, 0x00, 0x1F, 0x03, 0xE0, 0x01, 0xF0,
  0x3E, 0x00, 0x3F, 0x03, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x3E, 0x07, 0xE0,
  0x07, 0xE0, 0x7C, 0x00, 0xFC, 0x07, 0xC0, 0x1F, 0xC0, 0x7C, 0x03, 0xF8,
  0x0F, 0xC1, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xF0, 0x7F, 0x00, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0xFC,
  0x1F, 0x80, 0x01, 0xF8, 0x3E, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x03, 0xE1,
  0xF0, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x1F, 0x3F,
  0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0xF9, 0xF0,
  0x00, 0x01, 0xF7, 0xE0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x0F, 0xDF, 0x00,
  0x00, 0x1F, 0xBE, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x7D, 0xF8, 0x00,
  0x01, 0xFB, 0xF0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x0F, 0x9F, 0x00, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00,
  0xF8, 0xF8, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x1F,
  0x87, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x03, 0xF8,
  0x1F, 0x80, 0x07, 0xE0, 0x3F, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0xFF, 0x00,
  0x7F, 0x83, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x80, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0x80, 0xFF, 0x00,
  0xF8, 0x03, 0xF0, 0x0F, 0x80, 0x3F, 0x01, 0xF8, 0x01, 0xF0, 0x1F, 0x80,
  0x1F, 0x01, 0xF0, 0x01, 0xF0, 0x1F, 0x00, 0x1F, 0x01, 0xF0, 0x01, 0xF0,
  0x3F, 0x00, 0x1F, 0x03, 0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x3F, 0x03, 0xE0,
  0x03, 0xE0, 0x3E, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x7C, 0x00, 0xFC,
  0x07, 0xC0, 0x3F, 0x80, 0x7C, 0x0F, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0x83, 0xE0,
  0x01, 0xF8, 0x3E, 0x00, 0x1F, 0x03, 0xE0, 0x01, 0xF0, 0x3F, 0x00, 0x1F,
  0x01, 0xF0, 0x01, 0xF0, 0x1F, 0x00, 0x3F, 0x01, 0xF0, 0x03, 0xE0, 0x1F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07,
  0xE0, 0x0F, 0xC0, 0x7C, 0x00, 0xFC, 0x07, 0xC0, 0x07, 0xC0, 0x7C, 0x00,
  0x7C, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x0F, 0x80, 0x03, 0xE0,
  0xF8, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x3F,
  0xC1, 0xF8, 0x03, 0xF8, 0x01, 0x80, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x08, 0x00, 0x1F, 0x80, 0x60, 0x01, 0xFC, 0x03, 0xF0, 0x7F, 0xC0,
  0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF0, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3E,
  0x03, 0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7C,
  0x07, 0xC0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0xFC,
  0x0F, 0xC0, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0xF8,
  0x0F, 0x80, 0x00, 0xF8, 0x0F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF0,
  0x1F, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x01, 0xF0,
  0x1F, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x03, 0xE0,
  0x3E, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x07, 0xE0,
  0x7E, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x07, 0xC0,
  0x7C, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x0F, 0x80,
  0xF8, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x1F, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x3E, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x7F, 0x03, 0xF8, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x7E, 0xF8, 0x00, 0x07, 0xCF, 0x80, 0x00, 0xFC, 0xF8, 0x00,
  0x0F, 0xCF, 0x80, 0x01, 0xF8, 0xF8, 0x00, 0x1F, 0x8F, 0x80, 0x01, 0xF0,
  0xF8, 0x00, 0x3F, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x7E, 0x0F, 0x80,
  0x07, 0xC0, 0xF8, 0x00, 0xFC, 0x0F, 0x80, 0x0F, 0x80, 0xF8, 0x00, 0xF8,
  0x0F, 0x80, 0x1F, 0x80, 0xF8, 0x01, 0xF0, 0x0F, 0x80, 0x3F, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x00, 0xF8, 0x07, 0xC0, 0x0F, 0x80, 0xFC,
  0x00, 0xF8, 0x0F, 0x80, 0x0F, 0x80, 0xF8, 0x00, 0xF8, 0x1F, 0x00, 0x0F,
  0x81, 0xF0, 0x00, 0x78, 0x3F, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x78, 0x7E,
  0x00, 0x07, 0xC7, 0xC0, 0x00, 0x7C, 0xFC, 0x00, 0x07, 0xCF, 0x80, 0x00,
  0x7C, 0xF8, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7B, 0xE0, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x3F,
  0x00, 0x03, 0xEF, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xCF, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0x8F, 0x80, 0x0F, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0x8F,
  0x80, 0x0F, 0xF0, 0x01, 0xF0, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0x0F, 0x80,
  0x1E, 0xF0, 0x03, 0xE0, 0xF8, 0x03, 0xEF, 0x00, 0x3E, 0x0F, 0x80, 0x3C,
  0xF0, 0x07, 0xE0, 0xF8, 0x03, 0xCF, 0x00, 0x7C, 0x0F, 0x80, 0x7C, 0xF0,
  0x0F, 0xC0, 0xF8, 0x07, 0x8F, 0x00, 0xF8, 0x0F, 0x80, 0xF8, 0xF0, 0x0F,
  0x80, 0xF8, 0x0F, 0x0F, 0x01, 0xF0, 0x0F, 0x81, 0xF0, 0xF0, 0x1F, 0x00,
  0xF8, 0x1F, 0x0F, 0x03, 0xF0, 0x0F, 0x81, 0xE0, 0xF0, 0x3E, 0x00, 0xF8,
  0x3E, 0x0F, 0x03, 0xE0, 0x0F, 0x83, 0xC0, 0xF0, 0x7C, 0x00, 0xF8, 0x7C,
  0x0F, 0x07, 0xC0, 0x0F, 0x87, 0xC0, 0xF0, 0xFC, 0x00, 0xF8, 0x78, 0x0F,
  0x0F, 0x80, 0x0F, 0x8F, 0x80, 0xF0, 0xF8, 0x00, 0xF8, 0xF0, 0x0F, 0x1F,
  0x00, 0x0F, 0x9F, 0x00, 0xF1, 0xF0, 0x00, 0xF9, 0xF0, 0x0F, 0x3F, 0x00,
  0x0F, 0x9E, 0x00, 0xF3, 0xE0, 0x00, 0xFB, 0xE0, 0x0F, 0x3E, 0x00, 0x0F,
  0x3C, 0x00, 0xF7, 0xC0, 0x00, 0xF7, 0xC0, 0x0F, 0x7C, 0x00, 0x0F, 0x78,
  0x00, 0xF7, 0x80, 0x00, 0xF7, 0x80, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x0F, 0xC0,
  0x00, 0xF8, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x0F,
  0x80, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x00, 0xF8,
  0x1F, 0x00, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x00,
  0x3E, 0x3E, 0x00, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x00, 0xF9, 0xF0, 0x00,
  0x00, 0x1F, 0x7C, 0x00, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xDE, 0x00, 0x00, 0x01, 0xF3, 0xE0,
  0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x03, 0xE1,
  0xF0, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x7C, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x3E, 0x01, 0xF0, 0x00,
  0x0F, 0xC0, 0x3F, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x1F, 0x80, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0x0F, 0xDF, 0x00, 0x07, 0xE7, 0xC0, 0x01, 0xF1, 0xF0, 0x00, 0xFC,
  0x7C, 0x00, 0x3E, 0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x07, 0xC0, 0xF8, 0x03,
  0xF0, 0x3E, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3F, 0x00, 0xF8,
  0x0F, 0x80, 0x3E, 0x07, 0xE0, 0x07, 0xC1, 0xF0, 0x01, 0xF0, 0xFC, 0x00,
  0x7C, 0x3E, 0x00, 0x1F, 0x1F, 0x00, 0x07, 0xC7, 0xC0, 0x01, 0xF3, 0xE0,
  0x00, 0x7C, 0xF8, 0x00, 0x0F, 0x7C, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xF0, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xE0, 0x20, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xF8, 0x0F, 0x01, 0xE0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x3C, 0x07, 0x80, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0x78, 0x0F, 0x01, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x3C, 0x07, 0x80, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x80, 0xF0,
  0x1E, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x07, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xF7, 0x80, 0x00, 0x3C, 0xF8, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xE1, 0xE0,
  0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xC0, 0x78, 0x00, 0xF8,
  0x0F, 0x80, 0x1E, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF0, 0x03, 0xE0,
  0x3E, 0x00, 0x3C, 0x0F, 0x80, 0x07, 0x81, 0xF0, 0x00, 0xF8, 0x7C, 0x00,
  0x0F, 0x0F, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0x3E, 0xFC, 0x00, 0x03, 0xE0,
  0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x3E, 0x1F, 0x87, 0xC3, 0xE0, 0xF8, 0x3C, 0x1F, 0x07, 0x81, 0xC0, 0x00,
  0x1F, 0xC1, 0xE0, 0x0F, 0xFC, 0x7C, 0x03, 0xFF, 0xCF, 0x80, 0xFF, 0xF9,
  0xE0, 0x3F, 0x87, 0xFC, 0x0F, 0xE0, 0x7F, 0x81, 0xF8, 0x07, 0xF0, 0x7E,
  0x00, 0xFC, 0x0F, 0x80, 0x1F, 0x83, 0xF0, 0x03, 0xF0, 0x7C, 0x00, 0x7E,
  0x1F, 0x80, 0x0F, 0xC3, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x1F, 0x80,
  0x07, 0xC3, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x3F, 0x0F, 0x80, 0x07, 0xC1,
  0xF0, 0x00, 0xF8, 0x7E, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xE1, 0xF0, 0x00,
  0xF8, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x07, 0xE0, 0xF8, 0x00, 0xFC, 0x1F,
  0x00, 0x3F, 0x83, 0xE0, 0x07, 0xE0, 0x7E, 0x01, 0xFC, 0x0F, 0xC0, 0x7F,
  0x80, 0xFC, 0x1F, 0xF0, 0x1F, 0xFF, 0xBE, 0x01, 0xFF, 0xE7, 0x80, 0x3F,
  0xF8, 0xF0, 0x03, 0xFC, 0x1E, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x1F,
  0xC0, 0x0F, 0x8F, 0xFC, 0x01, 0xF3, 0xFF, 0xC0, 0x3E, 0xFF, 0xF8, 0x07,
  0xFC, 0x3F, 0x80, 0xFF, 0x03, 0xF0, 0x3F, 0xC0, 0x3E, 0x07, 0xF0, 0x07,
  0xC0, 0xFC, 0x00, 0xF8, 0x1F, 0x80, 0x1F, 0x07, 0xE0, 0x03, 0xE0, 0xFC,
  0x00, 0x7C, 0x1F, 0x80, 0x0F, 0x83, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x3E,
  0x1F, 0x80, 0x07, 0xC3, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x3F, 0x0F, 0x80,
  0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xE1,
  0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x3F, 0x07, 0xC0, 0x07, 0xC1, 0xF8, 0x01,
  0xF8, 0x3F, 0x00, 0x3F, 0x07, 0xF0, 0x0F, 0xC0, 0xFE, 0x03, 0xF0, 0x3F,
  0xE0, 0xFE, 0x07, 0xDF, 0xFF, 0x80, 0xF3, 0xFF, 0xE0, 0x1E, 0x3F, 0xF8,
  0x03, 0xC3, 0xFC, 0x00, 0x80, 0x0C, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x01,
  0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFE, 0x03, 0xF8, 0x38, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x81, 0xFC, 0x0C, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0,
  0x1F, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x03, 0xFC, 0x3E, 0x00, 0x1F, 0xF8, 0xF8, 0x00, 0xFF, 0xF3,
  0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0x87, 0xFC, 0x01, 0xF8, 0x0F, 0xF0,
  0x07, 0xC0, 0x1F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF8, 0x07,
  0xE0, 0x07, 0xE0, 0x1F, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x7E, 0x03, 0xE0,
  0x01, 0xF0, 0x0F, 0x80, 0x07, 0xC0, 0x7E, 0x00, 0x1F, 0x01, 0xF0, 0x00,
  0x7C, 0x07, 0xC0, 0x03, 0xE0, 0x1F, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x3E,
  0x03, 0xF0, 0x00, 0xF8, 0x0F, 0x80, 0x07, 0xE0, 0x3E, 0x00, 0x1F, 0x00,
  0xF8, 0x00, 0x7C, 0x03, 0xE0, 0x03, 0xF0, 0x0F, 0x80, 0x0F, 0xC0, 0x3E,
  0x00, 0x7F, 0x00, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x0F, 0xC0,
  0x7F, 0x80, 0x1F, 0x83, 0xFE, 0x00, 0x7F, 0xFE, 0xF0, 0x00, 0xFF, 0xF3,
  0xC0, 0x03, 0xFF, 0x8F, 0x00, 0x07, 0xF8, 0x3C, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x0F, 0xFF,
  0xE0, 0x3F, 0x07, 0xE0, 0xFC, 0x07, 0xC3, 0xF0, 0x0F, 0x87, 0xC0, 0x1F,
  0x1F, 0x80, 0x3E, 0x3E, 0x00, 0x7C, 0xFC, 0x01, 0xF1, 0xF0, 0x03, 0xE3,
  0xE0, 0x0F, 0x8F, 0xC0, 0x7F, 0x1F, 0x07, 0xFC, 0x3F, 0xFF, 0xF0, 0x7F,
  0xFF, 0x81, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x04,
  0x0F, 0xE0, 0x18, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x1F, 0x84, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xCF, 0xE0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x3C, 0x00, 0x3F,
  0xF1, 0xF0, 0x01, 0xFF, 0xE7, 0x80, 0x0F, 0xFF, 0xDE, 0x00, 0x7F, 0x0F,
  0xF8, 0x03, 0xF0, 0x1F, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xFC,
  0x01, 0xF0, 0x03, 0xF0, 0x0F, 0xC0, 0x0F, 0xC0, 0x3E, 0x00, 0x3F, 0x01,
  0xF8, 0x00, 0xFC, 0x07, 0xC0, 0x03, 0xE0, 0x1F, 0x00, 0x0F, 0x80, 0xFC,
  0x00, 0x3E, 0x03, 0xE0, 0x00, 0xF8, 0x0F, 0x80, 0x07, 0xC0, 0x3E, 0x00,
  0x1F, 0x01, 0xF8, 0x00, 0x7C, 0x07, 0xE0, 0x01, 0xF0, 0x1F, 0x00, 0x0F,
  0xC0, 0x7C, 0x00, 0x3E, 0x01, 0xF0, 0x01, 0xF8, 0x07, 0xC0, 0x07, 0xE0,
  0x1F, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0xFE, 0x01, 0xF0, 0x07, 0xF0, 0x07,
  0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0xFF, 0x00, 0x3F, 0x0F, 0xFC, 0x00, 0xFF,
  0xFD, 0xF0, 0x03, 0xFF, 0xEF, 0x80, 0x07, 0xFF, 0x3E, 0x00, 0x0F, 0xF0,
  0xF8, 0x00, 0x06, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x08, 0x00, 0x3F, 0x00, 0x38,
  0x01, 0xFC, 0x00, 0xFC, 0x1F, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x3F,
  0xC0, 0x0F, 0x8F, 0xFC, 0x01, 0xF3, 0xFF, 0xC0, 0x3E, 0xFF, 0xF8, 0x07,
  0xFC, 0x3F, 0x80, 0xFF, 0x03, 0xF0, 0x3F, 0xC0, 0x7E, 0x07, 0xF0, 0x07,
  0xC0, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x07, 0xC0, 0xFC,
  0x00, 0xF8, 0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0xFC,
  0x1F, 0x80, 0x1F, 0x03, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x0F, 0x80,
  0x0F, 0x81, 0xF0, 0x03, 0xF0, 0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x81,
  0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x3E, 0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x01,
  0xF0, 0x3E, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0xC0, 0xF8, 0x01, 0xF8, 0x3F,
  0x00, 0x3E, 0x07, 0xC0, 0x07, 0xC0, 0xF8, 0x00, 0xF8, 0x1F, 0x00, 0x1F,
  0x07, 0xE0, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0x80, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x8F, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x01,
  0xF0, 0x0F, 0xC0, 0x1F, 0x01, 0xF8, 0x01, 0xF0, 0x1F, 0x00, 0x1F, 0x03,
  0xE0, 0x03, 0xE0, 0x7E, 0x00, 0x3E, 0x0F, 0xC0, 0x03, 0xE1, 0xF8, 0x00,
  0x3E, 0x1F, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x7C, 0x7E, 0x00, 0x07, 0xCF,
  0xC0, 0x00, 0x7D, 0xF8, 0x00, 0x07, 0xBF, 0x00, 0x00, 0xFB, 0xF8, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFE,
  0xFC, 0x00, 0x1F, 0xC7, 0xC0, 0x01, 0xF8, 0x7C, 0x00, 0x1F, 0x07, 0xE0,
  0x01, 0xF0, 0x7E, 0x00, 0x1F, 0x03, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x3E,
  0x03, 0xF0, 0x03, 0xE0, 0x3F, 0x00, 0x3E, 0x01, 0xF0, 0x07, 0xE0, 0x1F,
  0x00, 0x7C, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x80, 0x7C, 0x00, 0xF8, 0x0F,
  0xC0, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x01,
  0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0xFC, 0x00, 0x00, 0xF0, 0xFE, 0x01, 0xFC, 0x00, 0xF8, 0xFF, 0xC3,
  0xFF, 0x80, 0x7D, 0xFF, 0xE3, 0xFF, 0xC0, 0x3C, 0xFF, 0xFB, 0xFF, 0xF0,
  0x1E, 0xF0, 0xFF, 0xE1, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0x7C, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3E, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0x81, 0xF8, 0x03, 0xF0, 0x07, 0xC1, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0xFC, 0x00, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0xFC, 0x01, 0xF0, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x1F, 0x80, 0x1F, 0x00,
  0x3E, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x03, 0xE0, 0x07, 0xC1, 0xF0, 0x01,
  0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x1F,
  0x00, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x83, 0xF0, 0x03, 0xE0, 0x07,
  0xC1, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x7E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x00, 0xF0,
  0xFF, 0x00, 0x3E, 0x3F, 0xF0, 0x07, 0xDF, 0xFF, 0x00, 0xF3, 0xFF, 0xE0,
  0x1E, 0xF8, 0xFE, 0x07, 0xFC, 0x0F, 0xC0, 0xFF, 0x01, 0xF8, 0x1F, 0xC0,
  0x1F, 0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x03,
  0xF0, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x81, 0xF0, 0x03,
  0xF0, 0x7E, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x81, 0xF0, 0x01, 0xF0, 0x3E,
  0x00, 0x3E, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x3E,
  0x07, 0xC0, 0x07, 0xC0, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x3E, 0x07, 0xC0,
  0x07, 0xC0, 0xF8, 0x00, 0xF8, 0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x07, 0xE0,
  0xFC, 0x00, 0xF8, 0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x03, 0xE0, 0x7C, 0x00,
  0x7C, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0x87, 0xE0, 0x3F, 0x01, 0xF8,
  0x3F, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x1F, 0x80, 0x1F, 0x0F, 0x80, 0x0F,
  0xCF, 0xC0, 0x07, 0xE7, 0xC0, 0x03, 0xF3, 0xE0, 0x01, 0xFB, 0xF0, 0x00,
  0xF9, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x3E, 0x00,
  0x0F, 0xBF, 0x00, 0x0F, 0xDF, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xE7, 0xC0,
  0x01, 0xF3, 0xE0, 0x01, 0xF9, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0xFC, 0x7C,
  0x00, 0x7C, 0x3E, 0x00, 0x7E, 0x1F, 0x80, 0x3E, 0x07, 0xC0, 0x3F, 0x03,
  0xF0, 0x7F, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x1E, 0x0F, 0xE0, 0x00,
  0xF8, 0xFF, 0xC0, 0x03, 0xE7, 0xFF, 0x80, 0x0F, 0xBF, 0xFE, 0x00, 0x3D,
  0xE1, 0xFC, 0x00, 0xFF, 0x03, 0xF0, 0x07, 0xF8, 0x07, 0xC0, 0x1F, 0xC0,
  0x1F, 0x00, 0x7F, 0x00, 0x7C, 0x01, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x07,
  0xC0, 0x3F, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x7C, 0x03, 0xE0, 0x01, 0xF0,
  0x0F, 0x80, 0x07, 0xC0, 0x7E, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x7C, 0x07,
  0xC0, 0x03, 0xF0, 0x1F, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x3E, 0x03, 0xE0,
  0x00, 0xF8, 0x0F, 0x80, 0x07, 0xE0, 0x3E, 0x00, 0x1F, 0x00, 0xF8, 0x00,
  0x7C, 0x03, 0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x0F, 0x80, 0x7E, 0x00, 0x7E,
  0x01, 0xFC, 0x03, 0xF0, 0x07, 0xF0, 0x1F, 0x80, 0x1F, 0xE0, 0xFE, 0x00,
  0xFB, 0xFF, 0xF0, 0x03, 0xEF, 0xFF, 0x80, 0x0F, 0x9F, 0xFC, 0x00, 0x3E,
  0x3F, 0xE0, 0x01, 0xF8, 0x18, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xC1, 0xE0, 0x0F, 0xFC, 0x7C, 0x03, 0xFF, 0xCF, 0x00, 0xFF, 0xFD,
  0xE0, 0x3F, 0x87, 0xFC, 0x0F, 0xC0, 0x7F, 0x81, 0xF8, 0x07, 0xF0, 0x7E,
  0x00, 0xFC, 0x0F, 0x80, 0x1F, 0x83, 0xF0, 0x03, 0xF0, 0x7C, 0x00, 0x7E,
  0x1F, 0x80, 0x0F, 0xC3, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x1F, 0x80,
  0x07, 0xC3, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC3,
  0xF0, 0x00, 0xF8, 0x7E, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xE1, 0xF0, 0x00,
  0xF8, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x07, 0xE0, 0xF8, 0x00, 0xFC, 0x1F,
  0x00, 0x3F, 0x83, 0xE0, 0x0F, 0xE0, 0x7E, 0x01, 0xFC, 0x0F, 0xC0, 0x7F,
  0x80, 0xFC, 0x1F, 0xF0, 0x1F, 0xFF, 0xBE, 0x03, 0xFF, 0xEF, 0x80, 0x3F,
  0xF9, 0xF0, 0x03, 0xFC, 0x3E, 0x00, 0x0C, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0xFC,
  0x07, 0xCF, 0xF0, 0x1E, 0x3F, 0xC0, 0x79, 0xFE, 0x01, 0xEF, 0xF8, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x07, 0xFF,
  0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x07, 0xE0, 0x78, 0x3F, 0x00, 0x20,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0,
  0x80, 0x0F, 0xC3, 0x80, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFE, 0x01, 0xFF, 0xE0, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x0F,
  0xFF, 0x3F, 0xFF, 0x1F, 0xFF, 0x9F, 0xFF, 0xC0, 0xF8, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0xC0, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xE0, 0x03,
  0x00, 0x00, 0x07, 0xE0, 0x07, 0xC1, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x7C,
  0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x0F, 0xC3, 0xE0, 0x03, 0xE0, 0xF8, 0x00,
  0xF8, 0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xF0,
  0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x07, 0xC3,
  0xF0, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x0F,
  0x83, 0xE0, 0x07, 0xE1, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x1F, 0x00,
  0x1F, 0x07, 0xC0, 0x0F, 0xC1, 0xF0, 0x03, 0xE0, 0xFC, 0x01, 0xF8, 0x3E,
  0x00, 0x7E, 0x0F, 0x80, 0x3F, 0x83, 0xE0, 0x1F, 0xE0, 0xFC, 0x07, 0xF0,
  0x3F, 0x07, 0xBC, 0x07, 0xFF, 0xDF, 0x01, 0xFF, 0xF7, 0xC0, 0x3F, 0xF1,
  0xF0, 0x07, 0xF8, 0x78, 0x00, 0x30, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0xF0,
  0x00, 0xFB, 0xE0, 0x03, 0xF7, 0xC0, 0x07, 0xCF, 0x80, 0x0F, 0x9F, 0x00,
  0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x0F,
  0x83, 0xE0, 0x1F, 0x07, 0xC0, 0x7E, 0x0F, 0x80, 0xF8, 0x1F, 0x03, 0xF0,
  0x3E, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x3E, 0x01, 0xF0, 0x7C, 0x03,
  0xE1, 0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x1E,
  0x7C, 0x00, 0x3C, 0xF8, 0x00, 0x79, 0xE0, 0x00, 0xF7, 0xC0, 0x01, 0xEF,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x01,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0x80, 0x1F, 0xF8, 0x03, 0xF8, 0x03, 0xFF,
  0x80, 0x3F, 0x80, 0x3E, 0xF8, 0x07, 0xF8, 0x07, 0xEF, 0x80, 0x7F, 0x80,
  0x7C, 0xF8, 0x07, 0xF8, 0x07, 0xCF, 0x80, 0xF7, 0x80, 0xF8, 0xF8, 0x0F,
  0x78, 0x0F, 0x8F, 0x81, 0xF7, 0x81, 0xF8, 0xF8, 0x1E, 0x78, 0x1F, 0x0F,
  0x81, 0xE7, 0x81, 0xF0, 0xF8, 0x3C, 0x78, 0x3E, 0x0F, 0x83, 0xC7, 0x83,
  0xE0, 0xF8, 0x7C, 0x78, 0x7C, 0x0F, 0x87, 0x87, 0x87, 0xC0, 0xF8, 0x78,
  0x78, 0x7C, 0x0F, 0x8F, 0x07, 0x8F, 0x80, 0xF8, 0xF0, 0xF8, 0xF8, 0x0F,
  0x9F, 0x0F, 0x8F, 0x00, 0xF9, 0xE0, 0xF9, 0xF0, 0x0F, 0x3E, 0x0F, 0x9F,
  0x00, 0xF3, 0xC0, 0xFB, 0xE0, 0x0F, 0x3C, 0x0F, 0xBE, 0x00, 0xF7, 0xC0,
  0xFB, 0xC0, 0x0F, 0x78, 0x0F, 0xFC, 0x00, 0xF7, 0x80, 0xF7, 0x80, 0x0F,
  0xF0, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x0F, 0xF0,
  0x00, 0xFE, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0xFC, 0x00,
  0xFE, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0xF8, 0x07,
  0xC0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x00, 0xF8, 0x07, 0xC0, 0x07, 0xC0,
  0x7E, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC3, 0xE0,
  0x00, 0x3E, 0x3F, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x07, 0xDF, 0x00, 0x00,
  0x3E, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3F, 0x3E, 0x00, 0x01, 0xF1,
  0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF8, 0x3E, 0x00, 0x0F, 0x81, 0xF0,
  0x00, 0xF8, 0x0F, 0x80, 0x0F, 0xC0, 0x7E, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xE0, 0x0F, 0x80, 0x7E, 0x00, 0x7C, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x03, 0xF0,
  0x00, 0xF8, 0x01, 0xF0, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x07, 0xC0, 0x3E,
  0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0xF0, 0x1F, 0x00, 0x00, 0x78, 0x1F,
  0x00, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x0F, 0x07,
  0xC0, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x01, 0xF1,
  0xE0, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0x3E,
  0xF8, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0C, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0x80,
  0x00, 0x7C, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x78,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x9F,
  0xFC, 0x00, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0x00, 0xFF, 0xFA, 0x00, 0x1F, 0xF9, 0x00, 0x00, 0xF0,
};

const GFXglyph NotoSans_Condensed_Italic63pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 15, 46, 15, 1, -45 },
  { 88, 18, 16, 22, 6, -45 },
  { 124, 31, 45, 31, 1, -45 },
  { 299, 27, 52, 28, 1, -48 },
  { 475, 36, 47, 42, 4, -46 },
  { 687, 30, 47, 32, 0, -46 },
  { 864, 8, 16, 12, 7, -45 },
  { 880, 19, 55, 17, 2, -45 },
  { 1011, 20, 55, 17, -5, -45 },
  { 1149, 22, 23, 26, 6, -48 },
  { 1213, 25, 30, 30, 3, -37 },
  { 1307, 12, 15, 14, -3, -7 },
  { 1330, 15, 4, 17, 1, -19 },
  { 1338, 7, 8, 14, 1, -7 },
  { 1345, 29, 45, 21, -3, -45 },
  { 1509, 25, 47, 28, 2, -46 },
  { 1656, 17, 45, 28, 7, -45 },
  { 1752, 28, 46, 28, -1, -46 },
  { 1913, 27, 47, 28, 0, -46 },
  { 2072, 28, 45, 28, -1, -45 },
  { 2230, 28, 46, 28, 0, -45 },
  { 2391, 27, 47, 28, 2, -46 },
  { 2550, 27, 45, 28, 3, -45 },
  { 2702, 27, 47, 28, 1, -46 },
  { 2861, 26, 47, 28, 1, -46 },
  { 3014, 13, 35, 14, 0, -34 },
  { 3071, 16, 42, 14, -3, -34 },
  { 3155, 25, 29, 30, 3, -37 },
  { 3246, 25, 18, 30, 3, -31 },
  { 3303, 25, 29, 30, 3, -37 },
  { 3394, 21, 47, 21, 2, -46 },
  { 3518, 39, 50, 42, 2, -45 },
  { 3762, 29, 45, 28, -4, -45 },
  { 3926, 29, 45, 30, 1, -45 },
  { 4090, 29, 47, 28, 3, -46 },
  { 4261, 31, 45, 33, 1, -45 },
  { 4436, 28, 45, 26, 1, -45 },
  { 4594, 28, 45, 24, 1, -45 },
  { 4752, 32, 47, 35, 3, -46 },
  { 4940, 34, 45, 34, 1, -45 },
  { 5132, 25, 45, 18, -3, -45 },
  { 5273, 25, 57, 14, -9, -45 },
  { 5452, 33, 45, 28, 1, -45 },
  { 5638, 19, 45, 24, 1, -45 },
  { 5745, 44, 45, 44, 1, -45 },
  { 5993, 36, 45, 36, 1, -45 },
  { 6196, 31, 47, 35, 3, -46 },
  { 6379, 28, 45, 29, 1, -45 },
  { 6537, 31, 57, 35, 3, -46 },
  { 6758, 28, 45, 29, 1, -45 },
  { 6916, 29, 47, 26, -1, -46 },
  { 7087, 25, 45, 25, 5, -45 },
  { 7228, 32, 46, 34, 3, -45 },
  { 7412, 28, 45, 28, 6, -45 },
  { 7570, 44, 45, 45, 6, -45 },
  { 7818, 35, 45, 26, -4, -45 },
  { 8015, 26, 45, 25, 5, -45 },
  { 8162, 30, 45, 25, -2, -45 },
  { 8331, 23, 55, 18, -1, -45 },
  { 8490, 11, 45, 22, 6, -45 },
  { 8552, 23, 55, 18, -4, -45 },
  { 8711, 27, 25, 28, 1, -45 },
  { 8796, 22, 4, 21, -6, 5 },
  { 8807, 9, 10, 16, 9, -48 },
  { 8819, 27, 35, 29, 2, -34 },
  { 8938, 27, 49, 29, 0, -48 },
  { 9104, 22, 35, 23, 2, -34 },
  { 9201, 30, 49, 30, 2, -48 },
  { 9385, 23, 35, 26, 2, -34 },
  { 9486, 32, 63, 16, -8, -48 },
  { 9738, 30, 49, 30, -1, -34 },
  { 9922, 27, 48, 29, 0, -48 },
  { 10084, 15, 46, 13, 0, -46 },
  { 10171, 23, 61, 13, -8, -46 },
  { 10347, 28, 48, 25, 0, -48 },
  { 10515, 16, 48, 13, 0, -48 },
  { 10611, 41, 34, 44, 0, -34 },
  { 10786, 27, 34, 29, 0, -34 },
  { 10901, 25, 35, 29, 2, -34 },
  { 11011, 30, 49, 29, -3, -34 },
  { 11195, 27, 49, 30, 2, -34 },
  { 11361, 22, 34, 20, 0, -34 },
  { 11455, 22, 35, 22, 0, -34 },
  { 11552, 17, 42, 17, 2, -41 },
  { 11642, 26, 35, 29, 2, -34 },
  { 11756, 23, 34, 24, 4, -34 },
  { 11854, 36, 34, 38, 4, -34 },
  { 12007, 29, 34, 24, -3, -34 },
  { 12131, 33, 49, 24, -6, -34 },
  { 12334, 24, 34, 21, -2, -34 },
  { 12436, 24, 55, 21, 1, -45 },
  { 12601, 5, 63, 27, 11, -48 },
  { 12641, 23, 55, 21, -3, -45 },
  { 12800, 25, 8, 30, 3, -26 },
};

const GFXfont NotoSans_Condensed_Italic63pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Italic63pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Italic63pt7bGlyphs,
  0x20, 0x7E, 86
};

#endif // _NOTOSANS_CONDENSED_ITALIC63PT7B_H_
