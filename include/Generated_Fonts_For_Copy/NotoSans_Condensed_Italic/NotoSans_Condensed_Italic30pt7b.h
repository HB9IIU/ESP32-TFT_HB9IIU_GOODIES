#ifndef _NOTOSANS_CONDENSED_ITALIC30PT7B_H_
#define _NOTOSANS_CONDENSED_ITALIC30PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Italic.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Italic30pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x0E, 0x0E, 0x0E, 0x0E, 0x0C, 0x0C, 0x1C, 0x1C, 0x18, 0x18,
  0x18, 0x38, 0x30, 0x30, 0x00, 0x00, 0x20, 0x70, 0xF0, 0xE0, 0x73, 0xB1,
  0x99, 0xCC, 0xEE, 0x66, 0x33, 0x18, 0x01, 0x8C, 0x03, 0x18, 0x06, 0x30,
  0x18, 0xC0, 0x31, 0x80, 0x63, 0x0F, 0xFF, 0x9F, 0xFF, 0x06, 0x30, 0x18,
  0x40, 0x31, 0x80, 0x63, 0x00, 0x84, 0x1F, 0xFF, 0x3F, 0xFE, 0x0C, 0x60,
  0x31, 0x80, 0x63, 0x00, 0xC6, 0x03, 0x18, 0x06, 0x30, 0x00, 0x00, 0x40,
  0x06, 0x00, 0x30, 0x0F, 0xF0, 0xFF, 0x8E, 0x44, 0x66, 0x03, 0x30, 0x19,
  0x00, 0xE8, 0x07, 0xC0, 0x1E, 0x00, 0x3C, 0x01, 0xF0, 0x0B, 0x80, 0x4C,
  0x06, 0x60, 0x33, 0x21, 0x39, 0xFF, 0x8F, 0xF8, 0x06, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x0C, 0x01, 0x1F, 0x03, 0x0D, 0xC3, 0x0C, 0x61, 0x86,
  0x31, 0x86, 0x18, 0xC3, 0x18, 0xC1, 0x8C, 0xE0, 0xC6, 0x60, 0x63, 0x67,
  0xB3, 0x37, 0xF9, 0xB3, 0x3F, 0x9B, 0x1B, 0x99, 0x8C, 0x19, 0x86, 0x0C,
  0xC3, 0x0C, 0x63, 0x06, 0x31, 0x86, 0x18, 0xC6, 0x0C, 0xC3, 0x07, 0xE3,
  0x01, 0xE0, 0x01, 0xC0, 0x07, 0xE0, 0x1D, 0xC0, 0x31, 0x80, 0xE3, 0x01,
  0x86, 0x03, 0x1C, 0x07, 0x30, 0x0E, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0xF8,
  0x13, 0xB8, 0xCE, 0x31, 0x98, 0x77, 0x70, 0xEC, 0xE0, 0xF1, 0xC1, 0xE3,
  0x83, 0x87, 0x0F, 0x87, 0xFB, 0x07, 0xC7, 0x00, 0x76, 0x66, 0x6C, 0xC0,
  0x01, 0x81, 0x81, 0x81, 0xC0, 0xC0, 0xE0, 0x60, 0x70, 0x30, 0x38, 0x18,
  0x0C, 0x0E, 0x07, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0x60, 0x30, 0x18, 0x00, 0x06, 0x01, 0x80, 0xC0, 0x60,
  0x38, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x38, 0x1C, 0x0C,
  0x06, 0x07, 0x03, 0x81, 0x81, 0xC0, 0xC0, 0xE0, 0x60, 0x60, 0x70, 0x30,
  0x30, 0x00, 0x06, 0x01, 0x80, 0x63, 0x90, 0xFC, 0xCF, 0xF1, 0xC0, 0xF8,
  0x77, 0x18, 0xC2, 0x38, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0xFF, 0xFF, 0xFF, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x39, 0x9C, 0xC6, 0x63, 0x00, 0xFF, 0xF8, 0x27, 0xFE, 0x00, 0x1C,
  0x00, 0xE0, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x60,
  0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x01, 0x80,
  0x06, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x7E, 0x0F, 0xE1, 0xC7, 0x18, 0x33, 0x83, 0x30, 0x37, 0x07, 0x70,
  0x76, 0x07, 0x60, 0x7E, 0x06, 0xE0, 0x6E, 0x0E, 0xC0, 0xEC, 0x0C, 0xC1,
  0xCC, 0x1C, 0xE3, 0x8E, 0x30, 0x7F, 0x03, 0xE0, 0x07, 0x0F, 0x1F, 0x7F,
  0xE6, 0x46, 0x0E, 0x0E, 0x0E, 0x0C, 0x0C, 0x1C, 0x1C, 0x18, 0x18, 0x18,
  0x38, 0x38, 0x30, 0x30, 0x70, 0x00, 0xE0, 0x0F, 0xE0, 0xFF, 0x81, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x00, 0xC0, 0x06, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0x7F, 0xE3, 0xFF, 0x80, 0x01, 0xC0, 0x7F, 0x87,
  0xDE, 0x10, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x07,
  0x03, 0xE0, 0x1F, 0x00, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0C, 0x00, 0xE0,
  0x07, 0x00, 0x31, 0x03, 0x8F, 0xF8, 0x7F, 0x80, 0x00, 0x38, 0x01, 0xC0,
  0x1E, 0x01, 0xE0, 0x0F, 0x00, 0xD8, 0x0D, 0xC0, 0xEE, 0x06, 0x60, 0x63,
  0x07, 0x18, 0x31, 0xC3, 0x0E, 0x38, 0x61, 0x83, 0x1F, 0xFE, 0xFF, 0xF0,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x07, 0xF8, 0x7F, 0xC3,
  0x80, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x1F, 0x81, 0xFE,
  0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0xE0,
  0x07, 0x20, 0x71, 0xFF, 0x0F, 0xF0, 0x00, 0x00, 0xF8, 0x1F, 0x81, 0xE4,
  0x1C, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x71, 0x03, 0xFE, 0x1F,
  0xF0, 0xE1, 0xCE, 0x0E, 0x70, 0x33, 0x83, 0x9C, 0x1C, 0xC0, 0xE7, 0x06,
  0x38, 0x70, 0xC7, 0x07, 0xF8, 0x1F, 0x00, 0x3F, 0xF9, 0xFF, 0xC0, 0x0C,
  0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00,
  0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x30, 0x03, 0x80, 0x18, 0x01, 0xC0,
  0x0C, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x3F, 0x83, 0xDE, 0x18,
  0x31, 0xC1, 0x8E, 0x0C, 0x70, 0x63, 0x87, 0x0C, 0x70, 0x77, 0x01, 0xE0,
  0x1F, 0x83, 0xDC, 0x18, 0x71, 0x81, 0x8C, 0x0C, 0xE0, 0x67, 0x03, 0x38,
  0x18, 0xE1, 0xC7, 0xFC, 0x1F, 0xC0, 0x01, 0xC0, 0x3F, 0x03, 0xFC, 0x38,
  0x71, 0x83, 0x8C, 0x1C, 0xE0, 0xE6, 0x07, 0x30, 0x39, 0x81, 0xCE, 0x1C,
  0x71, 0xE1, 0xFB, 0x07, 0xB8, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x06, 0x00,
  0x60, 0x07, 0x0F, 0xF0, 0x7E, 0x00, 0x1C, 0x71, 0xC2, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x21, 0xCF, 0x38, 0x07, 0x07, 0x07, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x18, 0x38, 0x30, 0x30,
  0x60, 0xE0, 0x00, 0x10, 0x03, 0x00, 0xF0, 0x3E, 0x07, 0x81, 0xE0, 0x78,
  0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x70, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x80, 0x07, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x0F, 0x01, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x0F, 0x00, 0x60, 0x00, 0x07,
  0x0F, 0xE3, 0xBC, 0x87, 0x00, 0xC0, 0x70, 0x1C, 0x06, 0x03, 0x01, 0xC0,
  0xE0, 0x70, 0x18, 0x0C, 0x03, 0x01, 0xC0, 0x00, 0x00, 0x02, 0x03, 0x80,
  0xE0, 0x38, 0x00, 0x00, 0x10, 0x00, 0x3F, 0xC0, 0x3C, 0x38, 0x1C, 0x06,
  0x0C, 0x00, 0xC6, 0x00, 0x31, 0x83, 0x8C, 0xC3, 0xF1, 0x31, 0x8C, 0x58,
  0xC6, 0x16, 0x31, 0x8D, 0x98, 0x63, 0xC6, 0x18, 0xF1, 0x8C, 0x3C, 0x63,
  0x1B, 0x18, 0xC6, 0xC6, 0x53, 0x31, 0xF7, 0x8C, 0x30, 0xC3, 0x00, 0x00,
  0x60, 0x00, 0x1C, 0x00, 0x03, 0x83, 0x00, 0x7F, 0xC0, 0x03, 0x00, 0x00,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x36, 0x00, 0xD8, 0x06, 0x60, 0x19,
  0x80, 0xE6, 0x03, 0x18, 0x1C, 0x60, 0x61, 0x83, 0x86, 0x0F, 0xF8, 0x3F,
  0xE1, 0xC1, 0x86, 0x07, 0x38, 0x1C, 0xC0, 0x77, 0x01, 0xDC, 0x07, 0xE0,
  0x1C, 0x07, 0xF8, 0x3F, 0xF0, 0xE1, 0xC3, 0x83, 0x0C, 0x0C, 0x30, 0x31,
  0xC1, 0xC7, 0x07, 0x1C, 0x78, 0x7F, 0x81, 0xFE, 0x0E, 0x1C, 0x38, 0x38,
  0xC0, 0xE3, 0x03, 0x8C, 0x0E, 0x70, 0x31, 0xC1, 0xC6, 0x0E, 0x1F, 0xF0,
  0xFF, 0x80, 0x00, 0xF0, 0x0F, 0xF0, 0x7F, 0xC3, 0x80, 0x1C, 0x00, 0x70,
  0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x1E,
  0x10, 0x3F, 0xC0, 0x7F, 0x00, 0x07, 0xF8, 0x1F, 0xF8, 0x38, 0x70, 0x70,
  0x70, 0xC0, 0xE1, 0x81, 0xC7, 0x01, 0x8E, 0x03, 0x1C, 0x0E, 0x30, 0x1C,
  0x60, 0x39, 0xC0, 0x73, 0x80, 0xC6, 0x03, 0x8C, 0x07, 0x18, 0x1C, 0x70,
  0x78, 0xE1, 0xE1, 0x87, 0x83, 0xFE, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x3F,
  0xE0, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x7F, 0x81, 0xFE, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x70, 0x01, 0xC0, 0x06, 0x04, 0x1F, 0xE0, 0xFF, 0x80, 0x07, 0xFC,
  0x3F, 0xE0, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x60, 0x01, 0xFE, 0x0F, 0xF8, 0x38, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x00,
  0x78, 0x03, 0xFF, 0x07, 0xFE, 0x0F, 0x02, 0x1E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0xFC, 0x60,
  0xFC, 0xE0, 0x1C, 0xE0, 0x18, 0xE0, 0x18, 0xE0, 0x18, 0x60, 0x38, 0x70,
  0x38, 0x78, 0x30, 0x3F, 0xF0, 0x1F, 0xE0, 0x06, 0x03, 0x83, 0x01, 0x83,
  0x80, 0xC1, 0xC0, 0xE0, 0xC0, 0x70, 0x60, 0x38, 0x70, 0x18, 0x38, 0x0C,
  0x1C, 0x0E, 0x0F, 0xFF, 0x07, 0xFF, 0x07, 0x01, 0x83, 0x80, 0xC1, 0x80,
  0xE0, 0xC0, 0x70, 0x60, 0x30, 0x70, 0x18, 0x38, 0x1C, 0x18, 0x0E, 0x0C,
  0x07, 0x0E, 0x03, 0x00, 0x0F, 0xE0, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x0E,
  0x01, 0xC0, 0x30, 0x06, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x00, 0x60, 0x3F, 0x0F, 0xE0, 0x00, 0x30, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C,
  0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80, 0x38,
  0x03, 0x00, 0x30, 0x07, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x7E, 0x07, 0xC0,
  0xF0, 0x00, 0x06, 0x07, 0x0E, 0x0E, 0x0E, 0x1C, 0x0E, 0x38, 0x0C, 0x70,
  0x0C, 0x60, 0x1C, 0xE0, 0x1D, 0xC0, 0x1B, 0x80, 0x1B, 0x80, 0x1F, 0x80,
  0x3D, 0x80, 0x39, 0x80, 0x31, 0xC0, 0x31, 0xC0, 0x30, 0xC0, 0x70, 0xE0,
  0x70, 0xE0, 0x60, 0xE0, 0x60, 0x60, 0xE0, 0x70, 0x06, 0x07, 0x03, 0x81,
  0xC0, 0xC0, 0x60, 0x70, 0x38, 0x18, 0x0C, 0x06, 0x07, 0x03, 0x81, 0x80,
  0xC0, 0x60, 0x70, 0x38, 0x18, 0x0F, 0xFF, 0xF8, 0x07, 0x00, 0x7C, 0x3C,
  0x01, 0xE0, 0xF8, 0x0F, 0x83, 0xE0, 0x3E, 0x0F, 0x80, 0xF8, 0x36, 0x06,
  0xC1, 0xD8, 0x1B, 0x07, 0x60, 0xDC, 0x19, 0x83, 0x70, 0x66, 0x19, 0xC1,
  0x98, 0x66, 0x0E, 0x63, 0x18, 0x39, 0x8C, 0xE0, 0xC6, 0x73, 0x83, 0x19,
  0x8E, 0x0C, 0x6E, 0x30, 0x71, 0xB0, 0xC1, 0x87, 0xC7, 0x06, 0x1E, 0x1C,
  0x18, 0x78, 0x60, 0xE1, 0xC1, 0x80, 0x07, 0x01, 0xC3, 0xC0, 0x60, 0xF0,
  0x18, 0x3E, 0x0E, 0x0D, 0x83, 0x83, 0x60, 0xC1, 0xD8, 0x30, 0x77, 0x0C,
  0x19, 0xC7, 0x06, 0x31, 0xC1, 0x8C, 0x60, 0xE3, 0x18, 0x38, 0xE6, 0x0C,
  0x1B, 0x83, 0x06, 0xE0, 0xC1, 0xB0, 0x70, 0x7C, 0x18, 0x0F, 0x06, 0x03,
  0xC1, 0x80, 0xE0, 0xE0, 0x38, 0x00, 0x00, 0xF0, 0x07, 0xF0, 0x1F, 0xF0,
  0x70, 0x71, 0xC0, 0xE3, 0x00, 0xCE, 0x01, 0x98, 0x03, 0x70, 0x06, 0xE0,
  0x0D, 0xC0, 0x3B, 0x00, 0x76, 0x00, 0xFC, 0x01, 0xB8, 0x07, 0x70, 0x0E,
  0xE0, 0x18, 0xC0, 0x71, 0xC1, 0xC3, 0x87, 0x83, 0xFE, 0x03, 0xF0, 0x00,
  0x07, 0xF0, 0x3F, 0xE0, 0xE1, 0xC3, 0x87, 0x0C, 0x1C, 0x30, 0x71, 0xC1,
  0xC7, 0x07, 0x18, 0x38, 0x61, 0xE1, 0xFF, 0x0F, 0xF8, 0x3F, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xE0,
  0x00, 0x00, 0xF0, 0x07, 0xF0, 0x1F, 0xF0, 0x70, 0x71, 0xC0, 0xE3, 0x00,
  0xCE, 0x01, 0x98, 0x03, 0x70, 0x06, 0xE0, 0x0D, 0xC0, 0x3B, 0x00, 0x76,
  0x00, 0xFC, 0x01, 0xB8, 0x07, 0x70, 0x0E, 0xE0, 0x18, 0xC0, 0x71, 0xC1,
  0xC3, 0x87, 0x83, 0xFE, 0x03, 0xF0, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0,
  0x03, 0x80, 0x03, 0x80, 0x07, 0xF0, 0x3F, 0xE0, 0xE1, 0xC3, 0x87, 0x0C,
  0x1C, 0x30, 0x71, 0xC1, 0xC7, 0x07, 0x1C, 0x38, 0x61, 0xC1, 0xFE, 0x0F,
  0xE0, 0x39, 0xC0, 0xC7, 0x03, 0x0C, 0x0C, 0x30, 0x70, 0xE1, 0xC3, 0x86,
  0x0E, 0x18, 0x18, 0xE0, 0x70, 0x00, 0xE0, 0x3F, 0xC3, 0xFE, 0x38, 0x11,
  0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x71,
  0x07, 0x8F, 0xF8, 0x7F, 0x80, 0x7F, 0xFF, 0xFF, 0x06, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x18,
  0x03, 0x80, 0x38, 0x03, 0x00, 0x30, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60,
  0x00, 0x0C, 0x07, 0x1C, 0x06, 0x1C, 0x06, 0x18, 0x0E, 0x18, 0x0E, 0x38,
  0x0C, 0x38, 0x0C, 0x38, 0x1C, 0x30, 0x1C, 0x30, 0x1C, 0x70, 0x18, 0x70,
  0x18, 0x60, 0x38, 0x60, 0x38, 0x60, 0x30, 0xE0, 0x30, 0xE0, 0x70, 0xE0,
  0x60, 0x70, 0xE0, 0x7F, 0xC0, 0x3F, 0x80, 0xC0, 0x3E, 0x03, 0xB0, 0x1D,
  0x80, 0xCC, 0x0E, 0x60, 0x63, 0x07, 0x18, 0x30, 0xC3, 0x86, 0x18, 0x31,
  0xC1, 0x8E, 0x0C, 0x60, 0x67, 0x03, 0x30, 0x1F, 0x80, 0xD8, 0x06, 0xC0,
  0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x00, 0xC0, 0x60, 0x3E, 0x07, 0x03, 0xB0,
  0x38, 0x1D, 0x81, 0xC0, 0xCC, 0x1E, 0x0E, 0x60, 0xF0, 0x63, 0x0D, 0x87,
  0x18, 0x6C, 0x38, 0xC7, 0x61, 0x86, 0x33, 0x1C, 0x31, 0x98, 0xC1, 0x98,
  0xCE, 0x0C, 0xC6, 0x70, 0x6E, 0x33, 0x03, 0x61, 0xB8, 0x1B, 0x0D, 0x80,
  0xF0, 0x6C, 0x07, 0x83, 0xC0, 0x3C, 0x1E, 0x01, 0xC0, 0xF0, 0x0E, 0x07,
  0x00, 0x00, 0x07, 0x03, 0x81, 0x83, 0x80, 0xC3, 0x80, 0x71, 0x80, 0x39,
  0xC0, 0x0C, 0xC0, 0x06, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x70, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3B, 0x00, 0x39, 0x80, 0x18, 0xC0,
  0x1C, 0x70, 0x1C, 0x38, 0x0E, 0x1C, 0x0E, 0x06, 0x0E, 0x03, 0x80, 0xC0,
  0xFC, 0x0E, 0xE1, 0xCE, 0x18, 0xE3, 0x86, 0x30, 0x67, 0x06, 0x60, 0x6E,
  0x06, 0xC0, 0x78, 0x07, 0x80, 0x30, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60,
  0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x07, 0xFE, 0x1F, 0xF8, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0,
  0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x07, 0x00, 0x0C,
  0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0xFF, 0x0F, 0xFC, 0x00, 0x03,
  0xF0, 0x3E, 0x03, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x03, 0x80, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60,
  0x07, 0xC0, 0xFC, 0x00, 0xC7, 0x38, 0xC6, 0x31, 0x8C, 0x73, 0x8C, 0x63,
  0x18, 0xC6, 0x39, 0xC6, 0x31, 0x80, 0x03, 0xE0, 0xFC, 0x01, 0x80, 0x70,
  0x0C, 0x01, 0x80, 0x30, 0x0E, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x38,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x03, 0x80, 0x60, 0x0C, 0x1F, 0x83, 0xF0, 0x00, 0x03, 0x00, 0x78, 0x07,
  0x80, 0xD8, 0x0D, 0xC1, 0x8C, 0x38, 0xC3, 0x0E, 0x70, 0x66, 0x06, 0xC0,
  0x3C, 0x03, 0xFF, 0xE0, 0xE3, 0x8C, 0x61, 0x80, 0x0F, 0x98, 0xFF, 0x8E,
  0x1C, 0x70, 0xE7, 0x07, 0x38, 0x39, 0x81, 0x9C, 0x0C, 0xE0, 0x67, 0x07,
  0x30, 0x39, 0x83, 0x8E, 0x1C, 0x71, 0xE1, 0xFB, 0x0F, 0xB0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01, 0xBE, 0x1F,
  0xF8, 0xF1, 0xC7, 0x06, 0x38, 0x33, 0x81, 0x9C, 0x1C, 0xC0, 0xE6, 0x07,
  0x30, 0x33, 0x83, 0x9C, 0x1C, 0xE1, 0xC7, 0x0E, 0x3F, 0xE3, 0x3E, 0x00,
  0x0F, 0xC7, 0xF3, 0x80, 0xC0, 0x70, 0x18, 0x06, 0x03, 0x80, 0xE0, 0x38,
  0x0C, 0x03, 0x00, 0xE0, 0x38, 0x47, 0xF0, 0xFC, 0x00, 0x0C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x03, 0x83, 0xEE, 0x1F, 0xF0,
  0xE1, 0xC3, 0x87, 0x1C, 0x1C, 0x70, 0x71, 0x81, 0x8E, 0x06, 0x38, 0x18,
  0xE0, 0xE3, 0x03, 0x8C, 0x1C, 0x30, 0x70, 0xE3, 0xC1, 0xFB, 0x07, 0xD8,
  0x00, 0x0F, 0xC3, 0xFC, 0xE3, 0x98, 0x37, 0x0E, 0xC1, 0x98, 0xF7, 0xFC,
  0xFC, 0x18, 0x03, 0x00, 0x60, 0x0E, 0x01, 0xC1, 0x1F, 0xE1, 0xF8, 0x00,
  0x1E, 0x00, 0x7C, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30,
  0x01, 0xFC, 0x07, 0xF8, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00,
  0x30, 0x00, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x00, 0x07, 0xCC, 0x3F, 0xE1,
  0xC3, 0x87, 0x0E, 0x38, 0x38, 0xE0, 0xE3, 0x03, 0x1C, 0x0C, 0x70, 0x71,
  0xC1, 0xC7, 0x07, 0x18, 0x38, 0x70, 0xE1, 0xC7, 0x87, 0xFE, 0x0F, 0xB0,
  0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x83, 0x83, 0xFC, 0x0F, 0xE0,
  0x00, 0x07, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30,
  0x01, 0xBE, 0x1F, 0xF8, 0xF1, 0xC7, 0x0E, 0x30, 0x73, 0x83, 0x1C, 0x18,
  0xC0, 0xC6, 0x0E, 0x30, 0x73, 0x83, 0x1C, 0x18, 0xC1, 0xC6, 0x0E, 0x30,
  0x73, 0x83, 0x00, 0x06, 0x1C, 0x38, 0x00, 0x00, 0x03, 0x0E, 0x1C, 0x30,
  0x61, 0xC3, 0x86, 0x0C, 0x18, 0x70, 0xE1, 0x83, 0x06, 0x1C, 0x00, 0x00,
  0x60, 0x1C, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x30, 0x0E, 0x01, 0xC0,
  0x30, 0x06, 0x01, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xE0,
  0x18, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x60, 0x0C, 0x03, 0x80, 0x60,
  0x7C, 0x0F, 0x00, 0x07, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x06,
  0x00, 0x30, 0x01, 0x87, 0x1C, 0x70, 0xE7, 0x06, 0x30, 0x33, 0x03, 0xB8,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3B, 0x83, 0x9C, 0x1C, 0x60, 0xC3, 0x06,
  0x1C, 0x30, 0xE3, 0x83, 0x00, 0x07, 0x06, 0x06, 0x0E, 0x0E, 0x0C, 0x0C,
  0x0C, 0x1C, 0x1C, 0x18, 0x18, 0x38, 0x38, 0x30, 0x30, 0x30, 0x70, 0x70,
  0x60, 0x60, 0x60, 0xE0, 0x0D, 0xF3, 0xE1, 0xBF, 0x7E, 0x1E, 0x3C, 0x71,
  0xC3, 0x87, 0x18, 0x38, 0x73, 0x83, 0x06, 0x38, 0x30, 0x63, 0x07, 0x0E,
  0x30, 0x70, 0xE3, 0x06, 0x0C, 0x70, 0x60, 0xC7, 0x0E, 0x0C, 0x60, 0xE1,
  0xC6, 0x0C, 0x1C, 0x60, 0xC1, 0x8E, 0x0C, 0x18, 0x1D, 0xF0, 0xDF, 0xC7,
  0x8E, 0x38, 0x71, 0xC3, 0x9C, 0x18, 0xE0, 0xC7, 0x06, 0x30, 0x71, 0x83,
  0x9C, 0x18, 0xE0, 0xC6, 0x0E, 0x30, 0x73, 0x83, 0x9C, 0x18, 0x0F, 0xC1,
  0xFE, 0x38, 0x63, 0x07, 0x70, 0x76, 0x07, 0x60, 0x7E, 0x06, 0xE0, 0x6C,
  0x0E, 0xC0, 0xEC, 0x0C, 0xE1, 0xCE, 0x38, 0x7F, 0x03, 0xE0, 0x06, 0xF8,
  0x37, 0xF0, 0xF1, 0xC3, 0x83, 0x0E, 0x0C, 0x70, 0x31, 0xC1, 0xC6, 0x07,
  0x18, 0x1C, 0x60, 0x63, 0x83, 0x8E, 0x0E, 0x38, 0x70, 0xE1, 0xC3, 0xFE,
  0x1D, 0xF0, 0x70, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80,
  0x0C, 0x00, 0x00, 0x0F, 0x98, 0xFF, 0x8E, 0x1C, 0x60, 0xE7, 0x07, 0x38,
  0x39, 0x81, 0x9C, 0x0C, 0xE0, 0xE7, 0x07, 0x30, 0x39, 0x83, 0x8C, 0x1C,
  0x71, 0xE3, 0xFF, 0x0F, 0xB0, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00,
  0x30, 0x01, 0x80, 0x1C, 0x00, 0x0D, 0xE3, 0x78, 0x78, 0x0E, 0x01, 0xC0,
  0x70, 0x0E, 0x01, 0x80, 0x30, 0x06, 0x01, 0xC0, 0x38, 0x06, 0x00, 0xC0,
  0x18, 0x07, 0x00, 0x0F, 0xE3, 0xF8, 0xE1, 0x18, 0x03, 0x00, 0x70, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x39, 0x0E, 0x3F, 0xC7,
  0xF0, 0x0C, 0x0C, 0x18, 0x18, 0x7F, 0xFF, 0x38, 0x30, 0x30, 0x70, 0x70,
  0x60, 0x60, 0x60, 0xE0, 0xE0, 0xC0, 0xC0, 0xF8, 0x78, 0x38, 0x39, 0xC1,
  0x8C, 0x0C, 0x60, 0xE3, 0x07, 0x38, 0x31, 0xC1, 0x8C, 0x1C, 0x60, 0xE3,
  0x07, 0x38, 0x31, 0xC3, 0x8E, 0x1C, 0x71, 0xE3, 0xFE, 0x0F, 0xB0, 0xC0,
  0xF8, 0x1B, 0x07, 0x60, 0xCC, 0x39, 0x86, 0x31, 0xC6, 0x30, 0xCE, 0x19,
  0x83, 0x70, 0x6C, 0x0D, 0x81, 0xE0, 0x3C, 0x07, 0x00, 0xC1, 0xC1, 0xE1,
  0xE1, 0xF0, 0xF0, 0xD8, 0x78, 0xEC, 0x6C, 0x66, 0x36, 0x33, 0x33, 0x39,
  0x99, 0x98, 0xCC, 0xDC, 0x6C, 0x6C, 0x36, 0x36, 0x1E, 0x1E, 0x0F, 0x0F,
  0x07, 0x87, 0x83, 0x83, 0x81, 0xC1, 0xC0, 0x1C, 0x1C, 0x30, 0xE0, 0xC7,
  0x03, 0x98, 0x06, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x3E,
  0x01, 0xD8, 0x06, 0x60, 0x39, 0x81, 0xC7, 0x06, 0x0C, 0x38, 0x30, 0x06,
  0x07, 0x06, 0x06, 0x06, 0x0E, 0x06, 0x0C, 0x06, 0x1C, 0x06, 0x18, 0x06,
  0x38, 0x06, 0x30, 0x07, 0x70, 0x07, 0x60, 0x07, 0x60, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x06,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x0F, 0xF1, 0xFE,
  0x00, 0xE0, 0x1C, 0x01, 0x80, 0x38, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xC0,
  0x1C, 0x03, 0x80, 0x30, 0x07, 0x00, 0xFF, 0x8F, 0xF0, 0x01, 0xE0, 0x78,
  0x1C, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x70,
  0x3C, 0x0E, 0x01, 0xE0, 0x0C, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x38,
  0x07, 0x00, 0xC0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0x80, 0xF8,
  0x07, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x70, 0x0E,
  0x00, 0xE0, 0x0E, 0x03, 0xC0, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x38, 0x07,
  0x00, 0xC0, 0x18, 0x07, 0x01, 0xE0, 0xF8, 0x18, 0x00, 0x10, 0x0B, 0xF0,
  0xFF, 0xFF, 0x07, 0xE0,
};

const GFXglyph NotoSans_Condensed_Italic30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 8, 21, 7, 0, -21 },
  { 22, 9, 7, 11, 3, -21 },
  { 30, 15, 21, 15, 0, -21 },
  { 70, 13, 25, 13, 0, -23 },
  { 111, 17, 22, 20, 2, -22 },
  { 158, 15, 22, 15, 0, -22 },
  { 200, 4, 7, 6, 3, -21 },
  { 204, 9, 27, 8, 1, -22 },
  { 235, 9, 27, 8, -2, -22 },
  { 266, 10, 11, 13, 3, -23 },
  { 280, 12, 14, 14, 1, -18 },
  { 301, 5, 7, 7, -1, -3 },
  { 306, 7, 2, 8, 1, -9 },
  { 308, 4, 4, 7, 0, -4 },
  { 310, 14, 21, 10, -1, -21 },
  { 347, 12, 22, 13, 1, -22 },
  { 380, 8, 21, 13, 3, -21 },
  { 401, 14, 22, 13, -1, -22 },
  { 440, 13, 22, 13, 0, -22 },
  { 476, 13, 22, 13, 0, -22 },
  { 512, 13, 21, 13, 0, -21 },
  { 547, 13, 22, 13, 1, -22 },
  { 583, 13, 21, 13, 1, -21 },
  { 618, 13, 22, 13, 0, -22 },
  { 654, 13, 22, 13, 0, -22 },
  { 690, 6, 16, 7, 0, -16 },
  { 702, 8, 20, 7, -2, -16 },
  { 722, 12, 14, 14, 1, -18 },
  { 743, 11, 9, 14, 2, -15 },
  { 756, 13, 14, 14, 1, -18 },
  { 779, 10, 22, 10, 1, -22 },
  { 807, 18, 25, 20, 1, -22 },
  { 864, 14, 21, 14, -2, -21 },
  { 901, 14, 21, 14, 0, -21 },
  { 938, 14, 22, 13, 1, -22 },
  { 977, 15, 21, 16, 0, -21 },
  { 1017, 14, 21, 12, 0, -21 },
  { 1054, 14, 21, 12, 0, -21 },
  { 1091, 16, 22, 16, 1, -22 },
  { 1135, 17, 21, 16, 0, -21 },
  { 1180, 11, 21, 8, -1, -21 },
  { 1209, 12, 27, 7, -5, -21 },
  { 1250, 16, 21, 14, 0, -21 },
  { 1292, 9, 21, 11, 0, -21 },
  { 1316, 22, 21, 21, 0, -21 },
  { 1374, 18, 21, 17, 0, -21 },
  { 1422, 15, 22, 17, 1, -22 },
  { 1464, 14, 21, 14, 0, -21 },
  { 1501, 15, 27, 17, 1, -22 },
  { 1552, 14, 21, 14, 0, -21 },
  { 1589, 13, 22, 12, 0, -22 },
  { 1625, 12, 21, 12, 2, -21 },
  { 1657, 16, 21, 16, 1, -21 },
  { 1699, 13, 21, 13, 3, -21 },
  { 1734, 21, 21, 21, 3, -21 },
  { 1790, 17, 21, 13, -2, -21 },
  { 1835, 12, 21, 12, 3, -21 },
  { 1867, 15, 21, 12, -1, -21 },
  { 1907, 12, 27, 9, -1, -22 },
  { 1948, 5, 21, 10, 3, -21 },
  { 1962, 11, 27, 9, -2, -22 },
  { 2000, 12, 12, 14, 1, -21 },
  { 2018, 11, 1, 10, -3, 3 },
  { 2020, 5, 5, 8, 4, -23 },
  { 2024, 13, 16, 14, 1, -16 },
  { 2050, 13, 23, 14, 0, -23 },
  { 2088, 10, 16, 11, 1, -16 },
  { 2108, 14, 23, 14, 1, -23 },
  { 2149, 11, 16, 13, 1, -16 },
  { 2171, 15, 30, 8, -4, -23 },
  { 2228, 14, 23, 14, 0, -16 },
  { 2269, 13, 23, 14, 0, -23 },
  { 2307, 7, 22, 6, 0, -22 },
  { 2327, 11, 29, 6, -4, -22 },
  { 2367, 13, 23, 12, 0, -23 },
  { 2405, 8, 23, 6, 0, -23 },
  { 2428, 20, 16, 21, 0, -16 },
  { 2468, 13, 16, 14, 0, -16 },
  { 2494, 12, 16, 14, 1, -16 },
  { 2518, 14, 23, 14, -1, -16 },
  { 2559, 13, 23, 14, 1, -16 },
  { 2597, 11, 16, 9, 0, -16 },
  { 2619, 11, 16, 11, 0, -16 },
  { 2641, 8, 20, 8, 1, -20 },
  { 2661, 13, 16, 14, 1, -16 },
  { 2687, 11, 16, 11, 2, -16 },
  { 2709, 17, 16, 18, 2, -16 },
  { 2743, 14, 16, 12, -1, -16 },
  { 2771, 16, 23, 11, -3, -16 },
  { 2817, 12, 16, 10, -1, -16 },
  { 2841, 11, 26, 10, 1, -21 },
  { 2877, 3, 30, 13, 5, -23 },
  { 2889, 11, 26, 10, -2, -21 },
  { 2925, 13, 4, 14, 1, -13 },
};

const GFXfont NotoSans_Condensed_Italic30pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Italic30pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Italic30pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _NOTOSANS_CONDENSED_ITALIC30PT7B_H_
