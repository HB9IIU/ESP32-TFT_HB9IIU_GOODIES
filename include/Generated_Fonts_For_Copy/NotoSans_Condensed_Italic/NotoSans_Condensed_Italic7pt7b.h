#ifndef _NOTOSANS_CONDENSED_ITALIC7PT7B_H_
#define _NOTOSANS_CONDENSED_ITALIC7PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Italic.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Italic7pt7bBitmaps[] PROGMEM = {
  0x00, 0x5A, 0x80, 0xE0, 0x67, 0x6E, 0xC0, 0x79, 0x3C, 0x5E, 0xF7, 0x50,
  0x6D, 0x5E, 0xC0, 0x5A, 0xA0, 0x24, 0x95, 0x80, 0xB0, 0x5D, 0x00, 0xC0,
  0xC0, 0x80, 0x29, 0x48, 0x76, 0xDC, 0xDA, 0x80, 0x64, 0xAC, 0x65, 0x1C,
  0x2E, 0xF4, 0x6A, 0x9C, 0x73, 0xDC, 0x65, 0x28, 0x6D, 0x5E, 0x77, 0x9C,
  0x90, 0x98, 0x39, 0x80, 0xFC, 0xC7, 0x00, 0xE5, 0x48, 0x73, 0xF5, 0xE8,
  0x30, 0x2E, 0xFA, 0x6D, 0xDE, 0x74, 0x88, 0x60, 0x65, 0x9A, 0xC0, 0x69,
  0xCC, 0x69, 0xC8, 0x74, 0xB9, 0x60, 0x55, 0x6A, 0xA0, 0x56, 0x80, 0x25,
  0x25, 0x80, 0x56, 0x4A, 0xA0, 0x5A, 0xC0, 0x4A, 0xF7, 0xDB, 0x00, 0x55,
  0xBA, 0xA0, 0x79, 0x99, 0xE0, 0x6F, 0xC8, 0x79, 0x99, 0xE2, 0x6D, 0xDA,
  0x71, 0x1C, 0xEA, 0x80, 0x55, 0x9A, 0xE0, 0xBB, 0x48, 0xCE, 0xAD, 0x4A,
  0x00, 0x69, 0x6A, 0xFA, 0x80, 0x65, 0x4C, 0x5A, 0xA0, 0xF8, 0x55, 0xA0,
  0x4E, 0x80, 0xE0, 0x80, 0x76, 0xF0, 0x4E, 0xDE, 0x72, 0x60, 0x16, 0xAA,
  0xE0, 0x77, 0x70, 0x36, 0x44, 0x44, 0x80, 0x76, 0xF3, 0x80, 0x4E, 0xDA,
  0x5A, 0x80, 0x25, 0x24, 0xA0, 0x4D, 0x6C, 0x5A, 0x80, 0x75, 0x6B, 0x60,
  0x76, 0xD0, 0x76, 0xE0, 0x76, 0xF9, 0x00, 0x76, 0xF2, 0x80, 0x6A, 0x67,
  0x7A, 0x80, 0x76, 0xE0, 0xB7, 0x40, 0xAD, 0xBD, 0x40, 0xA9, 0x60, 0x55,
  0x22, 0x48, 0x5B, 0x69, 0x49, 0x80, 0xFE, 0x55, 0xA0, 0xE0,
};

const GFXglyph NotoSans_Condensed_Italic7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 1, 0, -1 },
  { 1, 2, 5, 2, 0, -5 },
  { 3, 2, 2, 2, 1, -5 },
  { 4, 4, 5, 3, 0, -5 },
  { 7, 3, 5, 3, 0, -5 },
  { 9, 4, 5, 5, 0, -5 },
  { 12, 3, 5, 4, 0, -5 },
  { 14, 1, 2, 1, 1, -5 },
  { 15, 2, 6, 2, 0, -5 },
  { 17, 3, 6, 2, -1, -5 },
  { 20, 2, 2, 3, 1, -5 },
  { 21, 3, 3, 3, 0, -4 },
  { 23, 1, 2, 2, 0, -1 },
  { 24, 2, 1, 2, 0, -2 },
  { 25, 1, 1, 2, 0, -1 },
  { 26, 3, 5, 2, 0, -5 },
  { 28, 3, 5, 3, 0, -5 },
  { 30, 2, 5, 3, 1, -5 },
  { 32, 3, 5, 3, 0, -5 },
  { 34, 3, 5, 3, 0, -5 },
  { 36, 3, 5, 3, 0, -5 },
  { 38, 3, 5, 3, 0, -5 },
  { 40, 3, 5, 3, 0, -5 },
  { 42, 3, 5, 3, 0, -5 },
  { 44, 3, 5, 3, 0, -5 },
  { 46, 3, 5, 3, 0, -5 },
  { 48, 1, 4, 2, 0, -4 },
  { 49, 1, 5, 2, 0, -4 },
  { 50, 3, 3, 3, 0, -4 },
  { 52, 3, 2, 3, 0, -3 },
  { 53, 3, 3, 3, 0, -4 },
  { 55, 3, 5, 2, 0, -5 },
  { 57, 5, 6, 5, 0, -5 },
  { 61, 3, 5, 3, 0, -5 },
  { 63, 3, 5, 3, 0, -5 },
  { 65, 4, 5, 3, 0, -5 },
  { 68, 4, 5, 4, 0, -5 },
  { 71, 3, 5, 3, 0, -5 },
  { 73, 3, 5, 3, 0, -5 },
  { 75, 4, 5, 4, 0, -5 },
  { 78, 4, 5, 4, 0, -5 },
  { 81, 2, 5, 2, 0, -5 },
  { 83, 3, 6, 2, -1, -5 },
  { 86, 4, 5, 3, 0, -5 },
  { 89, 2, 5, 3, 0, -5 },
  { 91, 5, 5, 5, 0, -5 },
  { 95, 4, 5, 4, 0, -5 },
  { 98, 4, 5, 4, 0, -5 },
  { 101, 3, 5, 3, 0, -5 },
  { 103, 4, 6, 4, 0, -5 },
  { 106, 3, 5, 3, 0, -5 },
  { 108, 3, 5, 3, 0, -5 },
  { 110, 2, 5, 3, 1, -5 },
  { 112, 4, 5, 4, 0, -5 },
  { 115, 3, 5, 3, 1, -5 },
  { 117, 5, 5, 5, 1, -5 },
  { 121, 3, 5, 3, 0, -5 },
  { 123, 2, 5, 3, 1, -5 },
  { 125, 3, 5, 3, 0, -5 },
  { 127, 2, 6, 2, 0, -5 },
  { 129, 1, 5, 2, 1, -5 },
  { 130, 2, 6, 2, 0, -5 },
  { 132, 3, 3, 3, 0, -5 },
  { 134, 3, 1, 2, -1, 0 },
  { 135, 1, 1, 2, 1, -5 },
  { 136, 3, 4, 3, 0, -4 },
  { 138, 3, 5, 3, 0, -5 },
  { 140, 3, 4, 3, 0, -4 },
  { 142, 4, 5, 3, 0, -5 },
  { 145, 3, 4, 3, 0, -4 },
  { 147, 4, 7, 2, -1, -5 },
  { 151, 3, 6, 3, 0, -4 },
  { 154, 3, 5, 3, 0, -5 },
  { 156, 2, 5, 1, 0, -5 },
  { 158, 3, 7, 1, -1, -5 },
  { 161, 3, 5, 3, 0, -5 },
  { 163, 2, 5, 1, 0, -5 },
  { 165, 5, 4, 5, 0, -4 },
  { 168, 3, 4, 3, 0, -4 },
  { 170, 3, 4, 3, 0, -4 },
  { 172, 3, 6, 3, 0, -4 },
  { 175, 3, 6, 3, 0, -4 },
  { 178, 2, 4, 2, 0, -4 },
  { 179, 2, 4, 2, 0, -4 },
  { 180, 2, 5, 2, 0, -5 },
  { 182, 3, 4, 3, 0, -4 },
  { 184, 3, 4, 3, 0, -4 },
  { 186, 5, 4, 4, 0, -4 },
  { 189, 3, 4, 3, 0, -4 },
  { 191, 4, 6, 3, -1, -4 },
  { 194, 2, 4, 2, 0, -4 },
  { 195, 3, 6, 2, 0, -5 },
  { 198, 1, 7, 3, 1, -5 },
  { 199, 2, 6, 2, 0, -5 },
  { 201, 3, 1, 3, 0, -3 },
};

const GFXfont NotoSans_Condensed_Italic7pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Italic7pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Italic7pt7bGlyphs,
  0x20, 0x7E, 10
};

#endif // _NOTOSANS_CONDENSED_ITALIC7PT7B_H_
