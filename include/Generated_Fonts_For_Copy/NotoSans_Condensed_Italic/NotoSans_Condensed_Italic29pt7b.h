#ifndef _NOTOSANS_CONDENSED_ITALIC29PT7B_H_
#define _NOTOSANS_CONDENSED_ITALIC29PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Italic.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Italic29pt7bBitmaps[] PROGMEM = {
  0x00, 0x06, 0x1C, 0x38, 0x70, 0xC1, 0x83, 0x0E, 0x18, 0x30, 0x60, 0xC3,
  0x06, 0x0C, 0x00, 0x00, 0x01, 0xC7, 0x8E, 0x00, 0x73, 0x67, 0x67, 0x66,
  0xE6, 0xC6, 0xC6, 0xC4, 0x01, 0x8C, 0x03, 0x18, 0x04, 0x60, 0x18, 0xC0,
  0x31, 0x80, 0x62, 0x0F, 0xFF, 0x9F, 0xFF, 0x06, 0x20, 0x18, 0xC0, 0x31,
  0x80, 0x63, 0x01, 0x8C, 0x1F, 0xFF, 0x3F, 0xFE, 0x08, 0xC0, 0x31, 0x80,
  0x63, 0x00, 0xC4, 0x03, 0x18, 0x06, 0x30, 0x00, 0x00, 0xC0, 0x06, 0x00,
  0x70, 0x0F, 0xF0, 0xEF, 0x0C, 0xC0, 0x66, 0x03, 0x20, 0x19, 0x00, 0xF8,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0x70, 0x1B, 0x80, 0xCC, 0x04, 0xE4,
  0x26, 0x3D, 0xF1, 0xFF, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x03, 0x00, 0x1C,
  0x06, 0x3E, 0x0C, 0x66, 0x0C, 0x66, 0x18, 0xC6, 0x18, 0xC6, 0x30, 0xC6,
  0x60, 0xC6, 0x60, 0xC6, 0xCE, 0xCC, 0xDF, 0xCD, 0xB3, 0xFB, 0x33, 0x73,
  0x63, 0x06, 0x63, 0x06, 0x63, 0x0C, 0x63, 0x18, 0x42, 0x18, 0x46, 0x30,
  0x46, 0x30, 0x7C, 0x60, 0x78, 0x01, 0xE0, 0x1F, 0xC0, 0x67, 0x03, 0x8C,
  0x0C, 0x30, 0x31, 0xC0, 0xC6, 0x03, 0xB0, 0x0F, 0xC0, 0x1C, 0x00, 0xF0,
  0x06, 0xC3, 0x33, 0x9D, 0x86, 0x66, 0x1F, 0xB8, 0x3C, 0xE0, 0xE3, 0x83,
  0x8E, 0x1F, 0x1F, 0xFC, 0x3E, 0x38, 0x76, 0x66, 0x6C, 0xCC, 0x03, 0x83,
  0x81, 0x81, 0x81, 0xC0, 0xC0, 0xE0, 0x60, 0x70, 0x30, 0x18, 0x1C, 0x0E,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x00,
  0xC0, 0x60, 0x30, 0x00, 0x06, 0x01, 0x80, 0xC0, 0x60, 0x38, 0x1C, 0x0E,
  0x03, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x30, 0x18, 0x0C, 0x0E, 0x06, 0x03,
  0x03, 0x81, 0x81, 0xC0, 0xC0, 0xC0, 0xE0, 0x60, 0x60, 0x00, 0x06, 0x03,
  0x88, 0xC3, 0xB0, 0xFF, 0xC3, 0xF1, 0xC0, 0xD8, 0xE6, 0x18, 0xC0, 0x20,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0xFF, 0xFF, 0xFF,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x39, 0x9C, 0xC6,
  0x63, 0x00, 0xFF, 0xF0, 0x7F, 0xE0, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00,
  0xC0, 0x06, 0x00, 0x60, 0x07, 0x00, 0x30, 0x03, 0x80, 0x18, 0x01, 0xC0,
  0x0C, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x18,
  0x01, 0xC0, 0x0C, 0x00, 0x00, 0x03, 0xC0, 0xFE, 0x1C, 0xE1, 0x86, 0x38,
  0x73, 0x07, 0x30, 0x77, 0x06, 0x60, 0x66, 0x06, 0xE0, 0x6E, 0x0E, 0xE0,
  0xEC, 0x0C, 0xC0, 0xCC, 0x1C, 0xC1, 0x8C, 0x38, 0xE7, 0x07, 0xE0, 0x7C,
  0x00, 0x03, 0x0F, 0x1F, 0x3E, 0xF6, 0x66, 0x0E, 0x0E, 0x0C, 0x0C, 0x1C,
  0x1C, 0x18, 0x18, 0x18, 0x38, 0x38, 0x30, 0x30, 0x30, 0x70, 0x01, 0xE0,
  0x1F, 0xE0, 0xE3, 0x81, 0x06, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x0E,
  0x00, 0x30, 0x01, 0xC0, 0x0E, 0x00, 0x30, 0x01, 0x80, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x1F, 0xF8, 0xFF, 0xE0, 0x07,
  0xE0, 0xFF, 0x83, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x0E,
  0x00, 0xE0, 0x7E, 0x03, 0xC0, 0x07, 0x80, 0x0C, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x0E, 0x20, 0xF1, 0xFF, 0x0F, 0xE0, 0x00, 0x00, 0x38,
  0x03, 0x80, 0x3C, 0x01, 0xE0, 0x1B, 0x01, 0xB8, 0x0D, 0x80, 0xCC, 0x0C,
  0x60, 0x67, 0x06, 0x30, 0x61, 0x87, 0x0C, 0x30, 0x63, 0xFF, 0xDF, 0xFE,
  0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x00, 0x07, 0xF8, 0x3F,
  0xC3, 0x80, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x1F, 0x01,
  0xFE, 0x04, 0x78, 0x01, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00,
  0xE0, 0x06, 0x20, 0xF1, 0xFF, 0x0F, 0xE0, 0x00, 0x01, 0xF0, 0x3F, 0x0F,
  0x00, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x03, 0x00, 0x67, 0x86, 0xFC, 0x79,
  0xCE, 0x0E, 0xE0, 0xEE, 0x0E, 0xC0, 0xCC, 0x0C, 0xC1, 0xCE, 0x1C, 0xE3,
  0x87, 0xF0, 0x3E, 0x00, 0x3F, 0xF9, 0xFF, 0x80, 0x0C, 0x00, 0xE0, 0x06,
  0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00,
  0x60, 0x07, 0x00, 0x30, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0xE0,
  0x0E, 0x00, 0x00, 0x03, 0xE0, 0x3F, 0x83, 0x8E, 0x38, 0x71, 0xC1, 0x8C,
  0x1C, 0x70, 0xC3, 0x8E, 0x0E, 0xE0, 0x3E, 0x03, 0xE0, 0x3B, 0x83, 0x8C,
  0x38, 0x71, 0x81, 0x9C, 0x0C, 0xE0, 0x67, 0x07, 0x18, 0x30, 0xFF, 0x83,
  0xF0, 0x00, 0x03, 0xC0, 0x7E, 0x0E, 0x71, 0xC3, 0x18, 0x33, 0x83, 0x30,
  0x33, 0x03, 0x30, 0x33, 0x07, 0x38, 0xF3, 0xFF, 0x1F, 0x60, 0x06, 0x00,
  0xE0, 0x0C, 0x01, 0xC0, 0x18, 0x03, 0x0F, 0xF0, 0xFC, 0x00, 0x0C, 0x71,
  0xC6, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x8E, 0x38, 0x04, 0x1C,
  0x38, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x0C, 0x38,
  0x60, 0xC3, 0x06, 0x00, 0x00, 0x10, 0x07, 0x01, 0xF0, 0x7C, 0x1F, 0x07,
  0xC0, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x30,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x00, 0xC0, 0x00, 0x1F, 0x0F, 0xE3, 0x1C,
  0x07, 0x01, 0xC0, 0x60, 0x18, 0x0C, 0x07, 0x03, 0x81, 0xC0, 0x60, 0x30,
  0x0C, 0x06, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x03, 0x80, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x7F, 0xC0, 0x70, 0x30, 0x38, 0x06, 0x1C, 0x01, 0x86, 0x00,
  0x33, 0x0F, 0xCC, 0xC7, 0x63, 0x63, 0x18, 0xD8, 0xC6, 0x34, 0x61, 0x8F,
  0x18, 0xC6, 0xC6, 0x31, 0xB1, 0x0C, 0x6C, 0xC7, 0x33, 0x19, 0xCC, 0xC7,
  0xBE, 0x30, 0xC6, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0E, 0x08,
  0x01, 0xFE, 0x00, 0x08, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xB0,
  0x0D, 0x80, 0xCC, 0x06, 0x60, 0x73, 0x03, 0x18, 0x38, 0xC1, 0x86, 0x1C,
  0x30, 0xFF, 0x87, 0xFC, 0x70, 0x63, 0x03, 0x38, 0x19, 0x80, 0xDC, 0x06,
  0xC0, 0x3E, 0x01, 0x80, 0x07, 0xC0, 0x3F, 0xE0, 0xE3, 0xC3, 0x07, 0x0C,
  0x1C, 0x30, 0x71, 0xC1, 0xC7, 0x06, 0x18, 0x38, 0x7F, 0x81, 0xFC, 0x0E,
  0x3C, 0x38, 0x30, 0xC0, 0xC3, 0x03, 0x1C, 0x0C, 0x70, 0x71, 0xC1, 0xC6,
  0x1E, 0x1F, 0xF0, 0xFF, 0x00, 0x01, 0xF8, 0x0F, 0xF0, 0xF0, 0x83, 0x80,
  0x1C, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00,
  0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x60, 0x01, 0x80,
  0x07, 0x04, 0x0F, 0xF0, 0x1F, 0xC0, 0x07, 0xC0, 0x1F, 0xF0, 0x39, 0xE0,
  0x60, 0xE0, 0xC0, 0xC1, 0x81, 0xC7, 0x03, 0x8E, 0x07, 0x18, 0x0E, 0x30,
  0x1C, 0x60, 0x31, 0xC0, 0x63, 0x81, 0xC6, 0x03, 0x8C, 0x06, 0x38, 0x1C,
  0x70, 0x70, 0xC1, 0xC1, 0x87, 0x83, 0xFC, 0x0F, 0xE0, 0x00, 0x07, 0xF8,
  0x7F, 0xC3, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x18,
  0x00, 0xFF, 0x07, 0xF8, 0x70, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x00, 0x18, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x7F,
  0xC3, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x18, 0x00,
  0xC0, 0x07, 0xF8, 0x7F, 0x83, 0x80, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0xFC, 0x07, 0xFC,
  0x1C, 0x38, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xC0, 0x01, 0x83, 0xF3, 0x07, 0xCE, 0x01, 0x9C, 0x03, 0x38, 0x0E,
  0x70, 0x1C, 0x60, 0x30, 0xE0, 0x61, 0xE0, 0xC1, 0xFF, 0x81, 0xFE, 0x00,
  0x06, 0x03, 0x0E, 0x03, 0x0E, 0x07, 0x0C, 0x07, 0x0C, 0x06, 0x0C, 0x06,
  0x1C, 0x0E, 0x1C, 0x0E, 0x18, 0x0C, 0x1F, 0xFC, 0x1F, 0xFC, 0x38, 0x1C,
  0x38, 0x1C, 0x30, 0x18, 0x30, 0x18, 0x30, 0x18, 0x70, 0x38, 0x70, 0x38,
  0x60, 0x30, 0x60, 0x30, 0xE0, 0x70, 0x0F, 0xE1, 0xFC, 0x0C, 0x01, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x30, 0x06, 0x01, 0xC0, 0x38, 0x06, 0x00, 0xC0,
  0x18, 0x07, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x3E, 0x0F, 0xE0, 0x00,
  0x60, 0x1C, 0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x70, 0x0E, 0x01, 0x80,
  0x30, 0x06, 0x01, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xE0,
  0x18, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0xE0, 0xFC, 0x1F, 0x01, 0x00,
  0x00, 0x06, 0x07, 0x0E, 0x0E, 0x0E, 0x1C, 0x0C, 0x38, 0x0C, 0x30, 0x0C,
  0x70, 0x1C, 0xE0, 0x1D, 0xC0, 0x1B, 0x80, 0x1B, 0x00, 0x1F, 0x80, 0x3F,
  0x80, 0x39, 0x80, 0x31, 0x80, 0x31, 0xC0, 0x71, 0xC0, 0x70, 0xC0, 0x70,
  0xC0, 0x60, 0xE0, 0x60, 0xE0, 0xE0, 0x60, 0x06, 0x07, 0x03, 0x81, 0x80,
  0xC0, 0x60, 0x70, 0x38, 0x18, 0x0C, 0x06, 0x07, 0x03, 0x81, 0x80, 0xC0,
  0xE0, 0x70, 0x30, 0x18, 0x0F, 0xFF, 0xF8, 0x07, 0x00, 0x78, 0x78, 0x03,
  0xC3, 0xC0, 0x3C, 0x1E, 0x01, 0xE0, 0xF0, 0x1F, 0x07, 0x80, 0xF8, 0x7C,
  0x0F, 0xC3, 0x70, 0x6C, 0x1B, 0x87, 0x60, 0xCC, 0x33, 0x06, 0x63, 0xB8,
  0x73, 0x19, 0xC3, 0x19, 0xCC, 0x18, 0xCC, 0x60, 0xC6, 0xE3, 0x0E, 0x36,
  0x38, 0x71, 0xB1, 0xC3, 0x0F, 0x0C, 0x18, 0x78, 0x60, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0x00, 0x07, 0x01, 0x87, 0x81, 0xC3, 0xC0, 0xE1, 0xE0, 0x60,
  0xF0, 0x30, 0x7C, 0x18, 0x76, 0x1C, 0x33, 0x0E, 0x19, 0x86, 0x0C, 0xE3,
  0x06, 0x31, 0x87, 0x19, 0xC3, 0x0C, 0xC1, 0x86, 0x60, 0xC3, 0xB0, 0xE0,
  0xD8, 0x70, 0x7C, 0x30, 0x3C, 0x18, 0x1E, 0x0C, 0x07, 0x0E, 0x03, 0x80,
  0x01, 0xF0, 0x0F, 0xF0, 0x3C, 0x70, 0xE0, 0x61, 0xC0, 0xE7, 0x01, 0xCC,
  0x03, 0xB8, 0x07, 0x70, 0x0E, 0xE0, 0x1D, 0x80, 0x33, 0x00, 0x6E, 0x01,
  0xDC, 0x03, 0xB8, 0x06, 0x70, 0x1C, 0xE0, 0x30, 0xC0, 0xE1, 0xC3, 0x81,
  0xFE, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x7F, 0x83, 0x9E, 0x18, 0x30, 0xC1,
  0x86, 0x0C, 0x70, 0x63, 0x83, 0x18, 0x38, 0xC1, 0x86, 0x3C, 0x7F, 0xC3,
  0xF8, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x18, 0x00, 0xC0,
  0x0E, 0x00, 0x00, 0x01, 0xF0, 0x0F, 0xF0, 0x3C, 0x70, 0xE0, 0x61, 0xC0,
  0xE7, 0x01, 0xCC, 0x03, 0xB8, 0x07, 0x70, 0x0E, 0xE0, 0x1D, 0x80, 0x33,
  0x00, 0x6E, 0x01, 0xDC, 0x03, 0xB8, 0x06, 0x70, 0x1C, 0xE0, 0x30, 0xC0,
  0xE1, 0xC3, 0x81, 0xFE, 0x01, 0xF8, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0,
  0x01, 0xC0, 0x01, 0xC0, 0x07, 0xC0, 0x3F, 0xC0, 0xE7, 0x83, 0x06, 0x0C,
  0x1C, 0x30, 0x71, 0xC1, 0x87, 0x06, 0x18, 0x38, 0x61, 0xC1, 0xFE, 0x0F,
  0xF0, 0x39, 0x80, 0xC6, 0x03, 0x1C, 0x1C, 0x70, 0x70, 0xC1, 0xC3, 0x06,
  0x0E, 0x18, 0x38, 0xE0, 0x60, 0x03, 0xF0, 0x7F, 0xC7, 0x8C, 0x38, 0x01,
  0x80, 0x1C, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0xE0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x20, 0xF1,
  0xFF, 0x0F, 0xF0, 0x00, 0x7F, 0xF7, 0xFE, 0x86, 0x00, 0xE0, 0x0E, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x38, 0x03,
  0x80, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x00,
  0x0C, 0x06, 0x38, 0x1C, 0x60, 0x38, 0xC0, 0x61, 0x80, 0xC7, 0x01, 0x8E,
  0x07, 0x18, 0x0E, 0x30, 0x18, 0x60, 0x31, 0xC0, 0x63, 0x81, 0xC6, 0x03,
  0x0C, 0x06, 0x18, 0x0C, 0x70, 0x38, 0xE0, 0x61, 0xC1, 0xC1, 0xC3, 0x83,
  0xFE, 0x03, 0xF8, 0x00, 0xC0, 0x3C, 0x07, 0xC0, 0x6C, 0x0E, 0xC0, 0xEC,
  0x0C, 0xC1, 0xCC, 0x18, 0xC3, 0x8C, 0x30, 0xC7, 0x0C, 0x60, 0xCE, 0x0C,
  0xC0, 0xCC, 0x0D, 0xC0, 0xD8, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xE0, 0x00,
  0xC0, 0x60, 0x7C, 0x0E, 0x07, 0xC0, 0xE0, 0x6C, 0x1E, 0x0E, 0xC1, 0xE0,
  0xCC, 0x1E, 0x1C, 0xC3, 0x61, 0xCC, 0x36, 0x18, 0xC6, 0x63, 0x8C, 0x66,
  0x30, 0xC6, 0x67, 0x0C, 0xC6, 0x60, 0xCC, 0x66, 0x0D, 0x86, 0xE0, 0xD8,
  0x6C, 0x0F, 0x87, 0xC0, 0xF0, 0x78, 0x0F, 0x07, 0x80, 0xE0, 0x78, 0x0E,
  0x07, 0x00, 0xE0, 0x70, 0x00, 0x07, 0x03, 0x07, 0x07, 0x03, 0x0E, 0x03,
  0x0C, 0x03, 0x1C, 0x03, 0x98, 0x03, 0xB0, 0x01, 0xF0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xE0, 0x0E, 0xE0, 0x0C,
  0x60, 0x1C, 0x60, 0x18, 0x60, 0x30, 0x70, 0x70, 0x70, 0xE0, 0x30, 0xC0,
  0xF8, 0x1F, 0x07, 0x60, 0xCE, 0x39, 0xC6, 0x39, 0xC3, 0x30, 0x6E, 0x0D,
  0x81, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x03,
  0x80, 0x70, 0x0C, 0x00, 0x07, 0xFC, 0x3F, 0xF0, 0x01, 0x80, 0x0E, 0x00,
  0x30, 0x01, 0xC0, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x0E, 0x00, 0x30, 0x01,
  0xC0, 0x06, 0x00, 0x38, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x01, 0xC0, 0x07,
  0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x03, 0xE0, 0x7C, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0E, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x7C, 0x1F, 0x80, 0xC6, 0x31, 0xC6, 0x31, 0x8C, 0x63, 0x18,
  0xE3, 0x18, 0xC6, 0x31, 0x8E, 0x31, 0x80, 0x07, 0xE0, 0xFC, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0xC0,
  0x30, 0x06, 0x00, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xE0,
  0x18, 0x03, 0x00, 0x60, 0xFC, 0x1F, 0x80, 0x03, 0x00, 0x70, 0x07, 0x00,
  0xD8, 0x0D, 0x81, 0x98, 0x18, 0xC3, 0x0C, 0x70, 0xC6, 0x06, 0xE0, 0x6C,
  0x07, 0x7F, 0xFF, 0xF0, 0xE6, 0x33, 0x07, 0x31, 0xFB, 0x1C, 0xF3, 0x87,
  0x70, 0x67, 0x06, 0x60, 0x6E, 0x0E, 0xE0, 0xEE, 0x0C, 0xC0, 0xCC, 0x1C,
  0xC1, 0xCE, 0x3C, 0xFF, 0x87, 0xD8, 0x06, 0x00, 0x30, 0x03, 0x80, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x33, 0x83, 0xFE, 0x1F, 0x70, 0xE1, 0xC7, 0x0E,
  0x70, 0x73, 0x83, 0x98, 0x18, 0xC0, 0xC6, 0x06, 0x70, 0x73, 0x83, 0x1C,
  0x38, 0xE3, 0x87, 0xFC, 0x67, 0x80, 0x07, 0x83, 0xF1, 0xC8, 0xE0, 0x70,
  0x18, 0x06, 0x03, 0x80, 0xE0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x38, 0x47,
  0xE0, 0xF8, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00,
  0xE0, 0x73, 0x07, 0xEC, 0x1C, 0xF0, 0xE1, 0xC7, 0x06, 0x1C, 0x18, 0x60,
  0x63, 0x83, 0x8E, 0x0E, 0x30, 0x30, 0xC0, 0xC3, 0x07, 0x0C, 0x1C, 0x38,
  0xF0, 0xFF, 0x81, 0xF6, 0x00, 0x07, 0x83, 0xF1, 0x8C, 0xC3, 0x70, 0xD8,
  0x36, 0x1F, 0xFE, 0xFE, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x38, 0x27, 0xF0,
  0xFC, 0x00, 0x7C, 0x03, 0xE0, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00,
  0x3F, 0x01, 0xF8, 0x0B, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80,
  0x3C, 0x00, 0xE0, 0x00, 0x03, 0x98, 0x7E, 0xC3, 0x9E, 0x38, 0x73, 0x83,
  0x1C, 0x18, 0xC0, 0xCE, 0x0E, 0x70, 0x73, 0x03, 0x18, 0x18, 0xC1, 0xC6,
  0x0E, 0x38, 0xF1, 0xFF, 0x07, 0xD8, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x07,
  0x08, 0x70, 0x7F, 0x81, 0xF0, 0x00, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0xE1, 0xFF, 0x1E, 0x71, 0xC3, 0x18, 0x33, 0x83,
  0x38, 0x33, 0x07, 0x30, 0x63, 0x06, 0x70, 0x67, 0x0E, 0x60, 0xE6, 0x0C,
  0x60, 0xCE, 0x0C, 0x0E, 0x1C, 0x30, 0x00, 0x01, 0x87, 0x0C, 0x18, 0x30,
  0xE1, 0xC3, 0x06, 0x0C, 0x38, 0x70, 0xC1, 0x83, 0x0E, 0x00, 0x00, 0xE0,
  0x1C, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x30,
  0x0E, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x03, 0xE0, 0x78,
  0x00, 0x06, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0xE3, 0x8E, 0x18, 0xE0, 0xC6, 0x06, 0x60, 0x77, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0x60, 0x73, 0x03, 0x9C, 0x18, 0x60, 0xC3, 0x06, 0x1C, 0x70,
  0xE0, 0x06, 0x0C, 0x38, 0x70, 0xC1, 0x83, 0x0E, 0x18, 0x30, 0x61, 0xC3,
  0x86, 0x0C, 0x18, 0x70, 0xE1, 0x83, 0x06, 0x1C, 0x00, 0x08, 0xE3, 0xC3,
  0x7E, 0xFC, 0x79, 0xF3, 0x8E, 0x1C, 0x31, 0x83, 0x06, 0x70, 0xE1, 0xCE,
  0x1C, 0x39, 0x83, 0x06, 0x30, 0x60, 0xC6, 0x0C, 0x19, 0xC3, 0x87, 0x38,
  0x70, 0xC6, 0x0C, 0x18, 0xC1, 0x83, 0x18, 0x30, 0x67, 0x0E, 0x1C, 0x18,
  0xE1, 0xBF, 0x1E, 0x71, 0xC3, 0x1C, 0x33, 0x83, 0x38, 0x73, 0x07, 0x30,
  0x73, 0x06, 0x70, 0x67, 0x0E, 0x60, 0xE6, 0x0C, 0xE0, 0xCE, 0x1C, 0x07,
  0x83, 0xF8, 0x73, 0x98, 0x37, 0x06, 0xC0, 0xD8, 0x1F, 0x03, 0xE0, 0xF8,
  0x1F, 0x03, 0x60, 0x6C, 0x1D, 0xC7, 0x1F, 0xC1, 0xF0, 0x04, 0x70, 0x37,
  0xE0, 0xD9, 0x83, 0x87, 0x0E, 0x1C, 0x70, 0x71, 0xC1, 0xC6, 0x06, 0x18,
  0x18, 0x60, 0x63, 0x83, 0x8E, 0x0C, 0x38, 0x70, 0xE3, 0x83, 0xFE, 0x1D,
  0xE0, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x0C,
  0x00, 0x00, 0x07, 0x31, 0xFB, 0x1C, 0xF3, 0x87, 0x70, 0x67, 0x06, 0x60,
  0x6E, 0x0E, 0xE0, 0xEC, 0x0C, 0xC0, 0xCC, 0x1C, 0xC1, 0xCE, 0x3C, 0xFF,
  0x87, 0xD8, 0x01, 0x80, 0x38, 0x03, 0x80, 0x30, 0x03, 0x00, 0x30, 0x07,
  0x00, 0x09, 0xC6, 0xF1, 0xFC, 0x70, 0x1C, 0x0E, 0x03, 0x80, 0xC0, 0x30,
  0x0C, 0x07, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x03, 0x80, 0x0F, 0x87, 0xF3,
  0x8C, 0xC0, 0x30, 0x0C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x0C,
  0x03, 0x21, 0xCF, 0xF3, 0xF0, 0x0C, 0x18, 0x18, 0x3F, 0x7E, 0xB0, 0x30,
  0x30, 0x70, 0x70, 0x60, 0x60, 0x60, 0xE0, 0xE0, 0xC0, 0xC0, 0xF8, 0x78,
  0x38, 0x33, 0x83, 0x30, 0x73, 0x06, 0x30, 0x67, 0x06, 0x70, 0xE6, 0x0E,
  0x60, 0xC6, 0x0C, 0xE1, 0xCC, 0x1C, 0xC3, 0xCE, 0x38, 0xFD, 0x87, 0x98,
  0xC0, 0xF0, 0x7C, 0x1B, 0x0E, 0xC3, 0x30, 0xCC, 0x73, 0x18, 0xCE, 0x33,
  0x0D, 0xC3, 0x60, 0xF8, 0x3C, 0x0F, 0x03, 0x80, 0xC1, 0x83, 0xE1, 0xC1,
  0xB0, 0xE1, 0xD8, 0x50, 0xCC, 0x68, 0x66, 0x3C, 0x73, 0x36, 0x31, 0x9B,
  0x38, 0xCD, 0x98, 0x6C, 0xCC, 0x36, 0x6C, 0x1E, 0x36, 0x0F, 0x1F, 0x07,
  0x8F, 0x03, 0x87, 0x81, 0xC3, 0x80, 0x1C, 0x18, 0xE1, 0x83, 0x1C, 0x18,
  0xC0, 0xEC, 0x03, 0xE0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x07, 0xE0,
  0x33, 0x03, 0x98, 0x38, 0xC1, 0x87, 0x1C, 0x18, 0x06, 0x06, 0x0C, 0x0C,
  0x18, 0x30, 0x30, 0x60, 0x61, 0xC0, 0xC3, 0x01, 0x8E, 0x03, 0x18, 0x06,
  0x70, 0x0C, 0xC0, 0x1B, 0x80, 0x36, 0x00, 0x6C, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x01, 0xC0, 0x1F,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0xE1, 0xFC, 0x43, 0x80, 0xE0, 0x18, 0x07,
  0x00, 0xC0, 0x30, 0x0E, 0x01, 0x80, 0x70, 0x1C, 0x03, 0x00, 0xE0, 0x3F,
  0xE7, 0xF8, 0x00, 0x40, 0xF0, 0x70, 0x18, 0x06, 0x03, 0x80, 0xC0, 0x30,
  0x0C, 0x03, 0x01, 0x80, 0xE0, 0xF0, 0x38, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x01, 0xE0, 0x38, 0x02, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0x00, 0xF0, 0x0F, 0x00,
  0xE0, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x70, 0x0E, 0x00, 0xC0,
  0x1E, 0x03, 0xC0, 0xE0, 0x38, 0x06, 0x00, 0xC0, 0x38, 0x06, 0x00, 0xC0,
  0x18, 0x07, 0x03, 0xC0, 0xF8, 0x10, 0x00, 0x7C, 0x1F, 0xFF, 0xC7, 0xF8,
  0x08,
};

const GFXglyph NotoSans_Condensed_Italic29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 7, 21, 7, 0, -21 },
  { 20, 8, 8, 10, 3, -21 },
  { 28, 15, 21, 14, 0, -21 },
  { 68, 13, 24, 13, 0, -22 },
  { 107, 16, 21, 19, 2, -21 },
  { 149, 14, 21, 15, 0, -21 },
  { 186, 4, 8, 6, 3, -21 },
  { 190, 9, 26, 8, 1, -21 },
  { 220, 9, 26, 8, -2, -21 },
  { 250, 10, 11, 12, 3, -22 },
  { 264, 12, 14, 14, 1, -17 },
  { 285, 5, 7, 6, -1, -3 },
  { 290, 6, 2, 8, 1, -9 },
  { 292, 4, 3, 6, 0, -3 },
  { 294, 13, 21, 10, -1, -21 },
  { 329, 12, 21, 13, 1, -21 },
  { 361, 8, 21, 13, 3, -21 },
  { 382, 14, 21, 13, -1, -21 },
  { 419, 13, 21, 13, 0, -21 },
  { 454, 13, 21, 13, 0, -21 },
  { 489, 13, 21, 13, 0, -21 },
  { 524, 12, 21, 13, 1, -21 },
  { 556, 13, 21, 13, 1, -21 },
  { 591, 13, 21, 13, 0, -21 },
  { 626, 12, 21, 13, 0, -21 },
  { 658, 6, 16, 6, 0, -16 },
  { 670, 7, 20, 6, -1, -16 },
  { 688, 12, 13, 14, 1, -17 },
  { 708, 12, 8, 14, 1, -14 },
  { 720, 12, 13, 14, 1, -17 },
  { 740, 10, 21, 10, 1, -21 },
  { 767, 18, 24, 19, 1, -21 },
  { 821, 13, 21, 13, -2, -21 },
  { 856, 14, 21, 14, 0, -21 },
  { 893, 14, 21, 13, 1, -21 },
  { 930, 15, 21, 15, 0, -21 },
  { 970, 13, 21, 12, 0, -21 },
  { 1005, 13, 21, 11, 0, -21 },
  { 1040, 15, 21, 16, 1, -21 },
  { 1080, 16, 21, 16, 0, -21 },
  { 1122, 11, 21, 8, -1, -21 },
  { 1151, 11, 27, 6, -4, -21 },
  { 1189, 16, 21, 13, 0, -21 },
  { 1231, 9, 21, 11, 0, -21 },
  { 1255, 21, 21, 20, 0, -21 },
  { 1311, 17, 21, 17, 0, -21 },
  { 1356, 15, 21, 16, 1, -21 },
  { 1396, 13, 21, 13, 0, -21 },
  { 1431, 15, 26, 16, 1, -21 },
  { 1480, 14, 21, 13, 0, -21 },
  { 1517, 13, 21, 12, 0, -21 },
  { 1552, 12, 21, 11, 2, -21 },
  { 1584, 15, 21, 15, 1, -21 },
  { 1624, 12, 21, 13, 3, -21 },
  { 1656, 20, 21, 21, 3, -21 },
  { 1709, 16, 21, 12, -2, -21 },
  { 1751, 11, 21, 12, 3, -21 },
  { 1780, 14, 21, 11, -1, -21 },
  { 1817, 11, 26, 8, -1, -21 },
  { 1853, 5, 21, 10, 3, -21 },
  { 1867, 11, 26, 8, -2, -21 },
  { 1903, 12, 12, 13, 1, -21 },
  { 1921, 10, 2, 10, -3, 2 },
  { 1924, 4, 4, 7, 4, -22 },
  { 1926, 12, 16, 14, 1, -16 },
  { 1950, 13, 22, 14, 0, -22 },
  { 1986, 10, 16, 10, 1, -16 },
  { 2006, 14, 22, 14, 1, -22 },
  { 2045, 10, 16, 12, 1, -16 },
  { 2065, 14, 29, 7, -3, -22 },
  { 2116, 13, 23, 14, 0, -16 },
  { 2154, 12, 22, 13, 0, -22 },
  { 2187, 7, 21, 6, 0, -21 },
  { 2206, 11, 28, 6, -4, -21 },
  { 2245, 13, 22, 12, 0, -22 },
  { 2281, 7, 22, 6, 0, -22 },
  { 2301, 19, 16, 20, 0, -16 },
  { 2339, 12, 16, 13, 0, -16 },
  { 2363, 11, 16, 13, 1, -16 },
  { 2385, 14, 23, 14, -1, -16 },
  { 2426, 12, 23, 14, 1, -16 },
  { 2461, 10, 16, 9, 0, -16 },
  { 2481, 10, 16, 10, 0, -16 },
  { 2501, 8, 19, 8, 1, -19 },
  { 2520, 12, 16, 13, 1, -16 },
  { 2544, 10, 16, 11, 2, -16 },
  { 2564, 17, 16, 17, 2, -16 },
  { 2598, 13, 16, 11, -1, -16 },
  { 2624, 15, 23, 11, -3, -16 },
  { 2668, 11, 16, 10, -1, -16 },
  { 2690, 10, 26, 10, 1, -21 },
  { 2723, 2, 29, 12, 5, -22 },
  { 2731, 11, 26, 10, -2, -21 },
  { 2767, 12, 4, 14, 1, -12 },
};

const GFXfont NotoSans_Condensed_Italic29pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Italic29pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Italic29pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _NOTOSANS_CONDENSED_ITALIC29PT7B_H_
