#ifndef _NOTOSANS_CONDENSED_ITALIC57PT7B_H_
#define _NOTOSANS_CONDENSED_ITALIC57PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Italic.ttf
// Size: 57pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Italic57pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8,
  0x00, 0x80, 0x00, 0x3E, 0x1F, 0x3E, 0x1F, 0x3E, 0x1F, 0x3C, 0x1E, 0x7C,
  0x3E, 0x7C, 0x3E, 0x78, 0x3C, 0x78, 0x3C, 0x78, 0x3C, 0x78, 0x3C, 0xF0,
  0x78, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0x70, 0xE0, 0x70, 0x00, 0x07, 0x81,
  0xC0, 0x00, 0x70, 0x1C, 0x00, 0x07, 0x03, 0xC0, 0x00, 0xF0, 0x3C, 0x00,
  0x0F, 0x03, 0x80, 0x00, 0xE0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0,
  0x70, 0x00, 0x1C, 0x0F, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x3C, 0x0E, 0x00,
  0x03, 0x81, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x00, 0xF0, 0x3C, 0x00, 0x0F, 0x03, 0x80,
  0x00, 0xE0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0x70, 0x00, 0x1C,
  0x0F, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x3C, 0x0E, 0x00, 0x03, 0x81, 0xE0,
  0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0x00, 0xF0, 0x3C, 0x00, 0x0F, 0x03, 0x80, 0x00, 0xE0, 0x78,
  0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0x70, 0x00, 0x1C, 0x0F, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x3C, 0x0E, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x38, 0x1E,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFE,
  0x03, 0xE3, 0x06, 0x07, 0xC7, 0x00, 0x07, 0x87, 0x00, 0x07, 0x87, 0x00,
  0x0F, 0x86, 0x00, 0x0F, 0x86, 0x00, 0x0F, 0x8E, 0x00, 0x07, 0x8E, 0x00,
  0x07, 0xCE, 0x00, 0x07, 0xEC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x3B, 0xE0, 0x00, 0x39, 0xF0, 0x00, 0x31, 0xF0, 0x00, 0x30, 0xF0,
  0x00, 0x70, 0xF0, 0x00, 0x70, 0xF0, 0x00, 0x70, 0xF0, 0x00, 0x60, 0xF0,
  0x00, 0xE1, 0xF0, 0x80, 0xE3, 0xE0, 0xF0, 0xE7, 0xE0, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x3C, 0x01, 0xFE, 0x00, 0x1E, 0x01,
  0xFF, 0x80, 0x1E, 0x01, 0xF3, 0xC0, 0x0E, 0x00, 0xF1, 0xE0, 0x0F, 0x00,
  0xF0, 0x70, 0x0F, 0x00, 0x70, 0x38, 0x07, 0x80, 0x78, 0x1C, 0x07, 0x80,
  0x3C, 0x0E, 0x03, 0xC0, 0x1C, 0x07, 0x03, 0xC0, 0x1E, 0x07, 0x81, 0xC0,
  0x0F, 0x03, 0xC1, 0xE0, 0x07, 0x81, 0xE1, 0xE0, 0x03, 0x80, 0xF0, 0xF0,
  0x01, 0xC0, 0x70, 0xF0, 0x01, 0xE0, 0x78, 0x70, 0x00, 0xF0, 0x3C, 0x78,
  0x7C, 0x78, 0x1C, 0x78, 0x7F, 0x3C, 0x1E, 0x3C, 0x7F, 0xDE, 0x0F, 0x3C,
  0x7F, 0xEF, 0x0F, 0x1E, 0x78, 0x7B, 0xCF, 0x1E, 0x38, 0x3D, 0xFF, 0x9E,
  0x3C, 0x1E, 0x7F, 0x8F, 0x1C, 0x0F, 0x1F, 0x8F, 0x1E, 0x07, 0x80, 0x07,
  0x8F, 0x03, 0xC0, 0x07, 0x87, 0x81, 0xE0, 0x03, 0x87, 0x80, 0xE0, 0x03,
  0xC3, 0xC0, 0xF0, 0x03, 0xC1, 0xE0, 0x78, 0x01, 0xE0, 0xF0, 0x3C, 0x01,
  0xE0, 0x78, 0x1E, 0x00, 0xF0, 0x38, 0x1E, 0x00, 0xF0, 0x1C, 0x0F, 0x00,
  0xF0, 0x0E, 0x07, 0x80, 0x78, 0x07, 0x07, 0x80, 0x78, 0x03, 0xC3, 0xC0,
  0x3C, 0x01, 0xE3, 0xC0, 0x3C, 0x00, 0xFF, 0xC0, 0x3C, 0x00, 0x3F, 0xC0,
  0x1E, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xF7, 0xE0, 0x00,
  0x7C, 0x1E, 0x00, 0x07, 0x81, 0xE0, 0x00, 0xF8, 0x1E, 0x00, 0x0F, 0x81,
  0xE0, 0x00, 0xF0, 0x1E, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0xF0, 0x3E, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0xF0, 0x7C, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0xF9,
  0xF0, 0x00, 0x07, 0xBF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xF0, 0x01, 0x07, 0xDF, 0x01, 0xE0, 0xF8, 0xF8, 0x3E, 0x1F, 0x0F, 0x83,
  0xE3, 0xE0, 0x7C, 0x3C, 0x3E, 0x07, 0xC7, 0xC7, 0xC0, 0x3E, 0x78, 0x7C,
  0x03, 0xEF, 0x87, 0x80, 0x3F, 0xF0, 0xF8, 0x01, 0xFF, 0x0F, 0x80, 0x1F,
  0xE0, 0xF8, 0x00, 0xFC, 0x0F, 0x80, 0x0F, 0xC0, 0xF8, 0x01, 0xFC, 0x0F,
  0xC0, 0x3F, 0xC0, 0x7C, 0x07, 0xFE, 0x07, 0xFF, 0xFB, 0xE0, 0x3F, 0xFF,
  0x1F, 0x01, 0xFF, 0xE1, 0xF0, 0x0F, 0xF8, 0x1F, 0x80, 0x18, 0x00, 0x00,
  0x3E, 0x7C, 0xF9, 0xE3, 0xCF, 0x9F, 0x3C, 0x78, 0xF1, 0xE7, 0x8F, 0x1E,
  0x38, 0x00, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C,
  0x00, 0x1E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00,
  0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00,
  0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0,
  0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x00, 0x00, 0x40, 0x00, 0x07, 0xC0, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x04, 0x07, 0x00, 0x70, 0x70, 0x0F,
  0xCF, 0x00, 0xFF, 0xF0, 0x6F, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x1F, 0xFE,
  0x03, 0xF0, 0x10, 0x7F, 0x00, 0x0F, 0x78, 0x01, 0xF3, 0xC0, 0x3E, 0x3C,
  0x07, 0xC3, 0xE0, 0x3C, 0x1E, 0x01, 0x81, 0xF0, 0x10, 0x1E, 0x00, 0x01,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xE0, 0xF8, 0x1F, 0x07,
  0xC0, 0xF8, 0x1E, 0x07, 0xC0, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x3C, 0x0F,
  0x80, 0x7F, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x19, 0xFF,
  0xFF, 0xFF, 0xFF, 0x88, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x1F,
  0x8F, 0xC0, 0x7E, 0x0F, 0x80, 0xF8, 0x0F, 0x03, 0xE0, 0x1F, 0x07, 0xC0,
  0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x03,
  0xE3, 0xC0, 0x07, 0xCF, 0x80, 0x0F, 0x1F, 0x00, 0x1E, 0x3E, 0x00, 0x3C,
  0x78, 0x00, 0xF9, 0xF0, 0x01, 0xF3, 0xE0, 0x03, 0xE7, 0xC0, 0x07, 0xCF,
  0x00, 0x0F, 0x9E, 0x00, 0x1E, 0x7C, 0x00, 0x7C, 0xF8, 0x00, 0xF9, 0xF0,
  0x01, 0xF3, 0xE0, 0x03, 0xC7, 0xC0, 0x0F, 0x8F, 0x00, 0x1F, 0x1E, 0x00,
  0x3C, 0x3C, 0x00, 0xF8, 0x78, 0x01, 0xF0, 0xF0, 0x07, 0xC1, 0xF0, 0x0F,
  0x83, 0xE0, 0x3E, 0x07, 0xC0, 0xFC, 0x07, 0xC3, 0xF0, 0x0F, 0xFF, 0xC0,
  0x1F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0xF8, 0x03, 0xF0, 0x1F, 0xE0, 0x7F, 0xC1, 0xFF, 0x87,
  0xFE, 0x3F, 0xBC, 0xFC, 0xF9, 0xF1, 0xF1, 0xC3, 0xE3, 0x07, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1E, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF, 0x80,
  0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0xF8, 0x1F, 0x80, 0x1C, 0x03,
  0xE0, 0x04, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0x03, 0xF0, 0x06,
  0x00, 0xF8, 0x02, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x10, 0x00, 0x7C, 0x0C,
  0x00, 0xFE, 0x07, 0xF7, 0xFE, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xBC, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0xF3, 0xC0, 0x00, 0x79, 0xF0, 0x00, 0x1E, 0x78, 0x00, 0x0F,
  0x1E, 0x00, 0x07, 0x87, 0x80, 0x01, 0xE3, 0xE0, 0x00, 0xF0, 0xF8, 0x00,
  0x78, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x07, 0xC0, 0x07, 0x81, 0xF0,
  0x03, 0xE0, 0x7C, 0x00, 0xF0, 0x1E, 0x00, 0x78, 0x07, 0x80, 0x3E, 0x03,
  0xE0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x3E, 0x03, 0xE0, 0x0F, 0x00, 0xF0,
  0x03, 0xC0, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF0, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00,
  0x20, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x10, 0x00,
  0x7C, 0x0E, 0x00, 0xFE, 0x07, 0xF7, 0xFE, 0x03, 0xFF, 0xFE, 0x01, 0xFF,
  0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x0E, 0x00, 0x3E, 0x7F, 0xC0,
  0x3E, 0xFF, 0xE0, 0x3D, 0xFF, 0xE0, 0x7F, 0xE7, 0xF0, 0x7F, 0x81, 0xF0,
  0x7E, 0x01, 0xF8, 0x7E, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0xFC, 0x00, 0xF8,
  0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF0,
  0xF8, 0x00, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xE0,
  0xF8, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x0F, 0x80,
  0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xF0, 0x3F, 0x03, 0xE0, 0x1F,
  0x03, 0xE0, 0x1F, 0x07, 0xC0, 0x0F, 0x07, 0xC0, 0x0F, 0x07, 0xC0, 0x0F,
  0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1E, 0x03, 0xC0, 0x3E,
  0x03, 0xE0, 0x7C, 0x03, 0xE0, 0xF8, 0x01, 0xF1, 0xF0, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80,
  0x0F, 0xE7, 0xC0, 0x1F, 0x83, 0xE0, 0x3F, 0x03, 0xF0, 0x7E, 0x01, 0xF0,
  0x7C, 0x00, 0xF0, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF0, 0x00, 0xF8,
  0xF0, 0x00, 0xF8, 0xF0, 0x00, 0xF8, 0xF0, 0x00, 0xF8, 0xF0, 0x00, 0xF0,
  0xF8, 0x01, 0xF0, 0xF8, 0x03, 0xF0, 0xFC, 0x07, 0xE0, 0x7F, 0x9F, 0xC0,
  0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0,
  0x3F, 0x07, 0xC0, 0x7C, 0x07, 0xC1, 0xF0, 0x0F, 0x83, 0xE0, 0x0F, 0x0F,
  0x80, 0x1E, 0x1F, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0xF8, 0x00, 0xF1, 0xF0,
  0x01, 0xE3, 0xE0, 0x03, 0xC7, 0x80, 0x0F, 0x8F, 0x00, 0x1F, 0x1E, 0x00,
  0x3E, 0x3C, 0x00, 0xFC, 0x7C, 0x01, 0xF8, 0xF8, 0x07, 0xF1, 0xF0, 0x1F,
  0xC3, 0xF8, 0xFF, 0x83, 0xFF, 0xFF, 0x03, 0xFF, 0xBE, 0x07, 0xFC, 0x78,
  0x03, 0xE0, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x1F, 0xFF,
  0x80, 0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xE0, 0x3F, 0x03, 0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x03, 0xC0, 0x7E, 0x07, 0xE0, 0xFE, 0x0F, 0xC0, 0x78, 0x02,
  0x00, 0x00, 0x1C, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0x80, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F,
  0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x78, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x01, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF,
  0xE0, 0xE0, 0x7E, 0x10, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xF8, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFC, 0xFF,
  0x00, 0x01, 0xF8, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x07, 0x80, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x78,
  0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x1F, 0x80, 0xF0,
  0xF0, 0x0F, 0xFE, 0x1E, 0x1E, 0x03, 0xFF, 0x83, 0xC7, 0x80, 0xF9, 0xF0,
  0x78, 0xF0, 0x3C, 0x1E, 0x0F, 0x3C, 0x0F, 0x03, 0xC1, 0xE7, 0x81, 0xE0,
  0x70, 0x3C, 0xE0, 0x78, 0x1E, 0x07, 0xBC, 0x0E, 0x03, 0xC0, 0xF7, 0x83,
  0xC0, 0x78, 0x1C, 0xF0, 0x78, 0x0E, 0x03, 0x9C, 0x0E, 0x03, 0xC0, 0xF3,
  0x83, 0xC0, 0x78, 0x1E, 0xF0, 0x78, 0x0F, 0x03, 0x9E, 0x0F, 0x03, 0xC0,
  0xF3, 0xC1, 0xE0, 0x78, 0x1E, 0x78, 0x3C, 0x0F, 0x03, 0x8F, 0x07, 0x83,
  0xE0, 0xF1, 0xC0, 0xF0, 0xFC, 0x3C, 0x38, 0x1E, 0x1B, 0x87, 0x07, 0x03,
  0xFF, 0x7F, 0xE0, 0xF0, 0x3F, 0xCF, 0xF8, 0x1E, 0x07, 0xF0, 0xFE, 0x03,
  0xC0, 0x18, 0x02, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x01, 0x80, 0x00, 0x3F,
  0xC3, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0x78, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x79, 0xE0, 0x00, 0x3E, 0x78, 0x00, 0x0F, 0x1E, 0x00, 0x07, 0xC7, 0x80,
  0x01, 0xE1, 0xE0, 0x00, 0xF8, 0x78, 0x00, 0x3E, 0x1E, 0x00, 0x0F, 0x07,
  0x80, 0x07, 0xC1, 0xE0, 0x01, 0xE0, 0x78, 0x00, 0xF8, 0x1E, 0x00, 0x3C,
  0x07, 0x80, 0x1F, 0x01, 0xF0, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x1F, 0x00,
  0x1F, 0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x01, 0xF1, 0xF0, 0x00, 0x7C, 0x7C,
  0x00, 0x1F, 0x3F, 0x00, 0x07, 0xCF, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0x7D,
  0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0x07, 0xFC,
  0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xE0,
  0x07, 0xE0, 0x7C, 0x00, 0xFC, 0x0F, 0x80, 0x1F, 0x01, 0xF0, 0x03, 0xE0,
  0x3C, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x81, 0xF0, 0x03, 0xE0, 0x3E, 0x00,
  0xFC, 0x07, 0xC0, 0x3F, 0x00, 0xF0, 0x1F, 0xC0, 0x3F, 0xFF, 0xE0, 0x07,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xC0, 0x3F,
  0x00, 0xF8, 0x03, 0xF0, 0x1F, 0x00, 0x3E, 0x03, 0xE0, 0x07, 0xC0, 0x7C,
  0x00, 0xF8, 0x0F, 0x00, 0x0F, 0x03, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x7C,
  0x0F, 0x80, 0x0F, 0x81, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x7E, 0x0F, 0x80,
  0x0F, 0x81, 0xF0, 0x03, 0xF0, 0x3E, 0x00, 0xFC, 0x07, 0x80, 0x7F, 0x81,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xFC,
  0x01, 0xFF, 0xFE, 0x00, 0xFE, 0x03, 0x80, 0x7E, 0x00, 0x40, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0xC0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x08, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x80, 0x1F, 0x01, 0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x1F, 0x00, 0x7E, 0x01,
  0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x3E, 0x03, 0xE0, 0x01, 0xF0, 0x3E, 0x00,
  0x1F, 0x03, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0,
  0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x78, 0x00, 0x1F, 0x0F, 0x80,
  0x03, 0xF0, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x3E,
  0x0F, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x7E, 0x1F, 0x00, 0x07, 0xC1, 0xF0,
  0x00, 0x7C, 0x1E, 0x00, 0x0F, 0xC1, 0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x0F,
  0x83, 0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x3F, 0x03, 0xC0, 0x03, 0xE0, 0x7C,
  0x00, 0x7E, 0x07, 0xC0, 0x0F, 0xC0, 0x7C, 0x01, 0xF8, 0x07, 0xC0, 0x7F,
  0x00, 0x78, 0x3F, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0x80, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0x80, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xF0, 0x1F, 0x00, 0xFE, 0x00, 0x30, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x1F, 0xFC, 0x7C, 0x00, 0xFF, 0xE3, 0xE0, 0x07, 0xFE,
  0x1F, 0x00, 0x7F, 0xF0, 0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7C, 0x3E,
  0x00, 0x03, 0xC1, 0xF0, 0x00, 0x1E, 0x0F, 0x80, 0x01, 0xF0, 0x7C, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x3E,
  0x07, 0xE0, 0x01, 0xF0, 0x1F, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x7C, 0x03,
  0xF8, 0x03, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x3E, 0x01, 0xF0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0xF0, 0x07, 0x80,
  0x03, 0xE0, 0x1F, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x0F, 0x80, 0x7C, 0x00,
  0x1F, 0x00, 0xF8, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0xF8, 0x07, 0xC0, 0x01,
  0xF0, 0x0F, 0x80, 0x03, 0xE0, 0x1F, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x0F,
  0x00, 0x78, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0xF8,
  0x07, 0xC0, 0x01, 0xE0, 0x0F, 0x00, 0x07, 0xC0, 0x3F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x03,
  0xC0, 0x01, 0xF0, 0x0F, 0x80, 0x03, 0xE0, 0x1F, 0x00, 0x07, 0xC0, 0x3E,
  0x00, 0x0F, 0x80, 0x78, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x7C, 0x03, 0xE0,
  0x00, 0xF8, 0x07, 0xC0, 0x01, 0xF0, 0x0F, 0x80, 0x03, 0xC0, 0x1E, 0x00,
  0x0F, 0x80, 0x3C, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x3E, 0x01, 0xF0, 0x00,
  0x7C, 0x03, 0xE0, 0x00, 0xF0, 0x07, 0x80, 0x03, 0xE0, 0x1F, 0x00, 0x07,
  0xC0, 0x3E, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x3C,
  0x00, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x0F, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0xC0,
  0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x31, 0xF8, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0xFC, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00,
  0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x07, 0xC0, 0x3E, 0x00, 0x1F,
  0x01, 0xF8, 0x00, 0x7C, 0x07, 0xC0, 0x01, 0xE0, 0x3E, 0x00, 0x0F, 0x81,
  0xF0, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0xF8, 0x7E, 0x00, 0x03, 0xC1, 0xF0,
  0x00, 0x1F, 0x0F, 0x80, 0x00, 0x7C, 0x7E, 0x00, 0x01, 0xF3, 0xF0, 0x00,
  0x07, 0xCF, 0x80, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x07, 0xF3, 0xE0, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0x7C, 0x3E,
  0x00, 0x01, 0xE0, 0xF8, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x3E, 0x07, 0xC0,
  0x00, 0xF8, 0x1F, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x0F, 0x00, 0xF8, 0x00,
  0x7C, 0x03, 0xE0, 0x01, 0xF0, 0x0F, 0x80, 0x07, 0xC0, 0x1F, 0x00, 0x1F,
  0x00, 0x7C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x0F, 0x80, 0x3E, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x03,
  0xFE, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x03,
  0xFE, 0x00, 0x07, 0xBC, 0x03, 0xDF, 0x00, 0x0F, 0xFC, 0x03, 0xDF, 0x00,
  0x0F, 0x7C, 0x03, 0xDF, 0x00, 0x1F, 0x7C, 0x07, 0xCF, 0x00, 0x1E, 0x78,
  0x07, 0xCF, 0x00, 0x3E, 0xF8, 0x07, 0xCF, 0x00, 0x3C, 0xF8, 0x07, 0x8F,
  0x00, 0x7C, 0xF8, 0x07, 0x8F, 0x00, 0x78, 0xF0, 0x0F, 0x8F, 0x00, 0xF8,
  0xF0, 0x0F, 0x8F, 0x00, 0xF1, 0xF0, 0x0F, 0x8F, 0x01, 0xF1, 0xF0, 0x0F,
  0x0F, 0x01, 0xE1, 0xF0, 0x0F, 0x0F, 0x03, 0xE1, 0xE0, 0x1F, 0x0F, 0x03,
  0xC1, 0xE0, 0x1F, 0x0F, 0x07, 0xC3, 0xE0, 0x1E, 0x0F, 0x07, 0x83, 0xE0,
  0x1E, 0x0F, 0x8F, 0x83, 0xE0, 0x1E, 0x0F, 0x8F, 0x03, 0xC0, 0x3E, 0x07,
  0x9F, 0x07, 0xC0, 0x3E, 0x07, 0x9E, 0x07, 0xC0, 0x3C, 0x07, 0x9E, 0x07,
  0xC0, 0x3C, 0x07, 0xBC, 0x07, 0xC0, 0x7C, 0x07, 0xBC, 0x07, 0x80, 0x7C,
  0x07, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xF8, 0x0F, 0x80, 0x78, 0x07, 0xF0,
  0x0F, 0x80, 0x78, 0x07, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xE0, 0x0F, 0x00,
  0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x07, 0x80,
  0x3F, 0x00, 0x03, 0xC0, 0x1F, 0x80, 0x03, 0xE0, 0x1F, 0xE0, 0x01, 0xF0,
  0x0F, 0xF0, 0x00, 0xF0, 0x07, 0xF8, 0x00, 0x78, 0x03, 0xFC, 0x00, 0x7C,
  0x01, 0xFF, 0x00, 0x3E, 0x01, 0xFF, 0x80, 0x1F, 0x00, 0xF3, 0xC0, 0x0F,
  0x00, 0x79, 0xE0, 0x07, 0x80, 0x3C, 0xF0, 0x07, 0xC0, 0x3E, 0x7C, 0x03,
  0xE0, 0x1F, 0x1E, 0x01, 0xF0, 0x0F, 0x8F, 0x00, 0xF0, 0x07, 0x87, 0x80,
  0x78, 0x03, 0xC3, 0xE0, 0x7C, 0x03, 0xE1, 0xF0, 0x3E, 0x01, 0xF0, 0x78,
  0x1E, 0x00, 0xF8, 0x3C, 0x0F, 0x00, 0x78, 0x1F, 0x07, 0x80, 0x3C, 0x0F,
  0x87, 0xC0, 0x3E, 0x03, 0xC3, 0xE0, 0x1F, 0x01, 0xE1, 0xE0, 0x0F, 0x00,
  0xF0, 0xF0, 0x07, 0x80, 0x7C, 0xF8, 0x03, 0xC0, 0x1E, 0x7C, 0x03, 0xE0,
  0x0F, 0x3E, 0x01, 0xF0, 0x07, 0x9E, 0x00, 0xF0, 0x03, 0xEF, 0x00, 0x78,
  0x01, 0xF7, 0x80, 0x7C, 0x00, 0x7F, 0xC0, 0x3E, 0x00, 0x3F, 0xE0, 0x1F,
  0x00, 0x1F, 0xE0, 0x0F, 0x00, 0x0F, 0xF0, 0x07, 0x80, 0x03, 0xF8, 0x07,
  0xC0, 0x01, 0xFC, 0x03, 0xE0, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x7E, 0x00,
  0xF0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x01, 0xFC, 0x0F, 0xC0, 0x1F,
  0x80, 0x7E, 0x03, 0xF0, 0x03, 0xE0, 0x7E, 0x00, 0x3E, 0x07, 0xC0, 0x01,
  0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF1, 0xF0, 0x00, 0x1F, 0x1F,
  0x00, 0x01, 0xF3, 0xE0, 0x00, 0x1F, 0x3E, 0x00, 0x01, 0xF3, 0xE0, 0x00,
  0x1F, 0x7C, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x01, 0xF7,
  0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x7C,
  0xF8, 0x00, 0x07, 0xCF, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x8F, 0x80,
  0x00, 0xF8, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xF0, 0xF8, 0x00, 0x3E,
  0x0F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x07, 0xC0, 0x1F, 0x80, 0x7F,
  0x03, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x01, 0xF1, 0xFF,
  0x00, 0x7C, 0x07, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xE0,
  0x0F, 0x80, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x78, 0x0F, 0x80, 0x1E, 0x03,
  0xC0, 0x0F, 0x81, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x1F, 0x00, 0x3E,
  0x07, 0xC0, 0x1F, 0x01, 0xE0, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0x3E, 0x03,
  0xF8, 0x0F, 0x83, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC,
  0x01, 0xFC, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x03, 0xE0, 0x7E,
  0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x01,
  0xF1, 0xF0, 0x00, 0x1F, 0x1F, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x1F, 0x3E,
  0x00, 0x01, 0xF3, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x01, 0xF7, 0xC0, 0x00,
  0x1F, 0x7C, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00,
  0x07, 0xCF, 0x80, 0x00, 0x7C, 0xF8, 0x00, 0x07, 0xCF, 0x80, 0x00, 0xF8,
  0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x1F, 0x0F, 0x80,
  0x03, 0xF0, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0xFC,
  0x07, 0xC0, 0x1F, 0x80, 0x7F, 0x03, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x01, 0xF1,
  0xFF, 0x00, 0x7C, 0x07, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xE0, 0x0F, 0xC0, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x7C, 0x0F, 0x80, 0x1F,
  0x03, 0xC0, 0x0F, 0x81, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x1F, 0x00,
  0x3E, 0x07, 0xC0, 0x1F, 0x01, 0xE0, 0x0F, 0xC0, 0xF8, 0x07, 0xE0, 0x3E,
  0x07, 0xF0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00,
  0x7F, 0xFE, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC1, 0xE0, 0x01, 0xE0, 0x7C,
  0x00, 0x78, 0x1F, 0x00, 0x3E, 0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x03, 0xE0,
  0x3E, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x1F, 0x01, 0xF0, 0x07, 0xC0, 0x78, 0x01, 0xF0, 0x3E, 0x00, 0x7C,
  0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x00, 0xFE, 0x07, 0x80, 0x7E, 0x00, 0x60, 0x1F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x81, 0x00, 0x0F, 0xC0, 0x70, 0x0F, 0xF0, 0x1F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF8, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0xF8, 0x1E, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x03, 0xE0,
  0x7C, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0xF8, 0x1E, 0x00, 0x07, 0x81, 0xF0,
  0x00, 0x7C, 0x0F, 0x80, 0x03, 0xE0, 0x7C, 0x00, 0x1F, 0x03, 0xE0, 0x00,
  0xF0, 0x1E, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x03, 0xE0,
  0x7C, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0xF0, 0x1E, 0x00, 0x0F, 0x81, 0xF0,
  0x00, 0x7C, 0x0F, 0x80, 0x03, 0xE0, 0x7C, 0x00, 0x1F, 0x03, 0xC0, 0x00,
  0xF0, 0x3E, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x03, 0xE0,
  0x7C, 0x00, 0x1E, 0x03, 0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x0F, 0x81, 0xF0,
  0x00, 0x7C, 0x0F, 0x80, 0x03, 0xE0, 0x7C, 0x00, 0x1E, 0x03, 0xC0, 0x01,
  0xF0, 0x1E, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x78, 0x07, 0xC0, 0x07, 0xC0,
  0x3E, 0x00, 0x7E, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x7E, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xEF, 0x80, 0x03, 0xE7, 0xC0, 0x01,
  0xF3, 0xE0, 0x00, 0xF9, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x7C, 0x7C, 0x00,
  0x7C, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x07, 0xC0,
  0x1F, 0x01, 0xE0, 0x0F, 0x80, 0xF0, 0x07, 0x80, 0x78, 0x07, 0xC0, 0x3C,
  0x03, 0xE0, 0x1E, 0x03, 0xE0, 0x0F, 0x01, 0xF0, 0x07, 0x81, 0xF0, 0x03,
  0xC0, 0xF8, 0x01, 0xE0, 0xF8, 0x00, 0xF0, 0x7C, 0x00, 0x78, 0x3C, 0x00,
  0x3C, 0x3E, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x1F, 0x00, 0x07, 0x8F, 0x80,
  0x03, 0xCF, 0x80, 0x01, 0xE7, 0xC0, 0x00, 0xF3, 0xC0, 0x00, 0x7B, 0xE0,
  0x00, 0x3D, 0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0xF8, 0x00, 0x3E, 0x00,
  0x1F, 0xF8, 0x00, 0x7E, 0x00, 0x1E, 0xF8, 0x00, 0x7E, 0x00, 0x3E, 0xF8,
  0x00, 0xFE, 0x00, 0x3E, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0xF8, 0x01, 0xFC,
  0x00, 0x7C, 0xF8, 0x01, 0xFC, 0x00, 0x78, 0xF8, 0x01, 0xFC, 0x00, 0xF8,
  0xF8, 0x03, 0xDC, 0x00, 0xF8, 0xF8, 0x03, 0xDC, 0x01, 0xF0, 0xF8, 0x07,
  0xDC, 0x01, 0xF0, 0xF8, 0x07, 0x9C, 0x03, 0xE0, 0xF8, 0x07, 0xBC, 0x03,
  0xE0, 0xF8, 0x0F, 0x3C, 0x03, 0xC0, 0xF8, 0x0F, 0x3C, 0x07, 0xC0, 0xF8,
  0x1E, 0x3C, 0x07, 0xC0, 0xF8, 0x1E, 0x3C, 0x0F, 0x80, 0xF8, 0x1E, 0x3C,
  0x0F, 0x80, 0xF8, 0x3C, 0x3C, 0x0F, 0x00, 0xF8, 0x3C, 0x3C, 0x1F, 0x00,
  0xF8, 0x78, 0x3C, 0x1F, 0x00, 0xF8, 0x78, 0x3C, 0x3E, 0x00, 0xF8, 0xF8,
  0x3C, 0x3E, 0x00, 0xF8, 0xF0, 0x3C, 0x3C, 0x00, 0xF8, 0xF0, 0x3C, 0x7C,
  0x00, 0xF9, 0xE0, 0x3C, 0x7C, 0x00, 0xF9, 0xE0, 0x3C, 0x78, 0x00, 0xFB,
  0xE0, 0x3C, 0xF8, 0x00, 0xFB, 0xC0, 0x3C, 0xF0, 0x00, 0xF3, 0xC0, 0x3D,
  0xF0, 0x00, 0xF7, 0x80, 0x3D, 0xE0, 0x00, 0xF7, 0x80, 0x3D, 0xE0, 0x00,
  0xF7, 0x80, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x00, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x1F, 0x00,
  0x07, 0xC0, 0x3E, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x0F, 0x01, 0xF0, 0x00,
  0x1F, 0x07, 0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00,
  0x78, 0xF8, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x01, 0xF7, 0xC0,
  0x00, 0x07, 0xC7, 0x80, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x3E, 0x1F, 0x00,
  0x00, 0xF8, 0x3E, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xC0, 0xF8, 0x00,
  0x1F, 0x00, 0xF0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0xF8, 0x03, 0xE0, 0x01,
  0xF0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x0F, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x07, 0xC7, 0x80, 0x1F, 0x8F, 0x00, 0x3E,
  0x1F, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x80,
  0xF0, 0x3E, 0x01, 0xE0, 0x7C, 0x03, 0xC1, 0xF0, 0x07, 0x83, 0xC0, 0x0F,
  0x8F, 0x80, 0x1F, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x3D, 0xF0, 0x00, 0x7B,
  0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x00, 0xF0, 0x3C, 0x0F, 0x03, 0xE0, 0xF8, 0x1E,
  0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xF0, 0x7C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xE0, 0xF8, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E,
  0x07, 0x81, 0xF0, 0x7C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xE0,
  0xF8, 0x3E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0xC0, 0x00, 0x1F, 0xFC,
  0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x7B, 0xC0,
  0x00, 0x7B, 0xC0, 0x00, 0xF1, 0xE0, 0x00, 0xF1, 0xE0, 0x01, 0xE1, 0xE0,
  0x01, 0xE0, 0xF0, 0x03, 0xC0, 0xF0, 0x07, 0xC0, 0xF8, 0x07, 0x80, 0x78,
  0x0F, 0x80, 0x78, 0x0F, 0x00, 0x7C, 0x1F, 0x00, 0x3C, 0x1E, 0x00, 0x3C,
  0x3C, 0x00, 0x3E, 0x3C, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0xF8, 0x00, 0x1F,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0xFC, 0x3E, 0x1F, 0x07,
  0x83, 0xE0, 0xF0, 0x7C, 0x1E, 0x07, 0x80, 0x00, 0x3F, 0x0F, 0x00, 0xFF,
  0x8F, 0x01, 0xFF, 0xCF, 0x03, 0xFF, 0xDF, 0x07, 0xE1, 0xFE, 0x0F, 0xC0,
  0xFE, 0x0F, 0x80, 0x7E, 0x1F, 0x00, 0x7E, 0x1F, 0x00, 0x7E, 0x3E, 0x00,
  0x7C, 0x3E, 0x00, 0x7C, 0x3C, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00,
  0x78, 0x7C, 0x00, 0x78, 0x78, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00,
  0xF8, 0xF8, 0x00, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x01,
  0xF0, 0xF8, 0x03, 0xF0, 0xF8, 0x07, 0xE0, 0xF8, 0x07, 0xE0, 0xF8, 0x0F,
  0xE0, 0xFC, 0x1F, 0xE0, 0x7E, 0x7B, 0xC0, 0x7F, 0xFB, 0xC0, 0x3F, 0xF3,
  0xC0, 0x1F, 0xC3, 0xC0, 0x07, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x1F, 0x80,
  0x0F, 0x1F, 0xE0, 0x0F, 0xBF, 0xF8, 0x07, 0xDF, 0xFE, 0x03, 0xDC, 0x1F,
  0x01, 0xFC, 0x0F, 0xC0, 0xFC, 0x03, 0xE0, 0xFC, 0x01, 0xF0, 0x7E, 0x00,
  0xF8, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x0F, 0x80,
  0x0F, 0x87, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xC1, 0xE0, 0x03, 0xE0, 0xF0,
  0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x78, 0x3E, 0x00, 0x7C, 0x1E,
  0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x83,
  0xF0, 0x0F, 0x81, 0xF8, 0x0F, 0xC1, 0xFC, 0x0F, 0xC0, 0xF7, 0xDF, 0xC0,
  0x7B, 0xFF, 0xC0, 0x3C, 0xFF, 0xC0, 0x3C, 0x3F, 0xC0, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x07,
  0xE0, 0x40, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x06, 0x07, 0xF3, 0xE0, 0x3F,
  0xFE, 0x03, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x08, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0x80, 0x03, 0xF0, 0xF0, 0x01, 0xFF, 0x3E, 0x00, 0x7F, 0xF7, 0xC0,
  0x1F, 0xFE, 0xF8, 0x07, 0xE0, 0xFE, 0x01, 0xF8, 0x0F, 0xC0, 0x3E, 0x01,
  0xF8, 0x0F, 0x80, 0x3F, 0x01, 0xF0, 0x07, 0xC0, 0x7C, 0x00, 0xF8, 0x0F,
  0x80, 0x1F, 0x01, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x0F,
  0x01, 0xF0, 0x01, 0xE0, 0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x81, 0xF0,
  0x01, 0xF0, 0x3E, 0x00, 0x3C, 0x07, 0xC0, 0x0F, 0x80, 0xF8, 0x01, 0xF0,
  0x1F, 0x00, 0x7E, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x03, 0xF0, 0x0F, 0x80,
  0x7E, 0x01, 0xF0, 0x1F, 0xC0, 0x3F, 0x07, 0xF8, 0x03, 0xF3, 0xDE, 0x00,
  0x7F, 0xF3, 0xC0, 0x07, 0xFC, 0x78, 0x00, 0x7F, 0x0F, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0x00, 0x7F, 0xFC, 0x07, 0xFF,
  0xE0, 0x7E, 0x1F, 0x07, 0xC0, 0x7C, 0x3E, 0x03, 0xE3, 0xE0, 0x1F, 0x1E,
  0x00, 0xF1, 0xF0, 0x07, 0x8F, 0x00, 0x7C, 0xF8, 0x07, 0xC7, 0xC0, 0x7E,
  0x3C, 0x3F, 0xE3, 0xFF, 0xFE, 0x1F, 0xFF, 0xC0, 0xFF, 0xF0, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x40, 0xFE, 0x3E, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xF8, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7E, 0x60, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x08, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x0F, 0xC3, 0xC0, 0x0F, 0xF8, 0xF0, 0x07, 0xFF, 0x3C, 0x03,
  0xFF, 0xDF, 0x01, 0xF8, 0x3F, 0x80, 0xFC, 0x07, 0xE0, 0x3E, 0x01, 0xF8,
  0x1F, 0x00, 0x7E, 0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x01,
  0xF0, 0x3C, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x07, 0x81, 0xF0,
  0x01, 0xE0, 0x78, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x83,
  0xE0, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x7C, 0x0F, 0x80, 0x3F,
  0x03, 0xE0, 0x0F, 0xC0, 0xF8, 0x07, 0xE0, 0x3E, 0x01, 0xF8, 0x0F, 0x80,
  0xFE, 0x03, 0xE0, 0x7F, 0x80, 0x7E, 0x7B, 0xC0, 0x1F, 0xFE, 0xF0, 0x03,
  0xFF, 0x7C, 0x00, 0x7F, 0x1F, 0x00, 0x03, 0x07, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xF0, 0x08, 0x00, 0xF8, 0x02, 0x00, 0x7E, 0x00, 0xF8,
  0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xE1, 0xF8, 0x01, 0xE7, 0xFE, 0x03, 0xEF,
  0xFE, 0x03, 0xFF, 0xFF, 0x03, 0xDC, 0x3F, 0x03, 0xF8, 0x1F, 0x03, 0xF0,
  0x1F, 0x07, 0xE0, 0x1F, 0x07, 0xE0, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0xC0,
  0x1F, 0x07, 0x80, 0x1F, 0x0F, 0x80, 0x1E, 0x0F, 0x80, 0x3E, 0x0F, 0x80,
  0x3E, 0x0F, 0x00, 0x3E, 0x0F, 0x00, 0x3C, 0x1F, 0x00, 0x3C, 0x1F, 0x00,
  0x7C, 0x1E, 0x00, 0x7C, 0x1E, 0x00, 0x7C, 0x3E, 0x00, 0x78, 0x3E, 0x00,
  0x78, 0x3E, 0x00, 0xF8, 0x3C, 0x00, 0xF8, 0x3C, 0x00, 0xF8, 0x7C, 0x00,
  0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x78, 0x01, 0xF0, 0xF8, 0x01,
  0xF0, 0x00, 0x38, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x01, 0xE0,
  0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0,
  0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xF0, 0x01, 0x3F, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80,
  0x03, 0xF8, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0xF8, 0x0F,
  0x00, 0xF8, 0x07, 0x80, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x7C, 0x01,
  0xE0, 0x7C, 0x00, 0xF0, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x7E, 0x00,
  0x3E, 0x3E, 0x00, 0x1E, 0x3E, 0x00, 0x0F, 0x3E, 0x00, 0x0F, 0xBE, 0x00,
  0x07, 0xFF, 0x00, 0x03, 0xDF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0xFE, 0xF8, 0x00, 0x7E, 0x7C, 0x00, 0x3E, 0x1E, 0x00, 0x1E, 0x0F,
  0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xC0, 0xF8, 0x03, 0xC0,
  0x7C, 0x01, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x7C,
  0x03, 0xE0, 0x3C, 0x01, 0xF0, 0x3E, 0x00, 0xFC, 0x00, 0x00, 0x3C, 0x01,
  0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80,
  0x00, 0x01, 0xE1, 0xF8, 0x0F, 0xE0, 0x0F, 0x3F, 0xE0, 0xFF, 0x80, 0x73,
  0xFF, 0x8F, 0xFE, 0x07, 0xBF, 0xFC, 0xFF, 0xF0, 0x3D, 0xC3, 0xFF, 0x0F,
  0x81, 0xFC, 0x0F, 0xE0, 0x7C, 0x0F, 0xC0, 0x7E, 0x01, 0xE0, 0xFC, 0x03,
  0xF0, 0x0F, 0x07, 0xE0, 0x1F, 0x00, 0x78, 0x3E, 0x00, 0xF8, 0x07, 0xC1,
  0xF0, 0x07, 0x80, 0x3E, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xE0,
  0x0F, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x3E, 0x00, 0xF0, 0x07, 0xC1, 0xE0,
  0x07, 0x80, 0x3E, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xE0, 0x0F,
  0x07, 0xC0, 0x1F, 0x00, 0x78, 0x3E, 0x00, 0xF0, 0x07, 0xC1, 0xE0, 0x07,
  0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xE0, 0x0F, 0x07,
  0xC0, 0x1E, 0x00, 0xF8, 0x3C, 0x00, 0xF0, 0x07, 0xC1, 0xE0, 0x0F, 0x80,
  0x3E, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0xF8, 0x03, 0xE0, 0x0F, 0x07, 0xC0,
  0x1E, 0x00, 0xF8, 0x3C, 0x00, 0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0x01, 0xE1, 0xF8, 0x01, 0xE7, 0xFE, 0x03, 0xCF, 0xFE, 0x03, 0xDF,
  0xFF, 0x03, 0xDE, 0x3F, 0x03, 0xF8, 0x1F, 0x03, 0xF0, 0x1F, 0x07, 0xE0,
  0x1F, 0x07, 0xE0, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0x80,
  0x1F, 0x0F, 0x80, 0x1E, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x00,
  0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3C, 0x1F, 0x00, 0x7C, 0x1F, 0x00,
  0x7C, 0x1E, 0x00, 0x7C, 0x3E, 0x00, 0x78, 0x3E, 0x00, 0xF8, 0x3E, 0x00,
  0xF8, 0x3C, 0x00, 0xF8, 0x3C, 0x00, 0xF8, 0x7C, 0x00, 0xF0, 0x7C, 0x01,
  0xF0, 0x7C, 0x01, 0xF0, 0x78, 0x01, 0xF0, 0xF8, 0x01, 0xE0, 0x00, 0x3F,
  0x80, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xE1, 0xF8,
  0x3F, 0x03, 0xE0, 0xF8, 0x07, 0xC7, 0xC0, 0x1F, 0x1E, 0x00, 0x7C, 0xF8,
  0x01, 0xF3, 0xE0, 0x07, 0xDF, 0x00, 0x1F, 0x7C, 0x00, 0x7D, 0xF0, 0x01,
  0xF7, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7B, 0xE0, 0x03, 0xEF,
  0x80, 0x0F, 0xBE, 0x00, 0x3E, 0xF0, 0x01, 0xF3, 0xC0, 0x07, 0xCF, 0x00,
  0x1F, 0x3E, 0x00, 0xF8, 0xF8, 0x07, 0xE3, 0xE0, 0x1F, 0x07, 0xC0, 0xF8,
  0x1F, 0xDF, 0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0x80, 0x00,
  0x60, 0x00, 0x00, 0x78, 0x7E, 0x00, 0x0F, 0x1F, 0xE0, 0x01, 0xE7, 0xFE,
  0x00, 0x79, 0xFF, 0xE0, 0x0F, 0x70, 0x7C, 0x01, 0xFC, 0x0F, 0xC0, 0x3F,
  0x00, 0xF8, 0x0F, 0xE0, 0x1F, 0x01, 0xF8, 0x03, 0xE0, 0x3E, 0x00, 0x7C,
  0x07, 0xC0, 0x0F, 0x80, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x3E, 0x07, 0xC0,
  0x07, 0xC0, 0xF8, 0x00, 0xF0, 0x1E, 0x00, 0x3E, 0x03, 0xC0, 0x07, 0xC0,
  0xF8, 0x00, 0xF8, 0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x07, 0xC0, 0x78, 0x00,
  0xF8, 0x0F, 0x00, 0x1F, 0x03, 0xE0, 0x07, 0xC0, 0x7C, 0x00, 0xF8, 0x0F,
  0xC0, 0x3E, 0x01, 0xF8, 0x0F, 0xC0, 0x7F, 0x83, 0xF0, 0x0F, 0xFD, 0xFC,
  0x01, 0xE7, 0xFF, 0x00, 0x3C, 0xFF, 0xC0, 0x07, 0x8F, 0xF0, 0x01, 0xF0,
  0x20, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x0F, 0x00, 0xFF,
  0x8F, 0x01, 0xFF, 0xCF, 0x03, 0xFF, 0xDF, 0x07, 0xE1, 0xFE, 0x0F, 0xC0,
  0xFE, 0x0F, 0x80, 0x7E, 0x1F, 0x00, 0x7E, 0x1F, 0x00, 0x7C, 0x3E, 0x00,
  0x7C, 0x3E, 0x00, 0x7C, 0x3C, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00,
  0x78, 0x7C, 0x00, 0x78, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00,
  0xF8, 0xF8, 0x00, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x03,
  0xF0, 0xF8, 0x03, 0xF0, 0xF8, 0x07, 0xE0, 0xF8, 0x07, 0xE0, 0xF8, 0x0F,
  0xE0, 0xFC, 0x1F, 0xE0, 0x7E, 0x7B, 0xC0, 0x7F, 0xFB, 0xC0, 0x3F, 0xF7,
  0xC0, 0x1F, 0xC7, 0xC0, 0x02, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xE1,
  0xF0, 0x1C, 0x7F, 0x01, 0xCF, 0xF0, 0x3D, 0xFE, 0x03, 0xDF, 0xE0, 0x3F,
  0xC0, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x1F, 0xFE, 0x03, 0xFF, 0xF0,
  0x7F, 0xFE, 0x0F, 0xC0, 0xE0, 0xF8, 0x02, 0x0F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x08, 0x01, 0xF0, 0xC0, 0x3F, 0x0F,
  0x9F, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x20, 0x00,
  0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x03, 0xFF, 0x3F, 0xFE, 0xFF, 0xF9, 0xFF, 0xF0, 0x7C, 0x00, 0xF8,
  0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xF7, 0x07, 0xFE, 0x07, 0xFC, 0x07, 0xF8, 0x01,
  0x00, 0x00, 0x07, 0x80, 0x1F, 0x07, 0x80, 0x1E, 0x0F, 0x80, 0x1E, 0x0F,
  0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x00, 0x3E, 0x1F, 0x00, 0x3C, 0x1F,
  0x00, 0x3C, 0x1F, 0x00, 0x7C, 0x1E, 0x00, 0x7C, 0x1E, 0x00, 0x7C, 0x3E,
  0x00, 0x78, 0x3E, 0x00, 0x78, 0x3E, 0x00, 0xF8, 0x3C, 0x00, 0xF8, 0x3C,
  0x00, 0xF8, 0x7C, 0x00, 0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x78,
  0x01, 0xF0, 0xF8, 0x01, 0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0xF8,
  0x07, 0xE0, 0xF8, 0x0F, 0xE0, 0xF8, 0x0F, 0xC0, 0xF8, 0x1F, 0xC0, 0xFE,
  0xFB, 0xC0, 0x7F, 0xF3, 0xC0, 0x7F, 0xE3, 0xC0, 0x3F, 0xC3, 0x80, 0x06,
  0x04, 0x00, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x7D, 0xF0, 0x03,
  0xEF, 0x80, 0x1E, 0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0x0F, 0x00, 0xF8, 0x78,
  0x07, 0x83, 0xC0, 0x7C, 0x1E, 0x03, 0xE0, 0xF0, 0x3E, 0x07, 0x81, 0xF0,
  0x3C, 0x0F, 0x01, 0xE0, 0xF8, 0x0F, 0x07, 0x80, 0x78, 0x7C, 0x03, 0xC3,
  0xC0, 0x1E, 0x3E, 0x00, 0xF1, 0xE0, 0x07, 0x9F, 0x00, 0x3C, 0xF0, 0x01,
  0xEF, 0x80, 0x0F, 0x78, 0x00, 0x7B, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x03, 0xF0, 0x07, 0xFE, 0x00, 0xFC, 0x03, 0xEF, 0x80, 0x3F, 0x00,
  0xFB, 0xE0, 0x1F, 0xC0, 0x3C, 0xF8, 0x07, 0xF0, 0x1F, 0x3E, 0x03, 0xF8,
  0x07, 0x8F, 0x80, 0xFE, 0x03, 0xE3, 0xE0, 0x7B, 0x80, 0xF8, 0xF8, 0x1E,
  0xE0, 0x3C, 0x3E, 0x07, 0x38, 0x1F, 0x0F, 0x83, 0xCE, 0x07, 0x83, 0xE0,
  0xF3, 0x83, 0xE0, 0xF8, 0x78, 0xE0, 0xF8, 0x3E, 0x1E, 0x38, 0x3C, 0x0F,
  0x87, 0x0E, 0x1F, 0x03, 0xE3, 0xC3, 0x87, 0x80, 0xF8, 0xF0, 0xE3, 0xE0,
  0x3E, 0x78, 0x38, 0xF0, 0x0F, 0x9E, 0x0E, 0x3C, 0x03, 0xE7, 0x03, 0x9F,
  0x00, 0xFB, 0xC1, 0xE7, 0x80, 0x3E, 0xF0, 0x79, 0xE0, 0x0F, 0xF8, 0x1E,
  0xF0, 0x03, 0xDE, 0x07, 0xBC, 0x00, 0xF7, 0x01, 0xFF, 0x00, 0x3F, 0xC0,
  0x7F, 0x80, 0x0F, 0xF0, 0x1F, 0xE0, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0xFE,
  0x01, 0xFC, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00,
  0x03, 0xE0, 0x07, 0xC0, 0x78, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x07, 0xC0,
  0x7C, 0x01, 0xF0, 0x3E, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x87, 0xC0, 0x03,
  0xE3, 0xE0, 0x00, 0x78, 0xF0, 0x00, 0x1E, 0x7C, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xE7, 0x80, 0x00, 0xF9, 0xE0, 0x00,
  0x7C, 0x7C, 0x00, 0x1E, 0x1F, 0x00, 0x0F, 0x83, 0xC0, 0x07, 0xC0, 0xF0,
  0x01, 0xF0, 0x3E, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x01, 0xE0, 0x1F, 0x00,
  0x7C, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x78, 0x07, 0xC0, 0x07,
  0xC0, 0x3E, 0x00, 0x3E, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00,
  0x3C, 0x01, 0xF0, 0x01, 0xE0, 0x0F, 0x80, 0x0F, 0x00, 0xF8, 0x00, 0x78,
  0x07, 0xC0, 0x03, 0xC0, 0x3C, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0xF0, 0x1E,
  0x00, 0x07, 0x81, 0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xF0, 0xF8, 0x00,
  0x0F, 0x87, 0x80, 0x00, 0x7C, 0x7C, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x0F,
  0x3E, 0x00, 0x00, 0x79, 0xF0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x1E, 0xF8,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x9F, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00,
  0x1F, 0xF0, 0x01, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x3F, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x38, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x03, 0xFE, 0x00, 0x1F,
  0xE0, 0x00, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x02, 0x7F,
  0xC0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0x07,
  0xFF, 0xA0, 0x03, 0xFC, 0x40, 0x00, 0x00,
};

const GFXglyph NotoSans_Condensed_Italic57pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 14, 42, 14, 1, -41 },
  { 75, 16, 15, 20, 6, -41 },
  { 105, 28, 41, 28, 1, -41 },
  { 249, 24, 46, 25, 1, -43 },
  { 387, 33, 42, 38, 3, -41 },
  { 561, 28, 42, 29, 0, -41 },
  { 708, 7, 15, 11, 6, -41 },
  { 722, 18, 50, 15, 1, -41 },
  { 835, 17, 50, 15, -4, -41 },
  { 942, 20, 22, 24, 6, -44 },
  { 997, 23, 27, 27, 3, -34 },
  { 1075, 11, 13, 12, -3, -6 },
  { 1093, 13, 5, 16, 1, -18 },
  { 1102, 6, 8, 12, 1, -7 },
  { 1108, 27, 41, 19, -3, -41 },
  { 1247, 23, 42, 25, 2, -41 },
  { 1368, 15, 41, 25, 7, -41 },
  { 1445, 26, 41, 25, -1, -41 },
  { 1579, 25, 42, 25, 0, -41 },
  { 1711, 26, 41, 25, -1, -41 },
  { 1845, 25, 42, 25, 0, -41 },
  { 1977, 24, 42, 25, 2, -41 },
  { 2103, 24, 41, 25, 3, -41 },
  { 2226, 24, 42, 25, 1, -41 },
  { 2352, 23, 42, 25, 1, -41 },
  { 2473, 12, 32, 13, 0, -31 },
  { 2521, 15, 38, 13, -3, -31 },
  { 2593, 23, 26, 27, 3, -33 },
  { 2668, 22, 16, 27, 3, -28 },
  { 2712, 23, 26, 27, 3, -33 },
  { 2787, 19, 42, 19, 2, -41 },
  { 2887, 35, 46, 38, 2, -41 },
  { 3089, 26, 41, 26, -4, -41 },
  { 3223, 27, 41, 27, 1, -41 },
  { 3362, 26, 42, 25, 3, -41 },
  { 3499, 28, 41, 30, 1, -41 },
  { 3643, 25, 41, 23, 1, -41 },
  { 3772, 25, 41, 22, 1, -41 },
  { 3901, 29, 42, 31, 3, -41 },
  { 4054, 31, 41, 31, 1, -41 },
  { 4213, 22, 41, 16, -2, -41 },
  { 4326, 23, 52, 13, -9, -41 },
  { 4476, 30, 41, 26, 1, -41 },
  { 4630, 17, 41, 22, 1, -41 },
  { 4718, 40, 41, 40, 1, -41 },
  { 4923, 33, 41, 33, 1, -41 },
  { 5093, 28, 42, 32, 3, -41 },
  { 5240, 26, 41, 26, 1, -41 },
  { 5374, 28, 51, 32, 3, -41 },
  { 5553, 26, 41, 26, 1, -41 },
  { 5687, 26, 42, 24, -1, -41 },
  { 5824, 22, 41, 22, 5, -41 },
  { 5937, 29, 42, 30, 3, -41 },
  { 6090, 25, 41, 26, 5, -41 },
  { 6219, 40, 41, 41, 5, -41 },
  { 6424, 31, 41, 24, -3, -41 },
  { 6583, 23, 41, 23, 5, -41 },
  { 6701, 28, 41, 22, -2, -41 },
  { 6845, 21, 50, 16, -1, -41 },
  { 6977, 10, 41, 20, 6, -41 },
  { 7029, 22, 50, 16, -4, -41 },
  { 7167, 24, 23, 26, 1, -41 },
  { 7236, 20, 3, 19, -5, 5 },
  { 7244, 9, 9, 15, 8, -44 },
  { 7255, 24, 32, 27, 2, -31 },
  { 7351, 25, 44, 27, 0, -43 },
  { 7489, 20, 32, 20, 2, -31 },
  { 7569, 27, 44, 27, 2, -43 },
  { 7718, 21, 32, 24, 2, -31 },
  { 7802, 28, 58, 15, -7, -44 },
  { 8005, 26, 45, 27, 0, -31 },
  { 8152, 24, 43, 26, 0, -43 },
  { 8281, 14, 42, 12, 0, -42 },
  { 8355, 21, 56, 12, -7, -42 },
  { 8502, 25, 43, 23, 0, -43 },
  { 8637, 14, 43, 12, 0, -43 },
  { 8713, 37, 31, 39, 0, -31 },
  { 8857, 24, 31, 26, 0, -31 },
  { 8950, 22, 32, 26, 2, -31 },
  { 9038, 27, 44, 27, -2, -31 },
  { 9187, 24, 45, 27, 2, -31 },
  { 9322, 20, 31, 18, 0, -31 },
  { 9400, 20, 32, 20, 0, -31 },
  { 9480, 15, 39, 15, 2, -38 },
  { 9554, 24, 32, 26, 2, -31 },
  { 9650, 21, 31, 21, 3, -31 },
  { 9732, 34, 31, 34, 3, -31 },
  { 9864, 26, 31, 22, -2, -31 },
  { 9965, 29, 45, 22, -5, -31 },
  { 10129, 22, 31, 19, -2, -31 },
  { 10215, 21, 50, 19, 1, -41 },
  { 10347, 4, 57, 24, 10, -43 },
  { 10376, 21, 50, 19, -3, -41 },
  { 10508, 23, 8, 27, 3, -24 },
};

const GFXfont NotoSans_Condensed_Italic57pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Italic57pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Italic57pt7bGlyphs,
  0x20, 0x7E, 78
};

#endif // _NOTOSANS_CONDENSED_ITALIC57PT7B_H_
