#ifndef _NOTOSANS_CONDENSED_ITALIC19PT7B_H_
#define _NOTOSANS_CONDENSED_ITALIC19PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Italic.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Italic19pt7bBitmaps[] PROGMEM = {
  0x00, 0x18, 0xC4, 0x23, 0x18, 0x84, 0x23, 0x00, 0x0C, 0x60, 0x4A, 0x77,
  0xB9, 0x00, 0x04, 0x83, 0x20, 0x98, 0x24, 0x3F, 0xDF, 0xE1, 0x20, 0x48,
  0x26, 0x3F, 0xC2, 0x41, 0x90, 0x48, 0x12, 0x00, 0x04, 0x0F, 0x3F, 0x24,
  0x28, 0x38, 0x18, 0x0C, 0x0E, 0x12, 0x12, 0xD6, 0xF8, 0x10, 0x20, 0x30,
  0x4D, 0x11, 0x22, 0x24, 0x8C, 0xB1, 0x34, 0x25, 0xBF, 0xA9, 0x6B, 0x21,
  0x44, 0x49, 0x99, 0x22, 0x24, 0x87, 0x00, 0x0E, 0x0D, 0x84, 0xC2, 0x61,
  0x20, 0xB0, 0x60, 0x70, 0x6D, 0xE2, 0xB1, 0xD8, 0xCC, 0xF3, 0xD8, 0x5F,
  0x80, 0x04, 0x21, 0x84, 0x30, 0x86, 0x18, 0x41, 0x04, 0x30, 0xC1, 0x04,
  0x10, 0x60, 0x10, 0x42, 0x10, 0x84, 0x21, 0x08, 0xC6, 0x23, 0x11, 0x88,
  0x80, 0x18, 0x22, 0x47, 0xE3, 0x2F, 0x32, 0x08, 0x10, 0x10, 0x10, 0x10,
  0xFF, 0x10, 0x10, 0x10, 0x10, 0x36, 0x4C, 0x7F, 0x80, 0xF0, 0x01, 0x80,
  0x80, 0xC0, 0x40, 0x60, 0x20, 0x30, 0x10, 0x18, 0x08, 0x08, 0x0C, 0x04,
  0x06, 0x00, 0x0C, 0x7C, 0x8B, 0x14, 0x38, 0x71, 0xC3, 0x87, 0x0A, 0x34,
  0x6D, 0x9E, 0x00, 0x08, 0xDF, 0xB1, 0x08, 0xC6, 0x31, 0x08, 0xC6, 0x20,
  0x0E, 0x3F, 0x23, 0x01, 0x03, 0x03, 0x06, 0x04, 0x08, 0x18, 0x30, 0x60,
  0xC2, 0xFC, 0x0E, 0x3F, 0x21, 0x01, 0x03, 0x02, 0x1C, 0x3C, 0x06, 0x06,
  0x06, 0x06, 0x8C, 0xF8, 0x03, 0x03, 0x07, 0x0F, 0x0A, 0x12, 0x36, 0x26,
  0x46, 0xC4, 0xFF, 0x0C, 0x0C, 0x08, 0x1F, 0x1F, 0x10, 0x30, 0x30, 0x20,
  0x7C, 0x06, 0x02, 0x02, 0x02, 0x06, 0x8C, 0xF8, 0x07, 0x1E, 0x30, 0x60,
  0x40, 0x48, 0xFC, 0xC6, 0xC6, 0x86, 0x84, 0x8C, 0xC8, 0x78, 0x7F, 0x7F,
  0x02, 0x06, 0x04, 0x0C, 0x08, 0x18, 0x10, 0x30, 0x20, 0x60, 0x40, 0xC0,
  0x0E, 0x1F, 0x31, 0x31, 0x31, 0x32, 0x1C, 0x3C, 0x66, 0xC2, 0xC2, 0xC2,
  0xC6, 0x7C, 0x0E, 0x1F, 0x33, 0x21, 0x61, 0x63, 0x63, 0x77, 0x3A, 0x02,
  0x06, 0x04, 0x18, 0xF0, 0x33, 0x00, 0x00, 0x00, 0xCC, 0x18, 0xC0, 0x00,
  0x00, 0x00, 0x33, 0x11, 0x80, 0x03, 0x0E, 0x38, 0x60, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x80, 0xE0, 0x38, 0x0E, 0x07,
  0x1C, 0x70, 0xC0, 0x80, 0x39, 0xF0, 0xC3, 0x0C, 0x63, 0x08, 0x41, 0x00,
  0x00, 0xC3, 0x00, 0x03, 0x01, 0x98, 0x41, 0x90, 0x14, 0x7A, 0x92, 0x66,
  0x4C, 0x89, 0x93, 0x32, 0x4A, 0x59, 0x4C, 0xC8, 0x01, 0x80, 0x1D, 0x80,
  0xC0, 0x03, 0x07, 0x05, 0x05, 0x0D, 0x09, 0x19, 0x11, 0x3F, 0x3F, 0x61,
  0x61, 0xC1, 0xC1, 0x1E, 0x0F, 0xC4, 0x66, 0x33, 0x19, 0x8C, 0xF8, 0x7C,
  0x63, 0x30, 0x98, 0xC8, 0x64, 0x67, 0xE0, 0x07, 0x0F, 0xCC, 0x0C, 0x06,
  0x02, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0E, 0x43, 0xE0, 0x1C,
  0x07, 0xE1, 0x18, 0xC2, 0x30, 0xCC, 0x32, 0x0C, 0x82, 0x61, 0x98, 0x66,
  0x31, 0x0C, 0x4E, 0x3E, 0x00, 0x1F, 0x8F, 0x84, 0x06, 0x03, 0x01, 0x80,
  0xF8, 0x7C, 0x60, 0x30, 0x18, 0x08, 0x04, 0x07, 0xE0, 0x1F, 0x8F, 0x84,
  0x06, 0x03, 0x01, 0x80, 0x80, 0x7C, 0x60, 0x30, 0x18, 0x08, 0x04, 0x06,
  0x00, 0x07, 0x07, 0xF3, 0x01, 0x80, 0x60, 0x10, 0x0C, 0x03, 0x1E, 0xC1,
  0x30, 0x4C, 0x33, 0x0C, 0x62, 0x1F, 0x80, 0x18, 0x62, 0x08, 0x41, 0x18,
  0x63, 0x0C, 0x61, 0x8F, 0xE1, 0xFC, 0x61, 0x8C, 0x31, 0x84, 0x20, 0x84,
  0x31, 0x86, 0x00, 0x1F, 0x0C, 0x0C, 0x08, 0x08, 0x18, 0x18, 0x18, 0x10,
  0x10, 0x30, 0x30, 0x30, 0xF8, 0x03, 0x02, 0x02, 0x06, 0x06, 0x06, 0x04,
  0x04, 0x0C, 0x0C, 0x0C, 0x08, 0x08, 0x18, 0x18, 0x10, 0xF0, 0xC0, 0x18,
  0xC4, 0x21, 0x18, 0xCC, 0x36, 0x0F, 0x02, 0x80, 0xF0, 0x6C, 0x19, 0x06,
  0x61, 0x18, 0x46, 0x30, 0x80, 0x18, 0x41, 0x0C, 0x30, 0xC2, 0x08, 0x61,
  0x86, 0x10, 0x43, 0xF0, 0x18, 0x1C, 0x60, 0x61, 0x83, 0x8E, 0x0A, 0x3C,
  0x78, 0xF1, 0x62, 0xCD, 0x0B, 0x24, 0x6D, 0xB1, 0xB4, 0xC4, 0x53, 0x11,
  0x88, 0x46, 0x23, 0x11, 0x80, 0x18, 0x23, 0x0C, 0x61, 0x9E, 0x33, 0xC4,
  0x68, 0x89, 0x31, 0x36, 0x66, 0x8C, 0x51, 0x0A, 0x21, 0xC4, 0x39, 0x86,
  0x00, 0x0E, 0x0F, 0xCC, 0x6C, 0x16, 0x0A, 0x07, 0x03, 0x83, 0xC1, 0xE0,
  0xB0, 0xD8, 0x6E, 0x63, 0xE0, 0x1C, 0x0F, 0x84, 0x66, 0x33, 0x19, 0x8C,
  0x8C, 0x7C, 0x7C, 0x30, 0x18, 0x08, 0x04, 0x06, 0x00, 0x0E, 0x0F, 0xCC,
  0x6C, 0x16, 0x0A, 0x07, 0x03, 0x83, 0xC1, 0xE0, 0xB0, 0xD8, 0x6E, 0x63,
  0xE0, 0x20, 0x18, 0x0E, 0x00, 0x1C, 0x0F, 0x84, 0x66, 0x33, 0x19, 0x8C,
  0x8C, 0x7C, 0x6C, 0x32, 0x19, 0x88, 0xC4, 0x66, 0x10, 0x0E, 0x1F, 0x30,
  0x20, 0x20, 0x30, 0x38, 0x1C, 0x0E, 0x06, 0x06, 0x06, 0x8C, 0xF8, 0xFF,
  0xFC, 0xC1, 0x82, 0x04, 0x18, 0x30, 0x40, 0x83, 0x06, 0x0C, 0x10, 0x00,
  0x30, 0xC8, 0x22, 0x09, 0x86, 0x61, 0x90, 0x44, 0x13, 0x0C, 0xC3, 0x30,
  0xC8, 0x23, 0x18, 0xCC, 0x1F, 0x00, 0x83, 0x83, 0x82, 0x86, 0x84, 0x8C,
  0x88, 0x98, 0x90, 0xB0, 0xB0, 0xA0, 0xE0, 0xC0, 0x82, 0x1C, 0x30, 0xE1,
  0x85, 0x1C, 0x68, 0xA2, 0x45, 0x32, 0x69, 0x92, 0x48, 0xB2, 0xC5, 0x14,
  0x28, 0xE1, 0xC7, 0x0C, 0x30, 0x61, 0x80, 0x18, 0x46, 0x31, 0x98, 0x24,
  0x0B, 0x03, 0x80, 0xE0, 0x30, 0x1E, 0x05, 0x83, 0x61, 0x88, 0x62, 0x30,
  0xC0, 0x83, 0x0F, 0x36, 0x6D, 0x9A, 0x1C, 0x30, 0x60, 0x81, 0x06, 0x0C,
  0x18, 0x00, 0x1F, 0xC7, 0xE0, 0x18, 0x0C, 0x03, 0x01, 0x80, 0x40, 0x30,
  0x18, 0x04, 0x03, 0x01, 0x80, 0x60, 0x3F, 0x80, 0x1E, 0x3C, 0x41, 0x83,
  0x04, 0x08, 0x10, 0x60, 0xC1, 0x02, 0x04, 0x18, 0x30, 0x40, 0xE0, 0x9B,
  0x6C, 0x92, 0x4D, 0xB2, 0x40, 0x1E, 0x3C, 0x10, 0x20, 0x41, 0x83, 0x04,
  0x08, 0x30, 0x60, 0x81, 0x02, 0x0C, 0x18, 0xE0, 0x04, 0x0C, 0x1C, 0x16,
  0x32, 0x22, 0x63, 0xC1, 0xFE, 0xD9, 0x80, 0x3F, 0x66, 0x46, 0xC6, 0xC6,
  0x86, 0x84, 0x8C, 0xDC, 0xFC, 0x18, 0x10, 0x10, 0x30, 0x3F, 0x33, 0x31,
  0x21, 0x61, 0x63, 0x43, 0x42, 0xE6, 0xFC, 0x3D, 0x84, 0x30, 0x82, 0x08,
  0x20, 0xCB, 0xE0, 0x01, 0x80, 0x80, 0xC0, 0x63, 0xF3, 0x31, 0x19, 0x8C,
  0xC6, 0x43, 0x21, 0x11, 0x8D, 0xC7, 0x60, 0x3C, 0xCD, 0x16, 0x6F, 0x90,
  0x20, 0x40, 0xC8, 0xF0, 0x01, 0x01, 0xC1, 0x80, 0x80, 0x40, 0xF8, 0x30,
  0x10, 0x08, 0x0C, 0x06, 0x03, 0x01, 0x00, 0x80, 0xC0, 0x60, 0x30, 0x10,
  0x38, 0x10, 0x00, 0x1F, 0x99, 0x88, 0xCC, 0x66, 0x32, 0x19, 0x08, 0x8C,
  0x6E, 0x3F, 0x01, 0x00, 0x88, 0xC7, 0xC1, 0x80, 0x18, 0x10, 0x10, 0x30,
  0x3F, 0x33, 0x33, 0x23, 0x63, 0x62, 0x42, 0x46, 0xC6, 0xC6, 0x18, 0x80,
  0x03, 0x10, 0x84, 0x63, 0x10, 0x8C, 0x60, 0x06, 0x08, 0x00, 0x00, 0xC1,
  0x02, 0x04, 0x18, 0x30, 0x40, 0x83, 0x06, 0x0C, 0x10, 0x21, 0xC2, 0x00,
  0x18, 0x10, 0x10, 0x30, 0x33, 0x26, 0x2C, 0x28, 0x78, 0x68, 0x4C, 0x4C,
  0xCC, 0xC6, 0x18, 0x84, 0x63, 0x10, 0x84, 0x63, 0x10, 0x8C, 0x60, 0x3F,
  0x73, 0x39, 0x33, 0x12, 0x31, 0x62, 0x36, 0x23, 0x42, 0x34, 0x62, 0xC6,
  0x2C, 0x46, 0x3F, 0x33, 0x33, 0x23, 0x63, 0x62, 0x42, 0x46, 0xC6, 0xC6,
  0x3C, 0xCD, 0x1E, 0x38, 0x70, 0xE1, 0x46, 0xC8, 0xE0, 0x1F, 0x8C, 0x46,
  0x22, 0x13, 0x09, 0x8C, 0x86, 0x42, 0x73, 0x3F, 0x18, 0x08, 0x04, 0x06,
  0x00, 0x3F, 0x66, 0x46, 0xC6, 0xC6, 0x86, 0x84, 0x8C, 0xDC, 0xFC, 0x08,
  0x08, 0x08, 0x18, 0x18, 0x3E, 0x70, 0xC1, 0x06, 0x0C, 0x10, 0x20, 0xC1,
  0x80, 0x3E, 0xC5, 0x83, 0x03, 0x03, 0x02, 0x06, 0x99, 0xE0, 0x21, 0x09,
  0xF6, 0x21, 0x18, 0xC4, 0x21, 0x0E, 0x00, 0x63, 0x42, 0x46, 0xC6, 0xC6,
  0xC4, 0x84, 0x8C, 0x9C, 0xEC, 0xC7, 0x8B, 0x36, 0x4D, 0x9A, 0x3C, 0x70,
  0xE1, 0xC0, 0xC6, 0x79, 0x8B, 0x31, 0x6E, 0x6D, 0x49, 0xEB, 0x39, 0x45,
  0x28, 0xE7, 0x18, 0xC0, 0x31, 0x89, 0x86, 0x83, 0x80, 0xC0, 0xE0, 0x50,
  0x48, 0x66, 0x63, 0x00, 0x18, 0xC6, 0x21, 0x98, 0x64, 0x1B, 0x06, 0x80,
  0xA0, 0x38, 0x0C, 0x03, 0x00, 0x80, 0x60, 0x10, 0x3C, 0x04, 0x00, 0x1F,
  0x06, 0x04, 0x0C, 0x08, 0x18, 0x30, 0x20, 0x60, 0xFC, 0x02, 0x1C, 0x20,
  0x41, 0x83, 0x04, 0x18, 0xE0, 0x40, 0xC1, 0x02, 0x0C, 0x18, 0x30, 0x30,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x10, 0x38, 0x30, 0x60, 0xC1, 0x82, 0x04,
  0x06, 0x18, 0x60, 0x81, 0x06, 0x0C, 0x30, 0xC0, 0x71, 0xBF, 0x80,
};

const GFXglyph NotoSans_Condensed_Italic19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 5, 14, 5, 0, -14 },
  { 10, 5, 5, 7, 2, -14 },
  { 14, 10, 14, 9, 0, -14 },
  { 32, 8, 15, 8, 0, -14 },
  { 47, 11, 14, 13, 1, -14 },
  { 67, 9, 14, 10, 0, -14 },
  { 83, 2, 5, 4, 2, -14 },
  { 85, 6, 17, 5, 0, -14 },
  { 98, 5, 17, 5, -1, -14 },
  { 109, 7, 8, 8, 2, -15 },
  { 116, 8, 9, 9, 1, -11 },
  { 125, 4, 4, 4, -1, -2 },
  { 127, 5, 2, 5, 0, -6 },
  { 129, 2, 2, 4, 0, -2 },
  { 130, 9, 14, 6, -1, -14 },
  { 146, 7, 14, 8, 1, -14 },
  { 159, 5, 14, 8, 2, -14 },
  { 168, 8, 14, 8, 0, -14 },
  { 182, 8, 14, 8, 0, -14 },
  { 196, 8, 14, 8, 0, -14 },
  { 210, 8, 14, 8, 0, -14 },
  { 224, 8, 14, 8, 1, -14 },
  { 238, 8, 14, 8, 1, -14 },
  { 252, 8, 14, 8, 0, -14 },
  { 266, 8, 14, 8, 0, -14 },
  { 280, 4, 10, 4, 0, -10 },
  { 285, 5, 12, 4, -1, -10 },
  { 293, 8, 9, 9, 1, -11 },
  { 302, 7, 5, 9, 1, -9 },
  { 307, 8, 9, 9, 1, -11 },
  { 316, 6, 14, 6, 1, -14 },
  { 327, 11, 16, 13, 1, -14 },
  { 349, 8, 14, 9, -1, -14 },
  { 363, 9, 14, 9, 0, -14 },
  { 379, 9, 14, 8, 1, -14 },
  { 395, 10, 14, 10, 0, -14 },
  { 413, 9, 14, 8, 0, -14 },
  { 429, 9, 14, 7, 0, -14 },
  { 445, 10, 14, 10, 1, -14 },
  { 463, 11, 14, 10, 0, -14 },
  { 483, 8, 14, 5, -1, -14 },
  { 497, 8, 18, 4, -3, -14 },
  { 515, 10, 14, 9, 0, -14 },
  { 533, 6, 14, 7, 0, -14 },
  { 544, 14, 14, 13, 0, -14 },
  { 569, 11, 14, 11, 0, -14 },
  { 589, 9, 14, 11, 1, -14 },
  { 605, 9, 14, 9, 0, -14 },
  { 621, 9, 17, 11, 1, -14 },
  { 641, 9, 14, 9, 0, -14 },
  { 657, 8, 14, 8, 0, -14 },
  { 671, 7, 14, 7, 2, -14 },
  { 684, 10, 14, 10, 1, -14 },
  { 702, 8, 14, 9, 2, -14 },
  { 716, 13, 14, 14, 2, -14 },
  { 739, 10, 14, 8, -1, -14 },
  { 757, 7, 14, 8, 2, -14 },
  { 770, 10, 14, 7, -1, -14 },
  { 788, 7, 17, 5, 0, -14 },
  { 803, 3, 14, 7, 2, -14 },
  { 809, 7, 17, 5, -1, -14 },
  { 824, 8, 8, 9, 0, -14 },
  { 832, 7, 1, 6, -2, 2 },
  { 833, 3, 3, 5, 3, -15 },
  { 835, 8, 10, 9, 1, -10 },
  { 845, 8, 14, 9, 0, -14 },
  { 859, 6, 10, 7, 1, -10 },
  { 867, 9, 14, 9, 1, -14 },
  { 883, 7, 10, 8, 1, -10 },
  { 892, 9, 20, 5, -2, -15 },
  { 915, 9, 15, 9, 0, -10 },
  { 932, 8, 14, 9, 0, -14 },
  { 946, 5, 14, 4, 0, -14 },
  { 955, 7, 19, 4, -2, -14 },
  { 972, 8, 14, 8, 0, -14 },
  { 986, 5, 14, 4, 0, -14 },
  { 995, 12, 10, 13, 0, -10 },
  { 1010, 8, 10, 9, 0, -10 },
  { 1020, 7, 10, 9, 1, -10 },
  { 1029, 9, 14, 9, -1, -10 },
  { 1045, 8, 15, 9, 1, -10 },
  { 1060, 7, 10, 6, 0, -10 },
  { 1069, 7, 10, 7, 0, -10 },
  { 1078, 5, 13, 5, 1, -13 },
  { 1087, 8, 10, 9, 1, -10 },
  { 1097, 7, 10, 7, 1, -10 },
  { 1106, 11, 10, 11, 1, -10 },
  { 1120, 9, 10, 7, -1, -10 },
  { 1132, 10, 15, 7, -2, -10 },
  { 1151, 8, 10, 6, -1, -10 },
  { 1161, 7, 17, 6, 0, -14 },
  { 1176, 2, 20, 8, 3, -15 },
  { 1181, 7, 17, 6, -1, -14 },
  { 1196, 8, 3, 9, 1, -8 },
};

const GFXfont NotoSans_Condensed_Italic19pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Italic19pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Italic19pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _NOTOSANS_CONDENSED_ITALIC19PT7B_H_
