#ifndef _NOTOSANS_CONDENSED_ITALIC24PT7B_H_
#define _NOTOSANS_CONDENSED_ITALIC24PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Italic.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Italic24pt7bBitmaps[] PROGMEM = {
  0x00, 0x0C, 0x31, 0xC6, 0x18, 0x61, 0x8C, 0x30, 0xC3, 0x08, 0x00, 0x06,
  0x38, 0xE0, 0x76, 0xCD, 0x9B, 0x24, 0xD9, 0x80, 0x03, 0x30, 0x62, 0x06,
  0x60, 0x44, 0x04, 0x43, 0xFF, 0x08, 0xC0, 0x88, 0x19, 0x81, 0x98, 0xFF,
  0xEF, 0xFC, 0x33, 0x02, 0x20, 0x22, 0x06, 0x60, 0x46, 0x00, 0x01, 0x00,
  0x20, 0x3F, 0x8F, 0x63, 0x20, 0x64, 0x0C, 0x80, 0xF0, 0x1C, 0x01, 0xE0,
  0x1C, 0x02, 0xC0, 0x98, 0x13, 0x22, 0xC7, 0xF8, 0x7C, 0x02, 0x00, 0x40,
  0x00, 0x1C, 0x18, 0xD8, 0xC6, 0x63, 0x19, 0x98, 0x46, 0x41, 0x13, 0x0C,
  0x49, 0x33, 0x6F, 0xCB, 0x6D, 0xE9, 0x10, 0x6C, 0xC1, 0x33, 0x0C, 0x8C,
  0x62, 0x21, 0x09, 0x8C, 0x36, 0x60, 0xF0, 0x07, 0x80, 0xCC, 0x08, 0xC1,
  0x8C, 0x18, 0x81, 0x98, 0x0F, 0x00, 0xE0, 0x1E, 0x03, 0x67, 0x66, 0x6C,
  0x36, 0xC3, 0xCC, 0x18, 0xC3, 0x8F, 0xEC, 0x7C, 0xE0, 0xFB, 0x69, 0x00,
  0x06, 0x18, 0x60, 0x83, 0x0C, 0x18, 0x30, 0xC1, 0x83, 0x06, 0x0C, 0x10,
  0x20, 0x40, 0xC1, 0x83, 0x06, 0x06, 0x00, 0x06, 0x06, 0x06, 0x02, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x06, 0x06, 0x06, 0x06, 0x0C, 0x0C, 0x0C, 0x18,
  0x10, 0x30, 0x60, 0xC0, 0x0C, 0x06, 0x1B, 0x1F, 0xF1, 0xF9, 0xE1, 0x90,
  0x4C, 0x04, 0x00, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x3F, 0xF0, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x33, 0x66, 0x4C, 0xFC, 0x7F, 0x80, 0x00,
  0x60, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x00, 0x80, 0x30, 0x0C, 0x01,
  0x80, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0xC0, 0x00, 0x0F,
  0x0D, 0xCC, 0x66, 0x36, 0x1B, 0x0D, 0x87, 0x83, 0xC1, 0xE0, 0xF0, 0xF8,
  0x6C, 0x36, 0x33, 0x19, 0xF8, 0x78, 0x00, 0x0C, 0xF7, 0xF6, 0x98, 0x61,
  0x86, 0x30, 0xC3, 0x0C, 0x61, 0x86, 0x18, 0x60, 0x07, 0xC1, 0xDC, 0x21,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x06, 0x01, 0x80, 0x60, 0x1C, 0x07,
  0x01, 0xC0, 0x30, 0x0C, 0x03, 0xFC, 0xFF, 0x80, 0x0F, 0x87, 0x71, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x18, 0x7C, 0x1E, 0x00, 0xC0, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x33, 0xFC, 0xFC, 0x00, 0x00, 0xC0, 0x70, 0x3C, 0x0B, 0x06,
  0x83, 0x60, 0x98, 0x66, 0x31, 0x88, 0xC6, 0x33, 0xFF, 0xFF, 0xC0, 0xC0,
  0x60, 0x18, 0x06, 0x00, 0x0F, 0xE1, 0xF8, 0x60, 0x0C, 0x01, 0x80, 0x60,
  0x0D, 0x01, 0xF8, 0x23, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0xC7, 0xF8, 0xFC, 0x00, 0x07, 0xC3, 0x91, 0x80, 0xC0, 0x30, 0x18, 0x06,
  0xE1, 0x7C, 0xE3, 0x30, 0x6C, 0x1B, 0x0C, 0xC3, 0x30, 0xCC, 0x73, 0xF8,
  0x7C, 0x00, 0x3F, 0xDF, 0xF0, 0x08, 0x06, 0x03, 0x00, 0xC0, 0x60, 0x18,
  0x0C, 0x03, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x06, 0x01, 0x80, 0xC0, 0x00,
  0x0F, 0xC3, 0x98, 0x61, 0x8C, 0x31, 0x8C, 0x31, 0x86, 0x60, 0x78, 0x1F,
  0x06, 0x61, 0x86, 0x70, 0xCC, 0x19, 0x83, 0x38, 0x63, 0xB8, 0x3E, 0x00,
  0x0F, 0x87, 0x71, 0x8C, 0xC3, 0x30, 0xCC, 0x33, 0x0C, 0xC7, 0x31, 0xCF,
  0xB1, 0x98, 0x06, 0x01, 0x80, 0xC0, 0x63, 0x70, 0xF8, 0x00, 0x19, 0xCC,
  0x00, 0x00, 0x00, 0x00, 0x19, 0xCE, 0x00, 0x0C, 0x71, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x0C, 0x61, 0x8C, 0x30, 0x00, 0x40, 0x70, 0x70, 0x70,
  0x70, 0x30, 0x07, 0x80, 0x78, 0x07, 0x80, 0x70, 0x04, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x30, 0x78, 0x78, 0x78, 0x38, 0x08, 0x00, 0x7E, 0x77, 0x03, 0x03,
  0x03, 0x06, 0x0C, 0x18, 0x30, 0x30, 0x60, 0x60, 0x00, 0x00, 0xC0, 0xC0,
  0xC0, 0x03, 0xF0, 0x1C, 0x30, 0x60, 0x30, 0x80, 0x23, 0x08, 0x4C, 0x7C,
  0xD9, 0x99, 0xA2, 0x22, 0xCC, 0x45, 0x91, 0x8A, 0x23, 0x34, 0x44, 0x48,
  0x9D, 0x91, 0xDE, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE3, 0x00, 0x7E,
  0x00, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0xB0, 0x36, 0x06, 0xC1, 0x98, 0x33,
  0x0C, 0x61, 0x8C, 0x7F, 0x8F, 0xF1, 0x86, 0x60, 0xCC, 0x1B, 0x03, 0xE0,
  0x60, 0x0F, 0xC0, 0xFE, 0x18, 0x61, 0x87, 0x18, 0x61, 0x86, 0x38, 0xE3,
  0xF8, 0x3F, 0x83, 0x0C, 0x30, 0xC6, 0x0C, 0x60, 0xC6, 0x0C, 0x61, 0x87,
  0xF8, 0xFE, 0x00, 0x07, 0xE1, 0xCC, 0x60, 0x18, 0x03, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x18, 0x03,
  0xF8, 0x3F, 0x00, 0x0F, 0xC0, 0xFE, 0x18, 0x71, 0x83, 0x18, 0x31, 0x83,
  0x38, 0x33, 0x03, 0x30, 0x33, 0x07, 0x30, 0x66, 0x06, 0x60, 0xE6, 0x1C,
  0x63, 0x87, 0xF0, 0xFC, 0x00, 0x0F, 0xE1, 0xFC, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x0E, 0x01, 0xFC, 0x3F, 0x86, 0x00, 0xC0, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0xF8, 0xFE, 0x00, 0x0F, 0xE1, 0xFC, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x0E, 0x01, 0x80, 0x3F, 0x87, 0xF0, 0xC0, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0xC0, 0x00, 0x07, 0xF0, 0xF7, 0x1C, 0x03, 0x80, 0x30,
  0x06, 0x00, 0x60, 0x06, 0x00, 0xC1, 0xEC, 0x3E, 0xC0, 0x6C, 0x0C, 0xC0,
  0xCE, 0x0C, 0x60, 0xC7, 0xFC, 0x3F, 0x80, 0x0C, 0x18, 0x60, 0xC6, 0x06,
  0x30, 0x31, 0x83, 0x0C, 0x18, 0x60, 0xC7, 0xFE, 0x3F, 0xF1, 0x83, 0x0C,
  0x18, 0xC0, 0xC6, 0x06, 0x30, 0x31, 0x83, 0x0C, 0x18, 0xC0, 0xC0, 0x1F,
  0x83, 0x01, 0x80, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0xC0, 0x60, 0xFC, 0x00, 0x00, 0xC0, 0x30, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x0C, 0x03, 0x00, 0xC0, 0x60, 0x78, 0x30, 0x00, 0x0C,
  0x38, 0x63, 0x86, 0x18, 0x31, 0x81, 0x98, 0x0D, 0x80, 0xFC, 0x06, 0xC0,
  0x3E, 0x01, 0xF0, 0x0C, 0xC0, 0xC6, 0x06, 0x30, 0x31, 0x81, 0x86, 0x0C,
  0x30, 0xC1, 0x80, 0x0C, 0x0C, 0x18, 0x18, 0x18, 0x18, 0x38, 0x30, 0x30,
  0x30, 0x30, 0x60, 0x60, 0x60, 0x60, 0x7F, 0xFE, 0x0E, 0x03, 0x87, 0x03,
  0xC7, 0x81, 0xE3, 0xC0, 0xB1, 0xE0, 0xF0, 0xF0, 0x58, 0xD8, 0x6C, 0x6C,
  0x36, 0x36, 0x32, 0x19, 0x1B, 0x0C, 0x99, 0x8C, 0x4C, 0xC6, 0x2C, 0x63,
  0x1E, 0x61, 0x8E, 0x30, 0x87, 0x18, 0xC3, 0x0C, 0x00, 0x0C, 0x0C, 0x38,
  0x31, 0xE0, 0xC7, 0x86, 0x1E, 0x18, 0x68, 0x63, 0x31, 0x8C, 0xC6, 0x33,
  0x30, 0xC4, 0xC3, 0x1B, 0x18, 0x6C, 0x61, 0xA1, 0x87, 0x86, 0x0E, 0x18,
  0x38, 0xC0, 0xE0, 0x07, 0xC0, 0xEE, 0x18, 0x73, 0x03, 0x30, 0x36, 0x03,
  0x60, 0x36, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0x6C, 0x06, 0xC0, 0xEC, 0x0C,
  0x61, 0x87, 0xF8, 0x3E, 0x00, 0x0F, 0xC1, 0xFC, 0x61, 0x8C, 0x31, 0x86,
  0x30, 0xCE, 0x19, 0x86, 0x37, 0xC7, 0xE0, 0xC0, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0xC0, 0x00, 0x07, 0xC0, 0xEE, 0x18, 0x73, 0x03, 0x30,
  0x36, 0x03, 0x60, 0x36, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0x6C, 0x06, 0xC0,
  0xEC, 0x0C, 0xE1, 0x87, 0xF8, 0x3E, 0x00, 0x60, 0x07, 0x00, 0x30, 0x03,
  0x80, 0x0F, 0xC1, 0xFC, 0x61, 0x8C, 0x31, 0x86, 0x30, 0xCE, 0x19, 0x86,
  0x3F, 0x87, 0xC0, 0xCC, 0x31, 0x86, 0x30, 0xC6, 0x18, 0x63, 0x0C, 0xC1,
  0x80, 0x0F, 0xE3, 0xF8, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x18, 0x06, 0x20, 0xC7, 0xF0, 0xFC,
  0x00, 0xFF, 0xFF, 0xC6, 0x03, 0x01, 0x80, 0xC0, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0xC0, 0x00, 0x18, 0x33, 0x03,
  0x30, 0x33, 0x03, 0x30, 0x63, 0x06, 0x60, 0x66, 0x06, 0x60, 0xC6, 0x0C,
  0x60, 0xCC, 0x0C, 0xC0, 0xCC, 0x18, 0xC1, 0x87, 0xF0, 0x7E, 0x00, 0xC0,
  0xF8, 0x1B, 0x07, 0x60, 0xCC, 0x19, 0x86, 0x30, 0xC6, 0x30, 0xC6, 0x19,
  0x83, 0x30, 0x2C, 0x05, 0x80, 0xB0, 0x1C, 0x03, 0x80, 0x60, 0x00, 0xC1,
  0xC1, 0xE0, 0xE1, 0xB0, 0x70, 0xD8, 0x78, 0x6C, 0x3C, 0x66, 0x36, 0x33,
  0x1B, 0x31, 0x89, 0x98, 0xCC, 0xCC, 0x64, 0x6C, 0x36, 0x36, 0x1B, 0x16,
  0x0D, 0x0B, 0x07, 0x85, 0x03, 0x83, 0x81, 0xC1, 0xC0, 0xE0, 0xC0, 0x00,
  0x0C, 0x38, 0x61, 0x83, 0x18, 0x19, 0xC0, 0x6C, 0x03, 0xC0, 0x1E, 0x00,
  0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x36, 0x03, 0x90, 0x18, 0xC1, 0x86,
  0x0C, 0x30, 0xC1, 0x80, 0xC1, 0xF0, 0x6C, 0x31, 0x8C, 0x66, 0x1B, 0x86,
  0xC1, 0xE0, 0x78, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0xC0, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x60, 0x0C, 0x01, 0xC0, 0x18, 0x03,
  0x00, 0x70, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x38, 0x03, 0x00, 0x60,
  0x07, 0xF8, 0xFF, 0x00, 0x07, 0xC1, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x80,
  0x60, 0x18, 0x06, 0x01, 0xE0, 0xF8, 0x00, 0xC2, 0x18, 0xC6, 0x31, 0x8C,
  0x21, 0x8C, 0x63, 0x18, 0xC2, 0x18, 0x07, 0x84, 0xC0, 0x60, 0x30, 0x10,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x01, 0x80, 0xC0, 0x60, 0x20, 0x30, 0x18,
  0x0C, 0x06, 0x02, 0x0F, 0x0F, 0x80, 0x06, 0x01, 0xC0, 0xF0, 0x34, 0x19,
  0x84, 0x63, 0x08, 0x83, 0x60, 0xF0, 0x10, 0xFF, 0xFF, 0xE6, 0x30, 0x1E,
  0xCF, 0xF3, 0x1D, 0x86, 0x61, 0xB0, 0x6C, 0x1B, 0x0C, 0xC3, 0x30, 0xCC,
  0x73, 0xBC, 0x7A, 0x00, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x18, 0x06, 0xE1,
  0xFC, 0xE3, 0x38, 0xCC, 0x33, 0x0C, 0x83, 0x60, 0xD8, 0x36, 0x19, 0x86,
  0xF7, 0x37, 0x80, 0x1F, 0x3F, 0x70, 0x60, 0x60, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xEC, 0x7C, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x3D,
  0x8F, 0xF1, 0x8E, 0x61, 0x8C, 0x33, 0x06, 0x60, 0xCC, 0x31, 0x86, 0x30,
  0xC6, 0x38, 0xFB, 0x0F, 0x40, 0x1F, 0x1F, 0x9C, 0x6C, 0x2E, 0x36, 0x73,
  0xF1, 0x80, 0xC0, 0x60, 0x30, 0x1C, 0xC7, 0xE0, 0x00, 0xF0, 0x19, 0x01,
  0x80, 0x30, 0x03, 0x00, 0x7C, 0x0F, 0xC0, 0x30, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x03, 0x00, 0xF0, 0x0E, 0x00, 0x0F, 0x63, 0xFC, 0x63,
  0x98, 0x63, 0x0C, 0xC1, 0x98, 0x33, 0x0C, 0x61, 0x8C, 0x31, 0x8E, 0x3F,
  0xC3, 0xF0, 0x06, 0x00, 0xC0, 0x18, 0x86, 0x1F, 0x81, 0xE0, 0x00, 0x0C,
  0x03, 0x01, 0x80, 0x60, 0x18, 0x06, 0xE1, 0x7C, 0xE3, 0x30, 0xCC, 0x33,
  0x0C, 0xC3, 0x61, 0x98, 0x66, 0x19, 0x86, 0xC1, 0x30, 0xC0, 0x08, 0x70,
  0x80, 0x00, 0x61, 0x8C, 0x30, 0xC3, 0x0C, 0x61, 0x86, 0x18, 0xC3, 0x00,
  0x01, 0x01, 0xC0, 0x40, 0x00, 0x00, 0x18, 0x0C, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x08, 0x0C, 0x06, 0x03, 0x01, 0x81,
  0x83, 0xC1, 0xC0, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x31, 0xC6,
  0x61, 0x9C, 0x33, 0x06, 0xC0, 0xF0, 0x1E, 0x07, 0x60, 0xCC, 0x19, 0x83,
  0x18, 0xC3, 0x18, 0x60, 0x0C, 0x31, 0x86, 0x18, 0x61, 0x8C, 0x30, 0xC3,
  0x0C, 0x61, 0x86, 0x18, 0xC3, 0x00, 0x13, 0x9E, 0x17, 0xFF, 0x38, 0xE3,
  0x30, 0xC3, 0x30, 0xC2, 0x30, 0xC6, 0x31, 0x86, 0x61, 0x86, 0x61, 0x86,
  0x61, 0x8C, 0x61, 0x0C, 0xC3, 0x0C, 0xC3, 0x0C, 0x1B, 0x85, 0xF3, 0x8C,
  0xE3, 0x30, 0xCC, 0x33, 0x0D, 0x86, 0x61, 0x98, 0x66, 0x1B, 0x0E, 0xC3,
  0x00, 0x1F, 0x1F, 0xDC, 0x6C, 0x36, 0x1E, 0x0F, 0x07, 0x83, 0xC3, 0x61,
  0xB1, 0xDD, 0xC7, 0xC0, 0x0D, 0xC1, 0x7C, 0x71, 0x8E, 0x31, 0x86, 0x30,
  0xC4, 0x19, 0x83, 0x30, 0x66, 0x18, 0xC3, 0x15, 0xC6, 0xF0, 0xC0, 0x18,
  0x03, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x00, 0x1E, 0xCF, 0xF3, 0x1D, 0x86,
  0x61, 0xB0, 0x6C, 0x1B, 0x0C, 0xC3, 0x30, 0xCC, 0x73, 0xFC, 0x7E, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x13, 0x8B, 0x8E, 0x07, 0x03,
  0x01, 0x80, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x18, 0x0C, 0x00, 0x1F, 0x9F,
  0x8C, 0x0C, 0x03, 0x01, 0xC0, 0x70, 0x1C, 0x06, 0x03, 0x01, 0x9B, 0x8F,
  0x80, 0x18, 0x43, 0x1F, 0xFD, 0x86, 0x18, 0x61, 0x8C, 0x30, 0xC3, 0x0D,
  0x3C, 0x30, 0xCC, 0x36, 0x19, 0x86, 0x61, 0x98, 0x6C, 0x13, 0x0C, 0xC3,
  0x30, 0xCC, 0x73, 0xE8, 0xF2, 0x00, 0xC1, 0xE0, 0xF0, 0xC8, 0x64, 0x62,
  0x31, 0x30, 0x98, 0x58, 0x2C, 0x14, 0x0E, 0x06, 0x00, 0xC3, 0x0F, 0x0C,
  0x3C, 0x71, 0xB1, 0xC6, 0xC5, 0x1B, 0x34, 0xCC, 0x93, 0x36, 0x58, 0xD9,
  0x63, 0xC5, 0x0F, 0x1C, 0x38, 0x70, 0xE1, 0x80, 0x18, 0x63, 0x18, 0x66,
  0x06, 0xC0, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x1E, 0x06, 0x60, 0xCC, 0x31,
  0x8C, 0x38, 0x18, 0x30, 0x83, 0x08, 0x60, 0x86, 0x0C, 0xC0, 0xCC, 0x0D,
  0x80, 0xD8, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C,
  0x01, 0x80, 0x38, 0x0F, 0x00, 0xC0, 0x00, 0x1F, 0x8F, 0xC0, 0xE0, 0x60,
  0x60, 0x30, 0x30, 0x30, 0x18, 0x18, 0x18, 0x0F, 0xCF, 0xE0, 0x03, 0x83,
  0xC1, 0x80, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x18, 0x3C, 0x38, 0x06, 0x01,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x07, 0x01, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x0E, 0x07, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x08, 0x04, 0x03, 0xC0, 0xC1, 0xC0, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x18,
  0x0C, 0x1E, 0x0C, 0x00, 0x78, 0x7F, 0xF8, 0x78,
};

const GFXglyph NotoSans_Condensed_Italic24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 6, 17, 6, 0, -17 },
  { 14, 7, 6, 9, 2, -17 },
  { 20, 12, 17, 12, 0, -17 },
  { 46, 11, 19, 11, 0, -18 },
  { 73, 14, 17, 16, 1, -17 },
  { 103, 12, 17, 12, 0, -17 },
  { 129, 3, 6, 5, 3, -17 },
  { 132, 7, 21, 6, 1, -17 },
  { 151, 8, 21, 6, -2, -17 },
  { 172, 9, 9, 10, 2, -18 },
  { 183, 10, 11, 11, 1, -14 },
  { 197, 4, 6, 5, -1, -3 },
  { 200, 6, 1, 7, 0, -7 },
  { 201, 3, 3, 5, 0, -3 },
  { 203, 11, 17, 8, -1, -17 },
  { 227, 9, 17, 11, 1, -17 },
  { 247, 6, 17, 11, 3, -17 },
  { 260, 11, 17, 11, -1, -17 },
  { 284, 10, 17, 11, 0, -17 },
  { 306, 10, 17, 11, 0, -17 },
  { 328, 11, 17, 11, 0, -17 },
  { 352, 10, 17, 11, 1, -17 },
  { 374, 10, 17, 11, 1, -17 },
  { 396, 11, 17, 11, 0, -17 },
  { 420, 10, 17, 11, 0, -17 },
  { 442, 5, 13, 5, 0, -13 },
  { 451, 6, 16, 5, -1, -13 },
  { 463, 10, 11, 11, 1, -14 },
  { 477, 10, 7, 11, 1, -12 },
  { 486, 10, 11, 11, 1, -14 },
  { 500, 8, 17, 8, 1, -17 },
  { 517, 15, 19, 16, 1, -17 },
  { 553, 11, 17, 11, -2, -17 },
  { 577, 12, 17, 12, 0, -17 },
  { 603, 11, 17, 11, 1, -17 },
  { 627, 12, 17, 13, 0, -17 },
  { 653, 11, 17, 10, 0, -17 },
  { 677, 11, 17, 9, 0, -17 },
  { 701, 12, 17, 13, 1, -17 },
  { 727, 13, 17, 13, 0, -17 },
  { 755, 9, 17, 7, -1, -17 },
  { 775, 10, 22, 5, -4, -17 },
  { 803, 13, 17, 11, 0, -17 },
  { 831, 8, 17, 9, 0, -17 },
  { 848, 17, 17, 17, 0, -17 },
  { 885, 14, 17, 14, 0, -17 },
  { 915, 12, 17, 14, 1, -17 },
  { 941, 11, 17, 11, 0, -17 },
  { 965, 12, 21, 14, 1, -17 },
  { 997, 11, 17, 11, 0, -17 },
  { 1021, 11, 17, 10, 0, -17 },
  { 1045, 9, 17, 9, 2, -17 },
  { 1065, 12, 17, 13, 1, -17 },
  { 1091, 11, 17, 11, 2, -17 },
  { 1115, 17, 17, 17, 2, -17 },
  { 1152, 13, 17, 10, -1, -17 },
  { 1180, 10, 17, 10, 2, -17 },
  { 1202, 12, 17, 9, -1, -17 },
  { 1228, 10, 21, 7, -1, -17 },
  { 1255, 5, 17, 8, 2, -17 },
  { 1266, 9, 21, 7, -2, -17 },
  { 1290, 10, 10, 11, 0, -17 },
  { 1303, 8, 2, 8, -2, 2 },
  { 1305, 4, 3, 6, 3, -18 },
  { 1307, 10, 13, 11, 1, -13 },
  { 1324, 10, 18, 11, 0, -18 },
  { 1347, 8, 13, 9, 1, -13 },
  { 1360, 11, 18, 11, 1, -18 },
  { 1385, 9, 13, 10, 1, -13 },
  { 1400, 12, 24, 6, -3, -18 },
  { 1436, 11, 19, 11, 0, -13 },
  { 1463, 10, 18, 11, 0, -18 },
  { 1486, 6, 18, 5, 0, -18 },
  { 1500, 9, 24, 5, -3, -18 },
  { 1527, 11, 18, 10, 0, -18 },
  { 1552, 6, 18, 5, 0, -18 },
  { 1566, 16, 13, 17, 0, -13 },
  { 1592, 10, 13, 11, 0, -13 },
  { 1609, 9, 13, 11, 1, -13 },
  { 1624, 11, 19, 11, -1, -13 },
  { 1651, 10, 19, 11, 1, -13 },
  { 1675, 9, 13, 8, 0, -13 },
  { 1690, 9, 13, 8, 0, -13 },
  { 1705, 6, 16, 6, 1, -16 },
  { 1717, 10, 13, 11, 1, -13 },
  { 1734, 9, 13, 9, 1, -13 },
  { 1749, 14, 13, 14, 1, -13 },
  { 1772, 11, 13, 9, -1, -13 },
  { 1790, 12, 19, 9, -2, -13 },
  { 1819, 9, 13, 8, -1, -13 },
  { 1834, 9, 21, 8, 0, -17 },
  { 1858, 2, 24, 10, 4, -18 },
  { 1864, 9, 21, 8, -1, -17 },
  { 1888, 10, 3, 11, 1, -10 },
};

const GFXfont NotoSans_Condensed_Italic24pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Italic24pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Italic24pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _NOTOSANS_CONDENSED_ITALIC24PT7B_H_
