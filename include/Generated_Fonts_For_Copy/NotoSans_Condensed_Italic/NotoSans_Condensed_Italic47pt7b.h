#ifndef _NOTOSANS_CONDENSED_ITALIC47PT7B_H_
#define _NOTOSANS_CONDENSED_ITALIC47PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Italic.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Italic47pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x3C, 0x07, 0x81, 0xF0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x0E,
  0x03, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xC0, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x02, 0x00, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x1E, 0x00,
  0x3C, 0x7B, 0xE3, 0xDE, 0x1E, 0xF0, 0xE7, 0x8F, 0x38, 0x79, 0xC3, 0xCE,
  0x1C, 0xF0, 0xE7, 0x07, 0x38, 0x71, 0xC3, 0x8E, 0x1C, 0x00, 0x00, 0x0E,
  0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x3C,
  0x38, 0x00, 0x38, 0x38, 0x00, 0x38, 0x38, 0x00, 0x38, 0x38, 0x00, 0x70,
  0x70, 0x00, 0x70, 0x70, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0x00, 0xE0, 0xE0, 0x01, 0xC1, 0xC0, 0x01, 0xC1, 0xC0, 0x01, 0xC1,
  0xC0, 0x03, 0xC3, 0x80, 0x03, 0x83, 0x80, 0x03, 0x83, 0x80, 0x03, 0x83,
  0x00, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x0E, 0x0E,
  0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x1C,
  0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x38, 0x00, 0x38, 0x38,
  0x00, 0x78, 0x78, 0x00, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0C, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x7F,
  0xBE, 0x07, 0xCC, 0x30, 0x3C, 0x60, 0x01, 0xC3, 0x00, 0x0E, 0x38, 0x00,
  0xF1, 0x80, 0x07, 0x8C, 0x00, 0x1E, 0x60, 0x00, 0xFB, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x37, 0xC0, 0x01, 0x9E, 0x00, 0x0C, 0x70, 0x00, 0x63, 0xC0, 0x07, 0x1E,
  0x00, 0x30, 0xE0, 0x01, 0x87, 0x08, 0x0C, 0x78, 0x30, 0x67, 0x81, 0xFF,
  0xFC, 0x1F, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0xC0, 0x07, 0x81, 0xFC, 0x00, 0xE0, 0x7F, 0xC0, 0x38, 0x0E, 0x38, 0x07,
  0x03, 0x87, 0x01, 0xC0, 0x70, 0xE0, 0x78, 0x1C, 0x1C, 0x0E, 0x03, 0x83,
  0x83, 0x80, 0x70, 0x70, 0x70, 0x1C, 0x0E, 0x1C, 0x03, 0x81, 0xC7, 0x80,
  0x70, 0x70, 0xE0, 0x0E, 0x0E, 0x38, 0x01, 0xC1, 0xC7, 0x04, 0x38, 0x79,
  0xC7, 0xE7, 0x0E, 0x79, 0xFE, 0xE1, 0xCE, 0x79, 0xDC, 0x73, 0xCE, 0x3B,
  0xFE, 0x73, 0x87, 0xBF, 0x9C, 0x70, 0xF3, 0xC3, 0x9C, 0x1E, 0x00, 0xE3,
  0x83, 0x80, 0x3C, 0x70, 0x70, 0x07, 0x0E, 0x0E, 0x01, 0xC3, 0xC1, 0xC0,
  0x38, 0x70, 0x38, 0x0E, 0x0E, 0x0E, 0x03, 0xC1, 0xC1, 0xC0, 0x70, 0x38,
  0x38, 0x1E, 0x07, 0x0E, 0x03, 0x80, 0xE3, 0xC0, 0xE0, 0x1E, 0xF0, 0x3C,
  0x01, 0xFC, 0x07, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x80,
  0x01, 0xFF, 0x80, 0x07, 0x8F, 0x00, 0x1E, 0x0E, 0x00, 0x3C, 0x1C, 0x00,
  0x70, 0x38, 0x00, 0xE0, 0x70, 0x03, 0xC1, 0xE0, 0x07, 0x83, 0x80, 0x07,
  0x0F, 0x00, 0x0E, 0x3C, 0x00, 0x1E, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0,
  0x78, 0xF9, 0xE0, 0xE3, 0xE3, 0xC3, 0xC7, 0x83, 0xC7, 0x1E, 0x07, 0x9E,
  0x3C, 0x0F, 0xBC, 0x70, 0x0F, 0xF1, 0xE0, 0x1F, 0xC3, 0xC0, 0x1F, 0x87,
  0x80, 0x3E, 0x0F, 0x00, 0x7C, 0x1F, 0x01, 0xF8, 0x1F, 0x0F, 0xF8, 0x3F,
  0xFE, 0xF0, 0x3F, 0xF8, 0xF0, 0x3F, 0xC1, 0xF0, 0x3C, 0xF7, 0x9E, 0x79,
  0xE7, 0x1C, 0x73, 0xCE, 0x38, 0xE0, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x03, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x07, 0x80, 0x0F,
  0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x00,
  0xE0, 0x01, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x38,
  0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF0,
  0x03, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0xF0, 0x00, 0x01,
  0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x41, 0xC0, 0xF1, 0xC0, 0xFD,
  0xC1, 0xFF, 0xFF, 0x1F, 0xFF, 0x07, 0xFF, 0x0F, 0xC0, 0x1E, 0xE0, 0x3C,
  0xE0, 0x7C, 0xF0, 0x78, 0x70, 0x30, 0x78, 0x10, 0x70, 0x00, 0x40, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x0F, 0x1E, 0x1E, 0x1E, 0x3C,
  0x3C, 0x78, 0x70, 0x70, 0xE0, 0xFF, 0xFF, 0xFB, 0xFF, 0x00, 0x23, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0x00, 0xFB, 0xF0, 0x3C, 0x1E,
  0x0F, 0x83, 0xC1, 0xE0, 0x78, 0x78, 0x07, 0x0F, 0x00, 0xE3, 0xC0, 0x1C,
  0x78, 0x07, 0x8F, 0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x03, 0xCF, 0x00, 0x79,
  0xE0, 0x0F, 0x38, 0x01, 0xEF, 0x00, 0x39, 0xE0, 0x0F, 0x3C, 0x01, 0xE7,
  0x80, 0x3C, 0xF0, 0x07, 0x9C, 0x01, 0xE3, 0x80, 0x3C, 0xF0, 0x07, 0x9E,
  0x01, 0xE1, 0xC0, 0x3C, 0x38, 0x0F, 0x07, 0x81, 0xE0, 0xF0, 0x78, 0x1F,
  0x1F, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x03, 0xF8, 0x00, 0x00, 0x78, 0x07,
  0xC0, 0x7C, 0x07, 0xE0, 0xFF, 0x0F, 0xF8, 0xFB, 0xDF, 0x9C, 0x71, 0xE1,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0x00, 0x7F,
  0xFC, 0x07, 0xF7, 0xF0, 0x1C, 0x0F, 0x80, 0x40, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0xE0, 0x3E, 0x3F, 0x03, 0x00, 0xF0,
  0x20, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F,
  0x80, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x08,
  0x01, 0xF0, 0xE0, 0x3E, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1D, 0xC0, 0x01, 0xDE, 0x00, 0x1E, 0xF0,
  0x00, 0xE7, 0x80, 0x0E, 0x38, 0x00, 0xF3, 0xC0, 0x07, 0x1E, 0x00, 0x70,
  0xF0, 0x07, 0x87, 0x80, 0x38, 0x38, 0x03, 0x83, 0xC0, 0x3C, 0x1E, 0x01,
  0xC0, 0xF0, 0x1C, 0x07, 0x01, 0xE0, 0x78, 0x1E, 0x03, 0xC0, 0xE0, 0x1E,
  0x0F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0xBF, 0xFF, 0xFC, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0,
  0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x07, 0xB8, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xE0,
  0x0F, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x40, 0x0F,
  0x83, 0x80, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xF8, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0xFE, 0x30, 0x3E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x71, 0xF8, 0x1E, 0xFF, 0x83,
  0xFF, 0xF8, 0x7F, 0x1F, 0x0F, 0x81, 0xF3, 0xE0, 0x1E, 0x7C, 0x03, 0xCF,
  0x00, 0x79, 0xE0, 0x0F, 0x3C, 0x01, 0xE7, 0x80, 0x3C, 0xE0, 0x0F, 0x1C,
  0x01, 0xE3, 0x80, 0x3C, 0x78, 0x0F, 0x0F, 0x01, 0xE1, 0xE0, 0x78, 0x1E,
  0x1F, 0x03, 0xFF, 0xC0, 0x3F, 0xF0, 0x03, 0xFC, 0x00, 0x1F, 0xFF, 0xF1,
  0xFF, 0xFF, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x03, 0xFF, 0x00, 0x7F, 0xFC, 0x03, 0xE3, 0xE0, 0x3C, 0x0F, 0x81,
  0xE0, 0x3C, 0x1E, 0x01, 0xE0, 0xF0, 0x0F, 0x07, 0x80, 0x78, 0x3C, 0x03,
  0x81, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x3C, 0x1E, 0x01, 0xF3, 0xE0, 0x07,
  0xFE, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xF0, 0x01, 0xF7, 0xC0,
  0x3E, 0x1E, 0x01, 0xE0, 0x78, 0x1E, 0x03, 0xC1, 0xE0, 0x0F, 0x0F, 0x00,
  0x78, 0x70, 0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x00, 0xF1, 0xE0, 0x07, 0x87,
  0x80, 0x78, 0x3C, 0x03, 0xC1, 0xF0, 0x3C, 0x07, 0xFF, 0xE0, 0x1F, 0xFE,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x03,
  0xF3, 0xE0, 0x78, 0x3C, 0x1E, 0x03, 0xC3, 0xC0, 0x78, 0xF0, 0x0F, 0x1E,
  0x01, 0xE3, 0x80, 0x3C, 0xF0, 0x07, 0x9E, 0x00, 0xF3, 0xC0, 0x1E, 0x78,
  0x03, 0xCF, 0x00, 0xF9, 0xE0, 0x1E, 0x3C, 0x07, 0xC3, 0xC1, 0xF8, 0x7F,
  0xFF, 0x07, 0xFD, 0xE0, 0xFF, 0x38, 0x02, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x20, 0x7C, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xE0,
  0x00, 0x01, 0x01, 0xE0, 0x7C, 0x1F, 0x0F, 0x81, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x10, 0x1E, 0x07, 0xC3, 0xF0, 0xF8, 0x1E, 0x00, 0x00, 0x40,
  0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x03,
  0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x0C, 0x00, 0x07, 0x80, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00,
  0x7C, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF0, 0x00, 0x0E,
  0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x80, 0x00,
  0x18, 0x00, 0x03, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF0, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x7C, 0x00, 0x0E, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x3F, 0xF8, 0xFF, 0xF0, 0xF3, 0xF1, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xF0, 0x07, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x1E, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFC, 0x0F, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0xF0, 0x00, 0x70, 0x0F, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0E,
  0x0F, 0x00, 0x00, 0x70, 0x70, 0x04, 0x03, 0x87, 0x01, 0xFF, 0x1C, 0x38,
  0x1F, 0xF0, 0x63, 0x81, 0xE3, 0x83, 0x9C, 0x1C, 0x1C, 0x19, 0xE1, 0xE1,
  0xE1, 0xCE, 0x0E, 0x0E, 0x0E, 0x70, 0xE0, 0x70, 0x73, 0x87, 0x03, 0x83,
  0xB8, 0x38, 0x3C, 0x1D, 0xC3, 0x81, 0xC1, 0xCE, 0x1C, 0x0E, 0x0E, 0x70,
  0xE0, 0xF0, 0x73, 0x87, 0x07, 0x87, 0x1C, 0x38, 0x38, 0x38, 0xE1, 0xC3,
  0xC3, 0x87, 0x0F, 0x3F, 0x3C, 0x38, 0x7F, 0xBF, 0xC1, 0xC1, 0xF8, 0xFC,
  0x0E, 0x03, 0x03, 0x80, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x30, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xB8, 0x00, 0x1D, 0xC0, 0x01, 0xEE, 0x00, 0x0E,
  0x70, 0x00, 0xF3, 0x80, 0x07, 0x1C, 0x00, 0x78, 0xE0, 0x03, 0xC7, 0x80,
  0x3C, 0x3C, 0x01, 0xE1, 0xE0, 0x1E, 0x0F, 0x00, 0xF0, 0x78, 0x07, 0x03,
  0xC0, 0x78, 0x1E, 0x03, 0xC0, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x1F,
  0xFF, 0xE0, 0xF0, 0x0F, 0x0F, 0x80, 0x78, 0x78, 0x03, 0xC7, 0xC0, 0x1E,
  0x3C, 0x00, 0xF1, 0xE0, 0x07, 0x9E, 0x00, 0x3C, 0xF0, 0x01, 0xEF, 0x00,
  0x0F, 0x78, 0x00, 0x7F, 0xC0, 0x03, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFE, 0x03, 0xC0, 0xF8, 0x0F, 0x01, 0xF0,
  0x78, 0x07, 0xC1, 0xE0, 0x0F, 0x07, 0x80, 0x3C, 0x1E, 0x01, 0xF0, 0x70,
  0x07, 0x83, 0xC0, 0x1E, 0x0F, 0x00, 0xF0, 0x3C, 0x07, 0xC0, 0xF0, 0x7E,
  0x07, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x7F, 0xFE, 0x01, 0xE0, 0x7C, 0x07,
  0x80, 0xF0, 0x3C, 0x01, 0xE0, 0xF0, 0x07, 0x83, 0xC0, 0x1E, 0x0F, 0x00,
  0x78, 0x38, 0x01, 0xE1, 0xE0, 0x07, 0x87, 0x80, 0x3E, 0x1E, 0x00, 0xF0,
  0x78, 0x07, 0xC1, 0xC0, 0x3E, 0x0F, 0x07, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFC, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0xC0, 0x7F, 0xBE, 0x03, 0xF0, 0x10, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xF0, 0x60, 0x0F, 0xFF, 0x80, 0x1F, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x80,
  0x1F, 0xFF, 0x80, 0x3C, 0x1F, 0x80, 0x78, 0x0F, 0x81, 0xE0, 0x0F, 0x03,
  0xC0, 0x1E, 0x07, 0x80, 0x3E, 0x0F, 0x00, 0x7C, 0x1C, 0x00, 0x78, 0x78,
  0x00, 0xF0, 0xF0, 0x01, 0xE1, 0xE0, 0x03, 0xC3, 0xC0, 0x0F, 0x8F, 0x00,
  0x1F, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x78, 0x00, 0xF0, 0xF0, 0x01,
  0xE3, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x0F, 0x00, 0x3E, 0x1E, 0x00, 0x78,
  0x38, 0x00, 0xF0, 0xF0, 0x03, 0xC1, 0xE0, 0x0F, 0x83, 0xC0, 0x3E, 0x07,
  0x80, 0xF8, 0x0E, 0x03, 0xF0, 0x3C, 0x7F, 0xC0, 0x7F, 0xFE, 0x00, 0xFF,
  0xF8, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF,
  0xF0, 0x3F, 0xFF, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0x01,
  0xFF, 0xF0, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xFF,
  0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x03,
  0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0xFF,
  0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xFE, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0x7E, 0x01, 0xF0, 0x06, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x07, 0xFC, 0x78, 0x07,
  0xFC, 0xF8, 0x07, 0xF8, 0xF0, 0x0F, 0xF8, 0xF0, 0x00, 0x78, 0xF0, 0x00,
  0x78, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0xF0, 0x00,
  0xF0, 0xF8, 0x00, 0xF0, 0x78, 0x00, 0xE0, 0x7C, 0x01, 0xE0, 0x7C, 0x01,
  0xE0, 0x3F, 0x03, 0xE0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x07, 0xFF,
  0x80, 0x01, 0xE0, 0x07, 0x81, 0xE0, 0x03, 0xC0, 0xF0, 0x01, 0xE0, 0x78,
  0x00, 0xF0, 0x3C, 0x00, 0x70, 0x1E, 0x00, 0x78, 0x1E, 0x00, 0x3C, 0x0F,
  0x00, 0x1E, 0x07, 0x80, 0x0F, 0x03, 0xC0, 0x0F, 0x01, 0xC0, 0x07, 0x81,
  0xE0, 0x03, 0xC0, 0xF0, 0x01, 0xE0, 0x78, 0x00, 0xE0, 0x3C, 0x00, 0xF0,
  0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0x80, 0x1E,
  0x03, 0xC0, 0x0F, 0x03, 0xC0, 0x07, 0x81, 0xE0, 0x03, 0xC0, 0xF0, 0x01,
  0xE0, 0x78, 0x01, 0xE0, 0x38, 0x00, 0xF0, 0x3C, 0x00, 0x78, 0x1E, 0x00,
  0x3C, 0x0F, 0x00, 0x1E, 0x07, 0x80, 0x1E, 0x03, 0x80, 0x0F, 0x03, 0xC0,
  0x07, 0x81, 0xE0, 0x03, 0xC0, 0xF0, 0x01, 0xC0, 0x78, 0x01, 0xE0, 0x00,
  0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xFF, 0x00,
  0xFF, 0xF0, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00,
  0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x0F, 0x03, 0xC0, 0x1E, 0x03, 0xC0, 0x3E, 0x03, 0xC0, 0x7C,
  0x03, 0xC0, 0x78, 0x03, 0x80, 0xF0, 0x07, 0x81, 0xE0, 0x07, 0x83, 0xE0,
  0x07, 0x87, 0xC0, 0x07, 0x87, 0x80, 0x07, 0x0F, 0x00, 0x0F, 0x1F, 0x00,
  0x0F, 0x3E, 0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x78, 0x00, 0x1E, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x78, 0x00,
  0x3E, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3E, 0x00,
  0x38, 0x1E, 0x00, 0x78, 0x1E, 0x00, 0x78, 0x1E, 0x00, 0x78, 0x0F, 0x00,
  0x78, 0x0F, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x80,
  0xF0, 0x07, 0x80, 0xF0, 0x07, 0x80, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x38, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00,
  0x3F, 0xFF, 0xFF, 0xFB, 0xFF, 0xE0, 0x01, 0xF0, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x07, 0xE0, 0x3F,
  0x00, 0x07, 0xF0, 0x1F, 0x80, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xFC, 0x0F,
  0xF0, 0x01, 0xDC, 0x07, 0xF8, 0x01, 0xFE, 0x03, 0xBC, 0x00, 0xEF, 0x01,
  0xDE, 0x00, 0xF7, 0x81, 0xEF, 0x00, 0x73, 0xC0, 0xF7, 0x80, 0x7B, 0xC0,
  0x7B, 0xC0, 0x39, 0xE0, 0x38, 0xE0, 0x3C, 0xF0, 0x3C, 0x70, 0x1C, 0x78,
  0x1E, 0x38, 0x1E, 0x3C, 0x0F, 0x1C, 0x0E, 0x3C, 0x07, 0x8E, 0x0F, 0x1E,
  0x03, 0x87, 0x07, 0x0F, 0x03, 0xC3, 0x87, 0x87, 0x81, 0xE1, 0xC3, 0xC3,
  0x80, 0xF0, 0xE3, 0xC3, 0xC0, 0x70, 0x79, 0xE1, 0xE0, 0x38, 0x3C, 0xE0,
  0xF0, 0x3C, 0x1E, 0xF0, 0x78, 0x1E, 0x0F, 0x70, 0x38, 0x0F, 0x07, 0xF8,
  0x3C, 0x07, 0x03, 0xF8, 0x1E, 0x03, 0x80, 0xFC, 0x0F, 0x03, 0xC0, 0x7C,
  0x07, 0x81, 0xE0, 0x3E, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x0F,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x7C, 0x00, 0x38, 0x0F, 0xC0,
  0x0F, 0x01, 0xF8, 0x01, 0xE0, 0x3F, 0x00, 0x3C, 0x07, 0xE0, 0x07, 0x81,
  0xFE, 0x00, 0xE0, 0x3F, 0xC0, 0x3C, 0x07, 0xF8, 0x07, 0x80, 0xE7, 0x00,
  0xF0, 0x1C, 0xE0, 0x1E, 0x07, 0x9E, 0x03, 0x80, 0xF3, 0xC0, 0xF0, 0x1E,
  0x78, 0x1E, 0x03, 0x87, 0x03, 0xC0, 0xF0, 0xF0, 0x70, 0x1E, 0x1E, 0x0E,
  0x03, 0xC3, 0xC3, 0xC0, 0x78, 0x38, 0x78, 0x0E, 0x07, 0x0F, 0x03, 0xC0,
  0xF1, 0xC0, 0x78, 0x1E, 0x78, 0x0F, 0x01, 0xCF, 0x01, 0xE0, 0x39, 0xE0,
  0x38, 0x07, 0xBC, 0x0F, 0x00, 0xF7, 0x01, 0xE0, 0x1E, 0xE0, 0x3C, 0x01,
  0xFC, 0x07, 0x00, 0x3F, 0x80, 0xE0, 0x07, 0xF0, 0x3C, 0x00, 0xFC, 0x07,
  0x80, 0x0F, 0x80, 0xF0, 0x01, 0xF0, 0x1C, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xF8, 0x01, 0xFD, 0xFC, 0x03, 0xE0,
  0x3C, 0x07, 0xC0, 0x3E, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0x1E, 0x0F, 0x00,
  0x1E, 0x1E, 0x00, 0x1F, 0x1E, 0x00, 0x0F, 0x3C, 0x00, 0x1F, 0x3C, 0x00,
  0x1F, 0x3C, 0x00, 0x1E, 0x7C, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00,
  0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0xF8, 0x00, 0x3C, 0xF0, 0x00,
  0x3C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x78, 0xF0, 0x00,
  0x78, 0xF0, 0x00, 0xF0, 0xF0, 0x01, 0xF0, 0xF8, 0x01, 0xE0, 0x78, 0x03,
  0xE0, 0x7C, 0x07, 0xC0, 0x3E, 0x1F, 0x80, 0x3F, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x3C, 0x1F, 0x01, 0xE0, 0x7C, 0x1E, 0x01, 0xE0, 0xF0,
  0x0F, 0x07, 0x80, 0x78, 0x3C, 0x03, 0xC1, 0xC0, 0x1E, 0x1E, 0x00, 0xF0,
  0xF0, 0x0F, 0x07, 0x80, 0x78, 0x3C, 0x07, 0xC3, 0xC0, 0x7C, 0x1E, 0x07,
  0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xF8, 0x01, 0xFD, 0xFC, 0x03, 0xE0,
  0x3C, 0x07, 0xC0, 0x3E, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0x1E, 0x0F, 0x00,
  0x1E, 0x1E, 0x00, 0x1F, 0x1E, 0x00, 0x0F, 0x3C, 0x00, 0x1F, 0x3C, 0x00,
  0x1E, 0x3C, 0x00, 0x1E, 0x7C, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00,
  0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0xF8, 0x00, 0x3C, 0xF0, 0x00,
  0x3C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x78, 0xF0, 0x00,
  0x78, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0x78, 0x01, 0xE0, 0x78, 0x03,
  0xE0, 0x7C, 0x07, 0xC0, 0x3E, 0x1F, 0x80, 0x3F, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x3C, 0x1F, 0x01, 0xE0, 0x7C, 0x1E, 0x01, 0xE0, 0xF0,
  0x0F, 0x07, 0x80, 0x78, 0x3C, 0x03, 0xC1, 0xC0, 0x1E, 0x1E, 0x01, 0xF0,
  0xF0, 0x0F, 0x07, 0x80, 0x78, 0x3C, 0x07, 0x83, 0xC0, 0x7C, 0x1E, 0x0F,
  0xC0, 0xFF, 0xFC, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xC3, 0xC0, 0x1E,
  0x1E, 0x00, 0xF0, 0xF0, 0x07, 0x83, 0xC0, 0x38, 0x1E, 0x03, 0xC0, 0xF0,
  0x1E, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x38, 0x07, 0x83, 0xC0,
  0x3C, 0x1E, 0x00, 0xF0, 0xF0, 0x07, 0x87, 0x80, 0x3C, 0x00, 0x00, 0x3F,
  0xC0, 0x07, 0xFF, 0x80, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7C, 0x03, 0x03,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF0, 0x40, 0x0F, 0x83, 0xC1, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xF8,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x0F,
  0x07, 0x80, 0x0F, 0x07, 0x80, 0x0F, 0x07, 0x80, 0x0E, 0x07, 0x00, 0x1E,
  0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x3C,
  0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x3C,
  0x1E, 0x00, 0x78, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0x78,
  0x3C, 0x00, 0x70, 0x38, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0x78, 0x00, 0xF0,
  0x78, 0x00, 0xF0, 0x78, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xE0,
  0xF0, 0x01, 0xE0, 0xF0, 0x03, 0xC0, 0xF0, 0x03, 0xC0, 0xF0, 0x07, 0x80,
  0x78, 0x0F, 0x80, 0x7C, 0x1F, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x3D, 0xE0,
  0x03, 0xEF, 0x00, 0x1E, 0x78, 0x00, 0xF3, 0xC0, 0x0F, 0x1E, 0x00, 0x78,
  0xF0, 0x07, 0x87, 0x80, 0x3C, 0x1C, 0x03, 0xC0, 0xE0, 0x1E, 0x07, 0x00,
  0xF0, 0x38, 0x0F, 0x01, 0xC0, 0x78, 0x0E, 0x07, 0x80, 0x70, 0x3C, 0x03,
  0x83, 0xC0, 0x1C, 0x1E, 0x00, 0xE1, 0xE0, 0x07, 0x8F, 0x00, 0x3C, 0x70,
  0x01, 0xE7, 0x80, 0x0F, 0x3C, 0x00, 0x7B, 0xC0, 0x03, 0xDE, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0x70, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x01, 0xE0,
  0x07, 0xF8, 0x00, 0xF0, 0x03, 0xFC, 0x00, 0xF8, 0x03, 0xFE, 0x00, 0x7C,
  0x01, 0xEF, 0x00, 0x7E, 0x00, 0xF7, 0x80, 0x3F, 0x00, 0xF3, 0xC0, 0x1F,
  0x80, 0x79, 0xE0, 0x1F, 0xC0, 0x78, 0xF0, 0x0F, 0xE0, 0x3C, 0x78, 0x0F,
  0xF0, 0x1E, 0x3C, 0x07, 0x78, 0x1E, 0x1E, 0x07, 0xBC, 0x0F, 0x0F, 0x03,
  0x9E, 0x0F, 0x07, 0x81, 0xCF, 0x07, 0x83, 0xC1, 0xE7, 0x83, 0xC1, 0xE0,
  0xE3, 0xC3, 0xC0, 0xF0, 0xF1, 0xE1, 0xE0, 0x78, 0x70, 0xF1, 0xE0, 0x3C,
  0x38, 0x78, 0xF0, 0x1E, 0x3C, 0x3C, 0x70, 0x0F, 0x1C, 0x1E, 0x78, 0x07,
  0x9E, 0x0F, 0x3C, 0x03, 0xCE, 0x07, 0x3C, 0x01, 0xE7, 0x03, 0x9E, 0x00,
  0xF7, 0x81, 0xCE, 0x00, 0x7B, 0x80, 0xEF, 0x00, 0x3F, 0xC0, 0x77, 0x80,
  0x1F, 0xC0, 0x3B, 0x80, 0x0F, 0xE0, 0x1F, 0xC0, 0x07, 0xE0, 0x0F, 0xC0,
  0x03, 0xF0, 0x07, 0xE0, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0xF8, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x3C, 0x01,
  0xE0, 0x07, 0x80, 0x78, 0x01, 0xE0, 0x3C, 0x00, 0x78, 0x1F, 0x00, 0x1E,
  0x07, 0x80, 0x07, 0x83, 0xC0, 0x00, 0xE0, 0xF0, 0x00, 0x3C, 0x78, 0x00,
  0x0F, 0x1C, 0x00, 0x03, 0xCF, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x1D, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3D, 0xE0, 0x00, 0x0F, 0x78, 0x00, 0x07, 0x8E, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x3E, 0x0F,
  0x00, 0x0F, 0x03, 0xC0, 0x07, 0x80, 0x78, 0x01, 0xE0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x78, 0x01, 0xE0, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xFE,
  0x00, 0x7B, 0xC0, 0x0F, 0x38, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x1E, 0x1E,
  0x07, 0xC3, 0xC0, 0xF0, 0x78, 0x3C, 0x0F, 0x07, 0x80, 0xE1, 0xE0, 0x1C,
  0x3C, 0x03, 0xCF, 0x00, 0x79, 0xE0, 0x0F, 0x78, 0x01, 0xEE, 0x00, 0x1F,
  0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC,
  0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF8, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0xFC, 0x03,
  0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0xE0, 0xE0, 0xF0, 0xF0, 0xF0,
  0x70, 0x70, 0x70, 0x70, 0x78, 0x78, 0x78, 0x78, 0x38, 0x38, 0x38, 0x38,
  0x3C, 0x3C, 0x3C, 0x3C, 0x1C, 0x1C, 0x1C, 0x1E, 0x1E, 0x1E, 0x1E, 0x0E,
  0x0E, 0x0E, 0x0E, 0x0F, 0x0F, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x01, 0xCE, 0x00, 0x3C, 0xE0,
  0x03, 0x8F, 0x00, 0x78, 0x70, 0x07, 0x07, 0x00, 0xF0, 0x78, 0x0E, 0x03,
  0x81, 0xE0, 0x38, 0x1C, 0x03, 0xC3, 0xC0, 0x1C, 0x78, 0x01, 0xE7, 0x80,
  0x1E, 0xF0, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xF1,
  0xE3, 0xC3, 0xC3, 0x87, 0x07, 0x00, 0x30, 0x00, 0x0F, 0xF3, 0xC0, 0xFF,
  0x9C, 0x0F, 0xFE, 0xE0, 0x78, 0x3F, 0x07, 0x80, 0xF8, 0x7C, 0x07, 0x83,
  0xC0, 0x3C, 0x3E, 0x01, 0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0x78, 0xF0, 0x03,
  0x87, 0x80, 0x3C, 0x3C, 0x01, 0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0x78, 0x78,
  0x07, 0x83, 0x80, 0x3C, 0x3C, 0x03, 0xE1, 0xE0, 0x1F, 0x07, 0x81, 0xF0,
  0x3C, 0x0F, 0x81, 0xE0, 0xDC, 0x0F, 0xFD, 0xE0, 0x3F, 0xCF, 0x00, 0xFC,
  0x70, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC3, 0x00, 0x38, 0xFC, 0x07, 0xBF, 0xE0, 0x7F,
  0xFF, 0x07, 0x60, 0xF0, 0x7C, 0x0F, 0x0F, 0xC0, 0xF0, 0xF8, 0x07, 0x0F,
  0x00, 0x70, 0xF0, 0x07, 0x0F, 0x00, 0xF1, 0xE0, 0x0F, 0x1E, 0x00, 0xF1,
  0xE0, 0x0F, 0x1E, 0x00, 0xF1, 0xC0, 0x1E, 0x3C, 0x01, 0xE3, 0xC0, 0x1E,
  0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x3C, 0x07, 0xC7, 0xC0, 0x78, 0x7E, 0x1F,
  0x07, 0x7F, 0xF0, 0x73, 0xFE, 0x0F, 0x1F, 0x80, 0x00, 0x3C, 0x00, 0x7F,
  0xC0, 0xFF, 0xC0, 0xFF, 0xE0, 0x78, 0x10, 0x78, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x0E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x60, 0x7F, 0xF0, 0x3F,
  0xF8, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0xE1, 0xE0,
  0x0F, 0xE3, 0x80, 0x3F, 0xE7, 0x00, 0xFF, 0xFE, 0x01, 0xE0, 0xFC, 0x07,
  0x80, 0xF8, 0x1F, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0xF8, 0x07, 0x81, 0xE0,
  0x0F, 0x03, 0xC0, 0x1E, 0x0F, 0x00, 0x38, 0x1E, 0x00, 0xF0, 0x3C, 0x01,
  0xE0, 0x78, 0x03, 0xC0, 0xF0, 0x07, 0x01, 0xC0, 0x1E, 0x07, 0x80, 0x3C,
  0x0F, 0x00, 0xF8, 0x1E, 0x01, 0xF0, 0x1C, 0x07, 0xC0, 0x3C, 0x1F, 0x80,
  0x78, 0x7F, 0x00, 0xFF, 0xDE, 0x00, 0xFF, 0x3C, 0x00, 0xFC, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x3F, 0xC0, 0x3F, 0xF8, 0x1F, 0xFE, 0x0F, 0x83, 0xC3,
  0xC0, 0xF1, 0xE0, 0x3C, 0x78, 0x0E, 0x3C, 0x07, 0x8F, 0x01, 0xE3, 0x81,
  0xF1, 0xE1, 0xF8, 0x7F, 0xFC, 0x1F, 0xFC, 0x07, 0xF8, 0x01, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0xC0, 0xC0, 0xFF, 0xF0, 0x1F, 0xFC, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xE6, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0xFF,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x18, 0x00, 0x03,
  0xFC, 0xF0, 0x1F, 0xF3, 0x80, 0xFF, 0xEE, 0x03, 0xC1, 0xF8, 0x1E, 0x03,
  0xE0, 0xF8, 0x0F, 0x03, 0xC0, 0x3C, 0x1F, 0x00, 0xF0, 0x78, 0x03, 0xC1,
  0xE0, 0x0F, 0x0F, 0x00, 0x78, 0x3C, 0x01, 0xE0, 0xF0, 0x07, 0x83, 0xC0,
  0x1E, 0x0F, 0x00, 0xF0, 0x38, 0x03, 0xC1, 0xE0, 0x0F, 0x07, 0x80, 0x7C,
  0x1E, 0x01, 0xF0, 0x78, 0x0F, 0x80, 0xF0, 0x7E, 0x03, 0xC3, 0xF8, 0x0F,
  0xFD, 0xE0, 0x1F, 0xE7, 0x80, 0x3F, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x80, 0x3C, 0x03, 0x83, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC3, 0x00, 0x39, 0xFC, 0x07, 0xBF, 0xE0, 0x7F,
  0xFF, 0x07, 0xE0, 0xF0, 0x7C, 0x0F, 0x0F, 0x80, 0xF0, 0xF8, 0x0F, 0x0F,
  0x00, 0xF0, 0xF0, 0x0E, 0x0F, 0x01, 0xE1, 0xE0, 0x1E, 0x1E, 0x01, 0xE1,
  0xE0, 0x1E, 0x1E, 0x01, 0xC1, 0xC0, 0x3C, 0x3C, 0x03, 0xC3, 0xC0, 0x3C,
  0x3C, 0x03, 0xC3, 0xC0, 0x38, 0x38, 0x07, 0x87, 0x80, 0x78, 0x78, 0x07,
  0x87, 0x80, 0x78, 0x78, 0x0F, 0x0F, 0x00, 0xF0, 0x00, 0x40, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x0E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x38, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x70, 0x1E, 0x03, 0xC0, 0x78, 0x0E, 0x03, 0xC0, 0x00, 0x00, 0x01, 0x00,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x03, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x02, 0x07, 0x01, 0xE0, 0x78, 0x1E, 0x03, 0xC1, 0xF0,
  0x1E, 0x1F, 0x00, 0xF0, 0xF0, 0x07, 0x0F, 0x00, 0x78, 0xF0, 0x03, 0xCF,
  0x00, 0x1E, 0xF8, 0x00, 0xE7, 0x80, 0x0F, 0x78, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFB, 0xC0, 0x0F, 0x8F, 0x00, 0x78, 0x78,
  0x03, 0xC3, 0xC0, 0x1E, 0x1E, 0x00, 0xE0, 0x78, 0x0F, 0x03, 0xC0, 0x78,
  0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x03, 0xC1, 0xE0, 0x1E, 0x00, 0x00, 0xF0,
  0x0F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x78, 0x07,
  0x80, 0x70, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x60, 0x07, 0x3F, 0x87, 0xF0,
  0x1E, 0xFF, 0x9F, 0xF0, 0x3B, 0xFF, 0x7F, 0xF0, 0x7E, 0x1F, 0xC3, 0xE0,
  0xF8, 0x1F, 0x03, 0xC1, 0xE0, 0x3E, 0x07, 0x87, 0xC0, 0x78, 0x0F, 0x0F,
  0x01, 0xF0, 0x1C, 0x1E, 0x03, 0xC0, 0x78, 0x3C, 0x07, 0x80, 0xF0, 0xF0,
  0x0F, 0x01, 0xE1, 0xE0, 0x1C, 0x03, 0xC3, 0xC0, 0x78, 0x07, 0x07, 0x80,
  0xF0, 0x1E, 0x0E, 0x01, 0xE0, 0x3C, 0x3C, 0x03, 0xC0, 0x78, 0x78, 0x07,
  0x00, 0xF0, 0xF0, 0x1E, 0x01, 0xC1, 0xE0, 0x3C, 0x07, 0x83, 0x80, 0x78,
  0x0F, 0x0F, 0x00, 0xF0, 0x1E, 0x1E, 0x01, 0xC0, 0x3C, 0x3C, 0x07, 0x80,
  0x70, 0x78, 0x0F, 0x01, 0xE1, 0xE0, 0x1E, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x39, 0xFE, 0x07, 0xBF, 0xE0, 0x7F, 0xFF, 0x07, 0xE0, 0xF0, 0x7C, 0x0F,
  0x0F, 0x80, 0xF0, 0xF8, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x0F, 0x01,
  0xE1, 0xE0, 0x1E, 0x1E, 0x01, 0xE1, 0xE0, 0x1E, 0x1E, 0x01, 0xC1, 0xC0,
  0x3C, 0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x3C, 0x03, 0xC3, 0xC0, 0x78, 0x78,
  0x07, 0x87, 0x80, 0x78, 0x78, 0x07, 0x87, 0x80, 0x78, 0x78, 0x0F, 0x0F,
  0x00, 0xF0, 0x00, 0x38, 0x00, 0x1F, 0xE0, 0x0F, 0xFE, 0x03, 0xFF, 0xE0,
  0xF8, 0x3C, 0x1E, 0x07, 0x87, 0x80, 0x78, 0xF0, 0x0F, 0x3C, 0x01, 0xE7,
  0x80, 0x3C, 0xF0, 0x07, 0xBC, 0x00, 0xF7, 0x80, 0x1E, 0xF0, 0x07, 0x9E,
  0x00, 0xF3, 0x80, 0x1E, 0x70, 0x03, 0xDE, 0x00, 0xF3, 0xC0, 0x1E, 0x38,
  0x07, 0xC7, 0x80, 0xF0, 0xF0, 0x3C, 0x1F, 0x0F, 0x81, 0xFF, 0xE0, 0x3F,
  0xF8, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xC0, 0x03, 0x8F, 0xC0, 0x1E, 0xFF,
  0x80, 0x7F, 0xFF, 0x01, 0xD8, 0x3C, 0x07, 0xC0, 0xF0, 0x1F, 0x01, 0xC0,
  0xF8, 0x07, 0x03, 0xE0, 0x1C, 0x0F, 0x00, 0x70, 0x3C, 0x03, 0xC1, 0xE0,
  0x0F, 0x07, 0x80, 0x3C, 0x1E, 0x00, 0xF0, 0x78, 0x03, 0xC1, 0xC0, 0x0E,
  0x0F, 0x00, 0x78, 0x3C, 0x01, 0xE0, 0xF0, 0x0F, 0x03, 0xC0, 0x3C, 0x0F,
  0x01, 0xF0, 0x7E, 0x07, 0x81, 0xF8, 0x7C, 0x07, 0xFF, 0xF0, 0x1C, 0xFF,
  0x80, 0x71, 0xF8, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x0F, 0xF3, 0xC0, 0xFF, 0x9C, 0x0F, 0xFE, 0xE0, 0x78, 0x3F, 0x07,
  0x81, 0xF8, 0x7C, 0x07, 0x83, 0xC0, 0x3C, 0x3E, 0x01, 0xE1, 0xE0, 0x0F,
  0x0F, 0x00, 0x78, 0xF0, 0x03, 0x87, 0x80, 0x3C, 0x3C, 0x01, 0xE1, 0xE0,
  0x0F, 0x0F, 0x00, 0x70, 0x70, 0x07, 0x87, 0x80, 0x3C, 0x3C, 0x03, 0xE1,
  0xE0, 0x1F, 0x0F, 0x01, 0xF0, 0x3C, 0x1F, 0x81, 0xE1, 0xFC, 0x0F, 0xFD,
  0xE0, 0x3F, 0xCF, 0x00, 0xFC, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x07, 0x81, 0xCF, 0x81, 0xEF, 0xC0, 0xEF, 0xE0, 0x77, 0x00, 0x3F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x01, 0xFF,
  0x81, 0xFF, 0xE1, 0xFF, 0xE1, 0xF0, 0x20, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x07, 0x84, 0x03, 0xC3, 0x03, 0xE1, 0xFF, 0xE0, 0xFF,
  0xE0, 0x7F, 0xE0, 0x00, 0x03, 0x80, 0x30, 0x07, 0x00, 0x70, 0x0F, 0x00,
  0xF0, 0x3F, 0xF7, 0xFF, 0xFF, 0xE1, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x70, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0xFF, 0x0F,
  0xF0, 0x7F, 0x00, 0x1E, 0x01, 0xE3, 0xC0, 0x3C, 0x78, 0x07, 0x8F, 0x00,
  0xE1, 0xC0, 0x3C, 0x78, 0x07, 0x8F, 0x00, 0xF1, 0xE0, 0x1E, 0x3C, 0x03,
  0x87, 0x00, 0xF1, 0xE0, 0x1E, 0x3C, 0x03, 0xC7, 0x80, 0x78, 0xE0, 0x1E,
  0x3C, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x0F, 0x1E, 0x03, 0xC3, 0xC0, 0x78,
  0x78, 0x1F, 0x0F, 0x07, 0xE1, 0xE1, 0xFC, 0x3F, 0xF7, 0x07, 0xFC, 0xE0,
  0x7F, 0x1C, 0x00, 0xE0, 0x07, 0xF0, 0x07, 0xB8, 0x03, 0xDC, 0x03, 0xCF,
  0x01, 0xE7, 0x81, 0xE3, 0xC0, 0xF1, 0xE0, 0x70, 0xF0, 0x78, 0x78, 0x38,
  0x3C, 0x3C, 0x1E, 0x1E, 0x0F, 0x1E, 0x07, 0x8F, 0x03, 0xCF, 0x01, 0xE7,
  0x80, 0xF7, 0x80, 0x7B, 0xC0, 0x3D, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x1F, 0x01,
  0xFE, 0x03, 0xE0, 0x3B, 0xC0, 0xFC, 0x0F, 0x78, 0x1F, 0x81, 0xEF, 0x07,
  0xF0, 0x79, 0xC0, 0xFE, 0x0F, 0x38, 0x1F, 0xC1, 0xC7, 0x07, 0x78, 0x78,
  0xE0, 0xEF, 0x0F, 0x1C, 0x3D, 0xE3, 0xC3, 0x87, 0x3C, 0x78, 0x71, 0xE7,
  0x8E, 0x0E, 0x38, 0xE3, 0xC1, 0xC7, 0x1C, 0x70, 0x39, 0xC3, 0x9E, 0x07,
  0x38, 0x73, 0xC0, 0xEF, 0x0E, 0x70, 0x1D, 0xC1, 0xDE, 0x03, 0xB8, 0x3B,
  0x80, 0x7E, 0x07, 0x70, 0x0F, 0xC0, 0xFE, 0x01, 0xF8, 0x1F, 0x80, 0x3E,
  0x03, 0xF0, 0x07, 0xC0, 0x7C, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0x03, 0xC0,
  0x7C, 0x0F, 0x03, 0xE0, 0x3C, 0x0F, 0x00, 0x70, 0x78, 0x01, 0xE3, 0xE0,
  0x07, 0x8F, 0x00, 0x1E, 0x78, 0x00, 0x39, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xDC, 0x00, 0x1E, 0x78, 0x00,
  0xF1, 0xE0, 0x03, 0xC7, 0x80, 0x1E, 0x0F, 0x00, 0xF0, 0x3C, 0x03, 0xC0,
  0xF0, 0x1E, 0x03, 0xC0, 0xF0, 0x07, 0x80, 0x01, 0xE0, 0x0F, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x01, 0xE0, 0x3C, 0x01, 0xE0,
  0x38, 0x01, 0xE0, 0x78, 0x01, 0xE0, 0x78, 0x01, 0xE0, 0xF0, 0x01, 0xE0,
  0xF0, 0x01, 0xE1, 0xE0, 0x00, 0xE1, 0xE0, 0x00, 0xE3, 0xC0, 0x00, 0xE3,
  0xC0, 0x00, 0xE3, 0x80, 0x00, 0xE7, 0x80, 0x00, 0xE7, 0x00, 0x00, 0xEF,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0xEE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC1, 0xFF, 0xE0,
  0x7F, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0xFF, 0x83, 0xFF,
  0xE0, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x80, 0x07, 0xC0, 0x0F, 0xE0, 0x0F,
  0xF0, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xF0,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x80, 0x00, 0x7C,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xF8, 0x01, 0xFC, 0x01, 0xE0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0,
  0x00, 0xF0, 0x00, 0xF8, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x00,
  0x0C, 0x00, 0x27, 0xF8, 0x05, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0x00, 0x7F, 0x00,
};

const GFXglyph NotoSans_Condensed_Italic47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 11, 34, 11, 1, -34 },
  { 48, 13, 13, 17, 5, -34 },
  { 70, 24, 34, 23, 0, -34 },
  { 172, 21, 39, 21, 0, -36 },
  { 275, 27, 34, 31, 3, -34 },
  { 390, 23, 34, 24, 0, -34 },
  { 488, 6, 13, 9, 5, -34 },
  { 498, 15, 41, 13, 1, -34 },
  { 575, 14, 41, 13, -3, -34 },
  { 647, 16, 18, 20, 5, -36 },
  { 683, 19, 23, 22, 2, -28 },
  { 738, 8, 11, 10, -2, -5 },
  { 749, 11, 3, 13, 1, -14 },
  { 754, 5, 6, 10, 1, -6 },
  { 758, 22, 34, 16, -2, -34 },
  { 852, 19, 34, 21, 1, -34 },
  { 933, 13, 34, 21, 5, -34 },
  { 989, 21, 34, 21, -1, -34 },
  { 1079, 20, 34, 21, 0, -34 },
  { 1164, 21, 34, 21, -1, -34 },
  { 1254, 21, 34, 21, 0, -34 },
  { 1344, 19, 34, 21, 2, -34 },
  { 1425, 20, 34, 21, 2, -34 },
  { 1510, 21, 34, 21, 0, -34 },
  { 1600, 19, 34, 21, 1, -34 },
  { 1681, 10, 26, 10, 0, -26 },
  { 1714, 12, 32, 10, -2, -26 },
  { 1762, 19, 22, 22, 2, -28 },
  { 1815, 19, 13, 22, 2, -23 },
  { 1846, 19, 22, 22, 2, -28 },
  { 1899, 15, 34, 16, 2, -34 },
  { 1963, 29, 38, 31, 2, -34 },
  { 2101, 21, 34, 21, -3, -34 },
  { 2191, 22, 34, 23, 1, -34 },
  { 2285, 22, 34, 21, 2, -34 },
  { 2379, 23, 34, 25, 1, -34 },
  { 2477, 20, 34, 19, 1, -34 },
  { 2562, 20, 34, 18, 1, -34 },
  { 2647, 24, 34, 26, 2, -34 },
  { 2749, 25, 34, 25, 1, -34 },
  { 2856, 18, 34, 13, -2, -34 },
  { 2933, 19, 43, 10, -7, -34 },
  { 3036, 24, 34, 21, 1, -34 },
  { 3138, 14, 34, 18, 1, -34 },
  { 3198, 33, 34, 33, 1, -34 },
  { 3339, 27, 34, 27, 1, -34 },
  { 3454, 24, 34, 26, 2, -34 },
  { 3556, 21, 34, 21, 1, -34 },
  { 3646, 24, 42, 26, 2, -34 },
  { 3772, 21, 34, 22, 1, -34 },
  { 3862, 21, 34, 20, 0, -34 },
  { 3952, 18, 34, 18, 4, -34 },
  { 4029, 24, 34, 25, 2, -34 },
  { 4131, 21, 34, 21, 4, -34 },
  { 4221, 33, 34, 34, 4, -34 },
  { 4362, 26, 34, 20, -3, -34 },
  { 4473, 19, 34, 19, 4, -34 },
  { 4554, 23, 34, 19, -2, -34 },
  { 4652, 18, 42, 13, -1, -34 },
  { 4747, 8, 34, 16, 5, -34 },
  { 4781, 18, 42, 13, -3, -34 },
  { 4876, 20, 19, 21, 1, -34 },
  { 4924, 16, 3, 16, -4, 4 },
  { 4930, 7, 8, 12, 7, -36 },
  { 4937, 21, 26, 22, 1, -26 },
  { 5006, 20, 36, 22, 0, -36 },
  { 5096, 17, 26, 17, 1, -26 },
  { 5152, 23, 36, 22, 1, -36 },
  { 5256, 18, 26, 20, 1, -26 },
  { 5315, 24, 47, 12, -6, -36 },
  { 5456, 22, 37, 22, 0, -26 },
  { 5558, 20, 36, 22, 0, -36 },
  { 5648, 11, 35, 10, 0, -35 },
  { 5697, 17, 46, 10, -6, -35 },
  { 5795, 21, 36, 19, 0, -36 },
  { 5890, 12, 36, 10, 0, -36 },
  { 5944, 31, 26, 33, 0, -26 },
  { 6045, 20, 26, 22, 0, -26 },
  { 6110, 19, 26, 21, 1, -26 },
  { 6172, 22, 37, 22, -2, -26 },
  { 6274, 21, 37, 22, 1, -26 },
  { 6372, 17, 26, 15, 0, -26 },
  { 6428, 17, 26, 17, 0, -26 },
  { 6484, 12, 31, 13, 2, -31 },
  { 6531, 19, 25, 22, 2, -25 },
  { 6591, 17, 25, 18, 3, -25 },
  { 6645, 27, 25, 28, 3, -25 },
  { 6730, 22, 25, 18, -2, -25 },
  { 6799, 24, 36, 18, -4, -25 },
  { 6907, 18, 25, 16, -1, -25 },
  { 6964, 17, 41, 16, 1, -34 },
  { 7052, 4, 47, 20, 8, -36 },
  { 7076, 17, 41, 16, -2, -34 },
  { 7164, 19, 6, 22, 2, -20 },
};

const GFXfont NotoSans_Condensed_Italic47pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Italic47pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Italic47pt7bGlyphs,
  0x20, 0x7E, 64
};

#endif // _NOTOSANS_CONDENSED_ITALIC47PT7B_H_
