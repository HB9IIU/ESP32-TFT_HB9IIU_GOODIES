#ifndef _NOTOSANS_CONDENSED_ITALIC71PT7B_H_
#define _NOTOSANS_CONDENSED_ITALIC71PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Italic.ttf
// Size: 71pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Italic71pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x07, 0xF0,
  0x03, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x00, 0x06, 0x00, 0x00, 0x1F, 0x83, 0xF8, 0xFC, 0x1F, 0x87, 0xE0, 0xFC,
  0x3E, 0x07, 0xE3, 0xF0, 0x3E, 0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0x87, 0xC0,
  0xFC, 0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x1F, 0x81, 0xF0, 0xF8, 0x1F, 0x07,
  0xC0, 0xF8, 0x3E, 0x07, 0xC1, 0xE0, 0x3E, 0x0F, 0x01, 0xE0, 0x78, 0x0F,
  0x07, 0xC0, 0x78, 0x3C, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00,
  0x1F, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x78, 0x07, 0x80,
  0x00, 0x1F, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x78, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x78,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00,
  0x7C, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x3E, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x1E, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x1E, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0xF0, 0x00,
  0x01, 0xE0, 0x1E, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0xF8,
  0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x7C, 0x03, 0xC0, 0x07, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x3C, 0x03, 0xC0, 0x00,
  0x0F, 0x80, 0xF8, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x3C, 0x03, 0xC0,
  0x00, 0x0F, 0x80, 0xF8, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x3C, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x3C,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00,
  0x3E, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x01, 0xF0, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xF3, 0xC7,
  0xC0, 0x1F, 0x87, 0x83, 0x80, 0x3E, 0x0E, 0x00, 0x00, 0xFC, 0x1C, 0x00,
  0x01, 0xF0, 0x78, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x07, 0xC1, 0xC0, 0x00,
  0x0F, 0x83, 0x80, 0x00, 0x1F, 0x07, 0x00, 0x00, 0x3E, 0x1E, 0x00, 0x00,
  0x7E, 0x3C, 0x00, 0x00, 0xFE, 0x70, 0x00, 0x00, 0xFE, 0xE0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0x7F, 0x00, 0x00, 0x0E,
  0x7F, 0x00, 0x00, 0x3C, 0x7E, 0x00, 0x00, 0x78, 0x7C, 0x00, 0x00, 0xE0,
  0xF8, 0x00, 0x01, 0xC1, 0xF8, 0x00, 0x03, 0x83, 0xF0, 0x00, 0x0F, 0x07,
  0xC0, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x38, 0x3F, 0x02, 0x00, 0x70, 0x7E,
  0x06, 0x00, 0xE1, 0xF8, 0x0F, 0x03, 0xC7, 0xF0, 0x1F, 0xF7, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7C, 0x00, 0xFF, 0xC0, 0x00, 0x7C, 0x00, 0xFF, 0xF0,
  0x00, 0x7C, 0x00, 0x7F, 0xF8, 0x00, 0x3E, 0x00, 0x7C, 0x7E, 0x00, 0x3E,
  0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x01, 0xF0,
  0x0F, 0x80, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x07, 0x80, 0x7C, 0x07, 0xC0,
  0x03, 0xC0, 0x3E, 0x03, 0xC0, 0x03, 0xE0, 0x1F, 0x03, 0xE0, 0x01, 0xF0,
  0x0F, 0x03, 0xE0, 0x00, 0xF0, 0x0F, 0x81, 0xF0, 0x00, 0x78, 0x07, 0xC1,
  0xF0, 0x00, 0x3C, 0x03, 0xE0, 0xF0, 0x00, 0x3E, 0x01, 0xE0, 0xF8, 0x00,
  0x1F, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x80, 0xF8, 0x7C, 0x1F, 0x87, 0xC0,
  0x7C, 0x7C, 0x3F, 0xE3, 0xE0, 0x7C, 0x3E, 0x3F, 0xF9, 0xF0, 0x3E, 0x3E,
  0x3F, 0xFE, 0xF8, 0x3E, 0x1E, 0x1F, 0x1F, 0x7C, 0x1F, 0x1F, 0x1F, 0x07,
  0x9F, 0x1F, 0x1F, 0x1F, 0x03, 0xEF, 0xFF, 0x0F, 0x8F, 0x81, 0xF7, 0xFF,
  0x8F, 0x87, 0x80, 0xF9, 0xFF, 0x87, 0x87, 0xC0, 0x7C, 0x7F, 0x07, 0xC3,
  0xE0, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x1E, 0x00, 0x03, 0xE1, 0xF0, 0x0F,
  0x00, 0x03, 0xE0, 0xF8, 0x0F, 0x80, 0x01, 0xF0, 0x78, 0x07, 0xC0, 0x01,
  0xF0, 0x7C, 0x03, 0xE0, 0x01, 0xF0, 0x3E, 0x01, 0xF0, 0x00, 0xF8, 0x1F,
  0x00, 0xF0, 0x00, 0xF8, 0x0F, 0x80, 0xF8, 0x00, 0x7C, 0x07, 0xC0, 0x7C,
  0x00, 0x7C, 0x03, 0xC0, 0x3E, 0x00, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0x3E,
  0x00, 0xF0, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x0F, 0x00, 0x1F, 0x00, 0x3C,
  0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x87, 0xC0,
  0x0F, 0x80, 0x07, 0xFF, 0xC0, 0x0F, 0x80, 0x01, 0xFF, 0xE0, 0x07, 0xC0,
  0x00, 0xFF, 0xE0, 0x07, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xE3, 0xF8, 0x00,
  0x03, 0xE0, 0x7E, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x7C, 0x03, 0xE0,
  0x00, 0x3F, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x03, 0xE0, 0x0F,
  0x80, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x7C, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0x3F,
  0x07, 0xC0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x00,
  0x7E, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xEF, 0xC0,
  0x1F, 0x07, 0xF3, 0xF8, 0x0F, 0xC1, 0xF8, 0x7E, 0x03, 0xF0, 0xFC, 0x1F,
  0x81, 0xF8, 0x7E, 0x03, 0xF0, 0x7E, 0x1F, 0x80, 0xFC, 0x1F, 0x0F, 0xC0,
  0x1F, 0x8F, 0xC3, 0xE0, 0x07, 0xE3, 0xE1, 0xF8, 0x01, 0xFD, 0xF8, 0x7E,
  0x00, 0x3F, 0xFC, 0x1F, 0x00, 0x0F, 0xFF, 0x07, 0xC0, 0x01, 0xFF, 0x83,
  0xF0, 0x00, 0x7F, 0xC0, 0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0x00, 0x03, 0xF8,
  0x0F, 0xC0, 0x01, 0xFE, 0x01, 0xF8, 0x00, 0xFF, 0xC0, 0x7E, 0x00, 0x7F,
  0xF0, 0x1F, 0xC0, 0x3F, 0xFC, 0x07, 0xFC, 0x7F, 0xFF, 0x80, 0xFF, 0xFF,
  0xE7, 0xE0, 0x1F, 0xFF, 0xE1, 0xFC, 0x03, 0xFF, 0xF0, 0x3F, 0x00, 0x7F,
  0xF0, 0x0F, 0xE0, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0xC7, 0xE1, 0xF8, 0x7E,
  0x1F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x7C, 0x1F,
  0x07, 0xC1, 0xE0, 0x78, 0x1E, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x80, 0x7C, 0x00, 0xF0,
  0x3C, 0x00, 0x7E, 0x1E, 0x00, 0x3F, 0xCF, 0x00, 0x7F, 0xFF, 0x9F, 0xE7,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x03, 0xF8, 0xFE,
  0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xF7, 0xC0, 0x03, 0xF1, 0xE0,
  0x03, 0xF0, 0xF8, 0x03, 0xF8, 0x7C, 0x03, 0xF8, 0x1F, 0x00, 0x78, 0x0F,
  0x80, 0x18, 0x07, 0xE0, 0x04, 0x01, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xE0, 0x7E, 0x03,
  0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x7E, 0x03, 0xE0,
  0x3F, 0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF,
  0xFF, 0xCF, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xF8, 0x3E, 0x7F, 0x7F, 0xFF,
  0xFF, 0xFE, 0xFE, 0x7C, 0x30, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0x83, 0xF8, 0x03, 0xF8,
  0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x01, 0xFC, 0x01, 0xF0, 0x0F, 0xC0, 0x0F,
  0xC0, 0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x83,
  0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xE1, 0xF8, 0x00, 0x3F, 0x0F, 0xC0,
  0x01, 0xF8, 0x7E, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x7C, 0x3F, 0x00, 0x03,
  0xE1, 0xF8, 0x00, 0x3F, 0x1F, 0x80, 0x01, 0xF8, 0xFC, 0x00, 0x0F, 0xC7,
  0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x1F, 0x1F, 0x80,
  0x01, 0xF8, 0xFC, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x03,
  0xF1, 0xF8, 0x00, 0x3F, 0x0F, 0x80, 0x01, 0xF8, 0x7C, 0x00, 0x0F, 0xC7,
  0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x3F, 0x0F, 0xC0,
  0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x0F,
  0xC0, 0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xF0, 0x1F, 0x00, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x3F, 0x80, 0x3F, 0x83, 0xF8, 0x00, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x01, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xFC, 0x03, 0xFF, 0x80,
  0xFF, 0xF0, 0x3F, 0xFE, 0x0F, 0xEF, 0x87, 0xFB, 0xF1, 0xFE, 0x7E, 0x7F,
  0x0F, 0xC7, 0xC1, 0xF0, 0x70, 0x7E, 0x04, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFC, 0x07, 0xF8,
  0x00, 0x7C, 0x01, 0xFC, 0x00, 0x18, 0x00, 0x7E, 0x00, 0x08, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xC0, 0x7F, 0x80, 0x1E, 0x00, 0x3F, 0x00, 0x10, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x08, 0x00, 0x0F, 0xF0,
  0x1C, 0x00, 0x3F, 0xC0, 0x3F, 0x83, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x3E, 0xFC,
  0x00, 0x00, 0x3C, 0xFC, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0xF8, 0xF8,
  0x00, 0x01, 0xF9, 0xF8, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x03, 0xE1, 0xF0,
  0x00, 0x07, 0xC1, 0xF0, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x0F, 0x83, 0xF0,
  0x00, 0x1F, 0x03, 0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xE0,
  0x00, 0x7C, 0x07, 0xE0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0xF8, 0x07, 0xE0,
  0x01, 0xF0, 0x07, 0xC0, 0x03, 0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x0F, 0xC0,
  0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80,
  0x1F, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x1F, 0x80,
  0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x08, 0x00, 0x0F, 0xF0, 0x1E, 0x00,
  0x3F, 0xC0, 0x3F, 0x87, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E,
  0x07, 0xE0, 0x03, 0xF1, 0xFF, 0xC0, 0x1F, 0x9F, 0xFF, 0x00, 0xF9, 0xFF,
  0xF8, 0x0F, 0xDF, 0xFF, 0xE0, 0x7F, 0xF0, 0x7F, 0x03, 0xFE, 0x01, 0xFC,
  0x1F, 0xE0, 0x07, 0xE0, 0xFE, 0x00, 0x3F, 0x0F, 0xE0, 0x01, 0xF8, 0x7F,
  0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3E, 0x1F, 0x80, 0x01, 0xF0, 0xFC, 0x00,
  0x1F, 0x87, 0xE0, 0x00, 0xFC, 0x3E, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x3F,
  0x0F, 0x80, 0x01, 0xF8, 0x7C, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0xFC, 0x1F,
  0x00, 0x07, 0xE0, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x00,
  0x1F, 0x81, 0xF8, 0x01, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x81, 0xFC,
  0x01, 0xFF, 0x7F, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0x80, 0x0F, 0xE0, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E,
  0x01, 0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x01, 0xF8,
  0x0F, 0x80, 0x03, 0xE0, 0x1F, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x1F, 0x80,
  0x7C, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x7C, 0x01, 0xF8, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x03, 0xF0, 0x1F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x07,
  0xE3, 0xFC, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0x8F, 0xE0, 0x01, 0xFC, 0x0F,
  0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x0F, 0xC0, 0x3F, 0x00, 0x1F,
  0x80, 0xFC, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x3E, 0x00, 0x03, 0xF0,
  0x7C, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x1F, 0x83,
  0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xE0, 0x03, 0xF0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x1F, 0xF0, 0x7F, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0x83,
  0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x3F, 0x03, 0xF8, 0x01, 0xF8,
  0x1F, 0x80, 0x0F, 0xC1, 0xF8, 0x00, 0x3E, 0x0F, 0xC0, 0x01, 0xF0, 0x7E,
  0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x3F, 0x00, 0x03, 0xE1, 0xF8, 0x00,
  0x3F, 0x0F, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x7E,
  0x1F, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x3F, 0x87, 0xC0, 0x01, 0xFC, 0x3F,
  0x00, 0x1F, 0xE1, 0xF8, 0x00, 0xFE, 0x0F, 0xC0, 0x0F, 0xF0, 0x7F, 0x00,
  0xFF, 0x81, 0xFC, 0x0F, 0xFC, 0x0F, 0xFF, 0xF7, 0xE0, 0x7F, 0xFF, 0xBE,
  0x01, 0xFF, 0xFB, 0xF0, 0x07, 0xFF, 0x1F, 0x80, 0x0F, 0xE0, 0xFC, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xF0, 0x03, 0xE7, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x10, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x3F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F,
  0x80, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0xF8, 0x00, 0x3F, 0x80, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x08, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0xF8, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0x80,
  0xFF, 0x06, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x81, 0xFF, 0x00, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x00, 0x1F,
  0x03, 0xE0, 0x01, 0xFE, 0x01, 0xF0, 0x3E, 0x00, 0x7F, 0xFC, 0x0F, 0x07,
  0xC0, 0x1F, 0xFF, 0x80, 0xF0, 0x7C, 0x03, 0xFF, 0xF8, 0x0F, 0x0F, 0x80,
  0x7E, 0x0F, 0x80, 0xF0, 0xF8, 0x07, 0xC0, 0xF8, 0x0F, 0x0F, 0x00, 0xF8,
  0x0F, 0x00, 0xF1, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x1E, 0x01, 0xE0, 0x1F,
  0x01, 0xF1, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x3E, 0x03, 0xC0, 0x1E, 0x01,
  0xF3, 0xE0, 0x7C, 0x03, 0xE0, 0x1E, 0x3C, 0x07, 0xC0, 0x3E, 0x01, 0xE3,
  0xC0, 0x78, 0x03, 0xE0, 0x3E, 0x7C, 0x0F, 0x80, 0x3C, 0x03, 0xE7, 0xC0,
  0xF8, 0x07, 0xC0, 0x3C, 0x78, 0x0F, 0x80, 0x7C, 0x03, 0xC7, 0x80, 0xF0,
  0x07, 0xC0, 0x7C, 0x78, 0x0F, 0x00, 0xF8, 0x07, 0x87, 0x81, 0xF0, 0x0F,
  0x80, 0xF8, 0xF8, 0x1F, 0x01, 0xF8, 0x0F, 0x0F, 0x81, 0xF0, 0x1F, 0x81,
  0xF0, 0xF8, 0x1F, 0x03, 0xF8, 0x1E, 0x0F, 0x80, 0xF8, 0x3F, 0x83, 0xE0,
  0xF8, 0x0F, 0x87, 0x7C, 0x7C, 0x0F, 0x80, 0xFF, 0xF3, 0xFF, 0x80, 0xF8,
  0x07, 0xFE, 0x3F, 0xF0, 0x0F, 0x80, 0x7F, 0xC1, 0xFE, 0x00, 0x78, 0x01,
  0xF0, 0x0F, 0xC0, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x03, 0x00, 0x00, 0x07, 0xF8, 0x01, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x3F,
  0x7C, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x7C,
  0x7C, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0x00, 0xF8,
  0x7C, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xF0,
  0x7C, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x07, 0xE0,
  0x7E, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x0F, 0x80,
  0x7E, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x3F, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x00,
  0x7E, 0x03, 0xF0, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00,
  0x7E, 0x0F, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7E, 0x1F, 0xC0, 0x00,
  0x3E, 0x1F, 0x80, 0x00, 0x3E, 0x3F, 0x80, 0x00, 0x3F, 0x3F, 0x00, 0x00,
  0x3F, 0x3F, 0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xF0, 0x3F, 0xF8, 0x01, 0xF8,
  0x01, 0xFE, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x3F,
  0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x03, 0xF0, 0x0F,
  0xC0, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x7E, 0x03,
  0xF0, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x3F, 0x80,
  0x7E, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x1F, 0xC0,
  0x1F, 0x80, 0x3F, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0xFC, 0x03, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x1F,
  0xC0, 0x3F, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x03, 0xF0, 0x0F, 0xC0, 0x01,
  0xF8, 0x07, 0xC0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x7E, 0x03, 0xF0, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x0F, 0xC0, 0xFC, 0x00,
  0x07, 0xE0, 0x7E, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x03, 0xF0, 0x1F, 0x80,
  0x03, 0xF8, 0x0F, 0xC0, 0x01, 0xFC, 0x0F, 0xC0, 0x01, 0xFC, 0x07, 0xE0,
  0x03, 0xFC, 0x03, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0x80, 0x70, 0x00, 0xFF, 0x00, 0x08, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x70, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0x80, 0x3F, 0xE0, 0x03, 0xF0,
  0x03, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xC0, 0x0F, 0xC0, 0x03, 0xF8, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0xFE,
  0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0xFC, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x00, 0x7E,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00,
  0x3F, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x01, 0xFC, 0x1F, 0x80,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x01, 0xFC, 0x0F,
  0xC0, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x01, 0xFC,
  0x0F, 0xC0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x03,
  0xF8, 0x0F, 0xC0, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x3F, 0x00,
  0x07, 0xF8, 0x07, 0xE0, 0x01, 0xFE, 0x00, 0xFC, 0x00, 0x7F, 0x80, 0x3F,
  0x00, 0x1F, 0xE0, 0x07, 0xE0, 0x0F, 0xF8, 0x00, 0xFC, 0x1F, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x80, 0x1F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0xFC, 0x03, 0xF0, 0x00, 0xFF, 0x00, 0x03, 0x80, 0x0F, 0xF0, 0x00, 0x08,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFF, 0x83, 0xF0, 0x00, 0x7F, 0xFC, 0x1F,
  0x80, 0x07, 0xFF, 0xE0, 0xFC, 0x00, 0x3F, 0xFE, 0x07, 0xE0, 0x01, 0xFF,
  0xF0, 0x3F, 0x00, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x00, 0xFC, 0x1F, 0xC0,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x3F, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0xFC, 0x0F, 0xE0, 0x00,
  0x07, 0xC0, 0x7F, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0x07,
  0xC0, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x03, 0xFC,
  0x00, 0x1F, 0x80, 0x0F, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x01, 0xF8, 0x00,
  0x03, 0xE0, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x00, 0xF8, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80,
  0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x03, 0xF8, 0x01, 0xF8, 0x00,
  0x3F, 0x80, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03,
  0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x03, 0xF0,
  0x0F, 0xE0, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x7F, 0x00, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x03, 0xE0, 0x7F,
  0x00, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x0F,
  0xC3, 0xF8, 0x00, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0x03, 0xE3, 0xF8, 0x00,
  0x00, 0x3F, 0x1F, 0x80, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x00, 0x0F, 0xDF,
  0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xEF, 0xF0, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0x9F, 0x80, 0x00, 0x07, 0xF8, 0xFC, 0x00, 0x00, 0x3F,
  0x87, 0xE0, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0xFC, 0x00,
  0x00, 0x7C, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x3F, 0x01,
  0xFC, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00,
  0xFC, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x0F, 0xE0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00,
  0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x00, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xF7, 0xC0, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x00, 0x3E, 0xFC, 0x00, 0xFB, 0xF0, 0x00, 0x1F, 0xBF, 0x00,
  0x3E, 0xFC, 0x00, 0x07, 0xEF, 0x80, 0x0F, 0xBF, 0x00, 0x01, 0xF7, 0xE0,
  0x07, 0xE7, 0xC0, 0x00, 0xFD, 0xF8, 0x01, 0xF9, 0xF0, 0x00, 0x3E, 0x7E,
  0x00, 0x7E, 0x7C, 0x00, 0x1F, 0x9F, 0x80, 0x1F, 0x1F, 0x00, 0x07, 0xC7,
  0xC0, 0x07, 0xC7, 0xC0, 0x03, 0xF3, 0xF0, 0x03, 0xF1, 0xF0, 0x00, 0xF8,
  0xFC, 0x00, 0xFC, 0x7C, 0x00, 0x7E, 0x3F, 0x00, 0x3E, 0x1F, 0x00, 0x1F,
  0x0F, 0xC0, 0x0F, 0x87, 0xC0, 0x0F, 0xC7, 0xE0, 0x07, 0xE1, 0xF0, 0x03,
  0xE1, 0xF8, 0x01, 0xF8, 0x7C, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0x00,
  0x7C, 0x1F, 0x80, 0x1F, 0x07, 0xC0, 0x3F, 0x07, 0xC0, 0x07, 0xC1, 0xF8,
  0x0F, 0x83, 0xF0, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x0F,
  0x81, 0xF0, 0x3F, 0x00, 0x3F, 0x03, 0xE0, 0xFC, 0x0F, 0xC0, 0x0F, 0x80,
  0xF8, 0x3E, 0x03, 0xE0, 0x03, 0xE0, 0x3E, 0x1F, 0x81, 0xF8, 0x01, 0xF8,
  0x0F, 0x87, 0xC0, 0x7E, 0x00, 0x7E, 0x03, 0xE3, 0xF0, 0x1F, 0x80, 0x1F,
  0x00, 0xF8, 0xF8, 0x07, 0xE0, 0x07, 0xC0, 0x3E, 0x3E, 0x03, 0xF0, 0x03,
  0xF0, 0x0F, 0x9F, 0x00, 0xFC, 0x00, 0xFC, 0x03, 0xE7, 0xC0, 0x3F, 0x00,
  0x3F, 0x00, 0xFB, 0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x3E, 0xF8, 0x03, 0xF0,
  0x03, 0xE0, 0x0F, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xFF, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0xFF, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0xE0, 0x07,
  0xE0, 0x07, 0xC0, 0x07, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x1F, 0xE0, 0x00, 0x0F, 0xC0, 0x0F, 0xF0, 0x00, 0x07,
  0xC0, 0x07, 0xF8, 0x00, 0x07, 0xE0, 0x03, 0xFC, 0x00, 0x03, 0xF0, 0x03,
  0xFF, 0x00, 0x01, 0xF8, 0x01, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0xFF, 0xC0,
  0x00, 0x7C, 0x00, 0x7F, 0xE0, 0x00, 0x7E, 0x00, 0x3F, 0xF0, 0x00, 0x3F,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0x80, 0x1F, 0xFE, 0x00, 0x0F, 0x80, 0x0F,
  0x9F, 0x00, 0x07, 0xC0, 0x07, 0xCF, 0x80, 0x07, 0xE0, 0x03, 0xE7, 0xE0,
  0x03, 0xF0, 0x03, 0xF3, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x7C, 0x00, 0xFC, 0x00, 0x7C, 0x3E, 0x00, 0x7E, 0x00, 0x3E,
  0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x83, 0xE0,
  0x0F, 0x80, 0x0F, 0x81, 0xF0, 0x0F, 0xC0, 0x07, 0xC0, 0xFC, 0x07, 0xE0,
  0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x03, 0xF0, 0x1F, 0x01, 0xF0, 0x01, 0xF8,
  0x0F, 0x80, 0xF8, 0x00, 0xF8, 0x07, 0xE0, 0xFC, 0x00, 0x7C, 0x03, 0xF0,
  0x7E, 0x00, 0x7E, 0x00, 0xF8, 0x3F, 0x00, 0x3F, 0x00, 0x7C, 0x1F, 0x00,
  0x1F, 0x80, 0x3E, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x8F, 0xC0, 0x07, 0xC0,
  0x0F, 0xC7, 0xE0, 0x07, 0xE0, 0x03, 0xE3, 0xF0, 0x03, 0xF0, 0x01, 0xF1,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0xF8, 0x00, 0x7E, 0xFC, 0x00,
  0xFC, 0x00, 0x1F, 0x7E, 0x00, 0x7E, 0x00, 0x0F, 0xBE, 0x00, 0x3F, 0x00,
  0x07, 0xDF, 0x00, 0x1F, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0x80, 0x01, 0xFF,
  0xC0, 0x0F, 0xC0, 0x00, 0x7F, 0xE0, 0x07, 0xE0, 0x00, 0x3F, 0xE0, 0x03,
  0xF0, 0x00, 0x1F, 0xF0, 0x01, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0xFE,
  0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0x1F, 0xC0, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x1F, 0xC0, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x00,
  0x7E, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x7F, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0xFC, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x07, 0xF1,
  0xFC, 0x00, 0x00, 0x7F, 0x1F, 0x80, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x00,
  0x7E, 0x3F, 0x80, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00, 0x7E, 0x3F, 0x00,
  0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x07, 0xE7,
  0xE0, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x00,
  0xFC, 0x7E, 0x00, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x00, 0xFC, 0xFE, 0x00,
  0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x01, 0xF8, 0xFE, 0x00, 0x00, 0x1F, 0x8F,
  0xC0, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0xFC, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0xFE, 0x00,
  0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x01, 0xFC, 0x07,
  0xE0, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0xFF,
  0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7E, 0x3F,
  0xFC, 0x00, 0x7E, 0x01, 0xFE, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x7E, 0x00,
  0x7F, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0xF8, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3F, 0x01, 0xF8, 0x00,
  0x7E, 0x01, 0xF8, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x7E, 0x03, 0xF0, 0x00,
  0xFE, 0x03, 0xF0, 0x00, 0xFC, 0x03, 0xF0, 0x01, 0xFC, 0x03, 0xF0, 0x03,
  0xF8, 0x07, 0xE0, 0x0F, 0xF0, 0x07, 0xE0, 0x3F, 0xF0, 0x07, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x03, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xF0, 0x00,
  0xFC, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x7E, 0x03, 0xF8,
  0x00, 0x07, 0xE0, 0x3F, 0x80, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x07, 0xE0,
  0x7E, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x00,
  0x3F, 0x0F, 0xC0, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x00, 0x7F, 0x1F, 0x80,
  0x00, 0x07, 0xF1, 0xF8, 0x00, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0x07, 0xE3,
  0xF0, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00,
  0x7E, 0x7F, 0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0x7E, 0x7E, 0x00,
  0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x0F, 0xC7,
  0xE0, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x01,
  0xF8, 0xFE, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x03, 0xF8, 0xFC, 0x00,
  0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x7F, 0x0F,
  0xE0, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x7E, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x7F, 0x00,
  0x07, 0xF8, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x03,
  0xFC, 0x03, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7E, 0x1F, 0xFE, 0x00, 0x7E, 0x01,
  0xFE, 0x00, 0x7E, 0x00, 0xFF, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x3F, 0x01, 0xF8, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x7E, 0x01, 0xF8, 0x00,
  0x7E, 0x01, 0xF0, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0xFC, 0x03, 0xF0, 0x01,
  0xFC, 0x03, 0xF0, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xF8, 0x07, 0xE0, 0x3F,
  0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xC0, 0xF8,
  0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x0F, 0x80, 0xFC,
  0x00, 0x1F, 0x80, 0x7E, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x1F, 0x80, 0x7E,
  0x00, 0x1F, 0x80, 0x7E, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x80, 0x7E, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x1F,
  0x80, 0x7E, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x0F,
  0xC0, 0xFC, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0x03, 0xF0, 0x01, 0xFE,
  0x00, 0x30, 0x01, 0xFC, 0x00, 0x08, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x10, 0x00, 0x07, 0xF0, 0x06, 0x00,
  0x07, 0xF8, 0x03, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x0F, 0x80, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x1F, 0x80, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00,
  0x7E, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x7C, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x0F, 0xC0,
  0x7E, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x01,
  0xF8, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x01, 0xF8, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0xFC, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x03,
  0xE0, 0x1F, 0x80, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x1F, 0x80,
  0x00, 0x7E, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0xFC, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x0F,
  0xC0, 0x7E, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x7E, 0x00,
  0x01, 0xF8, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x01, 0xF8, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0xFE, 0x00,
  0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x07,
  0xF8, 0x07, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0xFC, 0xFC,
  0x00, 0x00, 0xFC, 0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x01, 0xF8, 0x7C,
  0x00, 0x03, 0xF8, 0x7C, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x07, 0xF0, 0x7C,
  0x00, 0x07, 0xE0, 0x7C, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x0F, 0xC0, 0x7E,
  0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x1F, 0x80, 0x7E,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0xFC, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x7E,
  0x03, 0xF0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7E,
  0x07, 0xE0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x7E,
  0x3F, 0x00, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x3E,
  0x7E, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x3E,
  0xFC, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0xDF, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x3F, 0x00,
  0x01, 0xFD, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x7C, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0x9F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xF1, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x7C, 0x00, 0x1F,
  0xF0, 0x00, 0x7E, 0x1F, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0x87, 0xC0, 0x01,
  0xFF, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xF0, 0x7C, 0x00,
  0x3F, 0xF0, 0x01, 0xF8, 0x1F, 0x00, 0x1F, 0x7C, 0x00, 0x7E, 0x07, 0xC0,
  0x07, 0xDF, 0x00, 0x1F, 0x81, 0xF0, 0x03, 0xF7, 0xC0, 0x0F, 0xC0, 0x7C,
  0x00, 0xF9, 0xF0, 0x03, 0xF0, 0x1F, 0x00, 0x3E, 0x7C, 0x01, 0xF8, 0x07,
  0xC0, 0x1F, 0x1F, 0x00, 0x7E, 0x01, 0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x80,
  0x7C, 0x03, 0xF1, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0xF8, 0x7C, 0x03, 0xF0,
  0x0F, 0xC0, 0x3E, 0x1F, 0x01, 0xF8, 0x03, 0xF0, 0x1F, 0x07, 0xC0, 0x7E,
  0x00, 0xFC, 0x07, 0xC1, 0xF0, 0x1F, 0x00, 0x3F, 0x03, 0xE0, 0x7C, 0x0F,
  0xC0, 0x0F, 0xC0, 0xF8, 0x1F, 0x03, 0xF0, 0x03, 0xF0, 0x7E, 0x07, 0xC1,
  0xF8, 0x00, 0xFC, 0x1F, 0x01, 0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xC0, 0x7C,
  0x1F, 0x00, 0x0F, 0xC3, 0xE0, 0x1F, 0x0F, 0xC0, 0x03, 0xF0, 0xF8, 0x07,
  0xC3, 0xF0, 0x00, 0xFC, 0x7E, 0x01, 0xF1, 0xF8, 0x00, 0x3F, 0x1F, 0x00,
  0x7C, 0x7E, 0x00, 0x0F, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x03, 0xF3, 0xE0,
  0x07, 0xCF, 0xC0, 0x00, 0xFC, 0xF8, 0x01, 0xF3, 0xF0, 0x00, 0x3F, 0x7E,
  0x00, 0x7C, 0xF8, 0x00, 0x0F, 0xDF, 0x00, 0x1F, 0x7E, 0x00, 0x03, 0xF7,
  0xC0, 0x07, 0xDF, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x3F,
  0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x00,
  0x7C, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0x00, 0x01, 0xF9, 0xF8,
  0x00, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x00, 0x3F, 0x1F, 0x00, 0x00,
  0x00, 0xFC, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0x9F, 0x80, 0x01, 0xFC, 0xFC, 0x00,
  0x0F, 0xC7, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x7E,
  0x0F, 0xC0, 0x07, 0xF0, 0x7E, 0x00, 0x3F, 0x01, 0xF0, 0x03, 0xF8, 0x0F,
  0xC0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80,
  0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x1F, 0x03, 0xF0,
  0x00, 0xF8, 0x3F, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x3F, 0x1F, 0x80, 0x01,
  0xF9, 0xF8, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x3E, 0xFC, 0x00, 0x01, 0xF7,
  0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFC,
  0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xE0, 0x7E,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xF0, 0x3F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x81, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0xC0, 0xFC, 0x07,
  0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7E, 0x07, 0xE0, 0x7E, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x3F,
  0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x7C, 0xF8, 0x00,
  0x01, 0xF3, 0xF0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7E, 0x1F, 0x00, 0x01,
  0xF0, 0x7E, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x3E, 0x03, 0xE0, 0x01, 0xF0,
  0x0F, 0xC0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00,
  0xF8, 0x07, 0xC0, 0x03, 0xE0, 0x3F, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x1F,
  0x07, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03, 0xE3,
  0xE0, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7C, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFE, 0x0F, 0xC1, 0xFC, 0x1F, 0x81, 0xF0, 0x3F, 0x03, 0xE0,
  0x7C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F,
  0xF0, 0x7C, 0x00, 0xFF, 0xF1, 0xF0, 0x03, 0xFF, 0xF3, 0xE0, 0x0F, 0xFF,
  0xE7, 0xC0, 0x3F, 0xE3, 0xFF, 0x80, 0xFF, 0x03, 0xFE, 0x01, 0xFC, 0x03,
  0xFC, 0x07, 0xF0, 0x03, 0xF8, 0x0F, 0xC0, 0x07, 0xF0, 0x3F, 0x00, 0x0F,
  0xE0, 0x7E, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x7E,
  0x07, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0x03, 0xE0,
  0x7E, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x3E,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0x7E, 0x07, 0xE0, 0x01, 0xFC, 0x0F, 0xC0, 0x03, 0xF8, 0x1F, 0x80,
  0x0F, 0xF0, 0x3F, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x7F, 0x80, 0x7E, 0x01,
  0xFF, 0x00, 0xFE, 0x07, 0xFE, 0x01, 0xFE, 0x3E, 0xFC, 0x01, 0xFF, 0xFD,
  0xF0, 0x03, 0xFF, 0xF3, 0xE0, 0x03, 0xFF, 0x87, 0xC0, 0x03, 0xFE, 0x0F,
  0x80, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3E, 0x03, 0xC0, 0x01, 0xF8, 0x7F, 0xC0, 0x07, 0xE3, 0xFF,
  0x80, 0x1F, 0x9F, 0xFF, 0x00, 0x7C, 0xFF, 0xFE, 0x01, 0xF7, 0xC7, 0xF8,
  0x0F, 0xFC, 0x07, 0xE0, 0x3F, 0xE0, 0x1F, 0xC0, 0xFF, 0x00, 0x3F, 0x03,
  0xF8, 0x00, 0xFC, 0x0F, 0xE0, 0x03, 0xF0, 0x7F, 0x00, 0x0F, 0xC1, 0xFC,
  0x00, 0x3F, 0x07, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x03, 0xF0, 0x7E, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xF8, 0x3F, 0x00, 0x07,
  0xE0, 0xF8, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7E, 0x1F, 0x80, 0x01, 0xF8,
  0x7E, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0xFC, 0x3F,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7E, 0x0F, 0xC0,
  0x03, 0xF8, 0x3F, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x7F, 0x07, 0xF8, 0x03,
  0xF8, 0x1F, 0xE0, 0x0F, 0xC0, 0x7F, 0xC0, 0x7F, 0x01, 0xFF, 0xC7, 0xF8,
  0x0F, 0x9F, 0xFF, 0xC0, 0x3E, 0x7F, 0xFE, 0x00, 0xF8, 0xFF, 0xF0, 0x03,
  0xC1, 0xFF, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0,
  0x0F, 0xF8, 0x78, 0x0F, 0xF0, 0x08, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x80, 0x30, 0x0F, 0xF0, 0xF8, 0x07, 0xFF, 0xFC,
  0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x07, 0x81, 0xF8, 0x00, 0x1F, 0xF8,
  0x7C, 0x00, 0x0F, 0xFF, 0x1F, 0x00, 0x07, 0xFF, 0xEF, 0xC0, 0x03, 0xFF,
  0xFB, 0xF0, 0x01, 0xFF, 0x1F, 0xFC, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x3F,
  0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF8, 0x03,
  0xF0, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x1F, 0x80, 0x03, 0xF0, 0x0F, 0xE0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x3E,
  0x00, 0xFC, 0x00, 0x0F, 0x80, 0x3F, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x01,
  0xF8, 0x07, 0xE0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x1F, 0x80, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0xFC, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x07, 0xE0, 0x0F,
  0xC0, 0x03, 0xF8, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x7F, 0x80,
  0x3F, 0x00, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xF0, 0x01, 0xF8, 0x07, 0xFC,
  0x00, 0x7E, 0x03, 0xFF, 0x00, 0x1F, 0xE3, 0xEF, 0x80, 0x03, 0xFF, 0xF3,
  0xE0, 0x00, 0xFF, 0xF8, 0xF8, 0x00, 0x1F, 0xFC, 0x3E, 0x00, 0x03, 0xFE,
  0x0F, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80,
  0x7F, 0x87, 0xF0, 0x3F, 0x80, 0xFC, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x07,
  0xC3, 0xF8, 0x01, 0xF0, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x1F, 0x80,
  0x0F, 0x87, 0xC0, 0x07, 0xE3, 0xF0, 0x03, 0xF8, 0xFC, 0x01, 0xFC, 0x3F,
  0x01, 0xFE, 0x1F, 0xBF, 0xFF, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x06, 0x03, 0xFC, 0x0F,
  0x80, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x08, 0x3F, 0x80,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7F, 0xC1, 0xF0, 0x00, 0x7F,
  0xF8, 0xF8, 0x00, 0x3F, 0xFF, 0x3E, 0x00, 0x1F, 0xFF, 0xCF, 0x80, 0x0F,
  0xF8, 0xFF, 0xE0, 0x07, 0xF8, 0x1F, 0xF0, 0x01, 0xFC, 0x03, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x1F, 0x80, 0x07, 0xF0,
  0x07, 0xE0, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x3F, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x01, 0xF8, 0x07, 0xE0, 0x00,
  0xFC, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x3F, 0x00,
  0x03, 0xF0, 0x0F, 0xC0, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x7E, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x03, 0xF8, 0x07,
  0xE0, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x1F, 0xC0,
  0x1F, 0x80, 0x07, 0xF0, 0x07, 0xE0, 0x03, 0xFC, 0x01, 0xF8, 0x01, 0xFE,
  0x00, 0x7E, 0x00, 0x7F, 0x80, 0x0F, 0xC0, 0x3F, 0xE0, 0x03, 0xF0, 0x1F,
  0xF8, 0x00, 0xFF, 0x1F, 0x7E, 0x00, 0x1F, 0xFF, 0xDF, 0x00, 0x07, 0xFF,
  0xEF, 0xC0, 0x00, 0xFF, 0xF3, 0xF0, 0x00, 0x1F, 0xF0, 0xFC, 0x00, 0x00,
  0xE0, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x80, 0x00, 0xFE, 0x00, 0x38, 0x00, 0x7F, 0x00, 0x0F, 0x80, 0x7F,
  0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x03, 0xE0, 0x01, 0xF8, 0x7F,
  0xC0, 0x0F, 0xCF, 0xFF, 0x00, 0x7E, 0xFF, 0xFC, 0x03, 0xEF, 0xFF, 0xF0,
  0x1F, 0x7E, 0x7F, 0x81, 0xFF, 0x81, 0xFC, 0x0F, 0xF8, 0x07, 0xE0, 0x7F,
  0x80, 0x3F, 0x03, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xC1, 0xFC, 0x00,
  0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xF8,
  0x1F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0x7E,
  0x00, 0x1F, 0x83, 0xE0, 0x00, 0xF8, 0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x03, 0xE0, 0x01, 0xF8,
  0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0x7E,
  0x00, 0x1F, 0x03, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0x7C, 0x00, 0x1F, 0x03, 0xE0, 0x01, 0xF8,
  0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xE0, 0x7C,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x01, 0xF8, 0x01,
  0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x02,
  0x1F, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x01, 0xFC,
  0x07, 0xE0, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x01,
  0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x7F, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0xFC,
  0x0F, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x7E, 0x1F,
  0xC0, 0x01, 0xF8, 0xFE, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x1F, 0x1F, 0x80,
  0x00, 0x7C, 0xFC, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x3E, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F,
  0xF7, 0xE0, 0x00, 0x7F, 0x9F, 0x80, 0x01, 0xFC, 0x7E, 0x00, 0x07, 0xE0,
  0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x3F,
  0x00, 0x0F, 0x80, 0x7E, 0x00, 0x3E, 0x01, 0xF8, 0x01, 0xF8, 0x07, 0xE0,
  0x07, 0xE0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xFC, 0x01,
  0xF0, 0x03, 0xF0, 0x0F, 0xC0, 0x0F, 0xC0, 0x3F, 0x00, 0x1F, 0x80, 0xFC,
  0x00, 0x7E, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0x80,
  0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC1, 0xFF, 0x01,
  0xFF, 0x80, 0x1F, 0x1F, 0xFE, 0x0F, 0xFF, 0x00, 0x7C, 0xFF, 0xF8, 0x7F,
  0xFE, 0x01, 0xF7, 0xFF, 0xF3, 0xFF, 0xF8, 0x07, 0xDF, 0x1F, 0xDF, 0x9F,
  0xE0, 0x3F, 0xF0, 0x3F, 0xF8, 0x1F, 0x80, 0xFF, 0x80, 0xFF, 0xC0, 0x7F,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x81, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x07,
  0xE0, 0x03, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0xFC, 0x00, 0x7C, 0x0F, 0xC0,
  0x03, 0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x7E, 0x00, 0x1F, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x1F, 0x00, 0x0F, 0xC0,
  0x07, 0xE0, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0xF8, 0x00, 0x7E, 0x00, 0x3E, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x81,
  0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x3F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x0F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0xFF, 0x80, 0x0F, 0x8F, 0xFF, 0x00, 0x3E,
  0x7F, 0xFE, 0x00, 0xFB, 0xFF, 0xFC, 0x03, 0xFF, 0xDF, 0xF0, 0x1F, 0xF8,
  0x1F, 0xC0, 0x7F, 0xC0, 0x3F, 0x01, 0xFE, 0x00, 0xFC, 0x07, 0xF0, 0x03,
  0xF0, 0x1F, 0xC0, 0x0F, 0xC0, 0xFE, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0xFC,
  0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x7E, 0x07,
  0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0x7E, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0xFC, 0x00,
  0x3F, 0x03, 0xF0, 0x00, 0xFC, 0x0F, 0x80, 0x07, 0xE0, 0x7E, 0x00, 0x1F,
  0x81, 0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x07, 0xC0,
  0xFC, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x3F,
  0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x01, 0xF8, 0x1F, 0x80,
  0x07, 0xE0, 0x7E, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x7C, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xE1, 0xFC, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xF0, 0xFE, 0x00,
  0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0xF8, 0x00, 0x3F, 0x1F, 0x80, 0x03, 0xF1,
  0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x3F, 0x3F, 0x00,
  0x03, 0xF7, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x7E,
  0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E, 0x7C, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x0F,
  0xCF, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF0, 0xFC,
  0x00, 0x3F, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0xFE, 0x07, 0xF0, 0x1F,
  0xC0, 0x3F, 0xC7, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC1, 0xFF, 0x00, 0x01, 0xF0, 0xFF, 0xE0, 0x00,
  0x7C, 0x7F, 0xFC, 0x00, 0x1F, 0x3F, 0xFF, 0x80, 0x07, 0xDF, 0x0F, 0xE0,
  0x03, 0xFF, 0x01, 0xF8, 0x00, 0xFF, 0x80, 0x7F, 0x00, 0x3F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x01, 0xFC, 0x00,
  0x3F, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x03, 0xF0, 0x07, 0xE0,
  0x00, 0xFC, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x3F,
  0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0x7E, 0x00,
  0xF8, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x01, 0xF8,
  0x07, 0xE0, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x3F, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x01, 0xF8, 0x03, 0xF0, 0x00,
  0xFE, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xE0, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xFF, 0x01, 0xFC, 0x00, 0x7F,
  0xF1, 0xFE, 0x00, 0x3F, 0x7F, 0xFF, 0x00, 0x0F, 0xCF, 0xFF, 0x80, 0x03,
  0xF3, 0xFF, 0xC0, 0x00, 0xF8, 0x3F, 0xE0, 0x00, 0x3E, 0x03, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1F, 0xF0, 0x7C, 0x00, 0xFF, 0xF1, 0xF0, 0x03, 0xFF, 0xF3, 0xE0,
  0x0F, 0xFF, 0xE7, 0xC0, 0x3F, 0xE3, 0xFF, 0x80, 0xFF, 0x03, 0xFE, 0x01,
  0xF8, 0x03, 0xFC, 0x07, 0xF0, 0x03, 0xF8, 0x0F, 0xC0, 0x07, 0xF0, 0x3F,
  0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0x7E, 0x07, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x00,
  0x03, 0xE0, 0x7E, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0x7C, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x03,
  0xF0, 0x7E, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x01, 0xFC, 0x0F, 0xC0, 0x03, 0xF8,
  0x1F, 0x80, 0x0F, 0xF0, 0x3F, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x7F, 0x80,
  0x7E, 0x01, 0xFF, 0x00, 0xFC, 0x07, 0xFE, 0x01, 0xFE, 0x3E, 0xF8, 0x01,
  0xFF, 0xF9, 0xF0, 0x03, 0xFF, 0xF7, 0xE0, 0x03, 0xFF, 0x8F, 0xC0, 0x03,
  0xFE, 0x1F, 0x80, 0x00, 0xE0, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0xF0, 0x7F, 0x01, 0xF1, 0xFF, 0x01, 0xF3, 0xFE, 0x01, 0xF7, 0xFE,
  0x01, 0xF7, 0xFE, 0x03, 0xEF, 0x80, 0x03, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xFF,
  0x00, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xC0,
  0xF8, 0x1F, 0xC0, 0x18, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x80, 0x07,
  0xF0, 0x60, 0x07, 0xF0, 0x3E, 0x0F, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF8, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0xFF, 0xFC, 0xFF,
  0xFF, 0x9F, 0xFF, 0xF3, 0xFF, 0xFC, 0x7F, 0xFF, 0x80, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x40, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xE0,
  0x07, 0xFC, 0x00, 0x1C, 0x00, 0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x03,
  0xF0, 0x3F, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x3E, 0x07, 0xE0, 0x01, 0xF8,
  0x1F, 0x80, 0x07, 0xE0, 0x7E, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x7C, 0x07,
  0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xE0, 0x3E, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x7E, 0x07, 0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0x7C, 0x00, 0x1F,
  0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xC0,
  0xFC, 0x00, 0x3E, 0x03, 0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0x7E,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0xFE, 0x07, 0xE0, 0x03, 0xF0, 0x1F, 0x00,
  0x1F, 0xC0, 0x7C, 0x00, 0x7F, 0x03, 0xF0, 0x03, 0xFC, 0x0F, 0xC0, 0x0F,
  0xF0, 0x3F, 0x80, 0x7F, 0x80, 0x7E, 0x07, 0xFE, 0x01, 0xFE, 0x7E, 0xF8,
  0x07, 0xFF, 0xF3, 0xE0, 0x0F, 0xFF, 0x8F, 0x00, 0x3F, 0xFC, 0x7C, 0x00,
  0x7F, 0xE1, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x07, 0xEF, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x3F,
  0x3F, 0x00, 0x0F, 0xCF, 0xC0, 0x07, 0xE3, 0xF0, 0x01, 0xF8, 0xFC, 0x00,
  0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x07, 0xE0, 0x7C,
  0x01, 0xF0, 0x1F, 0x00, 0xFC, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x80,
  0x7C, 0x07, 0xC0, 0x1F, 0x03, 0xF0, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x7E,
  0x00, 0x7C, 0x1F, 0x80, 0x1F, 0x0F, 0xC0, 0x07, 0xC3, 0xF0, 0x01, 0xF0,
  0xF8, 0x00, 0x7C, 0x7E, 0x00, 0x1F, 0x1F, 0x00, 0x07, 0xCF, 0xC0, 0x01,
  0xF3, 0xE0, 0x00, 0x7D, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x07, 0xDF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xEF, 0xC0,
  0x07, 0xF0, 0x01, 0xFB, 0xF0, 0x03, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0x3F, 0x00, 0x7F, 0xC0, 0x1F, 0x8F, 0xC0, 0x1F, 0xF0, 0x07,
  0xE3, 0xF0, 0x07, 0xFC, 0x01, 0xF0, 0xFC, 0x03, 0xFF, 0x00, 0xFC, 0x3F,
  0x00, 0xF7, 0xC0, 0x3F, 0x0F, 0xC0, 0x7D, 0xF0, 0x1F, 0x83, 0xF0, 0x1F,
  0x7C, 0x07, 0xE0, 0xFC, 0x0F, 0x9F, 0x01, 0xF0, 0x3F, 0x03, 0xE7, 0xC0,
  0xFC, 0x0F, 0xC0, 0xF1, 0xF0, 0x3E, 0x03, 0xF0, 0x7C, 0x7C, 0x1F, 0x80,
  0xFC, 0x1F, 0x1F, 0x07, 0xE0, 0x3F, 0x0F, 0x87, 0xC1, 0xF0, 0x0F, 0xC3,
  0xE1, 0xF0, 0xFC, 0x03, 0xF0, 0xF0, 0x7C, 0x3E, 0x00, 0xFC, 0x7C, 0x1F,
  0x1F, 0x80, 0x3F, 0x1F, 0x07, 0xC7, 0xE0, 0x0F, 0xCF, 0x81, 0xF1, 0xF0,
  0x03, 0xF3, 0xE0, 0x7C, 0xFC, 0x00, 0xFC, 0xF0, 0x1F, 0x3E, 0x00, 0x3E,
  0x7C, 0x07, 0xCF, 0x80, 0x0F, 0x9F, 0x01, 0xF7, 0xC0, 0x03, 0xEF, 0x80,
  0x7D, 0xF0, 0x00, 0xFB, 0xE0, 0x1F, 0xFC, 0x00, 0x3E, 0xF0, 0x07, 0xFE,
  0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x1F,
  0x80, 0x03, 0xE0, 0x1F, 0xC0, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0xFC, 0x0F,
  0xC0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x0F, 0xC7,
  0xE0, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x00, 0xFB,
  0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x7E, 0xFC, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00,
  0x3F, 0x0F, 0x80, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0x1F, 0x80, 0xF8, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x0F, 0xC0, 0x3F, 0x00,
  0x0F, 0xC0, 0x1F, 0x80, 0x0F, 0xE0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x07, 0xE0, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x03,
  0xF0, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0x0F,
  0x80, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0x07, 0xC0,
  0x3F, 0x00, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x7E,
  0x00, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x03,
  0xE1, 0xF0, 0x00, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0xF8, 0x00,
  0x00, 0x07, 0xCF, 0xC0, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x01, 0xF3,
  0xE0, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x04, 0x1F, 0xE0, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x08, 0xFF, 0xC0, 0x00, 0x4F, 0xFF, 0x80, 0x06, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xDC,
  0x00, 0x7F, 0xFC, 0x80, 0x00, 0x7F, 0xC4, 0x00, 0x00, 0x00, 0x00,
};

const GFXglyph NotoSans_Condensed_Italic71pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 17, 52, 17, 1, -51 },
  { 112, 21, 19, 25, 7, -51 },
  { 162, 35, 51, 35, 1, -51 },
  { 386, 31, 58, 31, 1, -54 },
  { 611, 41, 52, 47, 4, -51 },
  { 878, 34, 52, 36, 0, -51 },
  { 1099, 10, 19, 14, 7, -51 },
  { 1123, 22, 62, 19, 2, -51 },
  { 1294, 22, 62, 19, -5, -51 },
  { 1465, 25, 26, 30, 7, -54 },
  { 1547, 29, 34, 34, 3, -42 },
  { 1671, 13, 17, 15, -3, -8 },
  { 1699, 17, 6, 20, 1, -22 },
  { 1712, 8, 9, 15, 1, -8 },
  { 1721, 33, 51, 24, -3, -51 },
  { 1932, 29, 52, 31, 2, -51 },
  { 2121, 19, 51, 31, 8, -51 },
  { 2243, 33, 51, 31, -2, -51 },
  { 2454, 31, 52, 31, 0, -51 },
  { 2656, 32, 51, 31, -1, -51 },
  { 2860, 31, 52, 31, 0, -51 },
  { 3062, 29, 52, 31, 3, -51 },
  { 3251, 31, 51, 31, 3, -51 },
  { 3449, 31, 52, 31, 1, -51 },
  { 3651, 29, 52, 31, 1, -51 },
  { 3840, 15, 40, 16, 0, -39 },
  { 3915, 19, 48, 16, -4, -39 },
  { 4029, 29, 33, 34, 3, -42 },
  { 4149, 28, 20, 34, 4, -35 },
  { 4219, 29, 33, 34, 3, -42 },
  { 4339, 24, 52, 24, 2, -51 },
  { 4495, 44, 57, 47, 2, -51 },
  { 4809, 32, 51, 32, -4, -51 },
  { 5013, 33, 51, 34, 1, -51 },
  { 5224, 33, 52, 32, 3, -51 },
  { 5439, 35, 51, 37, 1, -51 },
  { 5663, 31, 51, 29, 1, -51 },
  { 5861, 31, 51, 27, 1, -51 },
  { 6059, 37, 52, 39, 3, -51 },
  { 6300, 39, 51, 38, 1, -51 },
  { 6549, 28, 51, 20, -3, -51 },
  { 6728, 29, 65, 16, -11, -51 },
  { 6964, 37, 51, 32, 1, -51 },
  { 7200, 21, 51, 27, 1, -51 },
  { 7334, 50, 51, 50, 1, -51 },
  { 7653, 41, 51, 41, 1, -51 },
  { 7915, 36, 52, 40, 3, -51 },
  { 8149, 32, 51, 32, 1, -51 },
  { 8353, 36, 63, 40, 3, -51 },
  { 8637, 32, 51, 33, 1, -51 },
  { 8841, 33, 52, 29, -1, -51 },
  { 9056, 27, 51, 28, 6, -51 },
  { 9229, 36, 52, 38, 3, -51 },
  { 9463, 32, 51, 32, 6, -51 },
  { 9667, 50, 51, 51, 6, -51 },
  { 9986, 39, 51, 30, -4, -51 },
  { 10235, 29, 51, 29, 6, -51 },
  { 10420, 34, 51, 28, -2, -51 },
  { 10637, 27, 62, 20, -2, -51 },
  { 10847, 12, 51, 25, 7, -51 },
  { 10924, 27, 62, 20, -5, -51 },
  { 11134, 30, 29, 32, 1, -51 },
  { 11243, 24, 5, 24, -6, 6 },
  { 11258, 11, 11, 18, 10, -54 },
  { 11274, 31, 40, 33, 2, -39 },
  { 11429, 30, 55, 33, 1, -54 },
  { 11636, 25, 40, 25, 2, -39 },
  { 11761, 34, 55, 33, 2, -54 },
  { 11995, 26, 40, 30, 2, -39 },
  { 12125, 36, 71, 18, -9, -54 },
  { 12445, 34, 56, 33, -1, -39 },
  { 12683, 29, 54, 33, 1, -54 },
  { 12879, 16, 52, 15, 1, -52 },
  { 12983, 26, 69, 15, -9, -52 },
  { 13208, 30, 54, 28, 1, -54 },
  { 13411, 17, 54, 15, 1, -54 },
  { 13526, 46, 39, 49, 1, -39 },
  { 13751, 30, 39, 33, 0, -39 },
  { 13898, 28, 40, 32, 2, -39 },
  { 14038, 34, 56, 33, -3, -39 },
  { 14276, 31, 56, 33, 2, -39 },
  { 14493, 24, 39, 22, 1, -39 },
  { 14610, 25, 40, 25, 0, -39 },
  { 14735, 19, 48, 19, 2, -47 },
  { 14849, 30, 39, 33, 2, -38 },
  { 14996, 26, 38, 27, 4, -38 },
  { 15120, 42, 38, 42, 4, -38 },
  { 15320, 33, 38, 27, -3, -38 },
  { 15477, 37, 55, 27, -7, -38 },
  { 15732, 27, 38, 24, -2, -38 },
  { 15861, 27, 62, 24, 1, -51 },
  { 16071, 5, 71, 30, 13, -54 },
  { 16116, 26, 62, 24, -4, -51 },
  { 16318, 29, 10, 34, 3, -30 },
};

const GFXfont NotoSans_Condensed_Italic71pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Italic71pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Italic71pt7bGlyphs,
  0x20, 0x7E, 97
};

#endif // _NOTOSANS_CONDENSED_ITALIC71PT7B_H_
