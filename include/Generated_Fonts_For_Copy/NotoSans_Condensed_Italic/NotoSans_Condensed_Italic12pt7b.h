#ifndef _NOTOSANS_CONDENSED_ITALIC12PT7B_H_
#define _NOTOSANS_CONDENSED_ITALIC12PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Italic.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Italic12pt7bBitmaps[] PROGMEM = {
  0x00, 0x24, 0xA4, 0x90, 0x80, 0x5A, 0xAA, 0x14, 0x52, 0x9F, 0x29, 0x4F,
  0x94, 0xA0, 0x11, 0xD4, 0xA3, 0x18, 0xB6, 0x42, 0x00, 0x45, 0x52, 0xA5,
  0x8D, 0xD5, 0x4D, 0x2A, 0x8C, 0x10, 0xA2, 0x8C, 0x21, 0x59, 0xA6, 0xE8,
  0x5A, 0x12, 0x24, 0x48, 0x88, 0x88, 0x40, 0x21, 0x11, 0x11, 0x22, 0x24,
  0x80, 0x2F, 0x6F, 0x44, 0xF4, 0x44, 0x6A, 0x00, 0xE0, 0xC0, 0x04, 0x20,
  0x84, 0x10, 0x82, 0x10, 0xC0, 0x11, 0x52, 0x94, 0xC6, 0x32, 0x60, 0x16,
  0xA2, 0x24, 0x44, 0x40, 0x32, 0x42, 0x11, 0x11, 0x88, 0xF0, 0x32, 0x42,
  0x13, 0x08, 0x42, 0xF0, 0x08, 0xC6, 0x55, 0x2B, 0xE2, 0x30, 0x39, 0x10,
  0x87, 0x04, 0x22, 0xF0, 0x19, 0x10, 0x87, 0xA6, 0x32, 0x70, 0xF8, 0x84,
  0x42, 0x21, 0x10, 0x80, 0x11, 0x52, 0xD3, 0x2A, 0x32, 0x70, 0x33, 0x52,
  0x95, 0xB4, 0x42, 0xE0, 0x50, 0x08, 0x23, 0x00, 0x02, 0x44, 0x80, 0x16,
  0x8C, 0x30, 0xF0, 0xF0, 0x86, 0x13, 0xC0, 0x35, 0x11, 0x24, 0x40, 0xC0,
  0x0C, 0x32, 0x21, 0x5D, 0x55, 0xA9, 0xAA, 0x94, 0x40, 0x78, 0x08, 0x21,
  0x85, 0x24, 0xF4, 0x51, 0xC4, 0x30, 0xB2, 0x52, 0x71, 0x24, 0xA2, 0xF0,
  0x3B, 0x71, 0x08, 0x42, 0x10, 0xE0, 0x30, 0xB2, 0x51, 0x45, 0x14, 0xA6,
  0xF0, 0x39, 0x08, 0x87, 0xA1, 0x10, 0xF0, 0x39, 0x08, 0x87, 0x21, 0x10,
  0x80, 0x19, 0x9C, 0x20, 0x9A, 0x28, 0xA4, 0xF0, 0x22, 0x48, 0x92, 0x27,
  0xC8, 0x92, 0x44, 0x88, 0x38, 0x84, 0x22, 0x10, 0x84, 0xE0, 0x08, 0x42,
  0x21, 0x08, 0x44, 0x21, 0x38, 0x24, 0xB2, 0x94, 0x61, 0x45, 0x24, 0x88,
  0x22, 0x24, 0x44, 0x48, 0xF0, 0x21, 0x90, 0x94, 0xCA, 0x65, 0x52, 0xA9,
  0x69, 0x34, 0x92, 0x00, 0x22, 0x45, 0x4A, 0xA5, 0x4A, 0x93, 0x46, 0x88,
  0x31, 0x2C, 0xE3, 0x8A, 0x28, 0xA4, 0xF0, 0x30, 0xA2, 0x52, 0x49, 0xC4,
  0x20, 0x80, 0x31, 0x2C, 0xE3, 0x8A, 0x28, 0xA4, 0xF0, 0x83, 0x00, 0x30,
  0xA2, 0x52, 0x59, 0xC5, 0x24, 0x98, 0x3B, 0x50, 0x82, 0x08, 0x42, 0xF0,
  0xF9, 0x10, 0x84, 0x21, 0x10, 0x80, 0x45, 0x28, 0xA2, 0x8A, 0x29, 0x24,
  0xE0, 0x8C, 0x65, 0x29, 0x52, 0x98, 0xC0, 0x89, 0xCC, 0xA6, 0x53, 0x4A,
  0xA5, 0x63, 0x31, 0x98, 0x88, 0x00, 0x22, 0x28, 0x50, 0xC1, 0x02, 0x0A,
  0x24, 0xC8, 0x8C, 0xA5, 0x46, 0x21, 0x10, 0x80, 0x78, 0x44, 0x22, 0x31,
  0x10, 0xF0, 0x32, 0x44, 0x44, 0x48, 0x88, 0xC0, 0xA9, 0x55, 0x40, 0x38,
  0x44, 0x21, 0x08, 0x84, 0x21, 0x38, 0x11, 0x8C, 0x9C, 0x80, 0xF0, 0xC0,
  0x15, 0xA4, 0x92, 0x8A, 0x47, 0x00, 0x21, 0x14, 0xD4, 0xA5, 0x3B, 0xF0,
  0x13, 0x50, 0x88, 0x41, 0xC0, 0x04, 0x11, 0x5A, 0x49, 0x28, 0xA4, 0x70,
  0x13, 0x52, 0xE8, 0x41, 0xC0, 0x1C, 0x41, 0x88, 0x20, 0x82, 0x10, 0x41,
  0x04, 0x20, 0x15, 0xA4, 0x92, 0x8A, 0x47, 0x04, 0x13, 0x80, 0x21, 0x14,
  0xD4, 0xA5, 0x32, 0x90, 0x20, 0x24, 0x94, 0x80, 0x08, 0x00, 0x21, 0x08,
  0x44, 0x21, 0x09, 0x80, 0x21, 0x10, 0xB5, 0x31, 0x92, 0x90, 0x25, 0x24,
  0x94, 0x80, 0x12, 0x6D, 0x49, 0x49, 0x4A, 0x92, 0x92, 0x13, 0x52, 0x94,
  0xCA, 0x40, 0x13, 0x52, 0x98, 0xC9, 0xC0, 0x13, 0x52, 0x94, 0xEF, 0xD0,
  0x84, 0x00, 0x15, 0xA4, 0x92, 0x8A, 0x47, 0x04, 0x10, 0x40, 0x16, 0x44,
  0x48, 0x80, 0x25, 0x46, 0x22, 0xE0, 0x27, 0x44, 0x44, 0x8C, 0x4A, 0x52,
  0x99, 0x38, 0x9A, 0xAC, 0xC8, 0xB7, 0x6B, 0x66, 0xC9, 0x92, 0x00, 0x2C,
  0xA1, 0x0C, 0x33, 0x20, 0x24, 0xA2, 0x8C, 0x30, 0x82, 0x10, 0xC0, 0x72,
  0x24, 0x8E, 0x08, 0x88, 0x42, 0x61, 0x08, 0x42, 0x18, 0xFF, 0xF0, 0x20,
  0x84, 0x21, 0x0C, 0x84, 0x21, 0x30, 0xF9,
};

const GFXglyph NotoSans_Condensed_Italic12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 3, 9, 3, 0, -9 },
  { 5, 4, 4, 4, 1, -9 },
  { 7, 6, 9, 6, 0, -9 },
  { 14, 5, 10, 5, 0, -9 },
  { 21, 7, 9, 8, 1, -9 },
  { 29, 6, 9, 6, 0, -9 },
  { 36, 2, 4, 2, 1, -9 },
  { 37, 4, 11, 3, 0, -9 },
  { 43, 4, 11, 3, -1, -9 },
  { 49, 4, 4, 5, 1, -9 },
  { 51, 4, 6, 6, 1, -7 },
  { 54, 3, 3, 3, -1, -1 },
  { 56, 3, 1, 3, 0, -4 },
  { 57, 2, 1, 3, 0, -1 },
  { 58, 6, 9, 4, -1, -9 },
  { 65, 5, 9, 5, 0, -9 },
  { 71, 4, 9, 5, 1, -9 },
  { 76, 5, 9, 5, 0, -9 },
  { 82, 5, 9, 5, 0, -9 },
  { 88, 5, 9, 5, 0, -9 },
  { 94, 5, 9, 5, 0, -9 },
  { 100, 5, 9, 5, 0, -9 },
  { 106, 5, 9, 5, 1, -9 },
  { 112, 5, 9, 5, 0, -9 },
  { 118, 5, 9, 5, 0, -9 },
  { 124, 2, 7, 3, 0, -7 },
  { 126, 4, 9, 3, -1, -7 },
  { 131, 4, 5, 6, 1, -7 },
  { 134, 4, 3, 6, 1, -6 },
  { 136, 4, 5, 6, 1, -7 },
  { 139, 4, 9, 4, 0, -9 },
  { 144, 8, 10, 8, 0, -9 },
  { 154, 6, 9, 5, -1, -9 },
  { 161, 6, 9, 6, 0, -9 },
  { 168, 5, 9, 5, 1, -9 },
  { 174, 6, 9, 6, 0, -9 },
  { 181, 5, 9, 5, 0, -9 },
  { 187, 5, 9, 5, 0, -9 },
  { 193, 6, 9, 7, 1, -9 },
  { 200, 7, 9, 7, 0, -9 },
  { 208, 5, 9, 3, -1, -9 },
  { 214, 5, 11, 3, -2, -9 },
  { 221, 6, 9, 5, 0, -9 },
  { 228, 4, 9, 5, 0, -9 },
  { 233, 9, 9, 8, 0, -9 },
  { 244, 7, 9, 7, 0, -9 },
  { 252, 6, 9, 7, 1, -9 },
  { 259, 6, 9, 5, 0, -9 },
  { 266, 6, 11, 7, 1, -9 },
  { 275, 6, 9, 6, 0, -9 },
  { 282, 5, 9, 5, 0, -9 },
  { 288, 5, 9, 5, 1, -9 },
  { 294, 6, 9, 6, 1, -9 },
  { 301, 5, 9, 5, 1, -9 },
  { 307, 9, 9, 9, 1, -9 },
  { 318, 7, 9, 5, -1, -9 },
  { 326, 5, 9, 5, 1, -9 },
  { 332, 5, 9, 5, 0, -9 },
  { 338, 4, 11, 3, 0, -9 },
  { 344, 2, 9, 4, 1, -9 },
  { 347, 5, 11, 3, -1, -9 },
  { 354, 5, 5, 5, 0, -9 },
  { 358, 4, 1, 4, -1, 1 },
  { 359, 1, 2, 3, 2, -9 },
  { 360, 6, 7, 6, 0, -7 },
  { 366, 5, 9, 6, 0, -9 },
  { 372, 5, 7, 4, 0, -7 },
  { 377, 6, 9, 6, 0, -9 },
  { 384, 5, 7, 5, 0, -7 },
  { 389, 6, 12, 3, -1, -9 },
  { 398, 6, 10, 6, 0, -7 },
  { 406, 5, 9, 6, 0, -9 },
  { 412, 3, 9, 3, 0, -9 },
  { 416, 5, 12, 3, -2, -9 },
  { 424, 5, 9, 5, 0, -9 },
  { 430, 3, 9, 3, 0, -9 },
  { 434, 8, 7, 8, 0, -7 },
  { 441, 5, 7, 6, 0, -7 },
  { 446, 5, 7, 5, 0, -7 },
  { 451, 5, 10, 6, 0, -7 },
  { 458, 6, 10, 6, 0, -7 },
  { 466, 4, 7, 4, 0, -7 },
  { 470, 4, 7, 4, 0, -7 },
  { 474, 4, 8, 3, 0, -8 },
  { 478, 5, 6, 6, 0, -6 },
  { 482, 4, 6, 5, 1, -6 },
  { 485, 7, 6, 7, 1, -6 },
  { 491, 6, 6, 5, -1, -6 },
  { 496, 6, 9, 5, -1, -6 },
  { 503, 4, 6, 4, 0, -6 },
  { 506, 5, 11, 4, 0, -9 },
  { 513, 1, 12, 5, 2, -9 },
  { 515, 5, 11, 4, -1, -9 },
  { 522, 4, 2, 6, 1, -5 },
};

const GFXfont NotoSans_Condensed_Italic12pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Italic12pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Italic12pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _NOTOSANS_CONDENSED_ITALIC12PT7B_H_
