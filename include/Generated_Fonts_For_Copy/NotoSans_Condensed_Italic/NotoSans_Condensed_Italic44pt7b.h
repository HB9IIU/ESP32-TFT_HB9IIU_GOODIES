#ifndef _NOTOSANS_CONDENSED_ITALIC44PT7B_H_
#define _NOTOSANS_CONDENSED_ITALIC44PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Italic.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Italic44pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xC0, 0xF0, 0x3C, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1C, 0x0F,
  0x03, 0xC0, 0xF0, 0x38, 0x0E, 0x03, 0x81, 0xE0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0xE0, 0x38, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x00, 0x3C, 0x79, 0xE3, 0xCE, 0x1C, 0x70, 0xE7, 0x8F,
  0x3C, 0x71, 0xC3, 0x8E, 0x1C, 0x70, 0xE3, 0x06, 0x38, 0x70, 0x00, 0x1C,
  0x38, 0x00, 0xE0, 0xE0, 0x03, 0x83, 0x00, 0x0E, 0x1C, 0x00, 0x70, 0x70,
  0x01, 0xC1, 0x80, 0x07, 0x0E, 0x00, 0x18, 0x38, 0x00, 0xE0, 0xE0, 0x3F,
  0xFF, 0xF1, 0xFF, 0xFF, 0xC0, 0x70, 0x70, 0x01, 0xC3, 0x80, 0x07, 0x0E,
  0x00, 0x38, 0x38, 0x00, 0xE0, 0xC0, 0x03, 0x87, 0x00, 0x1C, 0x1C, 0x00,
  0x70, 0x61, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x80, 0xE1,
  0xC0, 0x03, 0x07, 0x00, 0x1C, 0x1C, 0x00, 0x70, 0xE0, 0x01, 0xC3, 0x80,
  0x0E, 0x0E, 0x00, 0x38, 0x30, 0x00, 0xE1, 0xC0, 0x07, 0x07, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xF0, 0x00, 0xFF,
  0xF0, 0x3F, 0xFE, 0x03, 0xFD, 0xE0, 0x79, 0x84, 0x07, 0x18, 0x00, 0xF1,
  0x80, 0x0E, 0x18, 0x00, 0xE3, 0x00, 0x0F, 0x30, 0x00, 0x7B, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x07, 0xF0, 0x00, 0xEF, 0x00, 0x0C, 0x70, 0x00, 0xC7, 0x00, 0x0C, 0x70,
  0x00, 0xC7, 0x00, 0x18, 0x70, 0x41, 0x8F, 0x07, 0x9B, 0xE0, 0x7F, 0xFC,
  0x0F, 0xFF, 0x80, 0x0F, 0xC0, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x07, 0x80, 0x02, 0x07, 0xE0, 0x0E,
  0x07, 0xF8, 0x07, 0x07, 0x1C, 0x07, 0x03, 0x8E, 0x07, 0x03, 0x87, 0x03,
  0x81, 0xC3, 0x83, 0x80, 0xE1, 0xC1, 0xC0, 0xE0, 0xE1, 0xC0, 0x70, 0x70,
  0xE0, 0x38, 0x38, 0xE0, 0x1C, 0x38, 0xE0, 0x0C, 0x1C, 0x70, 0x06, 0x0E,
  0x71, 0xF3, 0x06, 0x39, 0xFD, 0x87, 0x39, 0xEE, 0xE7, 0x39, 0xC3, 0xFF,
  0x9C, 0xE1, 0xDF, 0x9C, 0xE0, 0xE7, 0x0E, 0x70, 0x70, 0x0E, 0x38, 0x30,
  0x0E, 0x1C, 0x38, 0x07, 0x1C, 0x1C, 0x07, 0x0E, 0x0E, 0x03, 0x87, 0x07,
  0x03, 0x83, 0x87, 0x01, 0xC1, 0xC3, 0x81, 0xC0, 0xE1, 0xC1, 0xC0, 0x71,
  0xC0, 0xE0, 0x3D, 0xE0, 0xE0, 0x0F, 0xE0, 0xF0, 0x07, 0xE0, 0x00, 0x1E,
  0x00, 0x03, 0xFC, 0x00, 0x3F, 0xF0, 0x03, 0xC7, 0x80, 0x1C, 0x1C, 0x01,
  0xE0, 0xE0, 0x0F, 0x07, 0x00, 0x70, 0x78, 0x03, 0x83, 0xC0, 0x1C, 0x1C,
  0x00, 0xF1, 0xC0, 0x07, 0x9E, 0x00, 0x1D, 0xE0, 0x00, 0xFE, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x7B, 0xC1, 0xC7, 0x9E, 0x1E,
  0x78, 0x70, 0xE3, 0x83, 0xC7, 0x3C, 0x1E, 0x79, 0xC0, 0x7F, 0x9E, 0x03,
  0xF8, 0xF0, 0x0F, 0xC7, 0x80, 0x7C, 0x3C, 0x03, 0xE1, 0xE0, 0x3F, 0x07,
  0x83, 0xFC, 0x3F, 0xFD, 0xE0, 0xFF, 0xC7, 0x83, 0xF8, 0x3C, 0x7B, 0xDC,
  0xE7, 0x7B, 0x9C, 0xE7, 0x30, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0,
  0x07, 0x80, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xE0,
  0x07, 0x80, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0xC0, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x3C,
  0x01, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80,
  0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x78,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x00, 0x01, 0x00, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xC0, 0x41, 0xC0, 0x71, 0xC0, 0x7D, 0xC1, 0xFF, 0xFF, 0x07, 0xFF,
  0x07, 0xDF, 0x0F, 0xC0, 0x1E, 0xE0, 0x3C, 0xE0, 0x7C, 0x70, 0x38, 0x70,
  0x10, 0x78, 0x00, 0x20, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x0F, 0x0F, 0x1E, 0x1E, 0x1C, 0x3C, 0x38, 0x78,
  0x70, 0x70, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x77, 0xFD, 0xEF, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00,
  0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x3F,
  0xC0, 0x1F, 0xF8, 0x0F, 0xBE, 0x07, 0xC3, 0xC1, 0xE0, 0xF0, 0xF0, 0x3C,
  0x3C, 0x07, 0x1E, 0x01, 0xC7, 0x80, 0xF1, 0xC0, 0x3C, 0xF0, 0x0F, 0x3C,
  0x03, 0xCF, 0x00, 0xF3, 0x80, 0x3D, 0xE0, 0x0E, 0x78, 0x03, 0x9E, 0x01,
  0xE7, 0x00, 0x79, 0xC0, 0x1E, 0x70, 0x07, 0x3C, 0x03, 0xCF, 0x00, 0xF3,
  0xC0, 0x38, 0xF0, 0x1E, 0x3C, 0x07, 0x07, 0x03, 0xC1, 0xC0, 0xE0, 0x78,
  0x78, 0x1F, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0x00, 0x01, 0xF0, 0x3E, 0x07,
  0xE0, 0xFE, 0x3F, 0xE7, 0xDE, 0xF9, 0xC6, 0x3C, 0x43, 0xC0, 0x3C, 0x03,
  0x80, 0x38, 0x07, 0x80, 0x78, 0x07, 0x80, 0x70, 0x07, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0xFC,
  0x01, 0xFF, 0xE0, 0x3F, 0x3E, 0x01, 0x80, 0xF0, 0x10, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF0, 0x00, 0x7E, 0x00, 0x3F, 0xF0, 0x1F, 0xFF, 0x03, 0xE3,
  0xF0, 0x30, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0xFF, 0x80, 0x1F, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x40, 0x0F, 0x0C, 0x07, 0xC1,
  0xFF, 0xF8, 0x3F, 0xFC, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0x70,
  0x01, 0xDE, 0x00, 0x3B, 0xC0, 0x0E, 0x70, 0x03, 0x8E, 0x00, 0xF3, 0xC0,
  0x1C, 0x78, 0x07, 0x0E, 0x01, 0xE1, 0xC0, 0x38, 0x78, 0x0E, 0x0F, 0x03,
  0xC1, 0xE0, 0x70, 0x38, 0x1C, 0x07, 0x07, 0x01, 0xE0, 0xE0, 0x3C, 0x3F,
  0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xC0, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x01,
  0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x81, 0xE0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x00, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x07, 0xFF, 0xC0, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01,
  0xE2, 0x00, 0x78, 0x60, 0x3F, 0x0F, 0xFF, 0xC1, 0xFF, 0xE0, 0x1F, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x1F, 0xF0, 0x0F, 0xFC, 0x07, 0xE2, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03,
  0xC0, 0x00, 0xE0, 0x00, 0x78, 0xF0, 0x1E, 0xFF, 0x07, 0x7F, 0xC1, 0xFC,
  0xF8, 0xFC, 0x1E, 0x3E, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x0F,
  0x38, 0x03, 0x8E, 0x00, 0xE3, 0x80, 0x78, 0xE0, 0x1E, 0x38, 0x07, 0x0E,
  0x03, 0xC3, 0xC0, 0xF0, 0xF0, 0x78, 0x1F, 0xFC, 0x07, 0xFE, 0x00, 0x7F,
  0x00, 0x1F, 0xFF, 0xE3, 0xFF, 0xF8, 0xFF, 0xFF, 0x00, 0x01, 0xE0, 0x00,
  0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03,
  0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xC0, 0x3E,
  0x3E, 0x03, 0xC1, 0xE0, 0x78, 0x0F, 0x07, 0x00, 0xF0, 0x70, 0x0F, 0x07,
  0x00, 0xE0, 0x70, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x3C, 0x03, 0xC7, 0x80,
  0x3F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xFC, 0x00, 0xFF, 0xE0,
  0x1F, 0x1E, 0x03, 0xC0, 0xF0, 0x3C, 0x07, 0x07, 0x80, 0x78, 0x70, 0x07,
  0x87, 0x00, 0x78, 0xF0, 0x07, 0x8F, 0x00, 0x78, 0xF0, 0x07, 0x07, 0x80,
  0xF0, 0x78, 0x1E, 0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0xFF, 0x00, 0x00,
  0x7C, 0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x1F, 0x3E, 0x0F, 0x07, 0x83, 0x80,
  0xF1, 0xE0, 0x3C, 0x70, 0x0F, 0x3C, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x3C,
  0xF0, 0x0F, 0x38, 0x03, 0xCE, 0x01, 0xE3, 0xC0, 0x78, 0xF0, 0x3E, 0x3E,
  0x1F, 0x87, 0xFF, 0xE1, 0xFF, 0x70, 0x3F, 0x9C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xF0, 0x3F, 0xF8, 0x0F, 0xFC, 0x03, 0xFC, 0x00, 0x03,
  0x03, 0xC3, 0xE1, 0xF0, 0xF0, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x07, 0x87, 0xC3,
  0xE0, 0xE0, 0x00, 0xE0, 0x3C, 0x0F, 0x81, 0xF0, 0x3E, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x3C, 0x07, 0x81, 0xE0, 0x3C,
  0x07, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x70, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xF0, 0x00, 0x3C, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80,
  0x00, 0x38, 0x00, 0x0F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3C,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x3F, 0x00, 0x0F, 0x00, 0x03, 0x00, 0x00, 0x01, 0xF0, 0x1F, 0xF0,
  0x7F, 0xF0, 0xF1, 0xF0, 0x81, 0xE0, 0x03, 0xC0, 0x03, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xC0, 0x78, 0x00, 0xF0,
  0x03, 0xC0, 0x1E, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0xE0, 0x78, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0xE0, 0xE0, 0x3F, 0x06, 0x0E, 0x0F, 0xF8, 0x71, 0xC1,
  0xF7, 0x87, 0x1C, 0x3C, 0x70, 0x73, 0x83, 0x87, 0x06, 0x38, 0x70, 0x70,
  0x63, 0x07, 0x07, 0x0E, 0x70, 0xE0, 0xE0, 0xE7, 0x0E, 0x0E, 0x0E, 0x70,
  0xE0, 0xE0, 0xE7, 0x0C, 0x0E, 0x1C, 0x61, 0xC1, 0xC1, 0xC6, 0x1C, 0x1C,
  0x18, 0xE1, 0xC3, 0xC3, 0x8E, 0x1C, 0x3C, 0x70, 0xE0, 0xEE, 0xEF, 0x0E,
  0x0F, 0xCF, 0xE0, 0x60, 0x78, 0x78, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x01, 0xEE, 0x00, 0x1C,
  0xE0, 0x03, 0xCE, 0x00, 0x38, 0xE0, 0x03, 0x8E, 0x00, 0x78, 0xE0, 0x07,
  0x0E, 0x00, 0xF0, 0xF0, 0x0E, 0x0F, 0x01, 0xE0, 0xF0, 0x1E, 0x0F, 0x03,
  0xC0, 0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0x00, 0xF0,
  0xF0, 0x0F, 0x0F, 0x00, 0xF1, 0xE0, 0x0F, 0x1E, 0x00, 0xF3, 0xC0, 0x0F,
  0x3C, 0x00, 0xF7, 0x80, 0x0F, 0x78, 0x00, 0xFF, 0x00, 0x0F, 0x03, 0xFF,
  0x80, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x78, 0x1F, 0x07, 0x80, 0xF0, 0x78,
  0x0F, 0x07, 0x00, 0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x0F,
  0x01, 0xE0, 0xE0, 0x3E, 0x1E, 0x07, 0xC1, 0xFF, 0xF0, 0x1F, 0xFC, 0x01,
  0xFF, 0xF0, 0x1C, 0x0F, 0x83, 0xC0, 0x78, 0x3C, 0x03, 0xC3, 0xC0, 0x3C,
  0x38, 0x03, 0xC3, 0x80, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x3C, 0x78, 0x07,
  0x87, 0x00, 0x78, 0xF0, 0x0F, 0x0F, 0x03, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF,
  0x80, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFB, 0xC0, 0x3E, 0x02, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x40, 0x1F, 0xFE, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFF, 0xF8,
  0x0F, 0x07, 0xE0, 0x78, 0x0F, 0x03, 0xC0, 0x3C, 0x1C, 0x01, 0xE1, 0xE0,
  0x0F, 0x0F, 0x00, 0x78, 0x78, 0x03, 0xC3, 0xC0, 0x1E, 0x1C, 0x00, 0xF1,
  0xE0, 0x07, 0x8F, 0x00, 0x3C, 0x78, 0x01, 0xE3, 0x80, 0x0F, 0x1C, 0x00,
  0x79, 0xE0, 0x07, 0x8F, 0x00, 0x3C, 0x78, 0x01, 0xE3, 0x80, 0x1E, 0x1C,
  0x00, 0xF1, 0xE0, 0x0F, 0x0F, 0x00, 0x78, 0x78, 0x07, 0x83, 0x80, 0x7C,
  0x3C, 0x0F, 0xC1, 0xE1, 0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x03, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x10, 0x3F, 0xFC, 0x07,
  0xFF, 0x80, 0xFF, 0xF0, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0xFF, 0x81, 0xFF,
  0xF0, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x07, 0xFF, 0xC0, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xF8,
  0x03, 0xFF, 0xF8, 0x0F, 0xE7, 0xE0, 0x3E, 0x00, 0x80, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x07, 0xF8, 0xF0, 0x0F, 0xF1, 0xE0, 0x1F, 0xE3, 0xC0, 0x7F,
  0xC7, 0x80, 0x07, 0x8F, 0x00, 0x0E, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x78,
  0x78, 0x00, 0xF0, 0xF0, 0x01, 0xC1, 0xE0, 0x03, 0x81, 0xE0, 0x0F, 0x03,
  0xE0, 0x1E, 0x03, 0xE0, 0x3C, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x03,
  0xFF, 0x00, 0x03, 0xC0, 0x0F, 0x03, 0x80, 0x0E, 0x03, 0x80, 0x1E, 0x07,
  0x80, 0x1E, 0x07, 0x80, 0x1E, 0x07, 0x80, 0x1C, 0x07, 0x00, 0x3C, 0x07,
  0x00, 0x3C, 0x0F, 0x00, 0x3C, 0x0F, 0x00, 0x38, 0x0F, 0x00, 0x38, 0x0E,
  0x00, 0x78, 0x1E, 0x00, 0x78, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF0, 0x1C, 0x00, 0xF0, 0x3C, 0x00, 0xF0, 0x3C, 0x00, 0xF0, 0x3C,
  0x00, 0xE0, 0x38, 0x01, 0xE0, 0x38, 0x01, 0xE0, 0x78, 0x01, 0xE0, 0x78,
  0x01, 0xE0, 0x78, 0x01, 0xC0, 0x70, 0x03, 0xC0, 0x70, 0x03, 0xC0, 0xF0,
  0x03, 0xC0, 0xF0, 0x03, 0x80, 0xF0, 0x03, 0x80, 0xE0, 0x07, 0x80, 0x01,
  0xFF, 0x81, 0xFF, 0xC0, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x01, 0xF8,
  0x07, 0xFF, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1F, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x03, 0xC0, 0x3E,
  0x07, 0x00, 0xF0, 0x0E, 0x03, 0xC0, 0x3C, 0x0F, 0x80, 0x78, 0x1E, 0x00,
  0xF0, 0x78, 0x01, 0xC1, 0xE0, 0x07, 0x87, 0x80, 0x0F, 0x1F, 0x00, 0x1E,
  0x3C, 0x00, 0x3C, 0xF0, 0x00, 0x73, 0xC0, 0x01, 0xEF, 0x80, 0x03, 0xDE,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0x70, 0x00, 0x7C, 0xF0,
  0x00, 0xF1, 0xE0, 0x01, 0xE3, 0xC0, 0x03, 0x83, 0x80, 0x07, 0x07, 0x80,
  0x1E, 0x0F, 0x00, 0x3C, 0x1E, 0x00, 0x78, 0x1C, 0x00, 0xE0, 0x3C, 0x03,
  0xC0, 0x78, 0x07, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x38,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xE0, 0x00, 0x7E, 0x07, 0xC0,
  0x01, 0xF8, 0x0F, 0x80, 0x03, 0xF0, 0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0x00,
  0x1F, 0xC0, 0xFE, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0xEE, 0x07, 0xB8, 0x03,
  0xDC, 0x0F, 0x70, 0x07, 0x78, 0x1E, 0xE0, 0x1E, 0xF0, 0x39, 0xC0, 0x39,
  0xC0, 0x73, 0x80, 0x73, 0x81, 0xE7, 0x01, 0xCF, 0x03, 0xCE, 0x03, 0x9E,
  0x07, 0x1C, 0x0E, 0x3C, 0x0E, 0x38, 0x1C, 0x70, 0x1C, 0x70, 0x70, 0xE0,
  0x78, 0xE0, 0xE3, 0xC0, 0xF1, 0xC3, 0xC7, 0x81, 0xC3, 0xC7, 0x0F, 0x03,
  0x87, 0x9E, 0x1C, 0x07, 0x0F, 0x38, 0x78, 0x1E, 0x0E, 0xF0, 0xF0, 0x3C,
  0x1D, 0xC1, 0xE0, 0x70, 0x3F, 0x83, 0xC0, 0xE0, 0x7E, 0x07, 0x03, 0xC0,
  0xFC, 0x1E, 0x07, 0x81, 0xF0, 0x3C, 0x0F, 0x03, 0xE0, 0x78, 0x1C, 0x07,
  0x80, 0xE0, 0x38, 0x0F, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x07, 0x81, 0xF0,
  0x03, 0xC0, 0xF8, 0x01, 0xC0, 0xFC, 0x00, 0xE0, 0x7E, 0x00, 0xF0, 0x3F,
  0x80, 0x78, 0x1D, 0xC0, 0x38, 0x1E, 0xE0, 0x1C, 0x0F, 0x70, 0x1E, 0x07,
  0x3C, 0x0F, 0x03, 0x9E, 0x07, 0x81, 0xC7, 0x03, 0x81, 0xE3, 0x81, 0xC0,
  0xF1, 0xE1, 0xE0, 0x78, 0xF0, 0xF0, 0x38, 0x38, 0x78, 0x1C, 0x1C, 0x38,
  0x1E, 0x0E, 0x1C, 0x0F, 0x07, 0x9E, 0x07, 0x01, 0xCF, 0x03, 0x80, 0xE7,
  0x01, 0xC0, 0x73, 0x81, 0xE0, 0x3D, 0xC0, 0xF0, 0x1F, 0xE0, 0x70, 0x07,
  0xF0, 0x38, 0x03, 0xF0, 0x3C, 0x01, 0xF8, 0x1E, 0x00, 0xFC, 0x0F, 0x00,
  0x3E, 0x07, 0x00, 0x1F, 0x03, 0x80, 0x0F, 0x00, 0x00, 0x1F, 0x80, 0x01,
  0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFE, 0xFC, 0x03, 0xC0, 0xF8, 0x1E, 0x01,
  0xE0, 0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x1E, 0x00, 0x3C, 0x78, 0x00, 0xF3,
  0xC0, 0x03, 0xCF, 0x00, 0x0F, 0x78, 0x00, 0x3D, 0xE0, 0x00, 0xF7, 0x80,
  0x03, 0xDE, 0x00, 0x0E, 0x70, 0x00, 0x7B, 0xC0, 0x01, 0xEF, 0x00, 0x07,
  0xBC, 0x00, 0x1E, 0xF0, 0x00, 0xF3, 0xC0, 0x03, 0xCF, 0x00, 0x0F, 0x3C,
  0x00, 0x78, 0xF0, 0x01, 0xE3, 0xC0, 0x0F, 0x0F, 0x80, 0x7C, 0x1E, 0x03,
  0xE0, 0x7C, 0x1F, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x03, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x03, 0xC1, 0xF0, 0x78, 0x1E,
  0x0F, 0x03, 0xC1, 0xC0, 0x38, 0x78, 0x07, 0x0F, 0x00, 0xE1, 0xE0, 0x3C,
  0x3C, 0x07, 0x87, 0x00, 0xF1, 0xE0, 0x3C, 0x3C, 0x07, 0x87, 0x83, 0xE0,
  0xE7, 0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0x80, 0x1E, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFE,
  0xFC, 0x03, 0xC0, 0xF8, 0x1E, 0x01, 0xE0, 0xF0, 0x03, 0xC3, 0xC0, 0x0F,
  0x1E, 0x00, 0x3C, 0x78, 0x00, 0xF3, 0xC0, 0x03, 0xCF, 0x00, 0x0F, 0x78,
  0x00, 0x3D, 0xE0, 0x00, 0xF7, 0x80, 0x03, 0xDE, 0x00, 0x0E, 0x70, 0x00,
  0x7B, 0xC0, 0x01, 0xEF, 0x00, 0x07, 0xBC, 0x00, 0x1E, 0xF0, 0x00, 0xF3,
  0xC0, 0x03, 0xCF, 0x00, 0x0F, 0x3C, 0x00, 0x78, 0xF0, 0x01, 0xE3, 0xC0,
  0x0F, 0x0F, 0x80, 0x7C, 0x1E, 0x03, 0xE0, 0x7C, 0x1F, 0x00, 0xFF, 0xF8,
  0x01, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x78, 0x3E,
  0x07, 0x81, 0xE0, 0x78, 0x0E, 0x07, 0x00, 0xF0, 0xF0, 0x0F, 0x0F, 0x00,
  0xE0, 0xF0, 0x1E, 0x0F, 0x01, 0xE0, 0xE0, 0x1E, 0x1E, 0x03, 0xC1, 0xE0,
  0x7C, 0x1E, 0x1F, 0x81, 0xFF, 0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x3C,
  0x78, 0x03, 0xC3, 0x80, 0x38, 0x3C, 0x03, 0x83, 0xC0, 0x78, 0x3C, 0x07,
  0x83, 0xC0, 0x78, 0x1E, 0x07, 0x01, 0xE0, 0xF0, 0x1E, 0x0F, 0x01, 0xE0,
  0xF0, 0x0F, 0x0F, 0x00, 0xF0, 0xE0, 0x0F, 0x00, 0x00, 0x3F, 0x00, 0x0F,
  0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xC0, 0x40, 0xF8, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x1E, 0x08, 0x03, 0xE0, 0xE0, 0x7C, 0x0F, 0xFF, 0xC0, 0xFF,
  0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xC0, 0x78,
  0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x1C, 0x1C, 0x00, 0xF0, 0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x0F, 0x00, 0x38,
  0x38, 0x01, 0xE1, 0xE0, 0x07, 0x87, 0x80, 0x1E, 0x1E, 0x00, 0x78, 0x70,
  0x01, 0xC1, 0xC0, 0x0F, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0xF0, 0xF0, 0x03,
  0x83, 0x80, 0x0E, 0x0E, 0x00, 0x78, 0x78, 0x01, 0xE1, 0xE0, 0x07, 0x87,
  0x80, 0x1C, 0x1C, 0x00, 0xF0, 0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x0F, 0x00,
  0x38, 0x3C, 0x01, 0xE0, 0xF0, 0x07, 0x83, 0xC0, 0x1C, 0x0F, 0x00, 0xF0,
  0x1E, 0x0F, 0x80, 0x7F, 0xFE, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x00,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0x78, 0x01, 0xEF, 0x00, 0x79,
  0xE0, 0x0F, 0x3C, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x0E, 0x1E, 0x03, 0xC3,
  0xC0, 0x70, 0x78, 0x1E, 0x0F, 0x03, 0xC1, 0xE0, 0xF0, 0x3C, 0x1E, 0x07,
  0x87, 0x80, 0xF0, 0xF0, 0x0E, 0x1C, 0x01, 0xC7, 0x80, 0x38, 0xE0, 0x07,
  0x3C, 0x00, 0xE7, 0x00, 0x1D, 0xE0, 0x03, 0xBC, 0x00, 0x77, 0x00, 0x0F,
  0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x07, 0x80, 0x1F, 0xE0, 0x0F, 0x00, 0x7B, 0xC0, 0x1E,
  0x00, 0xF7, 0x80, 0x7C, 0x01, 0xCF, 0x00, 0xF8, 0x07, 0x9E, 0x03, 0xF0,
  0x0F, 0x3C, 0x07, 0xE0, 0x3C, 0x78, 0x0F, 0xC0, 0x78, 0xF0, 0x3B, 0x80,
  0xE1, 0xE0, 0x77, 0x03, 0xC3, 0xC1, 0xCE, 0x07, 0x07, 0x83, 0x9C, 0x1E,
  0x0F, 0x0F, 0x38, 0x3C, 0x1E, 0x1C, 0x70, 0x70, 0x38, 0x38, 0xE1, 0xE0,
  0x70, 0xE1, 0xC3, 0x80, 0xE1, 0xC3, 0x8F, 0x01, 0xC7, 0x87, 0x1E, 0x03,
  0x8E, 0x0E, 0x38, 0x07, 0x1C, 0x1C, 0xF0, 0x0E, 0x70, 0x39, 0xC0, 0x1C,
  0xE0, 0x77, 0x80, 0x3B, 0xC0, 0xEF, 0x00, 0x77, 0x01, 0xDC, 0x00, 0xEE,
  0x03, 0xF8, 0x01, 0xF8, 0x07, 0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x07, 0xE0,
  0x1F, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x3C, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0x00, 0x3C, 0x07,
  0x80, 0x0E, 0x07, 0x80, 0x07, 0x03, 0xC0, 0x03, 0xC3, 0xC0, 0x01, 0xE1,
  0xC0, 0x00, 0xF1, 0xE0, 0x00, 0x39, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x1E, 0x70, 0x00, 0x1E, 0x38, 0x00,
  0x0F, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x07, 0x80, 0x07, 0x81, 0xC0,
  0x07, 0x80, 0xE0, 0x03, 0xC0, 0x78, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x1E,
  0x03, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0xFC, 0x01, 0xCF, 0x00, 0xF3, 0xC0,
  0x78, 0x70, 0x1E, 0x1C, 0x0F, 0x07, 0x03, 0xC1, 0xE1, 0xE0, 0x78, 0x70,
  0x1E, 0x3C, 0x07, 0x8E, 0x00, 0xE7, 0x80, 0x39, 0xC0, 0x0E, 0xF0, 0x03,
  0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0x03,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x1C, 0x00, 0x1E, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0xE1,
  0xC3, 0x87, 0x0E, 0x1C, 0x3C, 0x78, 0x70, 0xE1, 0xC3, 0x87, 0x0F, 0x1E,
  0x3C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x8F, 0x0E, 0x1C, 0x38, 0x70, 0xE1,
  0xC3, 0xC7, 0x87, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x00, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x07, 0xF8, 0x07, 0xFC, 0x03,
  0xFC, 0x00, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01,
  0xDC, 0x00, 0xF7, 0x00, 0x39, 0xC0, 0x1E, 0x38, 0x07, 0x0E, 0x03, 0x83,
  0xC0, 0xE0, 0x70, 0x70, 0x1C, 0x3C, 0x07, 0x8E, 0x00, 0xE7, 0x80, 0x39,
  0xC0, 0x0F, 0xF0, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF0,
  0xF1, 0xE1, 0xC3, 0xC3, 0x83, 0x80, 0x00, 0xF8, 0xE0, 0x7F, 0x9C, 0x1F,
  0xFB, 0x87, 0xC7, 0xF0, 0xF0, 0x7C, 0x3C, 0x07, 0x87, 0x80, 0xF1, 0xE0,
  0x1E, 0x3C, 0x03, 0xC7, 0x00, 0x71, 0xE0, 0x0E, 0x3C, 0x03, 0xC7, 0x80,
  0x78, 0xE0, 0x0E, 0x1C, 0x01, 0xC7, 0x80, 0x78, 0xF0, 0x0F, 0x1E, 0x03,
  0xE3, 0xC0, 0x78, 0x38, 0x1F, 0x07, 0x87, 0xE0, 0xFF, 0xDC, 0x0F, 0xF7,
  0x80, 0xFC, 0xE0, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0xF1, 0xE0, 0x1E, 0xFF, 0x03, 0xBF, 0xE0, 0x7E, 0x3E, 0x1F, 0x83,
  0xC3, 0xE0, 0x78, 0x78, 0x07, 0x0F, 0x00, 0xE1, 0xE0, 0x3C, 0x78, 0x07,
  0x8F, 0x00, 0xF1, 0xE0, 0x1E, 0x38, 0x03, 0xC7, 0x00, 0x71, 0xE0, 0x1E,
  0x3C, 0x03, 0xC7, 0x80, 0x70, 0xF0, 0x1E, 0x1E, 0x03, 0xC7, 0xC0, 0xF0,
  0xFC, 0x3C, 0x1D, 0xFF, 0x83, 0xBF, 0xE0, 0xE3, 0xF0, 0x00, 0x00, 0xFE,
  0x01, 0xFF, 0x07, 0xFE, 0x0F, 0x86, 0x0F, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00,
  0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x78, 0x10, 0x7F, 0xF0, 0x3F, 0xF0, 0x1F, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x07, 0xC7,
  0x00, 0xFF, 0x78, 0x0F, 0xFF, 0xC0, 0xF8, 0x7E, 0x07, 0x83, 0xE0, 0x78,
  0x0F, 0x03, 0xC0, 0x78, 0x3C, 0x03, 0xC1, 0xE0, 0x1C, 0x0E, 0x00, 0xE0,
  0xF0, 0x07, 0x07, 0x80, 0x78, 0x3C, 0x03, 0xC1, 0xC0, 0x1C, 0x0E, 0x00,
  0xE0, 0xF0, 0x0F, 0x07, 0x80, 0x78, 0x3C, 0x07, 0xC1, 0xE0, 0x3C, 0x0F,
  0x03, 0xE0, 0x3C, 0x3F, 0x01, 0xFF, 0xB8, 0x07, 0xFB, 0xC0, 0x1F, 0x9C,
  0x00, 0x00, 0xFC, 0x03, 0xFE, 0x07, 0xFF, 0x0F, 0x8F, 0x0F, 0x07, 0x1E,
  0x07, 0x1C, 0x07, 0x3C, 0x07, 0x38, 0x0F, 0x78, 0x1E, 0x78, 0xFC, 0x7F,
  0xF8, 0x7F, 0xE0, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x08, 0x7F, 0xF8, 0x3F, 0xF8, 0x1F,
  0xF0, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xF4,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0xC0, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x7C, 0x70, 0x1F, 0xE7, 0x03, 0xFF,
  0x70, 0x7C, 0x7F, 0x07, 0x83, 0xE0, 0xF0, 0x1E, 0x0F, 0x01, 0xE1, 0xE0,
  0x1E, 0x1E, 0x01, 0xE1, 0xC0, 0x1C, 0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x3C,
  0x03, 0xC3, 0x80, 0x38, 0x38, 0x07, 0x87, 0x80, 0x78, 0x78, 0x07, 0x87,
  0x80, 0xF8, 0x78, 0x0F, 0x07, 0x81, 0xF0, 0x3C, 0x3F, 0x03, 0xFF, 0xF0,
  0x1F, 0xEF, 0x00, 0xFC, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x80, 0x78, 0x0F, 0xFF,
  0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x04, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF1, 0xE0, 0x1E, 0xFF, 0x03,
  0xBF, 0xE0, 0x7E, 0x3E, 0x1F, 0x83, 0xC3, 0xE0, 0x78, 0x78, 0x0F, 0x0F,
  0x01, 0xC1, 0xC0, 0x38, 0x78, 0x0F, 0x0F, 0x01, 0xE1, 0xE0, 0x3C, 0x38,
  0x07, 0x07, 0x00, 0xE1, 0xE0, 0x3C, 0x3C, 0x07, 0x87, 0x80, 0xF0, 0xE0,
  0x1C, 0x1C, 0x03, 0x87, 0x80, 0xF0, 0xF0, 0x1E, 0x1C, 0x03, 0x83, 0x80,
  0x70, 0xF0, 0x1E, 0x00, 0x01, 0xE0, 0x3C, 0x0F, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x70, 0x0E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x38, 0x0F, 0x01,
  0xE0, 0x38, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x01, 0xFE,
  0x00, 0xFE, 0x00, 0x7E, 0x00, 0x18, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x3C, 0x1E, 0x07, 0x83, 0x81,
  0xE0, 0x70, 0x78, 0x0E, 0x1E, 0x03, 0xC7, 0x80, 0x79, 0xE0, 0x0E, 0x3C,
  0x01, 0xCF, 0x00, 0x7B, 0xC0, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xE0,
  0x07, 0xDC, 0x01, 0xF3, 0xC0, 0x3C, 0x78, 0x07, 0x0F, 0x00, 0xE0, 0xE0,
  0x1C, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x78, 0x1C, 0x07, 0x03, 0x80, 0xF0,
  0xF0, 0x1E, 0x00, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1C, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0x70, 0x0E, 0x03, 0xC0,
  0x78, 0x0E, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x38, 0x07, 0x01, 0xE0,
  0x3C, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0xF0,
  0x00, 0x07, 0x1F, 0x03, 0xE0, 0x39, 0xFC, 0x7F, 0x81, 0xDF, 0xF7, 0xFC,
  0x0F, 0xC7, 0xF1, 0xF0, 0xFC, 0x1F, 0x07, 0x87, 0xC0, 0xF0, 0x3C, 0x3C,
  0x07, 0x81, 0xE1, 0xE0, 0x38, 0x0F, 0x0E, 0x03, 0xC0, 0x70, 0xF0, 0x1E,
  0x03, 0x87, 0x80, 0xE0, 0x3C, 0x3C, 0x07, 0x01, 0xE1, 0xC0, 0x78, 0x0F,
  0x0E, 0x03, 0xC0, 0x70, 0xF0, 0x1E, 0x03, 0x87, 0x80, 0xE0, 0x3C, 0x3C,
  0x07, 0x01, 0xE1, 0xC0, 0x78, 0x0E, 0x0E, 0x03, 0xC0, 0x70, 0xF0, 0x1E,
  0x07, 0x87, 0x80, 0xE0, 0x3C, 0x38, 0x07, 0x01, 0xE1, 0xC0, 0x78, 0x0E,
  0x1E, 0x03, 0xC0, 0x70, 0x07, 0x1F, 0x80, 0xE7, 0xF8, 0x1D, 0xFF, 0x03,
  0xF1, 0xF0, 0xFC, 0x1E, 0x1F, 0x03, 0xC3, 0xC0, 0x78, 0x78, 0x0E, 0x0E,
  0x01, 0xC3, 0xC0, 0x78, 0x78, 0x0F, 0x0F, 0x01, 0xE1, 0xC0, 0x38, 0x38,
  0x07, 0x0F, 0x01, 0xE1, 0xE0, 0x3C, 0x3C, 0x07, 0x87, 0x00, 0xE1, 0xE0,
  0x1C, 0x3C, 0x07, 0x87, 0x80, 0xF0, 0xE0, 0x1E, 0x1C, 0x03, 0x87, 0x80,
  0xF0, 0x00, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x3E, 0x3E, 0x0F, 0x07,
  0x87, 0x80, 0xE1, 0xC0, 0x38, 0xF0, 0x0F, 0x38, 0x03, 0xDE, 0x00, 0xE7,
  0x80, 0x39, 0xE0, 0x0E, 0x70, 0x07, 0x9C, 0x01, 0xEF, 0x00, 0x7B, 0xC0,
  0x1C, 0xF0, 0x0F, 0x3C, 0x03, 0xC7, 0x01, 0xE1, 0xC0, 0x78, 0x78, 0x3C,
  0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0x80, 0x01, 0xC3, 0xC0, 0x0E, 0x7F,
  0x80, 0x77, 0xFC, 0x03, 0xF1, 0xF0, 0x3F, 0x07, 0x81, 0xF0, 0x3C, 0x0F,
  0x80, 0xE0, 0x78, 0x07, 0x03, 0xC0, 0x78, 0x3C, 0x03, 0xC1, 0xE0, 0x1E,
  0x0F, 0x00, 0xF0, 0x70, 0x07, 0x83, 0x80, 0x38, 0x3C, 0x03, 0xC1, 0xE0,
  0x1E, 0x0F, 0x00, 0xE0, 0x78, 0x0F, 0x03, 0xC0, 0x78, 0x3E, 0x07, 0x81,
  0xF8, 0x78, 0x0E, 0xFF, 0xC0, 0x77, 0xFC, 0x07, 0x9F, 0x80, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0xF8, 0xE0, 0x7F, 0x9C, 0x1F, 0xFB, 0x87, 0xC7, 0xF0, 0xF0,
  0x7C, 0x3C, 0x07, 0x87, 0x80, 0xF1, 0xE0, 0x1E, 0x3C, 0x03, 0xC7, 0x00,
  0x71, 0xE0, 0x1E, 0x3C, 0x03, 0xC7, 0x80, 0x78, 0xE0, 0x0E, 0x1C, 0x03,
  0xC7, 0x80, 0x78, 0xF0, 0x0F, 0x1E, 0x03, 0xE3, 0xC0, 0x78, 0x78, 0x1F,
  0x07, 0x87, 0xE0, 0xFF, 0xFC, 0x0F, 0xF7, 0x80, 0xFC, 0xE0, 0x00, 0x1C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x1F, 0x07, 0x3E, 0x07, 0x7E, 0x07, 0xFE, 0x0F, 0xC0, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0,
  0x00, 0x01, 0xF8, 0x07, 0xFF, 0x0F, 0xFE, 0x1F, 0x0E, 0x1E, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x70, 0x80, 0xF0, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF,
  0x80, 0x01, 0x80, 0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0xFF, 0x3F, 0xF7,
  0xFF, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0x80, 0x38, 0x07, 0x80, 0x78, 0x07, 0x80, 0x70, 0x07,
  0x00, 0xF0, 0x07, 0x00, 0x7F, 0x07, 0xF0, 0x3F, 0x00, 0x0F, 0x01, 0xE1,
  0xE0, 0x3C, 0x38, 0x07, 0x07, 0x00, 0xE1, 0xE0, 0x3C, 0x3C, 0x07, 0x87,
  0x80, 0xF0, 0xE0, 0x1C, 0x1C, 0x03, 0x87, 0x80, 0xF0, 0xF0, 0x1E, 0x1C,
  0x03, 0xC3, 0x80, 0x70, 0xF0, 0x1E, 0x1E, 0x03, 0xC3, 0xC0, 0x78, 0x70,
  0x0E, 0x0E, 0x03, 0xC1, 0xC0, 0xF8, 0x78, 0x1F, 0x07, 0x87, 0xE0, 0xFF,
  0xB8, 0x1F, 0xF7, 0x01, 0xF8, 0xE0, 0xF0, 0x07, 0xB8, 0x07, 0x9C, 0x03,
  0xCE, 0x01, 0xC7, 0x01, 0xE3, 0x80, 0xE1, 0xC0, 0xF0, 0xE0, 0x70, 0x70,
  0x78, 0x38, 0x38, 0x1C, 0x3C, 0x0E, 0x1E, 0x07, 0x0E, 0x03, 0x8F, 0x01,
  0xC7, 0x00, 0xE7, 0x80, 0x73, 0x80, 0x3B, 0xC0, 0x1D, 0xC0, 0x0E, 0xE0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xE0, 0x3C, 0x03,
  0xF0, 0x1E, 0x03, 0xF8, 0x0F, 0x01, 0xDC, 0x0F, 0x81, 0xEE, 0x07, 0xC0,
  0xF7, 0x07, 0x60, 0x73, 0x83, 0xF0, 0x79, 0xC3, 0xB8, 0x38, 0xE1, 0xDC,
  0x3C, 0x70, 0xEE, 0x1C, 0x38, 0xE7, 0x0E, 0x1C, 0x73, 0x8F, 0x0E, 0x71,
  0xC7, 0x07, 0x38, 0xE7, 0x83, 0x9C, 0x73, 0x81, 0xDC, 0x39, 0xC0, 0xEE,
  0x1D, 0xE0, 0x7E, 0x0E, 0xE0, 0x3F, 0x07, 0x70, 0x1F, 0x83, 0xF0, 0x0F,
  0x81, 0xF8, 0x07, 0xC0, 0xF8, 0x03, 0xC0, 0x7C, 0x01, 0xE0, 0x3E, 0x00,
  0x07, 0x80, 0xF0, 0x38, 0x0F, 0x03, 0xC1, 0xE0, 0x3C, 0x1C, 0x03, 0xC3,
  0xC0, 0x1C, 0x78, 0x01, 0xC7, 0x00, 0x1E, 0xF0, 0x00, 0xFE, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x3F, 0x80, 0x07, 0xBC, 0x00, 0x71, 0xC0, 0x0F, 0x1C, 0x01,
  0xE1, 0xE0, 0x3C, 0x1E, 0x03, 0xC0, 0xE0, 0x78, 0x0E, 0x0F, 0x00, 0xF0,
  0x01, 0xC0, 0x1E, 0x03, 0x80, 0x38, 0x07, 0x00, 0xF0, 0x0E, 0x01, 0xC0,
  0x1C, 0x07, 0x80, 0x38, 0x0F, 0x00, 0x70, 0x3C, 0x00, 0xE0, 0x78, 0x01,
  0xC1, 0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x87, 0x00, 0x0F, 0x1E, 0x00, 0x1E,
  0x38, 0x00, 0x3C, 0xF0, 0x00, 0x79, 0xC0, 0x00, 0x77, 0x80, 0x00, 0xEE,
  0x00, 0x01, 0xDC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x00,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x70, 0x00,
  0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0xFF,
  0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x7F, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07,
  0x80, 0x0F, 0x00, 0xFE, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3E, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x07, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x78,
  0x00, 0x3F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xE0, 0x01, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x3E, 0x00,
  0xFE, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0x3F, 0x00, 0x7F, 0xF8, 0x3F, 0xFF,
  0xFF, 0x03, 0xFE, 0x80, 0x3F, 0x00,
};

const GFXglyph NotoSans_Condensed_Italic44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 10, 31, 11, 1, -31 },
  { 40, 13, 11, 16, 4, -31 },
  { 58, 22, 31, 22, 0, -31 },
  { 144, 20, 36, 19, 0, -33 },
  { 234, 25, 32, 29, 3, -32 },
  { 334, 21, 32, 22, 0, -32 },
  { 418, 5, 11, 9, 5, -31 },
  { 425, 14, 39, 12, 1, -32 },
  { 494, 13, 39, 12, -3, -32 },
  { 558, 16, 17, 18, 4, -34 },
  { 592, 18, 21, 21, 2, -26 },
  { 640, 8, 11, 10, -2, -5 },
  { 651, 10, 4, 12, 1, -14 },
  { 656, 5, 5, 10, 1, -5 },
  { 660, 20, 32, 15, -2, -32 },
  { 740, 18, 32, 19, 1, -32 },
  { 812, 12, 31, 19, 5, -31 },
  { 859, 20, 32, 19, -1, -32 },
  { 939, 19, 32, 19, 0, -32 },
  { 1015, 19, 32, 19, 0, -32 },
  { 1091, 19, 31, 19, 0, -31 },
  { 1165, 18, 32, 19, 2, -32 },
  { 1237, 19, 31, 19, 2, -31 },
  { 1311, 20, 32, 19, 0, -32 },
  { 1391, 18, 32, 19, 1, -32 },
  { 1463, 9, 24, 10, 0, -24 },
  { 1490, 11, 30, 10, -2, -24 },
  { 1532, 18, 20, 21, 2, -26 },
  { 1577, 18, 13, 21, 2, -22 },
  { 1607, 18, 20, 21, 2, -26 },
  { 1652, 15, 32, 15, 1, -32 },
  { 1712, 28, 36, 29, 1, -32 },
  { 1838, 20, 32, 20, -3, -32 },
  { 1918, 20, 31, 21, 1, -31 },
  { 1996, 21, 32, 20, 2, -32 },
  { 2080, 21, 31, 23, 1, -31 },
  { 2162, 19, 31, 18, 1, -31 },
  { 2236, 19, 31, 17, 1, -31 },
  { 2310, 23, 32, 24, 2, -32 },
  { 2402, 24, 31, 24, 1, -31 },
  { 2495, 17, 31, 12, -2, -31 },
  { 2561, 18, 39, 10, -7, -31 },
  { 2649, 23, 31, 20, 1, -31 },
  { 2739, 13, 31, 17, 1, -31 },
  { 2790, 31, 31, 31, 1, -31 },
  { 2911, 25, 31, 25, 1, -31 },
  { 3008, 22, 32, 25, 2, -32 },
  { 3096, 19, 31, 20, 1, -31 },
  { 3170, 22, 39, 25, 2, -32 },
  { 3278, 20, 31, 20, 1, -31 },
  { 3356, 20, 32, 18, 0, -32 },
  { 3436, 17, 31, 17, 4, -31 },
  { 3502, 22, 31, 23, 2, -31 },
  { 3588, 19, 31, 20, 4, -31 },
  { 3662, 31, 31, 31, 4, -31 },
  { 3783, 25, 31, 18, -3, -31 },
  { 3880, 18, 31, 18, 4, -31 },
  { 3950, 21, 31, 17, -1, -31 },
  { 4032, 17, 39, 13, -1, -32 },
  { 4115, 7, 32, 15, 5, -32 },
  { 4143, 17, 39, 13, -3, -32 },
  { 4226, 18, 17, 20, 1, -31 },
  { 4265, 15, 3, 15, -4, 4 },
  { 4271, 7, 7, 11, 6, -34 },
  { 4278, 19, 24, 21, 1, -24 },
  { 4335, 19, 33, 21, 0, -33 },
  { 4414, 16, 24, 16, 1, -24 },
  { 4462, 21, 33, 21, 1, -33 },
  { 4549, 16, 24, 18, 1, -24 },
  { 4597, 22, 45, 11, -5, -34 },
  { 4721, 20, 35, 21, 0, -24 },
  { 4809, 19, 33, 20, 0, -33 },
  { 4888, 11, 32, 9, 0, -32 },
  { 4932, 17, 43, 9, -6, -32 },
  { 5024, 19, 33, 18, 0, -33 },
  { 5103, 11, 33, 9, 0, -33 },
  { 5149, 29, 24, 30, 0, -24 },
  { 5236, 19, 24, 20, 0, -24 },
  { 5293, 18, 24, 20, 1, -24 },
  { 5347, 21, 34, 21, -2, -24 },
  { 5437, 19, 35, 21, 1, -24 },
  { 5521, 16, 24, 14, 0, -24 },
  { 5569, 16, 24, 15, 0, -24 },
  { 5617, 12, 29, 12, 1, -29 },
  { 5661, 19, 24, 20, 1, -24 },
  { 5718, 17, 24, 17, 2, -24 },
  { 5769, 25, 24, 26, 3, -24 },
  { 5844, 20, 24, 17, -2, -24 },
  { 5904, 23, 35, 17, -4, -24 },
  { 6005, 16, 24, 15, -1, -24 },
  { 6053, 16, 38, 15, 1, -31 },
  { 6129, 3, 44, 19, 8, -34 },
  { 6146, 16, 38, 15, -2, -31 },
  { 6222, 18, 5, 21, 2, -18 },
};

const GFXfont NotoSans_Condensed_Italic44pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Italic44pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Italic44pt7bGlyphs,
  0x20, 0x7E, 60
};

#endif // _NOTOSANS_CONDENSED_ITALIC44PT7B_H_
