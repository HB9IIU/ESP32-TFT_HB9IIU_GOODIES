#ifndef _NOTOSANS_CONDENSED_ITALIC27PT7B_H_
#define _NOTOSANS_CONDENSED_ITALIC27PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Italic.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Italic27pt7bBitmaps[] PROGMEM = {
  0x00, 0x0E, 0x1C, 0x30, 0x61, 0xC3, 0x86, 0x0C, 0x18, 0x30, 0xC1, 0x83,
  0x06, 0x00, 0x00, 0x61, 0xC3, 0x80, 0x66, 0xCF, 0x1E, 0x6C, 0xD9, 0xA3,
  0x00, 0x03, 0x18, 0x0C, 0x40, 0x33, 0x00, 0x8C, 0x06, 0x30, 0xFF, 0xF3,
  0xFF, 0xC3, 0x18, 0x0C, 0x40, 0x23, 0x01, 0x8C, 0x3F, 0xFC, 0xFF, 0xF0,
  0x46, 0x03, 0x18, 0x0C, 0xC0, 0x23, 0x01, 0x8C, 0x06, 0x60, 0x00, 0x00,
  0x80, 0x08, 0x01, 0x80, 0x7F, 0x0F, 0xF1, 0x91, 0x19, 0x01, 0xB0, 0x1B,
  0x01, 0xE0, 0x0E, 0x00, 0x78, 0x07, 0xC0, 0x4C, 0x04, 0xC0, 0x4C, 0x0C,
  0xCE, 0xF8, 0xFF, 0x01, 0xC0, 0x08, 0x01, 0x80, 0x18, 0x00, 0x08, 0x04,
  0x78, 0x11, 0x98, 0x63, 0x31, 0x8C, 0x63, 0x18, 0xCC, 0x31, 0x10, 0x46,
  0x60, 0x8D, 0x9D, 0x1B, 0x7F, 0x6D, 0x9F, 0x9B, 0x32, 0x6C, 0x61, 0x98,
  0xC3, 0x31, 0x8C, 0x62, 0x18, 0xCC, 0x61, 0x98, 0x83, 0x63, 0x07, 0x80,
  0x01, 0x00, 0x3E, 0x03, 0xB8, 0x18, 0xC0, 0xC6, 0x06, 0x30, 0x33, 0x01,
  0xB8, 0x0F, 0x80, 0x78, 0x07, 0x80, 0x76, 0x37, 0x33, 0x31, 0xDB, 0x87,
  0x98, 0x3C, 0xC0, 0xC7, 0x1F, 0x1F, 0xD8, 0xFC, 0xE0, 0x6F, 0xED, 0xA0,
  0x07, 0x06, 0x0C, 0x18, 0x18, 0x30, 0x30, 0x60, 0x60, 0x60, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x60, 0x06,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x06, 0x06, 0x06, 0x0C, 0x0C, 0x18, 0x18, 0x30, 0x60, 0xE0, 0x08, 0x06,
  0x03, 0x19, 0x0F, 0xB8, 0xFC, 0xF0, 0xF8, 0xE6, 0x23, 0x00, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x3F, 0xF8, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x39, 0x9C, 0xC6, 0x63, 0x00, 0x7F, 0xF8, 0x7F,
  0x80, 0x00, 0x30, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18, 0x03, 0x80,
  0x30, 0x07, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x03,
  0x00, 0x60, 0x06, 0x00, 0xC0, 0x00, 0x03, 0x01, 0xF8, 0x7F, 0x0C, 0x73,
  0x8E, 0x60, 0xDC, 0x3B, 0x07, 0x60, 0xCC, 0x1B, 0x83, 0x60, 0x6C, 0x1D,
  0x83, 0x30, 0x66, 0x1C, 0xC3, 0x18, 0xE3, 0xF8, 0x3E, 0x00, 0x0E, 0x3C,
  0xFF, 0xE4, 0xC1, 0x83, 0x0E, 0x18, 0x30, 0x60, 0xC3, 0x86, 0x0C, 0x18,
  0x70, 0xE1, 0x80, 0x00, 0x80, 0x3F, 0x83, 0xDC, 0x08, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x30, 0x03, 0x00, 0x38,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x1F, 0xF1, 0xFF, 0x80,
  0x01, 0x00, 0xFE, 0x1E, 0xE1, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x0E,
  0x01, 0xC0, 0xF8, 0x1F, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x01, 0xC8, 0x38, 0xFF, 0x0F, 0xE0, 0x00, 0x70, 0x0E, 0x01, 0xE0, 0x16,
  0x03, 0x60, 0x6E, 0x06, 0xC0, 0xCC, 0x18, 0xC3, 0x0C, 0x31, 0x86, 0x18,
  0xC1, 0x8F, 0xFE, 0xFF, 0xE0, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00, 0x0F,
  0xF0, 0xFF, 0x0C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x03, 0xF0, 0x3F,
  0x80, 0x1C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x1C, 0x83,
  0x8F, 0xF0, 0xFE, 0x00, 0x00, 0x40, 0x7C, 0x3C, 0x8E, 0x01, 0x80, 0x60,
  0x0C, 0x03, 0x00, 0x6F, 0x0F, 0xF3, 0xC7, 0x70, 0x6E, 0x0D, 0x83, 0xB0,
  0x76, 0x0C, 0xC1, 0x9C, 0x61, 0xFC, 0x1F, 0x00, 0x3F, 0xF3, 0xFE, 0x00,
  0x60, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60, 0x06,
  0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x00, 0x70, 0x06, 0x00, 0xE0,
  0x00, 0x01, 0x00, 0x7E, 0x0E, 0x71, 0xC3, 0x18, 0x31, 0x83, 0x18, 0x71,
  0xC6, 0x0D, 0xC0, 0x78, 0x1F, 0x83, 0x98, 0x71, 0xC6, 0x0C, 0xE0, 0xCE,
  0x0C, 0xE0, 0xCE, 0x1C, 0x7F, 0x83, 0xF0, 0x01, 0x00, 0x7C, 0x0E, 0xE1,
  0x86, 0x38, 0x63, 0x07, 0x30, 0x73, 0x06, 0x30, 0x63, 0x0E, 0x39, 0xE3,
  0xF6, 0x0E, 0xE0, 0x0C, 0x00, 0xC0, 0x18, 0x03, 0x80, 0x70, 0xFE, 0x0F,
  0xC0, 0x08, 0x71, 0x86, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x63, 0x8E,
  0x00, 0x04, 0x1C, 0x38, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x86, 0x1C, 0x30, 0x61, 0x82, 0x00, 0x00, 0x20, 0x0C, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x30, 0x02,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x80, 0x1C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x38, 0x1E, 0x0F, 0x07, 0x83,
  0xC0, 0x60, 0x08, 0x00, 0x04, 0x3F, 0x8C, 0xE0, 0x30, 0x18, 0x0C, 0x0C,
  0x0E, 0x06, 0x06, 0x06, 0x06, 0x03, 0x03, 0x01, 0x80, 0x00, 0x00, 0x70,
  0x38, 0x18, 0x00, 0x01, 0xFC, 0x03, 0x87, 0x03, 0x00, 0xC3, 0x00, 0x61,
  0x80, 0x31, 0x87, 0xC9, 0x8E, 0xC6, 0xC6, 0x62, 0x46, 0x31, 0x63, 0x19,
  0xB3, 0x18, 0xD9, 0x8C, 0x6C, 0xC6, 0x26, 0x67, 0x33, 0x3F, 0xF1, 0x8E,
  0x70, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0x0C, 0x01, 0xFC, 0x00,
  0x00, 0x70, 0x07, 0x80, 0x3C, 0x03, 0x60, 0x1B, 0x01, 0xD8, 0x0C, 0xC0,
  0x66, 0x06, 0x30, 0x31, 0x83, 0x0C, 0x1F, 0xE1, 0xFF, 0x0C, 0x18, 0xE0,
  0xC6, 0x06, 0x70, 0x33, 0x01, 0xF8, 0x0E, 0x0F, 0xE0, 0x7F, 0x83, 0x0E,
  0x18, 0x31, 0xC1, 0x8C, 0x1C, 0x60, 0xC3, 0x0E, 0x1F, 0xC1, 0xFE, 0x0C,
  0x38, 0x60, 0xC3, 0x07, 0x38, 0x39, 0xC1, 0x8C, 0x1C, 0x61, 0xC3, 0xFE,
  0x3F, 0xC0, 0x00, 0x40, 0x1F, 0xC3, 0xFC, 0x38, 0x01, 0x80, 0x1C, 0x00,
  0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x1F, 0xE0, 0x3F, 0x00, 0x0F,
  0xE0, 0x3F, 0xC0, 0xC3, 0x83, 0x06, 0x1C, 0x1C, 0x60, 0x71, 0x81, 0xC6,
  0x07, 0x18, 0x18, 0xE0, 0x63, 0x01, 0x8C, 0x0E, 0x30, 0x31, 0xC0, 0xC7,
  0x07, 0x18, 0x38, 0x63, 0xC1, 0xFE, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0xFF,
  0x0C, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x1F, 0xC3, 0xFC,
  0x30, 0x03, 0x00, 0x30, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x07, 0xF8,
  0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x03, 0xFC, 0x3F, 0xC3, 0x00, 0x30, 0x07, 0x00, 0x70,
  0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x00, 0x00, 0x40, 0x0F, 0xF0, 0xFB,
  0xC7, 0x81, 0x1C, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x0F, 0xB8, 0x7C, 0xE0, 0x33, 0x80, 0xCE, 0x07, 0x38, 0x1C, 0x60,
  0x61, 0xC1, 0x83, 0xFE, 0x07, 0xF0, 0x0E, 0x06, 0x18, 0x1C, 0x30, 0x38,
  0x60, 0x61, 0xC0, 0xC3, 0x01, 0x86, 0x07, 0x0C, 0x0C, 0x1F, 0xF8, 0x7F,
  0xF0, 0xC0, 0x61, 0x81, 0xC3, 0x03, 0x0E, 0x06, 0x1C, 0x0C, 0x30, 0x38,
  0x60, 0x70, 0xC0, 0xC3, 0x81, 0x80, 0x0F, 0xC0, 0xC0, 0x70, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x38, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x1C, 0x06, 0x01,
  0x80, 0x60, 0x38, 0x1E, 0x8F, 0xC0, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60,
  0x1C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x38,
  0x3E, 0x07, 0x80, 0x0E, 0x1C, 0x30, 0x60, 0xC3, 0x03, 0x1C, 0x1C, 0xE0,
  0x67, 0x01, 0x98, 0x06, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xB0, 0x0C, 0xE0,
  0x33, 0x81, 0xC6, 0x07, 0x18, 0x18, 0x70, 0x60, 0xC1, 0x83, 0x0E, 0x0E,
  0x00, 0x0E, 0x06, 0x03, 0x01, 0x81, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x1C,
  0x0C, 0x06, 0x03, 0x03, 0x81, 0xC0, 0xC0, 0x60, 0x3F, 0xFF, 0xC0, 0x0F,
  0x00, 0xE1, 0xE0, 0x3C, 0x3C, 0x07, 0x87, 0x81, 0xB1, 0xB0, 0x3C, 0x36,
  0x0D, 0x86, 0xC1, 0xB0, 0xD8, 0x66, 0x1B, 0x0D, 0xC6, 0x63, 0xB0, 0xCC,
  0x66, 0x19, 0x9C, 0xC3, 0x33, 0x18, 0xE6, 0xE7, 0x18, 0xD8, 0xC3, 0x0F,
  0x18, 0x61, 0xC3, 0x0C, 0x38, 0xE3, 0x86, 0x1C, 0x00, 0x0E, 0x03, 0x0E,
  0x07, 0x0F, 0x06, 0x0F, 0x06, 0x1B, 0x06, 0x1B, 0x06, 0x1B, 0x8C, 0x19,
  0x8C, 0x19, 0x8C, 0x31, 0x8C, 0x31, 0x9C, 0x30, 0xD8, 0x30, 0xD8, 0x70,
  0xD8, 0x60, 0xD8, 0x60, 0xF8, 0x60, 0x70, 0x60, 0x70, 0xE0, 0x70, 0x00,
  0x80, 0x1F, 0xC0, 0xF7, 0x87, 0x06, 0x18, 0x18, 0xE0, 0x73, 0x01, 0xDC,
  0x07, 0x60, 0x1D, 0x80, 0x66, 0x01, 0xB8, 0x06, 0xE0, 0x3B, 0x80, 0xEE,
  0x03, 0x38, 0x1C, 0xE0, 0xE1, 0xC3, 0x07, 0xFC, 0x0F, 0xC0, 0x0F, 0xE0,
  0x7F, 0x83, 0x0C, 0x18, 0x71, 0xC3, 0x8C, 0x18, 0x60, 0xC3, 0x0E, 0x18,
  0x61, 0xFF, 0x0F, 0xE0, 0x60, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x38, 0x00, 0x00, 0x80, 0x1F, 0xC0, 0xF7, 0x87, 0x06,
  0x18, 0x18, 0xE0, 0x73, 0x01, 0xDC, 0x07, 0x60, 0x1D, 0x80, 0x66, 0x01,
  0xB8, 0x06, 0xE0, 0x3B, 0x80, 0xEE, 0x03, 0x38, 0x1C, 0xE0, 0x61, 0xC3,
  0x07, 0xFC, 0x0F, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x01,
  0xC0, 0x0F, 0xE0, 0x7F, 0x83, 0x0C, 0x18, 0x71, 0xC3, 0x8C, 0x1C, 0x60,
  0xC3, 0x0E, 0x18, 0xE1, 0xFE, 0x0F, 0xC0, 0x67, 0x03, 0x18, 0x38, 0xC1,
  0xC6, 0x0C, 0x38, 0x60, 0xC3, 0x06, 0x38, 0x38, 0x00, 0x80, 0xFF, 0x1F,
  0xE1, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0x80, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x88, 0x38, 0xFF,
  0x0F, 0xE0, 0xFF, 0xFF, 0xF8, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x06, 0x00,
  0xC0, 0x18, 0x07, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x00,
  0x60, 0x0C, 0x03, 0x80, 0x00, 0x18, 0x0C, 0x60, 0x71, 0x81, 0x8E, 0x06,
  0x30, 0x18, 0xC0, 0xE3, 0x03, 0x8C, 0x0C, 0x70, 0x31, 0x80, 0xC6, 0x07,
  0x18, 0x18, 0x60, 0x63, 0x81, 0x8E, 0x0E, 0x38, 0x30, 0xE1, 0xC1, 0xFE,
  0x03, 0xF0, 0x00, 0xE0, 0x3E, 0x07, 0xE0, 0x66, 0x0E, 0x60, 0xC6, 0x1C,
  0x61, 0x86, 0x18, 0x63, 0x06, 0x30, 0x66, 0x06, 0x60, 0x6E, 0x06, 0xC0,
  0x7C, 0x07, 0x80, 0x78, 0x07, 0x00, 0x70, 0x00, 0xE0, 0x60, 0x7C, 0x1C,
  0x1F, 0x83, 0x83, 0x70, 0xF0, 0x6E, 0x1E, 0x1D, 0xC2, 0xC3, 0x38, 0xD8,
  0xE7, 0x1B, 0x18, 0xE6, 0x63, 0x1C, 0xCC, 0xC3, 0xB1, 0x98, 0x76, 0x37,
  0x0E, 0xC6, 0xC1, 0xF0, 0xD8, 0x36, 0x1E, 0x06, 0x83, 0xC0, 0xF0, 0x78,
  0x1E, 0x0E, 0x03, 0x81, 0xC0, 0x00, 0x06, 0x0E, 0x0E, 0x18, 0x0C, 0x70,
  0x18, 0xC0, 0x33, 0x00, 0x6E, 0x00, 0xF8, 0x00, 0xE0, 0x01, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x36, 0x00, 0x6C, 0x01, 0x98, 0x07, 0x38, 0x0C, 0x70,
  0x30, 0x60, 0xE0, 0xC3, 0x81, 0x80, 0xE0, 0xEC, 0x19, 0x87, 0x30, 0xC6,
  0x38, 0xC6, 0x1D, 0x81, 0xB0, 0x3C, 0x07, 0x80, 0xE0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x00, 0x0F, 0xF8, 0x7F,
  0xC0, 0x0C, 0x00, 0xE0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x30, 0x03, 0x00,
  0x38, 0x01, 0x80, 0x1C, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x60,
  0x07, 0xFE, 0x3F, 0xE0, 0x07, 0xE0, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x70, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x3F, 0x00,
  0xCC, 0xCC, 0xC6, 0x66, 0x66, 0x66, 0x63, 0x33, 0x33, 0x30, 0x07, 0xC0,
  0x30, 0x0C, 0x07, 0x01, 0x80, 0x60, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x01, 0x80, 0x60, 0x18, 0x06, 0x03, 0x80, 0xC0, 0x30, 0x0C,
  0x03, 0x0F, 0x80, 0x06, 0x00, 0xE0, 0x3C, 0x0D, 0x81, 0x98, 0x63, 0x0C,
  0x63, 0x06, 0x60, 0xD8, 0x1B, 0x01, 0x80, 0xFF, 0xFF, 0xC0, 0xCE, 0x62,
  0x30, 0x06, 0x03, 0xEC, 0xE7, 0x98, 0x77, 0x0E, 0xC1, 0xB8, 0x37, 0x06,
  0xC0, 0xD8, 0x3B, 0x06, 0x61, 0xCC, 0x39, 0xFB, 0x1E, 0x40, 0x06, 0x00,
  0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x18, 0x81, 0xBE, 0x1E, 0x61,
  0xC7, 0x38, 0x33, 0x87, 0x30, 0x73, 0x06, 0x30, 0x67, 0x06, 0x60, 0xE6,
  0x0C, 0x71, 0xC5, 0xF8, 0xCF, 0x00, 0x07, 0x0F, 0xCE, 0x26, 0x06, 0x03,
  0x03, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0E, 0x03, 0xF1, 0xF8, 0x00,
  0x38, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x38, 0x19, 0x83, 0xEC,
  0x39, 0xE1, 0x87, 0x1C, 0x38, 0xC1, 0x8E, 0x0C, 0x70, 0x63, 0x07, 0x18,
  0x30, 0xC1, 0x86, 0x1C, 0x30, 0xE1, 0xFB, 0x07, 0x90, 0x00, 0x07, 0x07,
  0xE3, 0x9C, 0xC3, 0x61, 0xD8, 0x6E, 0x7B, 0xF8, 0xE0, 0x30, 0x0C, 0x03,
  0x00, 0xE0, 0x1F, 0xC7, 0xE0, 0x00, 0x30, 0x07, 0xC0, 0x32, 0x03, 0x80,
  0x18, 0x00, 0xC0, 0x0E, 0x01, 0xFC, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x18, 0x07, 0x80, 0x3C,
  0x00, 0x03, 0x00, 0xFB, 0x1C, 0xF1, 0x87, 0x38, 0x73, 0x06, 0x70, 0x67,
  0x06, 0x60, 0xE6, 0x0E, 0x60, 0xC6, 0x1C, 0x63, 0xC7, 0xEC, 0x3D, 0x80,
  0x18, 0x01, 0x80, 0x38, 0x03, 0x0C, 0xF0, 0xFE, 0x00, 0x06, 0x01, 0xC0,
  0x30, 0x06, 0x00, 0xC0, 0x38, 0x06, 0x70, 0xDF, 0x1E, 0x63, 0x8C, 0xE1,
  0x9C, 0x33, 0x06, 0x60, 0xCC, 0x3B, 0x86, 0x60, 0xCC, 0x19, 0x83, 0x30,
  0xEE, 0x18, 0x0C, 0x1C, 0x30, 0x00, 0x00, 0x06, 0x0C, 0x18, 0x70, 0xC1,
  0x83, 0x06, 0x1C, 0x30, 0x60, 0xC1, 0x86, 0x00, 0x01, 0x80, 0x70, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x0C, 0x03, 0x01, 0xC0, 0x60, 0x18, 0x06,
  0x01, 0x80, 0xE0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x70, 0x18, 0x06, 0x01,
  0x80, 0xE0, 0xF0, 0x38, 0x00, 0x06, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x18, 0x11, 0x86, 0x18, 0xC1, 0x98, 0x3B, 0x83, 0x70, 0x36,
  0x03, 0xE0, 0x3F, 0x07, 0x30, 0x63, 0x06, 0x30, 0x63, 0x86, 0x18, 0xE1,
  0x80, 0x06, 0x1C, 0x30, 0x60, 0xC1, 0x86, 0x0C, 0x18, 0x30, 0xE1, 0x83,
  0x06, 0x0C, 0x38, 0x60, 0xC1, 0x83, 0x0E, 0x00, 0x01, 0xC3, 0x06, 0xFB,
  0xE1, 0xE7, 0x9C, 0x71, 0xC7, 0x38, 0x61, 0xCE, 0x18, 0x63, 0x06, 0x18,
  0xC3, 0x86, 0x30, 0xC1, 0x9C, 0x30, 0xE6, 0x0C, 0x31, 0x83, 0x0C, 0x61,
  0x83, 0x18, 0x60, 0xCE, 0x18, 0x70, 0x19, 0xC1, 0xBE, 0x1E, 0x61, 0xC7,
  0x38, 0x63, 0x86, 0x30, 0x63, 0x06, 0x30, 0xE7, 0x0C, 0x60, 0xC6, 0x0C,
  0x61, 0xCE, 0x1C, 0xE1, 0x80, 0x07, 0x07, 0xE3, 0x9C, 0xC3, 0x60, 0xD8,
  0x3E, 0x0F, 0x03, 0xC0, 0xF0, 0x7C, 0x1B, 0x06, 0xC3, 0x1F, 0xC7, 0xC0,
  0x00, 0x40, 0x6F, 0x83, 0xCC, 0x1C, 0x71, 0xC1, 0x8E, 0x0C, 0x60, 0xE3,
  0x07, 0x18, 0x31, 0xC1, 0x8E, 0x1C, 0x60, 0xC3, 0x8E, 0x1F, 0xE1, 0xDE,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x06,
  0x03, 0xEC, 0xE7, 0x98, 0x77, 0x0E, 0xC1, 0xB8, 0x36, 0x06, 0xC1, 0xD8,
  0x3B, 0x06, 0x61, 0xCC, 0x79, 0xFB, 0x1E, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x1C, 0x03, 0x00, 0x60, 0x01, 0xC6, 0xE1, 0xF8, 0x70, 0x38, 0x0E, 0x03,
  0x00, 0xC0, 0x30, 0x1C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0E, 0x00, 0x0F,
  0x07, 0xF3, 0x88, 0xC0, 0x30, 0x0C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x30, 0x0C, 0x87, 0x3F, 0x8F, 0xC0, 0x08, 0x30, 0x61, 0xCF, 0xE6, 0x0C,
  0x38, 0x60, 0xC1, 0x83, 0x0E, 0x18, 0x30, 0x60, 0xF1, 0xE0, 0x30, 0x66,
  0x0C, 0xC3, 0xB8, 0x66, 0x0C, 0xC1, 0x98, 0x37, 0x0C, 0xC1, 0x98, 0x33,
  0x0E, 0x63, 0xCF, 0xF0, 0xF6, 0x00, 0xC1, 0xE1, 0xF0, 0xD8, 0xEC, 0x66,
  0x73, 0x31, 0x98, 0xD8, 0x6C, 0x3C, 0x1E, 0x0E, 0x07, 0x00, 0xC3, 0x87,
  0x8F, 0x1F, 0x1E, 0x36, 0x2C, 0xEC, 0xD9, 0x99, 0xB3, 0x36, 0x6C, 0x6C,
  0xD8, 0xD1, 0xB1, 0xE3, 0xC3, 0xC7, 0x87, 0x0E, 0x0E, 0x1C, 0x18, 0x30,
  0x00, 0x1C, 0x70, 0xC6, 0x0C, 0xC0, 0xDC, 0x0F, 0x80, 0x70, 0x07, 0x00,
  0xF0, 0x0F, 0x01, 0xB0, 0x3B, 0x83, 0x18, 0x61, 0x8E, 0x1C, 0x06, 0x0E,
  0x0C, 0x38, 0x18, 0x60, 0x31, 0xC0, 0x63, 0x00, 0xC6, 0x01, 0x98, 0x03,
  0x30, 0x06, 0xC0, 0x0D, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x02, 0xE0, 0x03, 0xC0, 0x0A,
  0x00, 0x00, 0x1F, 0xC0, 0x30, 0x18, 0x0E, 0x03, 0x01, 0x80, 0xE0, 0x30,
  0x18, 0x0E, 0x03, 0x01, 0x80, 0x7F, 0x3F, 0xC0, 0x03, 0xC1, 0xE0, 0x60,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x70, 0x18, 0x06, 0x0F, 0x03, 0x00, 0xF0,
  0x0C, 0x03, 0x00, 0xC0, 0x70, 0x18, 0x06, 0x01, 0x80, 0x60, 0x1E, 0x03,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x07, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x1C, 0x0C, 0x06, 0x03, 0x01, 0xE0, 0x30, 0x78, 0x60,
  0x30, 0x38, 0x18, 0x0C, 0x06, 0x03, 0x03, 0x07, 0x83, 0x80, 0x7C, 0x3F,
  0xFE, 0x0F, 0x00,
};

const GFXglyph NotoSans_Condensed_Italic27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 7, 19, 7, 0, -19 },
  { 18, 7, 7, 10, 3, -19 },
  { 25, 14, 19, 13, 0, -19 },
  { 59, 12, 23, 12, 0, -21 },
  { 94, 15, 20, 18, 2, -20 },
  { 132, 13, 20, 14, 0, -20 },
  { 165, 3, 7, 5, 3, -19 },
  { 168, 8, 23, 7, 1, -19 },
  { 191, 8, 23, 7, -2, -19 },
  { 214, 9, 10, 11, 3, -21 },
  { 226, 11, 13, 13, 1, -16 },
  { 244, 5, 7, 6, -1, -3 },
  { 249, 7, 2, 7, 0, -8 },
  { 251, 3, 3, 6, 0, -3 },
  { 253, 12, 19, 9, -1, -19 },
  { 282, 11, 20, 12, 1, -20 },
  { 310, 7, 19, 12, 3, -19 },
  { 327, 13, 20, 12, -1, -20 },
  { 360, 12, 20, 12, 0, -20 },
  { 390, 12, 19, 12, 0, -19 },
  { 419, 12, 19, 12, 0, -19 },
  { 448, 11, 20, 12, 1, -20 },
  { 476, 12, 19, 12, 1, -19 },
  { 505, 12, 20, 12, 0, -20 },
  { 535, 12, 20, 12, 0, -20 },
  { 565, 6, 15, 6, 0, -15 },
  { 577, 7, 19, 6, -1, -15 },
  { 594, 11, 13, 13, 1, -16 },
  { 612, 11, 7, 13, 1, -13 },
  { 622, 11, 13, 13, 1, -16 },
  { 640, 9, 20, 9, 1, -20 },
  { 663, 17, 21, 18, 1, -19 },
  { 708, 13, 19, 12, -2, -19 },
  { 739, 13, 19, 13, 0, -19 },
  { 770, 13, 20, 12, 1, -20 },
  { 803, 14, 19, 14, 0, -19 },
  { 837, 12, 19, 11, 0, -19 },
  { 866, 12, 19, 10, 0, -19 },
  { 895, 14, 20, 15, 1, -20 },
  { 930, 15, 19, 15, 0, -19 },
  { 966, 10, 19, 8, -1, -19 },
  { 990, 11, 24, 6, -4, -19 },
  { 1023, 14, 19, 12, 0, -19 },
  { 1057, 9, 19, 10, 0, -19 },
  { 1079, 19, 19, 19, 0, -19 },
  { 1125, 16, 19, 15, 0, -19 },
  { 1163, 14, 20, 15, 1, -20 },
  { 1198, 13, 19, 12, 0, -19 },
  { 1229, 14, 25, 15, 1, -20 },
  { 1273, 13, 19, 13, 0, -19 },
  { 1304, 12, 20, 11, 0, -20 },
  { 1334, 11, 19, 11, 2, -19 },
  { 1361, 14, 19, 14, 1, -19 },
  { 1395, 12, 19, 12, 2, -19 },
  { 1424, 19, 19, 19, 2, -19 },
  { 1470, 15, 19, 11, -2, -19 },
  { 1506, 11, 19, 11, 2, -19 },
  { 1533, 13, 19, 11, -1, -19 },
  { 1564, 11, 23, 8, -1, -19 },
  { 1596, 4, 19, 9, 3, -19 },
  { 1606, 10, 23, 8, -2, -19 },
  { 1635, 11, 11, 12, 1, -19 },
  { 1651, 9, 2, 9, -2, 2 },
  { 1654, 4, 5, 7, 4, -21 },
  { 1657, 11, 15, 13, 1, -15 },
  { 1678, 12, 21, 13, 0, -21 },
  { 1710, 9, 15, 10, 1, -15 },
  { 1727, 13, 21, 13, 1, -21 },
  { 1762, 10, 15, 11, 1, -15 },
  { 1781, 13, 27, 7, -3, -21 },
  { 1825, 12, 21, 13, 0, -15 },
  { 1857, 11, 21, 12, 0, -21 },
  { 1886, 7, 20, 6, 0, -20 },
  { 1904, 10, 26, 6, -3, -20 },
  { 1937, 12, 21, 11, 0, -21 },
  { 1969, 7, 21, 6, 0, -21 },
  { 1988, 18, 15, 19, 0, -15 },
  { 2022, 12, 15, 12, 0, -15 },
  { 2045, 10, 15, 12, 1, -15 },
  { 2064, 13, 21, 13, -1, -15 },
  { 2099, 11, 21, 13, 1, -15 },
  { 2128, 10, 15, 8, 0, -15 },
  { 2147, 10, 15, 9, 0, -15 },
  { 2166, 7, 18, 7, 1, -18 },
  { 2182, 11, 14, 13, 1, -14 },
  { 2202, 9, 14, 10, 2, -14 },
  { 2218, 15, 14, 16, 2, -14 },
  { 2245, 12, 14, 10, -1, -14 },
  { 2266, 15, 21, 10, -3, -14 },
  { 2306, 10, 14, 9, -1, -14 },
  { 2324, 10, 23, 9, 1, -19 },
  { 2353, 2, 27, 11, 5, -21 },
  { 2360, 9, 23, 9, -1, -19 },
  { 2386, 11, 3, 13, 1, -11 },
};

const GFXfont NotoSans_Condensed_Italic27pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Italic27pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Italic27pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _NOTOSANS_CONDENSED_ITALIC27PT7B_H_
