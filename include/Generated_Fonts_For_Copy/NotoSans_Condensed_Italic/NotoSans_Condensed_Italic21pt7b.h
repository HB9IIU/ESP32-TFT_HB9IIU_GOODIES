#ifndef _NOTOSANS_CONDENSED_ITALIC21PT7B_H_
#define _NOTOSANS_CONDENSED_ITALIC21PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Italic.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Italic21pt7bBitmaps[] PROGMEM = {
  0x00, 0x18, 0xC6, 0x31, 0x18, 0xC6, 0x21, 0x18, 0x00, 0x73, 0x00, 0x6D,
  0x34, 0xB2, 0xD8, 0x06, 0x40, 0x98, 0x32, 0x06, 0x43, 0xFE, 0x7F, 0xC6,
  0x40, 0x88, 0x13, 0x1F, 0xF0, 0x88, 0x13, 0x06, 0x40, 0x88, 0x13, 0x00,
  0x02, 0x01, 0x03, 0xE3, 0x93, 0x41, 0xA0, 0xD0, 0x38, 0x0E, 0x07, 0x02,
  0xC1, 0x61, 0x37, 0xF1, 0xF0, 0x20, 0x30, 0x00, 0x38, 0x26, 0xC4, 0x4C,
  0xC4, 0xC8, 0xCD, 0x8C, 0x90, 0xCA, 0x7D, 0xE9, 0x75, 0x90, 0xD1, 0x09,
  0x11, 0x93, 0x11, 0x22, 0x16, 0x61, 0xC0, 0x0F, 0x06, 0x61, 0x98, 0x64,
  0x1B, 0x07, 0x81, 0xC0, 0x70, 0x6C, 0xD9, 0xBC, 0x7B, 0x0C, 0xC3, 0x3B,
  0xC7, 0x98, 0x69, 0x6C, 0x0C, 0x61, 0x0C, 0x61, 0x84, 0x30, 0xC2, 0x08,
  0x20, 0x82, 0x08, 0x20, 0xC3, 0x00, 0x0C, 0x08, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x10, 0x60, 0xC3, 0x06, 0x18, 0x21, 0xC0, 0x18, 0x33,
  0x63, 0xF3, 0x8D, 0x33, 0x04, 0x18, 0x18, 0x18, 0x18, 0xFF, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x36, 0x64, 0xC0, 0xF8, 0xF8, 0x00, 0xC0, 0x60, 0x10,
  0x0C, 0x02, 0x01, 0x80, 0x40, 0x30, 0x08, 0x06, 0x03, 0x00, 0xC0, 0x60,
  0x10, 0x0C, 0x00, 0x1E, 0x3B, 0x33, 0x63, 0x63, 0x43, 0xC3, 0xC3, 0xC3,
  0x82, 0x86, 0x86, 0x8C, 0xD8, 0x70, 0x0C, 0x77, 0xB2, 0x18, 0x61, 0x84,
  0x30, 0xC3, 0x0C, 0x21, 0x86, 0x00, 0x1F, 0x1D, 0xC0, 0x60, 0x30, 0x18,
  0x08, 0x0C, 0x0C, 0x0C, 0x06, 0x06, 0x06, 0x06, 0x07, 0xF3, 0xF8, 0x1F,
  0x18, 0xC0, 0x60, 0x30, 0x18, 0x18, 0x38, 0x38, 0x06, 0x01, 0x80, 0xC0,
  0x60, 0x64, 0x73, 0xF0, 0x01, 0x81, 0xC1, 0xE0, 0xA0, 0xD0, 0xD8, 0x4C,
  0x66, 0x62, 0x23, 0x3F, 0xFF, 0xE0, 0x40, 0x20, 0x30, 0x1F, 0x8F, 0xC4,
  0x02, 0x03, 0x01, 0x80, 0xF8, 0x4E, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x64,
  0x73, 0xF0, 0x0F, 0x8E, 0x4C, 0x04, 0x06, 0x02, 0x03, 0x79, 0xCC, 0xC2,
  0x61, 0x20, 0x90, 0xCC, 0x66, 0x61, 0xE0, 0x7F, 0xBF, 0xC0, 0xC0, 0x60,
  0x60, 0x30, 0x30, 0x18, 0x18, 0x0C, 0x0C, 0x06, 0x06, 0x03, 0x03, 0x00,
  0x0F, 0x0C, 0xCC, 0x26, 0x13, 0x18, 0x98, 0x78, 0x3C, 0x36, 0x31, 0xB0,
  0xD8, 0x6C, 0x33, 0x31, 0xF0, 0x0F, 0x0D, 0xCC, 0x64, 0x32, 0x1B, 0x0D,
  0x86, 0x67, 0x3D, 0x01, 0x80, 0xC0, 0x40, 0x64, 0xE3, 0xE0, 0x33, 0x00,
  0x00, 0x00, 0x0E, 0xC0, 0x18, 0xC0, 0x00, 0x00, 0x00, 0x01, 0x98, 0xCC,
  0x40, 0x01, 0x07, 0x1C, 0x70, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0xF0, 0x38, 0x0E, 0x03, 0x07, 0x3C, 0xF0,
  0xC0, 0x7C, 0xDC, 0x18, 0x30, 0x41, 0x86, 0x18, 0x60, 0x81, 0x00, 0x00,
  0x18, 0x30, 0x00, 0x07, 0xC0, 0x61, 0x84, 0x04, 0x40, 0x26, 0x3D, 0xA2,
  0x4F, 0x22, 0x79, 0x32, 0x99, 0x94, 0x88, 0xA4, 0xC9, 0x3F, 0xC8, 0xC8,
  0x40, 0x03, 0x00, 0x0E, 0x60, 0x1E, 0x00, 0x03, 0x81, 0xC1, 0xE0, 0xB0,
  0xD8, 0x6C, 0x26, 0x33, 0x11, 0x9F, 0xCC, 0x6C, 0x36, 0x1E, 0x0F, 0x06,
  0x1F, 0x87, 0xF1, 0x8C, 0x43, 0x30, 0xCC, 0x23, 0xF8, 0xFC, 0x21, 0x98,
  0x66, 0x19, 0x86, 0x63, 0x1F, 0xCF, 0xC0, 0x0F, 0xC7, 0x23, 0x00, 0xC0,
  0x60, 0x18, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x19,
  0x83, 0xE0, 0x1F, 0x83, 0xF8, 0x63, 0x08, 0x33, 0x06, 0x60, 0xCC, 0x19,
  0x82, 0x20, 0xCC, 0x19, 0x82, 0x30, 0xC6, 0x30, 0xFC, 0x3F, 0x00, 0x1F,
  0xC7, 0xE1, 0x80, 0x40, 0x30, 0x0C, 0x03, 0xF0, 0xFC, 0x20, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x1F, 0x8F, 0xC0, 0x1F, 0xC7, 0xE1, 0x80, 0x40, 0x30,
  0x0C, 0x03, 0x00, 0xFC, 0x3E, 0x18, 0x06, 0x01, 0x80, 0x60, 0x10, 0x0C,
  0x00, 0x0F, 0xE3, 0x98, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x1E,
  0xC7, 0x98, 0x33, 0x06, 0x60, 0xCC, 0x18, 0xE6, 0x0F, 0xC0, 0x18, 0x31,
  0x82, 0x18, 0x61, 0x06, 0x30, 0x63, 0x06, 0x3F, 0xC3, 0xFC, 0x20, 0xC6,
  0x0C, 0x60, 0xC6, 0x08, 0x61, 0x84, 0x18, 0xC1, 0x80, 0x1F, 0x04, 0x0C,
  0x0C, 0x0C, 0x08, 0x08, 0x18, 0x18, 0x18, 0x10, 0x30, 0x30, 0x30, 0xF8,
  0x03, 0x03, 0x03, 0x02, 0x06, 0x06, 0x06, 0x06, 0x04, 0x0C, 0x0C, 0x0C,
  0x0C, 0x08, 0x18, 0x18, 0x18, 0xF0, 0xE0, 0x18, 0x63, 0x18, 0x66, 0x08,
  0xC3, 0x30, 0x6C, 0x0F, 0x01, 0xE0, 0x34, 0x0C, 0xC1, 0x98, 0x33, 0x06,
  0x30, 0x86, 0x30, 0xC0, 0x18, 0x30, 0x60, 0x83, 0x06, 0x0C, 0x18, 0x20,
  0xC1, 0x83, 0x06, 0x0F, 0xFF, 0x00, 0x1C, 0x0E, 0x38, 0x1C, 0x70, 0x78,
  0xA0, 0xA3, 0x43, 0xC6, 0x87, 0x8D, 0x1B, 0x12, 0x36, 0x24, 0xC8, 0xC9,
  0xB1, 0x9E, 0x63, 0x3C, 0xC4, 0x71, 0x88, 0xE2, 0x31, 0x8C, 0x00, 0x1C,
  0x11, 0xC3, 0x1C, 0x31, 0x43, 0x34, 0x23, 0x62, 0x36, 0x62, 0x26, 0x22,
  0x66, 0x34, 0x63, 0xC6, 0x3C, 0x41, 0xC4, 0x18, 0xC1, 0x80, 0x0F, 0x87,
  0x73, 0x0C, 0x81, 0x60, 0x58, 0x1C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x1B,
  0x06, 0xC3, 0x19, 0xC7, 0xC0, 0x1F, 0x07, 0xE1, 0x8C, 0x43, 0x30, 0xCC,
  0x23, 0x18, 0xDC, 0x3E, 0x18, 0x06, 0x01, 0x80, 0x60, 0x10, 0x0C, 0x00,
  0x0F, 0x87, 0x73, 0x0C, 0x81, 0x60, 0x58, 0x1C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x1B, 0x06, 0xC3, 0x19, 0xC3, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x60,
  0x1F, 0x07, 0xE1, 0x8C, 0x43, 0x30, 0xCC, 0x23, 0x18, 0xFC, 0x3E, 0x19,
  0x86, 0x61, 0x88, 0x63, 0x10, 0xCC, 0x30, 0x0F, 0x8C, 0xCC, 0x06, 0x03,
  0x01, 0x80, 0x60, 0x38, 0x06, 0x03, 0x00, 0xC0, 0x40, 0x66, 0x73, 0xF0,
  0xFF, 0xFF, 0x10, 0x30, 0x30, 0x30, 0x20, 0x20, 0x60, 0x60, 0x60, 0x40,
  0xC0, 0xC0, 0xC0, 0x30, 0x66, 0x08, 0xC3, 0x10, 0x66, 0x0C, 0xC1, 0x18,
  0x22, 0x0C, 0x41, 0x98, 0x33, 0x04, 0x61, 0x8C, 0x31, 0xCC, 0x1F, 0x00,
  0xC1, 0xE0, 0xF0, 0xD8, 0x6C, 0x66, 0x33, 0x31, 0x98, 0xC8, 0x6C, 0x34,
  0x1E, 0x0E, 0x07, 0x03, 0x80, 0xC3, 0x07, 0x86, 0x1B, 0x1C, 0x36, 0x38,
  0xCC, 0x51, 0x99, 0xA2, 0x32, 0x4C, 0x6C, 0x98, 0xD9, 0x61, 0xA2, 0xC3,
  0xC5, 0x05, 0x0E, 0x0E, 0x1C, 0x18, 0x30, 0x30, 0x60, 0x00, 0x18, 0x61,
  0x08, 0x33, 0x06, 0xC0, 0xD8, 0x1E, 0x01, 0x80, 0x30, 0x0E, 0x03, 0x40,
  0x48, 0x19, 0x86, 0x30, 0xC6, 0x30, 0xC0, 0xC3, 0xC2, 0xC6, 0xCC, 0x4C,
  0x58, 0x58, 0x70, 0x60, 0x60, 0x60, 0x60, 0x40, 0xC0, 0xC0, 0x0F, 0xC7,
  0xF0, 0x08, 0x06, 0x03, 0x00, 0xC0, 0x60, 0x30, 0x0C, 0x06, 0x01, 0x00,
  0xC0, 0x60, 0x1F, 0xCF, 0xF0, 0x1E, 0x30, 0x40, 0x81, 0x06, 0x0C, 0x10,
  0x20, 0xC1, 0x83, 0x04, 0x08, 0x30, 0x60, 0xC1, 0xE0, 0xCC, 0xC4, 0x44,
  0x66, 0x66, 0x22, 0x23, 0x30, 0x1E, 0x04, 0x18, 0x30, 0x60, 0x83, 0x06,
  0x0C, 0x10, 0x20, 0xC1, 0x83, 0x04, 0x08, 0x31, 0xE0, 0x04, 0x07, 0x02,
  0x83, 0x41, 0x31, 0x89, 0x85, 0xC3, 0xFE, 0xC9, 0x80, 0x3D, 0xB9, 0x98,
  0xD8, 0x6C, 0x36, 0x12, 0x19, 0x0C, 0x86, 0x67, 0x3D, 0x00, 0x18, 0x0C,
  0x06, 0x02, 0x01, 0x01, 0xBC, 0xE6, 0x63, 0x31, 0x90, 0xD8, 0x6C, 0x36,
  0x33, 0x1B, 0x99, 0xB8, 0x3E, 0xC1, 0x86, 0x0C, 0x18, 0x20, 0x40, 0xC1,
  0x91, 0xE0, 0x00, 0xC0, 0x20, 0x18, 0x06, 0x01, 0x8F, 0x46, 0x31, 0x8C,
  0xC3, 0x30, 0xCC, 0x22, 0x18, 0x86, 0x23, 0x8C, 0xE3, 0xD0, 0x3E, 0xC5,
  0x8E, 0x3D, 0xDF, 0x20, 0x40, 0x81, 0x89, 0xF0, 0x01, 0xE0, 0x34, 0x0C,
  0x01, 0x80, 0x20, 0x1F, 0x01, 0x80, 0x30, 0x06, 0x00, 0x80, 0x10, 0x06,
  0x00, 0xC0, 0x18, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x58, 0x0E,
  0x00, 0x1E, 0xCC, 0x63, 0x19, 0x86, 0x61, 0x98, 0x44, 0x31, 0x0C, 0x47,
  0x1B, 0xC7, 0xA0, 0x18, 0x06, 0x01, 0x8D, 0xC3, 0xE0, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x01, 0xBC, 0xE6, 0x63, 0x31, 0x90, 0xD8, 0x4C, 0x66, 0x32,
  0x1B, 0x09, 0x8C, 0x18, 0xC0, 0x03, 0x18, 0xC4, 0x23, 0x18, 0xC4, 0x63,
  0x00, 0x03, 0x03, 0x00, 0x00, 0x06, 0x06, 0x06, 0x04, 0x04, 0x0C, 0x0C,
  0x0C, 0x08, 0x18, 0x18, 0x18, 0x18, 0x10, 0xB0, 0xE0, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x01, 0x8C, 0xCC, 0x6C, 0x2C, 0x14, 0x1F, 0x0D, 0x86, 0xC2,
  0x33, 0x19, 0x8C, 0x18, 0xC6, 0x31, 0x18, 0xC6, 0x21, 0x18, 0xC6, 0x23,
  0x18, 0x3F, 0x78, 0xE7, 0x33, 0x18, 0xCC, 0x63, 0x21, 0x09, 0x8C, 0x66,
  0x31, 0x98, 0xC6, 0x42, 0x13, 0x08, 0x4C, 0x63, 0x00, 0x37, 0x9C, 0xCC,
  0x66, 0x32, 0x1B, 0x09, 0x8C, 0xC6, 0x43, 0x61, 0x31, 0x80, 0x3E, 0x63,
  0x63, 0xC3, 0xC3, 0xC3, 0x82, 0x86, 0x86, 0xCC, 0x78, 0x1B, 0xC7, 0x31,
  0x8C, 0x63, 0x10, 0xCC, 0x33, 0x0C, 0xC2, 0x31, 0x8C, 0xC6, 0xE1, 0x80,
  0x60, 0x10, 0x0C, 0x03, 0x00, 0x3D, 0xB1, 0x98, 0xD8, 0x6C, 0x36, 0x12,
  0x19, 0x0C, 0x8E, 0x67, 0x3D, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x36,
  0x70, 0xC1, 0x82, 0x0C, 0x18, 0x30, 0x41, 0x83, 0x00, 0x3E, 0xC5, 0x83,
  0x03, 0x03, 0x03, 0x06, 0x0D, 0x3B, 0xE0, 0x11, 0x89, 0xF6, 0x31, 0x08,
  0xC6, 0x31, 0x0C, 0x70, 0x61, 0x63, 0x63, 0x43, 0xC2, 0xC2, 0xC6, 0xC6,
  0x8E, 0xDC, 0xF4, 0xC3, 0xC6, 0xC6, 0xCC, 0xCC, 0xC8, 0xD8, 0x50, 0x70,
  0x60, 0x60, 0xC6, 0x3C, 0x63, 0xCE, 0x2C, 0xA6, 0xDA, 0x4D, 0x2C, 0xD2,
  0xCF, 0x28, 0xE3, 0x8E, 0x30, 0xC3, 0x00, 0x19, 0xC6, 0x61, 0xB0, 0x28,
  0x0E, 0x03, 0x01, 0xC0, 0xD8, 0x36, 0x19, 0x8C, 0x30, 0x18, 0x63, 0x18,
  0x63, 0x0C, 0x40, 0x98, 0x12, 0x02, 0xC0, 0x50, 0x0E, 0x01, 0x80, 0x30,
  0x04, 0x01, 0x80, 0x30, 0x2C, 0x07, 0x00, 0x1F, 0x03, 0x06, 0x04, 0x0C,
  0x18, 0x18, 0x30, 0x60, 0x60, 0xFC, 0x03, 0x06, 0x0C, 0x0C, 0x08, 0x08,
  0x18, 0x18, 0x70, 0xE0, 0x30, 0x30, 0x30, 0x20, 0x20, 0x60, 0x60, 0x38,
  0xFF, 0xFF, 0xF8, 0x1C, 0x0C, 0x06, 0x04, 0x04, 0x0C, 0x0C, 0x0C, 0x07,
  0x06, 0x08, 0x18, 0x18, 0x10, 0x30, 0x30, 0x30, 0xE0, 0x71, 0xFF, 0x8F,
};

const GFXglyph NotoSans_Condensed_Italic21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 5, 15, 5, 0, -15 },
  { 11, 6, 5, 7, 2, -15 },
  { 15, 11, 15, 10, 0, -15 },
  { 36, 9, 17, 9, 0, -16 },
  { 56, 12, 15, 14, 1, -15 },
  { 79, 10, 15, 11, 0, -15 },
  { 98, 3, 5, 4, 2, -15 },
  { 100, 6, 18, 6, 1, -15 },
  { 114, 7, 18, 6, -2, -15 },
  { 130, 7, 8, 9, 2, -16 },
  { 137, 8, 10, 10, 1, -12 },
  { 147, 4, 5, 5, -1, -2 },
  { 150, 5, 1, 6, 0, -6 },
  { 151, 3, 2, 5, 0, -2 },
  { 152, 10, 15, 7, -1, -15 },
  { 171, 8, 15, 9, 1, -15 },
  { 186, 6, 15, 9, 2, -15 },
  { 198, 9, 15, 9, 0, -15 },
  { 215, 9, 15, 9, 0, -15 },
  { 232, 9, 15, 9, 0, -15 },
  { 249, 9, 15, 9, 0, -15 },
  { 266, 9, 15, 9, 1, -15 },
  { 283, 9, 15, 9, 1, -15 },
  { 300, 9, 15, 9, 0, -15 },
  { 317, 9, 15, 9, 0, -15 },
  { 334, 4, 11, 5, 0, -11 },
  { 340, 5, 14, 5, -1, -11 },
  { 349, 8, 9, 10, 1, -12 },
  { 358, 8, 6, 10, 1, -10 },
  { 364, 8, 9, 10, 1, -12 },
  { 373, 7, 15, 7, 1, -15 },
  { 387, 13, 17, 14, 1, -15 },
  { 415, 9, 15, 9, -1, -15 },
  { 432, 10, 15, 10, 0, -15 },
  { 451, 10, 15, 9, 1, -15 },
  { 470, 11, 15, 11, 0, -15 },
  { 491, 10, 15, 9, 0, -15 },
  { 510, 10, 15, 8, 0, -15 },
  { 529, 11, 15, 12, 1, -15 },
  { 550, 12, 15, 11, 0, -15 },
  { 573, 8, 15, 6, -1, -15 },
  { 588, 8, 19, 5, -3, -15 },
  { 607, 11, 15, 9, 0, -15 },
  { 628, 7, 15, 8, 0, -15 },
  { 642, 15, 15, 15, 0, -15 },
  { 671, 12, 15, 12, 0, -15 },
  { 694, 10, 15, 12, 1, -15 },
  { 713, 10, 15, 10, 0, -15 },
  { 732, 10, 19, 12, 1, -15 },
  { 756, 10, 15, 10, 0, -15 },
  { 775, 9, 15, 9, 0, -15 },
  { 792, 8, 15, 8, 2, -15 },
  { 807, 11, 15, 11, 1, -15 },
  { 828, 9, 15, 9, 2, -15 },
  { 845, 15, 15, 15, 2, -15 },
  { 874, 11, 15, 9, -1, -15 },
  { 895, 8, 15, 8, 2, -15 },
  { 910, 10, 15, 8, -1, -15 },
  { 929, 7, 18, 6, 0, -15 },
  { 945, 4, 15, 7, 2, -15 },
  { 953, 7, 18, 6, -1, -15 },
  { 969, 9, 8, 9, 0, -15 },
  { 978, 7, 1, 7, -2, 2 },
  { 979, 3, 3, 5, 3, -16 },
  { 981, 9, 11, 10, 1, -11 },
  { 994, 9, 16, 10, 0, -16 },
  { 1012, 7, 11, 8, 1, -11 },
  { 1022, 10, 16, 10, 1, -16 },
  { 1042, 7, 11, 9, 1, -11 },
  { 1052, 11, 21, 5, -3, -16 },
  { 1081, 10, 16, 10, 0, -11 },
  { 1101, 9, 16, 10, 0, -16 },
  { 1119, 5, 15, 4, 0, -15 },
  { 1129, 8, 20, 4, -3, -15 },
  { 1149, 9, 16, 8, 0, -16 },
  { 1167, 5, 16, 4, 0, -16 },
  { 1177, 14, 11, 15, 0, -11 },
  { 1197, 9, 11, 10, 0, -11 },
  { 1210, 8, 11, 10, 1, -11 },
  { 1221, 10, 16, 10, -1, -11 },
  { 1241, 9, 16, 10, 1, -11 },
  { 1259, 7, 11, 7, 0, -11 },
  { 1269, 7, 11, 7, 0, -11 },
  { 1279, 5, 14, 6, 1, -14 },
  { 1288, 8, 11, 10, 1, -11 },
  { 1299, 8, 11, 8, 1, -11 },
  { 1310, 12, 11, 13, 1, -11 },
  { 1327, 10, 11, 8, -1, -11 },
  { 1341, 11, 16, 8, -2, -11 },
  { 1363, 8, 11, 7, -1, -11 },
  { 1374, 8, 18, 7, 0, -15 },
  { 1392, 1, 21, 9, 4, -16 },
  { 1395, 8, 18, 7, -1, -15 },
  { 1413, 8, 3, 10, 1, -9 },
};

const GFXfont NotoSans_Condensed_Italic21pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Italic21pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Italic21pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _NOTOSANS_CONDENSED_ITALIC21PT7B_H_
