#ifndef _NOTOSANS_CONDENSED_ITALIC15PT7B_H_
#define _NOTOSANS_CONDENSED_ITALIC15PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Italic.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Italic15pt7bBitmaps[] PROGMEM = {
  0x00, 0x33, 0x22, 0x26, 0x44, 0x04, 0xC0, 0xBA, 0xAA, 0x0A, 0x12, 0x12,
  0x7F, 0x24, 0x24, 0x28, 0xFE, 0x48, 0x50, 0xD0, 0x08, 0x7C, 0xA3, 0x83,
  0x07, 0x06, 0x0E, 0x29, 0xF0, 0x81, 0x00, 0x61, 0x52, 0x94, 0x94, 0xA9,
  0xAF, 0xD5, 0x15, 0x29, 0x49, 0xC6, 0x1C, 0x68, 0x91, 0x63, 0x86, 0x14,
  0xE7, 0x8D, 0x19, 0xD8, 0xEA, 0x08, 0x88, 0x44, 0x21, 0x08, 0xC6, 0x30,
  0x84, 0x00, 0x10, 0x84, 0x31, 0x88, 0x42, 0x11, 0x08, 0x8C, 0x00, 0x13,
  0x43, 0xDC, 0x58, 0x20, 0x82, 0x3F, 0x20, 0x82, 0x00, 0x2D, 0x60, 0xFF,
  0x70, 0x02, 0x0C, 0x10, 0x60, 0x82, 0x04, 0x10, 0x20, 0x83, 0x00, 0x1C,
  0x68, 0x9B, 0x24, 0x48, 0x91, 0x22, 0xC8, 0x91, 0xC0, 0x36, 0xA2, 0x26,
  0x44, 0x44, 0xC0, 0x1C, 0x48, 0x18, 0x20, 0x41, 0x04, 0x18, 0x61, 0x83,
  0xE0, 0x1C, 0x48, 0x18, 0x20, 0xC6, 0x02, 0x06, 0x09, 0x13, 0xC0, 0x06,
  0x18, 0x30, 0xA2, 0xC5, 0x12, 0x44, 0xFC, 0x30, 0x40, 0x3E, 0x40, 0x81,
  0x05, 0x0F, 0x03, 0x06, 0x0D, 0x13, 0xC0, 0x1C, 0x84, 0x10, 0xB3, 0x68,
  0xA2, 0x9A, 0x4F, 0x00, 0x7E, 0x10, 0x82, 0x10, 0x42, 0x18, 0x43, 0x08,
  0x00, 0x1C, 0x4C, 0x99, 0x22, 0xC6, 0x12, 0x66, 0x85, 0x91, 0xE0, 0x18,
  0x96, 0x51, 0x45, 0x33, 0x43, 0x08, 0x6F, 0x00, 0x2C, 0x00, 0x36, 0x13,
  0x00, 0x00, 0x26, 0x48, 0x04, 0x66, 0x20, 0x60, 0x60, 0x40, 0xFC, 0x00,
  0x3F, 0x83, 0x03, 0x03, 0x19, 0x88, 0x00, 0x39, 0x20, 0xC2, 0x18, 0xC2,
  0x10, 0x01, 0x0C, 0x00, 0x07, 0x06, 0x22, 0x04, 0x9D, 0x4A, 0x54, 0x95,
  0x2A, 0x5A, 0x9B, 0x10, 0x04, 0x00, 0xF0, 0x04, 0x18, 0x38, 0xF1, 0x62,
  0xCF, 0x9F, 0x62, 0x87, 0x08, 0x3C, 0x4C, 0x89, 0x12, 0x6F, 0x11, 0x22,
  0x44, 0x9B, 0xE0, 0x1E, 0x69, 0x02, 0x08, 0x10, 0x20, 0x40, 0x81, 0x81,
  0xC0, 0x3C, 0x26, 0x22, 0x23, 0x23, 0x62, 0x42, 0x42, 0x44, 0x4C, 0xF0,
  0x3E, 0x40, 0x81, 0x02, 0x0F, 0x90, 0x20, 0x40, 0x83, 0xE0, 0x3E, 0x40,
  0x81, 0x02, 0x0F, 0x90, 0x20, 0x40, 0x83, 0x00, 0x1E, 0x65, 0x86, 0x08,
  0x11, 0xE1, 0x42, 0x85, 0x89, 0xF0, 0x31, 0x21, 0x21, 0x23, 0x22, 0x7E,
  0x42, 0x42, 0x46, 0x44, 0xC4, 0x3C, 0x21, 0x84, 0x10, 0x43, 0x0C, 0x20,
  0x8F, 0x00, 0x0C, 0x20, 0x82, 0x08, 0x61, 0x04, 0x10, 0x43, 0x08, 0x63,
  0x00, 0x33, 0x22, 0x24, 0x2C, 0x38, 0x70, 0x78, 0x48, 0x48, 0x48, 0xCC,
  0x31, 0x08, 0x42, 0x31, 0x08, 0x42, 0x3E, 0x30, 0x66, 0x1C, 0xC3, 0x18,
  0xE3, 0x14, 0xF7, 0x96, 0xB2, 0x74, 0x4C, 0x89, 0x92, 0x26, 0x00, 0x30,
  0x98, 0xCC, 0x47, 0x22, 0x93, 0x49, 0x2C, 0x9C, 0x46, 0x23, 0x21, 0x80,
  0x1C, 0x4D, 0x0E, 0x18, 0x30, 0x61, 0xC2, 0x85, 0x11, 0xC0, 0x3C, 0x4C,
  0x89, 0x12, 0x6D, 0x9E, 0x20, 0x40, 0x83, 0x00, 0x1C, 0x4D, 0x0E, 0x18,
  0x30, 0x61, 0xC2, 0x85, 0x11, 0xC0, 0x81, 0x81, 0x00, 0x3C, 0x4C, 0x89,
  0x12, 0x6F, 0x9E, 0x24, 0x48, 0x93, 0x30, 0x1E, 0x49, 0x83, 0x02, 0x06,
  0x06, 0x04, 0x09, 0x33, 0xC0, 0xFC, 0xC2, 0x08, 0x20, 0x86, 0x10, 0x41,
  0x0C, 0x00, 0x62, 0x85, 0x0A, 0x3C, 0x50, 0xA1, 0x42, 0x8D, 0x13, 0xC0,
  0xC3, 0x8B, 0x16, 0x6C, 0x8B, 0x14, 0x38, 0x60, 0xC1, 0x00, 0xC4, 0x38,
  0x8B, 0x31, 0x66, 0x6D, 0x49, 0xA9, 0x35, 0x47, 0x28, 0xA7, 0x18, 0xC3,
  0x18, 0x00, 0x11, 0x13, 0x12, 0x1C, 0x0C, 0x08, 0x18, 0x3C, 0x24, 0x44,
  0xC4, 0xC7, 0x34, 0x96, 0x51, 0x86, 0x10, 0x41, 0x0C, 0x00, 0x3E, 0x08,
  0x30, 0x41, 0x82, 0x08, 0x30, 0x41, 0x03, 0xE0, 0x39, 0x08, 0x42, 0x21,
  0x08, 0x42, 0x21, 0x0E, 0x00, 0xAA, 0xAB, 0x54, 0x1C, 0x20, 0x82, 0x08,
  0x61, 0x04, 0x10, 0x42, 0x08, 0xE0, 0x08, 0x30, 0xE1, 0x64, 0x58, 0xC0,
  0xF8, 0xD0, 0x3A, 0x4D, 0x12, 0x24, 0x59, 0x93, 0x3C, 0x30, 0x40, 0x81,
  0xE6, 0x4C, 0xD1, 0x22, 0x45, 0x92, 0xE0, 0x3C, 0x84, 0x10, 0x43, 0x04,
  0x1C, 0x03, 0x02, 0x02, 0x3A, 0x26, 0x44, 0x44, 0x44, 0xCC, 0x48, 0x78,
  0x3C, 0x94, 0x5E, 0x43, 0x04, 0x1E, 0x07, 0x0C, 0x08, 0x1C, 0x08, 0x18,
  0x10, 0x10, 0x10, 0x10, 0x30, 0x20, 0x20, 0xE0, 0xC0, 0x3A, 0x4D, 0x12,
  0x24, 0x59, 0x93, 0x3C, 0x08, 0x12, 0xC3, 0x00, 0x30, 0x82, 0x0F, 0x65,
  0x94, 0x51, 0x4F, 0x28, 0x80, 0x32, 0x02, 0x24, 0x44, 0x4C, 0x80, 0x0C,
  0x20, 0x02, 0x08, 0x41, 0x04, 0x10, 0xC2, 0x08, 0x23, 0x8C, 0x00, 0x30,
  0x40, 0x81, 0x32, 0x8B, 0x1C, 0x38, 0x51, 0xB2, 0x20, 0x32, 0x22, 0x24,
  0x44, 0x4C, 0x80, 0x3D, 0xC9, 0x96, 0x45, 0x12, 0x44, 0x92, 0x2C, 0x8A,
  0x26, 0x3D, 0x96, 0x51, 0x45, 0x3C, 0xA2, 0x3C, 0x94, 0x51, 0x47, 0x34,
  0x9C, 0x1E, 0x12, 0x33, 0x22, 0x22, 0x22, 0x64, 0x5C, 0x40, 0x40, 0x40,
  0xC0, 0x3A, 0x4D, 0x12, 0x24, 0x59, 0x93, 0x3C, 0x08, 0x10, 0x60, 0x80,
  0x39, 0x18, 0x84, 0x23, 0x10, 0x7A, 0x10, 0xC3, 0x08, 0x5E, 0x4B, 0xAD,
  0x24, 0x98, 0x4F, 0x28, 0xA2, 0x8A, 0x69, 0x3C, 0x8C, 0xE5, 0x2A, 0x53,
  0x18, 0x99, 0xCC, 0xA6, 0xD5, 0x4A, 0xA6, 0x63, 0x31, 0x90, 0x32, 0x28,
  0x70, 0xC1, 0x85, 0x1A, 0x66, 0x22, 0x4C, 0x91, 0x22, 0x85, 0x0C, 0x18,
  0x20, 0x43, 0x04, 0x00, 0x78, 0xC4, 0x46, 0x22, 0x1E, 0x0C, 0x61, 0x04,
  0x30, 0x8E, 0x18, 0x21, 0x84, 0x10, 0x60, 0xFF, 0xFE, 0x10, 0x60, 0x82,
  0x18, 0x40, 0xC6, 0x10, 0x82, 0x08, 0xE0, 0xF6, 0x60,
};

const GFXglyph NotoSans_Condensed_Italic15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 4, 11, 4, 0, -11 },
  { 7, 4, 4, 5, 2, -11 },
  { 9, 8, 11, 7, 0, -11 },
  { 20, 7, 12, 7, 0, -11 },
  { 31, 8, 11, 10, 1, -11 },
  { 42, 7, 11, 8, 0, -11 },
  { 52, 2, 4, 3, 2, -11 },
  { 53, 5, 13, 4, 0, -11 },
  { 62, 5, 13, 4, -1, -11 },
  { 71, 6, 5, 6, 1, -11 },
  { 75, 6, 7, 7, 1, -9 },
  { 81, 3, 4, 3, -1, -2 },
  { 83, 4, 2, 4, 0, -5 },
  { 84, 2, 2, 3, 0, -2 },
  { 85, 7, 11, 5, -1, -11 },
  { 95, 7, 11, 7, 0, -11 },
  { 105, 4, 11, 7, 2, -11 },
  { 111, 7, 11, 7, 0, -11 },
  { 121, 7, 11, 7, 0, -11 },
  { 131, 7, 11, 7, 0, -11 },
  { 141, 7, 11, 7, 0, -11 },
  { 151, 6, 11, 7, 1, -11 },
  { 160, 6, 11, 7, 1, -11 },
  { 169, 7, 11, 7, 0, -11 },
  { 179, 6, 11, 7, 0, -11 },
  { 188, 3, 8, 3, 0, -8 },
  { 191, 4, 10, 3, -1, -8 },
  { 196, 6, 7, 7, 1, -9 },
  { 202, 6, 4, 7, 1, -7 },
  { 205, 6, 7, 7, 1, -9 },
  { 211, 6, 11, 5, 0, -11 },
  { 220, 10, 12, 10, 0, -11 },
  { 235, 7, 11, 7, -1, -11 },
  { 245, 7, 11, 7, 0, -11 },
  { 255, 7, 11, 7, 1, -11 },
  { 265, 8, 11, 8, 0, -11 },
  { 276, 7, 11, 6, 0, -11 },
  { 286, 7, 11, 6, 0, -11 },
  { 296, 7, 11, 8, 1, -11 },
  { 306, 8, 11, 8, 0, -11 },
  { 317, 6, 11, 4, -1, -11 },
  { 326, 6, 14, 3, -2, -11 },
  { 337, 8, 11, 7, 0, -11 },
  { 348, 5, 11, 6, 0, -11 },
  { 355, 11, 11, 11, 0, -11 },
  { 371, 9, 11, 9, 0, -11 },
  { 384, 7, 11, 8, 1, -11 },
  { 394, 7, 11, 7, 0, -11 },
  { 404, 7, 14, 8, 1, -11 },
  { 417, 7, 11, 7, 0, -11 },
  { 427, 7, 11, 6, 0, -11 },
  { 437, 6, 11, 6, 1, -11 },
  { 446, 7, 11, 8, 1, -11 },
  { 456, 7, 11, 7, 1, -11 },
  { 466, 11, 11, 11, 1, -11 },
  { 482, 8, 11, 6, -1, -11 },
  { 493, 6, 11, 6, 1, -11 },
  { 502, 7, 11, 6, 0, -11 },
  { 512, 5, 13, 4, 0, -11 },
  { 521, 2, 11, 5, 2, -11 },
  { 524, 6, 13, 4, -1, -11 },
  { 534, 7, 6, 7, 0, -11 },
  { 540, 5, 1, 5, -1, 1 },
  { 541, 2, 2, 4, 2, -11 },
  { 542, 7, 8, 7, 0, -8 },
  { 549, 7, 11, 7, 0, -11 },
  { 559, 6, 8, 5, 0, -8 },
  { 565, 8, 11, 7, 0, -11 },
  { 576, 6, 8, 6, 0, -8 },
  { 582, 8, 15, 4, -2, -11 },
  { 597, 7, 12, 7, 0, -8 },
  { 608, 6, 11, 7, 0, -11 },
  { 617, 4, 11, 3, 0, -11 },
  { 623, 6, 15, 3, -2, -11 },
  { 635, 7, 11, 6, 0, -11 },
  { 645, 4, 11, 3, 0, -11 },
  { 651, 10, 8, 10, 0, -8 },
  { 661, 6, 8, 7, 0, -8 },
  { 667, 6, 8, 7, 0, -8 },
  { 673, 8, 12, 7, -1, -8 },
  { 685, 7, 12, 7, 0, -8 },
  { 696, 5, 8, 5, 0, -8 },
  { 701, 5, 8, 5, 0, -8 },
  { 706, 3, 10, 4, 1, -10 },
  { 710, 6, 8, 7, 1, -8 },
  { 716, 5, 8, 6, 1, -8 },
  { 721, 9, 8, 9, 1, -8 },
  { 730, 7, 8, 6, -1, -8 },
  { 737, 7, 12, 6, -1, -8 },
  { 748, 5, 8, 5, 0, -8 },
  { 753, 6, 13, 5, 0, -11 },
  { 763, 1, 15, 6, 3, -11 },
  { 765, 6, 13, 5, -1, -11 },
  { 775, 6, 2, 7, 1, -6 },
};

const GFXfont NotoSans_Condensed_Italic15pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Italic15pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Italic15pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _NOTOSANS_CONDENSED_ITALIC15PT7B_H_
