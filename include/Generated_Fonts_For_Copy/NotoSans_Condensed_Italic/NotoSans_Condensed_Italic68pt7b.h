#ifndef _NOTOSANS_CONDENSED_ITALIC68PT7B_H_
#define _NOTOSANS_CONDENSED_ITALIC68PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Italic.ttf
// Size: 68pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Italic68pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01,
  0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFC, 0x00, 0x30, 0x00, 0x1F, 0x87, 0xE7, 0xE0, 0xFC, 0xFC, 0x1F,
  0x9F, 0x83, 0xF3, 0xF0, 0x7C, 0x7C, 0x0F, 0x8F, 0x83, 0xF1, 0xF0, 0x7C,
  0x7C, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x3E, 0x3E, 0x07, 0x87, 0x81, 0xF0,
  0xF0, 0x3E, 0x3E, 0x07, 0xC7, 0xC0, 0xF0, 0xF0, 0x1E, 0x1E, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x1F, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x1F, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x00, 0xF8,
  0x0F, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x03,
  0xC0, 0x78, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x00, 0x78, 0x0F, 0x80, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x03, 0xC0, 0x3C, 0x00,
  0x7F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF8, 0x0F,
  0x00, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x07, 0xC0,
  0x78, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x3E,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x01,
  0xF0, 0x1E, 0x00, 0x00, 0x78, 0x07, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFE,
  0x00, 0x3C, 0x07, 0x80, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x07, 0x80, 0xF8,
  0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x3C, 0x03,
  0xC0, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x01, 0xE0,
  0x1E, 0x00, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x0F,
  0x80, 0xF0, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00,
  0x7C, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xF8, 0xE1,
  0xE0, 0x1F, 0x8F, 0x02, 0x01, 0xF8, 0x70, 0x00, 0x0F, 0x83, 0x80, 0x00,
  0x7C, 0x1C, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x3E, 0x0F, 0x00, 0x01, 0xF0,
  0x70, 0x00, 0x07, 0xC3, 0x80, 0x00, 0x3E, 0x1C, 0x00, 0x01, 0xF9, 0xE0,
  0x00, 0x0F, 0xEE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xCF,
  0xC0, 0x00, 0x0E, 0x3F, 0x00, 0x00, 0x71, 0xF8, 0x00, 0x03, 0x87, 0xC0,
  0x00, 0x3C, 0x3E, 0x00, 0x01, 0xC1, 0xF0, 0x00, 0x0E, 0x0F, 0x80, 0x00,
  0x70, 0x7C, 0x00, 0x03, 0x83, 0xE0, 0x00, 0x3C, 0x3F, 0x04, 0x01, 0xC1,
  0xF0, 0x38, 0x0E, 0x3F, 0x81, 0xF8, 0x77, 0xF8, 0x0F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x03, 0xFE, 0x00,
  0x03, 0xC0, 0x0F, 0xFE, 0x00, 0x0F, 0x80, 0x3F, 0xFC, 0x00, 0x3E, 0x00,
  0xFC, 0x7C, 0x00, 0x78, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0x07, 0xC1, 0xF0,
  0x03, 0xC0, 0x0F, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x03, 0xC0, 0x3E, 0x00,
  0x7C, 0x07, 0x80, 0x78, 0x00, 0xF0, 0x1F, 0x01, 0xF0, 0x03, 0xE0, 0x3E,
  0x03, 0xC0, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0x0F, 0x00, 0xF8, 0x1E, 0x00,
  0x1E, 0x01, 0xE0, 0x7C, 0x00, 0x3C, 0x03, 0xC1, 0xF0, 0x00, 0xF8, 0x0F,
  0x83, 0xC0, 0x01, 0xF0, 0x1F, 0x0F, 0x80, 0x03, 0xE0, 0x3C, 0x1E, 0x00,
  0x07, 0x80, 0x78, 0x7C, 0x0F, 0x0F, 0x01, 0xF1, 0xF0, 0xFF, 0x1E, 0x03,
  0xC3, 0xC3, 0xFF, 0x3C, 0x0F, 0x8F, 0x8F, 0xFF, 0x78, 0x1F, 0x1E, 0x3F,
  0x3E, 0xF8, 0x7C, 0x7C, 0x7C, 0x3D, 0xF1, 0xF1, 0xF1, 0xF0, 0x7D, 0xFF,
  0xE3, 0xE3, 0xC0, 0xFB, 0xFF, 0x8F, 0x8F, 0x81, 0xF3, 0xFE, 0x1E, 0x1E,
  0x03, 0xE3, 0xF0, 0x7C, 0x3C, 0x07, 0xC0, 0x00, 0xF0, 0xF8, 0x0F, 0x80,
  0x03, 0xE1, 0xF0, 0x1E, 0x00, 0x0F, 0x83, 0xC0, 0x3C, 0x00, 0x1E, 0x07,
  0x80, 0x78, 0x00, 0x7C, 0x1F, 0x01, 0xF0, 0x00, 0xF0, 0x3E, 0x03, 0xE0,
  0x03, 0xE0, 0x78, 0x07, 0x80, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0x1F, 0x01,
  0xE0, 0x3E, 0x00, 0x7C, 0x03, 0xC0, 0x7C, 0x00, 0xF0, 0x07, 0x80, 0xF0,
  0x03, 0xE0, 0x0F, 0x03, 0xE0, 0x0F, 0x80, 0x1E, 0x07, 0x80, 0x1F, 0x00,
  0x3C, 0x1F, 0x00, 0x7C, 0x00, 0x7C, 0x3C, 0x00, 0xF0, 0x00, 0xFF, 0xF8,
  0x03, 0xE0, 0x00, 0xFF, 0xE0, 0x07, 0x80, 0x01, 0xFF, 0x80, 0x1F, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7C, 0x07,
  0xC0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x07, 0xE0,
  0x3E, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0x7C,
  0x1F, 0x80, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x0F,
  0xDF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x07, 0xE0,
  0xFE, 0x7E, 0x03, 0xE0, 0xFE, 0x3F, 0x01, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x7E, 0x07, 0xE0, 0xF8, 0x7E, 0x01, 0xF8, 0xFC, 0x3E, 0x00, 0xFC, 0x7C,
  0x3F, 0x00, 0x7E, 0x7E, 0x1F, 0x80, 0x1F, 0xBE, 0x0F, 0x80, 0x0F, 0xFF,
  0x07, 0xC0, 0x03, 0xFF, 0x07, 0xE0, 0x01, 0xFF, 0x03, 0xF0, 0x00, 0x7F,
  0x81, 0xF8, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x1F,
  0xE0, 0x1F, 0x80, 0x1F, 0xF8, 0x0F, 0xE0, 0x3F, 0xFC, 0x07, 0xF8, 0x7F,
  0xFF, 0x01, 0xFF, 0xFF, 0x9F, 0x80, 0xFF, 0xFF, 0x8F, 0xE0, 0x3F, 0xFF,
  0x03, 0xF0, 0x07, 0xFF, 0x01, 0xFC, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F,
  0x8F, 0xCF, 0xC7, 0xE3, 0xF1, 0xF0, 0xF8, 0x7C, 0x3E, 0x3E, 0x1F, 0x0F,
  0x87, 0xC3, 0xC1, 0xE0, 0xF0, 0xF0, 0x78, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0xC0, 0x18, 0x0F, 0x80, 0x3C, 0x1F, 0x00, 0x7E,
  0x3C, 0x01, 0xFF, 0x78, 0x07, 0xFF, 0xF7, 0xF8, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7F, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x1F, 0x9E, 0x00, 0x7E, 0x3E, 0x01, 0xF8, 0x7C, 0x07, 0xF0, 0x7C,
  0x07, 0xC0, 0xF8, 0x07, 0x01, 0xF8, 0x04, 0x01, 0xF0, 0x00, 0x03, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0x7C, 0x0F, 0xC0, 0xF8,
  0x1F, 0x81, 0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x07, 0x80,
  0xF0, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFE, 0xFF, 0xFE,
  0x1C, 0x7E, 0x7E, 0xFF, 0xFE, 0xFE, 0xFE, 0xFC, 0x30, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC,
  0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x01, 0xF8,
  0x03, 0xE0, 0x7E, 0x00, 0x7C, 0x0F, 0xC0, 0x0F, 0x83, 0xF0, 0x01, 0xF0,
  0x7E, 0x00, 0x3E, 0x1F, 0x80, 0x07, 0xC3, 0xF0, 0x00, 0xF8, 0x7E, 0x00,
  0x1F, 0x1F, 0x80, 0x03, 0xE3, 0xF0, 0x00, 0x7C, 0x7E, 0x00, 0x0F, 0x8F,
  0x80, 0x03, 0xF3, 0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x0F, 0xCF, 0xC0, 0x01,
  0xF9, 0xF0, 0x00, 0x3E, 0x7E, 0x00, 0x07, 0xCF, 0xC0, 0x01, 0xF9, 0xF8,
  0x00, 0x3F, 0x3F, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x3F,
  0x1F, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0x1F, 0x80,
  0x07, 0xE3, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x0F, 0xC0, 0x07, 0xE1,
  0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x01,
  0xF8, 0x0F, 0x80, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x07,
  0xF9, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x03,
  0xF0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x7F, 0xF8,
  0x3F, 0xFC, 0x1F, 0xDF, 0x0F, 0xE7, 0xCF, 0xF3, 0xF3, 0xF0, 0xFC, 0x78,
  0x3E, 0x0C, 0x0F, 0x82, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xF0, 0x3F, 0xC0, 0x07,
  0x80, 0x3F, 0x80, 0x04, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xF0, 0x0F, 0xE0, 0x07, 0x00, 0x1F, 0x80,
  0x10, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x08, 0x00,
  0x0F, 0xE0, 0x38, 0x00, 0x7F, 0x00, 0xFC, 0x0F, 0xFC, 0x03, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x01, 0xF7, 0xC0,
  0x00, 0x03, 0xCF, 0x80, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x3E, 0x3E, 0x00,
  0x00, 0x78, 0xFC, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x07, 0xC3, 0xE0, 0x00,
  0x1F, 0x07, 0xC0, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0xF8, 0x3F, 0x00, 0x03,
  0xE0, 0x7C, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x7C,
  0x07, 0xE0, 0x00, 0xF8, 0x0F, 0xC0, 0x03, 0xE0, 0x1F, 0x00, 0x0F, 0x80,
  0x3E, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x7C, 0x01, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x3E, 0x00, 0x3F,
  0x00, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xE0, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0x80, 0xFF,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xFC, 0x08, 0x00, 0x0F, 0xE0, 0x38, 0x00, 0x7F, 0x80,
  0xFC, 0x0F, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x70, 0x00, 0x3F, 0x1F, 0xF0, 0x01,
  0xF1, 0xFF, 0xC0, 0x0F, 0xBF, 0xFF, 0x00, 0xFD, 0xFF, 0xFC, 0x07, 0xFF,
  0x1F, 0xE0, 0x3F, 0xE0, 0x3F, 0x81, 0xFE, 0x00, 0xFC, 0x1F, 0xE0, 0x07,
  0xE0, 0xFE, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0xF8, 0x3F, 0x00, 0x07, 0xC1,
  0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x83, 0xE0,
  0x00, 0xFC, 0x3F, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x01,
  0xF0, 0x7E, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0xFC, 0x0F, 0x80, 0x07, 0xC0,
  0x7C, 0x00, 0x7E, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x03, 0xF0, 0x03, 0xF8, 0x7F, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0x80, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xE0, 0x07, 0xFD, 0xFF, 0x00, 0x7F, 0x01, 0xFC, 0x03, 0xF0, 0x07,
  0xE0, 0x3F, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0xF8, 0x0F, 0x80, 0x07, 0xC0,
  0xFC, 0x00, 0x3E, 0x07, 0xE0, 0x01, 0xF0, 0x3F, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xC0, 0x3E, 0x00, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x3F, 0x07, 0xF0, 0x01, 0xF8, 0x7F, 0x00,
  0x07, 0xEF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0x7F,
  0x00, 0x0F, 0xE1, 0xF8, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x80,
  0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xE0, 0x7E, 0x00, 0x1F, 0x87, 0xE0,
  0x00, 0xFC, 0x3F, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x00,
  0xF8, 0x7C, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x7E, 0x1F, 0x00, 0x03, 0xF0,
  0xF8, 0x00, 0x1F, 0x07, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0xC1, 0xFC,
  0x01, 0xFC, 0x07, 0xF8, 0x3F, 0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80,
  0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xE0, 0xFE, 0x01, 0xF8,
  0x07, 0xE0, 0x3F, 0x80, 0x3E, 0x03, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x3F,
  0x07, 0xE0, 0x03, 0xF0, 0x7C, 0x00, 0x1F, 0x0F, 0xC0, 0x01, 0xF0, 0xFC,
  0x00, 0x1F, 0x0F, 0xC0, 0x03, 0xF0, 0xF8, 0x00, 0x3F, 0x0F, 0x80, 0x03,
  0xF0, 0xF8, 0x00, 0x3F, 0x1F, 0x80, 0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x1F,
  0x80, 0x07, 0xE1, 0xF8, 0x00, 0x7E, 0x0F, 0x80, 0x0F, 0xE0, 0xFC, 0x01,
  0xFE, 0x0F, 0xC0, 0x3F, 0xE0, 0xFE, 0x07, 0xFE, 0x07, 0xFF, 0xF7, 0xC0,
  0x7F, 0xFF, 0x7C, 0x03, 0xFF, 0xE7, 0xC0, 0x1F, 0xF8, 0xFC, 0x00, 0x7E,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0xE0,
  0x7F, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x03, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x0F, 0xF0, 0x1F, 0x80, 0x7C, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x0F, 0xF0, 0x1F, 0x80, 0x7C,
  0x00, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00,
  0x0F, 0x80, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0,
  0xFF, 0xFF, 0xC0, 0xF0, 0x1F, 0xC1, 0x80, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFE,
  0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03,
  0xE0, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x03, 0xE0,
  0x00, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x38,
  0x00, 0xF0, 0x3C, 0x00, 0x7F, 0xE0, 0x3C, 0x1F, 0x00, 0x7F, 0xFC, 0x0F,
  0x07, 0x80, 0x3F, 0xFF, 0x03, 0xC3, 0xE0, 0x1F, 0x8F, 0xC0, 0xF0, 0xF0,
  0x0F, 0x81, 0xE0, 0x3C, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x1E, 0x01, 0xE0,
  0x3E, 0x03, 0xC7, 0x80, 0xF8, 0x0F, 0x00, 0xF3, 0xE0, 0x3C, 0x03, 0xC0,
  0x7C, 0xF0, 0x1E, 0x01, 0xF0, 0x1F, 0x3C, 0x07, 0x80, 0x7C, 0x07, 0x8F,
  0x03, 0xE0, 0x1E, 0x01, 0xE7, 0xC0, 0xF0, 0x07, 0x80, 0x79, 0xE0, 0x3C,
  0x03, 0xE0, 0x3E, 0x78, 0x1F, 0x00, 0xF8, 0x0F, 0x1E, 0x07, 0xC0, 0x3C,
  0x03, 0xC7, 0x81, 0xF0, 0x1F, 0x01, 0xF1, 0xE0, 0x78, 0x07, 0xC0, 0x78,
  0xF8, 0x1E, 0x01, 0xF0, 0x1E, 0x3E, 0x07, 0x80, 0xFC, 0x0F, 0x0F, 0x81,
  0xE0, 0x3F, 0x03, 0xC3, 0xE0, 0x7C, 0x1F, 0xC1, 0xE0, 0xF8, 0x1F, 0x0F,
  0xF0, 0xF8, 0x3E, 0x07, 0xFF, 0xBE, 0xFC, 0x0F, 0x80, 0xFF, 0xC7, 0xFE,
  0x03, 0xE0, 0x3F, 0xE1, 0xFF, 0x00, 0xF8, 0x07, 0xF0, 0x3F, 0x80, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x18, 0x00, 0x00, 0x7F,
  0x80, 0x7E, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0x3E, 0xF8,
  0x00, 0x00, 0x7D, 0xF0, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x03, 0xE7, 0xC0,
  0x00, 0x0F, 0xCF, 0x80, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x7E, 0x3E, 0x00,
  0x00, 0xF8, 0x7C, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x01,
  0xF8, 0x1F, 0x80, 0x03, 0xE0, 0x3F, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x1F,
  0x80, 0xFC, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0xFC, 0x03, 0xF0, 0x01, 0xF0,
  0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xF8, 0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0x80, 0x07, 0xE0, 0x7E, 0x00, 0x0F,
  0xC0, 0xFC, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x3E,
  0x0F, 0xC0, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0xF8, 0x7E, 0x00, 0x01, 0xF1,
  0xF8, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x0F, 0x9F,
  0x80, 0x00, 0x1F, 0x7F, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7E, 0x0F, 0xFE, 0x00,
  0x7C, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x7F, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x3F, 0x00,
  0xF8, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x7E, 0x01,
  0xF8, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0xFC, 0x03,
  0xF0, 0x01, 0xFC, 0x03, 0xF0, 0x03, 0xF8, 0x03, 0xE0, 0x0F, 0xF0, 0x03,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xC0, 0x3F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xE0, 0x0F, 0xC0, 0x07, 0xE0, 0x0F, 0xC0, 0x03, 0xF0, 0x0F,
  0x80, 0x03, 0xF0, 0x0F, 0x80, 0x03, 0xF0, 0x1F, 0x80, 0x03, 0xF0, 0x1F,
  0x80, 0x03, 0xF0, 0x1F, 0x80, 0x03, 0xF0, 0x1F, 0x00, 0x03, 0xF0, 0x3F,
  0x00, 0x03, 0xF0, 0x3F, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0x3E,
  0x00, 0x07, 0xE0, 0x3E, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x1F, 0xC0, 0x7E,
  0x00, 0x3F, 0xC0, 0x7E, 0x00, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x3F, 0xE0, 0x1C, 0x00, 0x7F, 0x80, 0x08, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x0C, 0x00, 0x1F,
  0xF8, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xF1, 0xFF, 0xF0,
  0x01, 0xF8, 0x07, 0xF8, 0x00, 0xF8, 0x01, 0xFE, 0x00, 0xFC, 0x00, 0x7F,
  0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x0F, 0xE0, 0x1F, 0x00, 0x03,
  0xF0, 0x0F, 0x80, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0xFC, 0x07, 0xE0, 0x00,
  0x7E, 0x03, 0xF0, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x0F, 0xC0, 0xFC, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x03, 0xF0, 0x3F, 0x00,
  0x01, 0xF8, 0x1F, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7E, 0x0F, 0xC0,
  0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x1F, 0xC1, 0xF0,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0x7E,
  0x00, 0x03, 0xF8, 0x3E, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0xFC, 0x1F,
  0x80, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7F, 0x03,
  0xE0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x3F, 0x80,
  0xFC, 0x00, 0x1F, 0xC0, 0x7C, 0x00, 0x1F, 0xC0, 0x3E, 0x00, 0x1F, 0xC0,
  0x3F, 0x00, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0xC0, 0x0F, 0xC0, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xC0, 0x1F, 0x80, 0x1F, 0xE0, 0x00,
  0xE0, 0x07, 0xF8, 0x00, 0x04, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0xFF, 0xF8, 0x7E, 0x00, 0x1F, 0xFE, 0x0F, 0xC0, 0x07, 0xFF, 0xC1,
  0xF8, 0x00, 0xFF, 0xF8, 0x7E, 0x00, 0x1F, 0xFF, 0x0F, 0xC0, 0x00, 0x07,
  0xC1, 0xF8, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x1F, 0x03, 0xF0,
  0x00, 0x03, 0xE0, 0x7E, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0x81,
  0xF8, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x7F, 0x00, 0x03, 0xF0, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0xFE, 0x00,
  0x0F, 0x80, 0x1F, 0xE0, 0x01, 0xF0, 0x01, 0xFF, 0xC7, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x0F, 0x80, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0x03, 0xE0, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0xFC,
  0x00, 0x03, 0xE0, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0xFC, 0x00,
  0x03, 0xE0, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x01,
  0xF0, 0x00, 0x0F, 0xC0, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x03,
  0xE0, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x07, 0xC0, 0x00,
  0x3F, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x07, 0xC0, 0x00, 0x3F,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x41, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0xF8, 0x00,
  0x7F, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0x1F, 0x00, 0x3F, 0x80, 0x03, 0xE0, 0x07, 0xE0, 0x00,
  0xFC, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x03, 0xF0, 0x1F, 0xC0,
  0x00, 0x7C, 0x07, 0xF0, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x03, 0xF0, 0x3F,
  0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x01, 0xF0,
  0xFE, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x01,
  0xF9, 0xFC, 0x00, 0x00, 0x3E, 0x7F, 0x00, 0x00, 0x07, 0xCF, 0xC0, 0x00,
  0x01, 0xFB, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFD,
  0xF8, 0x00, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x03,
  0xE0, 0x7E, 0x00, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x03, 0xF0, 0x1F, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x7E,
  0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x1F, 0x80, 0x01, 0xF0, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0xFB, 0xE0, 0x00,
  0x1F, 0x7C, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0xFB, 0xE0, 0x00,
  0x3F, 0xFC, 0x00, 0xFB, 0xE0, 0x00, 0x3E, 0xFC, 0x01, 0xFB, 0xE0, 0x00,
  0x7E, 0xF8, 0x01, 0xF3, 0xE0, 0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xE0, 0x00,
  0xFD, 0xF8, 0x01, 0xF3, 0xE0, 0x00, 0xF9, 0xF8, 0x03, 0xF3, 0xE0, 0x01,
  0xF9, 0xF0, 0x03, 0xF3, 0xE0, 0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x03,
  0xF3, 0xF0, 0x03, 0xE3, 0xE0, 0x03, 0xE3, 0xF0, 0x03, 0xE3, 0xE0, 0x07,
  0xE3, 0xF0, 0x07, 0xE3, 0xE0, 0x07, 0xC3, 0xE0, 0x07, 0xE3, 0xE0, 0x07,
  0xC3, 0xE0, 0x07, 0xC3, 0xE0, 0x0F, 0x87, 0xE0, 0x07, 0xC1, 0xF0, 0x0F,
  0x87, 0xE0, 0x07, 0xC1, 0xF0, 0x1F, 0x07, 0xE0, 0x0F, 0xC1, 0xF0, 0x1F,
  0x07, 0xC0, 0x0F, 0xC1, 0xF0, 0x3E, 0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x3E,
  0x0F, 0xC0, 0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0xC0, 0x0F, 0x81, 0xF0, 0x7C,
  0x0F, 0xC0, 0x1F, 0x81, 0xF0, 0xF8, 0x0F, 0x80, 0x1F, 0x01, 0xF0, 0xF8,
  0x1F, 0x80, 0x1F, 0x01, 0xF1, 0xF0, 0x1F, 0x80, 0x1F, 0x01, 0xF1, 0xF0,
  0x1F, 0x80, 0x3F, 0x01, 0xF3, 0xE0, 0x1F, 0x00, 0x3F, 0x01, 0xF3, 0xE0,
  0x1F, 0x00, 0x3E, 0x01, 0xF7, 0xC0, 0x3F, 0x00, 0x3E, 0x01, 0xF7, 0xC0,
  0x3F, 0x00, 0x3E, 0x00, 0xFF, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xFF, 0x80,
  0x3E, 0x00, 0x7E, 0x00, 0xFF, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xFF, 0x00,
  0x7E, 0x00, 0x7C, 0x00, 0xFF, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFE, 0x00,
  0x7E, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x3E, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x03,
  0xFC, 0x00, 0x03, 0xE0, 0x07, 0xF8, 0x00, 0x07, 0xC0, 0x0F, 0xF8, 0x00,
  0x0F, 0x80, 0x1F, 0xF0, 0x00, 0x3F, 0x00, 0x3F, 0xE0, 0x00, 0x7E, 0x00,
  0xFF, 0xC0, 0x00, 0xF8, 0x01, 0xFF, 0xC0, 0x01, 0xF0, 0x03, 0xEF, 0x80,
  0x07, 0xE0, 0x07, 0xDF, 0x00, 0x0F, 0xC0, 0x0F, 0xBE, 0x00, 0x1F, 0x00,
  0x3F, 0x7E, 0x00, 0x3E, 0x00, 0x7C, 0xFC, 0x00, 0x7C, 0x00, 0xF8, 0xF8,
  0x01, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xF0, 0x07, 0xE3, 0xE0, 0x07, 0xC0,
  0x0F, 0xC7, 0xE0, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x0F,
  0x80, 0x7E, 0x00, 0x7C, 0x1F, 0x00, 0xFC, 0x01, 0xF8, 0x3F, 0x01, 0xF0,
  0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x0F, 0x80,
  0xF8, 0x1F, 0x80, 0x1F, 0x01, 0xF0, 0x3F, 0x00, 0x7E, 0x03, 0xF0, 0x7C,
  0x00, 0xFC, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x07, 0xC3, 0xF0, 0x03, 0xE0,
  0x0F, 0x87, 0xE0, 0x07, 0xC0, 0x1F, 0x8F, 0x80, 0x1F, 0x80, 0x1F, 0x1F,
  0x00, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0xFC, 0x00, 0xF8,
  0x00, 0xFD, 0xF8, 0x03, 0xF0, 0x00, 0xFB, 0xE0, 0x07, 0xE0, 0x01, 0xF7,
  0xC0, 0x0F, 0x80, 0x03, 0xEF, 0x80, 0x1F, 0x00, 0x07, 0xDF, 0x00, 0x3E,
  0x00, 0x0F, 0xFE, 0x00, 0xFC, 0x00, 0x0F, 0xF8, 0x01, 0xF8, 0x00, 0x1F,
  0xF0, 0x03, 0xE0, 0x00, 0x3F, 0xE0, 0x07, 0xC0, 0x00, 0x7F, 0xC0, 0x0F,
  0x80, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x01,
  0xFC, 0x00, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x07, 0xF0, 0x07,
  0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0xFE, 0x00,
  0x07, 0xE0, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0xFC, 0x3F,
  0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x03, 0xF3,
  0xF8, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x0F,
  0xCF, 0xC0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00,
  0x7E, 0x7E, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x07, 0xE7, 0xE0, 0x00,
  0x01, 0xF9, 0xF8, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x3F, 0x3F, 0x00,
  0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x01, 0xF8, 0xFC,
  0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x07,
  0xE0, 0x1F, 0xC0, 0x03, 0xF8, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x01,
  0xFE, 0x00, 0x3F, 0xFB, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80,
  0x0F, 0xC7, 0xFF, 0x00, 0x1F, 0x00, 0xFF, 0x00, 0x3E, 0x00, 0xFE, 0x00,
  0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x01, 0xF8, 0x07,
  0xC0, 0x03, 0xF0, 0x0F, 0x80, 0x07, 0xE0, 0x3F, 0x00, 0x0F, 0xC0, 0x7E,
  0x00, 0x1F, 0x00, 0xFC, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0xFC, 0x07, 0xE0,
  0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0x80, 0x0F, 0xC0, 0x3E, 0x00,
  0x1F, 0x80, 0x7C, 0x00, 0x7E, 0x01, 0xF8, 0x01, 0xFC, 0x03, 0xF0, 0x0F,
  0xF0, 0x07, 0xE0, 0x7F, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x1F, 0xF0, 0x3F, 0xC0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFE,
  0x01, 0xFC, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00,
  0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x0F, 0xC3, 0xF8, 0x00,
  0x03, 0xF0, 0xFC, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x3F, 0x1F, 0x80,
  0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x00, 0xFC, 0xFC,
  0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x03, 0xF7,
  0xE0, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x1F,
  0x9F, 0x80, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00,
  0x7E, 0xFC, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00,
  0x03, 0xF3, 0xF0, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x7E, 0x3F, 0x00,
  0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x01, 0xFC, 0x3F, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3F, 0x81,
  0xF8, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x07, 0xE0, 0x1F, 0xC0, 0x03, 0xF8,
  0x03, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0x3F, 0xFB, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xC7, 0xFF, 0x00, 0x1F, 0x00,
  0xFF, 0x00, 0x3E, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x00,
  0xFC, 0x03, 0xF0, 0x01, 0xF8, 0x07, 0xC0, 0x03, 0xF0, 0x0F, 0x80, 0x07,
  0xE0, 0x3F, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x7E,
  0x01, 0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xF0,
  0x1F, 0x80, 0x0F, 0xC0, 0x3F, 0x00, 0x3F, 0x80, 0x7C, 0x00, 0xFE, 0x01,
  0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x1F, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x07, 0xC0,
  0xFC, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x7E, 0x03,
  0xF0, 0x00, 0xF8, 0x07, 0xE0, 0x03, 0xF0, 0x07, 0xC0, 0x07, 0xE0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E,
  0x00, 0xFC, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0xFC, 0x03, 0xF0, 0x01, 0xF8,
  0x07, 0xC0, 0x03, 0xF0, 0x0F, 0x80, 0x03, 0xF0, 0x3F, 0x00, 0x07, 0xE0,
  0x7E, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xF8, 0x1F, 0x80, 0x3F, 0xC0, 0x06, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7E, 0x01, 0x00, 0x03, 0xFC, 0x03, 0xC0, 0x0F, 0xF0, 0x07, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xE0, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x00, 0xFC, 0x07,
  0xE0, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x00, 0xFC,
  0x03, 0xE0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x03, 0xE0, 0x1F, 0x80, 0x00,
  0x7C, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x03, 0xF0, 0x0F, 0x80,
  0x00, 0x7E, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x03, 0xF0, 0x0F,
  0xC0, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x01, 0xF8,
  0x0F, 0xC0, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x01,
  0xF8, 0x07, 0xC0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x3F, 0x00,
  0x00, 0xF8, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x1F,
  0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x03, 0xE0,
  0x1F, 0x80, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x03,
  0xF0, 0x1F, 0x80, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x7E, 0x00,
  0x03, 0xF0, 0x0F, 0x80, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x7E,
  0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x3F, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x1F, 0x80, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x80,
  0x3F, 0x80, 0x07, 0xFF, 0x7F, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xF3,
  0xF0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x7F, 0x3F, 0x00, 0x01, 0xF8, 0xFC,
  0x00, 0x07, 0xE3, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x03,
  0xF0, 0x1F, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x7E, 0x01, 0xF0, 0x01, 0xF0,
  0x07, 0xC0, 0x0F, 0xC0, 0x1F, 0x00, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x01,
  0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x3F, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x7C,
  0x03, 0xE0, 0x01, 0xF0, 0x1F, 0x80, 0x07, 0xC0, 0x7C, 0x00, 0x1F, 0x03,
  0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF0, 0x7E, 0x00, 0x07, 0xC1, 0xF8,
  0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x7C, 0x3F, 0x00, 0x01, 0xF0, 0xF8, 0x00,
  0x07, 0xC7, 0xE0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x01,
  0xF3, 0xE0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x7D,
  0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7C, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFC, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x3F,
  0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xF0, 0xFC, 0x00, 0x7F,
  0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7B,
  0xE0, 0x07, 0xE0, 0xFC, 0x00, 0xFB, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0xFB,
  0xE0, 0x07, 0xC0, 0xFC, 0x01, 0xF3, 0xE0, 0x0F, 0xC0, 0xFC, 0x01, 0xF3,
  0xE0, 0x0F, 0x80, 0xFC, 0x03, 0xE3, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xE3,
  0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xE3, 0xE0, 0x1F, 0x00, 0xFC, 0x07, 0xC3,
  0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xC3, 0xE0, 0x3E, 0x00, 0xFC, 0x0F, 0x83,
  0xE0, 0x7E, 0x00, 0xFC, 0x0F, 0x83, 0xE0, 0x7E, 0x00, 0xFC, 0x0F, 0x83,
  0xE0, 0x7C, 0x00, 0xFC, 0x1F, 0x03, 0xE0, 0xFC, 0x00, 0xFC, 0x1F, 0x03,
  0xE0, 0xF8, 0x00, 0xFC, 0x3E, 0x03, 0xE1, 0xF8, 0x00, 0xFC, 0x3E, 0x03,
  0xE1, 0xF0, 0x00, 0xFC, 0x3C, 0x03, 0xE1, 0xF0, 0x00, 0xFC, 0x7C, 0x03,
  0xE3, 0xF0, 0x00, 0xF8, 0x7C, 0x03, 0xE3, 0xE0, 0x00, 0xF8, 0xF8, 0x03,
  0xE7, 0xE0, 0x00, 0xF8, 0xF8, 0x03, 0xE7, 0xC0, 0x00, 0xF9, 0xF0, 0x03,
  0xC7, 0xC0, 0x00, 0xF9, 0xF0, 0x03, 0xCF, 0xC0, 0x00, 0xF9, 0xF0, 0x03,
  0xCF, 0x80, 0x00, 0xFB, 0xE0, 0x03, 0xCF, 0x80, 0x00, 0xFB, 0xE0, 0x03,
  0xDF, 0x00, 0x00, 0xFB, 0xC0, 0x03, 0xDF, 0x00, 0x00, 0xFF, 0xC0, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x00, 0x3F, 0x01,
  0xF8, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x00,
  0x3E, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x00, 0x0F, 0xC7, 0xE0,
  0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x00, 0x0F,
  0xBF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x00, 0x3F,
  0x7C, 0x00, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00,
  0x01, 0xF8, 0xFC, 0x00, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x00, 0xF8, 0x1F,
  0x00, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x07,
  0xE0, 0x3F, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0x7E, 0x00, 0x07, 0xE7, 0xC0, 0x01, 0xF8, 0xF8, 0x00, 0x7E, 0x1F, 0x00,
  0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x81,
  0xF8, 0x03, 0xF0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x07,
  0xE0, 0x0F, 0x80, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x03,
  0xE1, 0xF8, 0x00, 0x7C, 0x7E, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF3, 0xF0,
  0x00, 0x3E, 0x7C, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x02, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xFF, 0x80, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF,
  0xF0, 0x00, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xE0, 0x3E, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07,
  0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x3E, 0x03, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00,
  0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00,
  0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xEF, 0x80,
  0x00, 0x1F, 0x7C, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x0F, 0x8F, 0x80, 0x00,
  0xF8, 0x7C, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x03, 0xE0,
  0x7C, 0x00, 0x3E, 0x03, 0xE0, 0x01, 0xF0, 0x0F, 0x80, 0x1F, 0x00, 0x7C,
  0x01, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x0F, 0x80, 0xF8, 0x00, 0x7C, 0x07,
  0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x3E, 0x00,
  0x01, 0xF1, 0xF0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x01,
  0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFC, 0x3F, 0x87, 0xE1, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x0F,
  0x81, 0xE0, 0x3C, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFF, 0x87, 0xC0, 0x1F,
  0xFE, 0x3E, 0x01, 0xFF, 0xF9, 0xF0, 0x1F, 0xFF, 0xDF, 0x01, 0xFE, 0x0F,
  0xF8, 0x0F, 0xC0, 0x3F, 0xC0, 0xFC, 0x01, 0xFE, 0x0F, 0xE0, 0x07, 0xF0,
  0x7E, 0x00, 0x3F, 0x07, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x7E, 0x1F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x07, 0xE0, 0x00,
  0xF8, 0x7E, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x03, 0xE0,
  0xFC, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x7E, 0x1F, 0x80, 0x03, 0xE0, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x01,
  0xF8, 0x3F, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0xFE, 0x0F, 0xC0, 0x0F, 0xE0,
  0x7E, 0x00, 0x7F, 0x03, 0xF0, 0x07, 0xF8, 0x0F, 0xC0, 0x77, 0xC0, 0x7F,
  0x0F, 0xBE, 0x03, 0xFF, 0xFB, 0xE0, 0x0F, 0xFF, 0x9F, 0x00, 0x3F, 0xF8,
  0xF8, 0x00, 0xFF, 0x07, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF0, 0xFF, 0x80, 0x0F,
  0x9F, 0xFE, 0x00, 0x7D, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x3E, 0xF0,
  0x7F, 0x01, 0xFF, 0x01, 0xF8, 0x0F, 0xF0, 0x07, 0xC0, 0x7F, 0x00, 0x3F,
  0x07, 0xF0, 0x01, 0xF8, 0x3F, 0x80, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x0F,
  0xC0, 0x03, 0xF0, 0x7C, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0xF8, 0x3F, 0x00,
  0x07, 0xC1, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x1F,
  0x87, 0xE0, 0x00, 0xFC, 0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x7E, 0x0F,
  0x80, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x01, 0xF8, 0x3F, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0xFE, 0x00, 0x3F,
  0x07, 0xF0, 0x03, 0xF0, 0x3F, 0x80, 0x3F, 0x81, 0xFE, 0x03, 0xF8, 0x1F,
  0xF8, 0x3F, 0x80, 0xFB, 0xFF, 0xF8, 0x07, 0xCF, 0xFF, 0x80, 0x3C, 0x3F,
  0xF8, 0x01, 0xE0, 0xFF, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFE, 0x01, 0xFF,
  0xFE, 0x03, 0xFC, 0x04, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x40, 0x7F, 0x83,
  0xC0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x07, 0xFF,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xE0, 0xF8, 0x00, 0x3F, 0xF0, 0xF8,
  0x00, 0x7F, 0xF9, 0xF8, 0x00, 0xFF, 0xFD, 0xF8, 0x01, 0xFF, 0xFD, 0xF0,
  0x03, 0xF8, 0x1F, 0xF0, 0x03, 0xF0, 0x0F, 0xF0, 0x07, 0xE0, 0x07, 0xF0,
  0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xC0, 0x07, 0xE0, 0x1F, 0x80, 0x07, 0xE0,
  0x1F, 0x80, 0x07, 0xE0, 0x1F, 0x80, 0x07, 0xE0, 0x3F, 0x00, 0x07, 0xC0,
  0x3F, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x0F, 0xC0,
  0x7E, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x0F, 0x80,
  0x7C, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0xFC, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFE, 0x00,
  0xFC, 0x01, 0xFE, 0x00, 0xFC, 0x01, 0xFE, 0x00, 0x7E, 0x03, 0xBE, 0x00,
  0x7F, 0x0F, 0xFC, 0x00, 0x7F, 0xFF, 0x7C, 0x00, 0x3F, 0xFE, 0x7C, 0x00,
  0x1F, 0xFC, 0x7C, 0x00, 0x0F, 0xF0, 0x7C, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF,
  0xE0, 0x1F, 0xF7, 0xF0, 0x1F, 0xC0, 0xFC, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0,
  0x1F, 0x0F, 0xC0, 0x0F, 0x87, 0xE0, 0x07, 0xC7, 0xE0, 0x07, 0xE3, 0xF0,
  0x03, 0xE3, 0xF0, 0x03, 0xF1, 0xF8, 0x03, 0xF8, 0xF8, 0x03, 0xF8, 0xFC,
  0x07, 0xF8, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x60, 0x7F, 0x80, 0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x1F, 0x00, 0x0F, 0xFF, 0x1F,
  0x00, 0x1F, 0xFF, 0x9F, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0x03, 0xFE,
  0x00, 0x7E, 0x01, 0xFE, 0x00, 0xFC, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0xFE,
  0x01, 0xF8, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0xFC,
  0x03, 0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0xF8,
  0x07, 0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x01, 0xF8, 0x0F, 0xC0, 0x01, 0xF8,
  0x0F, 0xC0, 0x01, 0xF0, 0x0F, 0xC0, 0x01, 0xF0, 0x0F, 0x80, 0x03, 0xF0,
  0x1F, 0x80, 0x03, 0xF0, 0x1F, 0x80, 0x03, 0xF0, 0x1F, 0x80, 0x07, 0xE0,
  0x1F, 0x80, 0x07, 0xE0, 0x1F, 0x80, 0x07, 0xE0, 0x1F, 0x80, 0x0F, 0xE0,
  0x1F, 0x80, 0x0F, 0xE0, 0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0xC0,
  0x1F, 0x80, 0x7F, 0xC0, 0x0F, 0xC0, 0xFF, 0xC0, 0x0F, 0xE1, 0xFF, 0x80,
  0x0F, 0xFF, 0xEF, 0x80, 0x07, 0xFF, 0xCF, 0x80, 0x03, 0xFF, 0x9F, 0x80,
  0x01, 0xFE, 0x1F, 0x80, 0x00, 0x38, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x80, 0x01, 0xF8, 0x00, 0xF0, 0x03, 0xF8, 0x00,
  0xFF, 0x1F, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x87, 0xF0, 0x01, 0xF1, 0xFF, 0xC0, 0x1F, 0x3F, 0xFE, 0x01,
  0xF7, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xEF, 0x07, 0xF0, 0x3F, 0xC0,
  0x3F, 0x03, 0xF8, 0x03, 0xF0, 0x3F, 0x80, 0x3F, 0x07, 0xF0, 0x03, 0xF0,
  0x7F, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xE0, 0x7E, 0x00, 0x3E, 0x07, 0xC0,
  0x03, 0xE0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0xF8, 0x00, 0x7C,
  0x0F, 0x80, 0x07, 0xC1, 0xF8, 0x00, 0x7C, 0x1F, 0x80, 0x0F, 0xC1, 0xF8,
  0x00, 0xFC, 0x1F, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0xF8, 0x3F, 0x00, 0x1F,
  0x83, 0xF0, 0x01, 0xF8, 0x3E, 0x00, 0x1F, 0x83, 0xE0, 0x01, 0xF0, 0x3E,
  0x00, 0x1F, 0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xC0, 0x03,
  0xF0, 0x7C, 0x00, 0x3E, 0x0F, 0xC0, 0x03, 0xE0, 0xFC, 0x00, 0x7E, 0x0F,
  0xC0, 0x07, 0xE0, 0xF8, 0x00, 0x7C, 0x0F, 0x80, 0x07, 0xC0, 0x00, 0x1E,
  0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0x80,
  0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x01, 0x01, 0xF8, 0x03,
  0xF0, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x3F, 0x01, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0x81, 0xF8, 0x00, 0x7C,
  0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF0, 0xFC,
  0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x7C, 0xFC, 0x00, 0x07, 0xEF, 0xE0, 0x00,
  0x3E, 0x7E, 0x00, 0x01, 0xF7, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xDF, 0x80, 0x01, 0xFC, 0x7C,
  0x00, 0x0F, 0xC3, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00,
  0x3E, 0x03, 0xE0, 0x01, 0xF0, 0x1F, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0xFC,
  0x07, 0xE0, 0x07, 0xE0, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x07,
  0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x00, 0xF8, 0x07, 0xE0, 0x07, 0xE0,
  0x3E, 0x00, 0x3F, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0,
  0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80,
  0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x1F, 0x1F,
  0xF8, 0x1F, 0xF8, 0x01, 0xE3, 0xFF, 0xC3, 0xFF, 0xC0, 0x1E, 0x7F, 0xFE,
  0x7F, 0xFE, 0x03, 0xEF, 0xFF, 0xEF, 0xFF, 0xE0, 0x3E, 0xF0, 0x7F, 0xF0,
  0x7E, 0x03, 0xFC, 0x07, 0xFC, 0x03, 0xF0, 0x3F, 0x80, 0x3F, 0xC0, 0x3F,
  0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x7F, 0x00, 0x3F, 0x00, 0x3E, 0x07,
  0xE0, 0x03, 0xF0, 0x03, 0xE0, 0x7E, 0x00, 0x7E, 0x00, 0x3E, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x7C, 0x00, 0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x07,
  0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0xC0,
  0x07, 0xC0, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0x80, 0x0F,
  0xC1, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0x81,
  0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x1F, 0x00, 0x1F, 0x80, 0x1F, 0x83, 0xF0,
  0x01, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x03,
  0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x03, 0xE0, 0x03, 0xF0,
  0x03, 0xF0, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xE0,
  0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0xFC,
  0x00, 0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0xF8, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x3F, 0x80, 0x07, 0xC7, 0xFF, 0x00,
  0x3E, 0x7F, 0xFC, 0x01, 0xE7, 0xFF, 0xE0, 0x1F, 0x7F, 0xFF, 0x80, 0xFB,
  0xC1, 0xFC, 0x07, 0xFC, 0x07, 0xE0, 0x3F, 0xC0, 0x3F, 0x01, 0xFC, 0x01,
  0xF8, 0x1F, 0xC0, 0x0F, 0xC0, 0xFE, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF0,
  0x3F, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0xFC,
  0x00, 0x7E, 0x07, 0xC0, 0x03, 0xF0, 0x3E, 0x00, 0x1F, 0x03, 0xF0, 0x01,
  0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0x7E, 0x07, 0xC0, 0x03, 0xE0,
  0x3E, 0x00, 0x1F, 0x03, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0xFC,
  0x00, 0x7E, 0x07, 0xC0, 0x03, 0xE0, 0x7E, 0x00, 0x1F, 0x03, 0xF0, 0x01,
  0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0xF8, 0x00, 0x7E, 0x07, 0xC0, 0x03, 0xE0,
  0x7E, 0x00, 0x3F, 0x03, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0xF8,
  0x00, 0x7C, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF8,
  0x07, 0xF0, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0x7E, 0x0F, 0xC0,
  0x07, 0xC1, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF1,
  0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x0F, 0xCF, 0x80, 0x01, 0xF9, 0xF0, 0x00,
  0x3F, 0x7E, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0xF9, 0xF8, 0x00, 0x3F, 0x3E,
  0x00, 0x07, 0xE7, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x1F, 0x3F, 0x00, 0x07,
  0xE7, 0xE0, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0x9F, 0x80, 0x07, 0xE3, 0xF0,
  0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE0, 0xF8, 0x01, 0xF8,
  0x1F, 0x80, 0x7F, 0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0x87, 0xF0, 0x07, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x87, 0xFE,
  0x00, 0x07, 0xC7, 0xFF, 0x00, 0x03, 0xCF, 0xFF, 0xC0, 0x03, 0xE7, 0xFF,
  0xF0, 0x01, 0xF7, 0x81, 0xF8, 0x00, 0xFF, 0x80, 0xFC, 0x00, 0x7F, 0x80,
  0x3E, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0x0F, 0xC0, 0x1F, 0xC0,
  0x07, 0xE0, 0x0F, 0xC0, 0x03, 0xF0, 0x07, 0xE0, 0x01, 0xF8, 0x03, 0xF0,
  0x00, 0xFC, 0x03, 0xF0, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0xFC,
  0x00, 0x1F, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x0F, 0xC0, 0x3F,
  0x00, 0x07, 0xE0, 0x1F, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x03, 0xF0, 0x07,
  0xC0, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x7C, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x7F, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0,
  0x0F, 0xF0, 0x1F, 0xC0, 0x07, 0xFC, 0x1F, 0xC0, 0x07, 0xEF, 0xFF, 0xC0,
  0x03, 0xE7, 0xFF, 0xC0, 0x01, 0xF1, 0xFF, 0xC0, 0x00, 0xF8, 0x7F, 0xC0,
  0x00, 0x7C, 0x0E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFF, 0xC7, 0xC0, 0x1F, 0xFE, 0x3E, 0x01, 0xFF, 0xF9, 0xF0, 0x1F, 0xFF,
  0xDF, 0x01, 0xFC, 0x0F, 0xF8, 0x0F, 0xC0, 0x3F, 0xC0, 0xFC, 0x01, 0xFE,
  0x0F, 0xE0, 0x07, 0xF0, 0x7E, 0x00, 0x3F, 0x03, 0xE0, 0x01, 0xF8, 0x3F,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x03, 0xE0, 0xFC, 0x00,
  0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x7E, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7E,
  0x1F, 0x80, 0x03, 0xE0, 0xFC, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF8, 0x7E,
  0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00,
  0x3F, 0x07, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0xFE,
  0x0F, 0xC0, 0x0F, 0xE0, 0x7E, 0x00, 0xFF, 0x03, 0xF0, 0x0F, 0xF8, 0x0F,
  0xC0, 0xFF, 0xC0, 0x7F, 0x0F, 0xFC, 0x03, 0xFF, 0xFB, 0xE0, 0x0F, 0xFF,
  0x9F, 0x00, 0x3F, 0xF9, 0xF8, 0x00, 0xFF, 0x0F, 0xC0, 0x00, 0xE0, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x10, 0x7E, 0x03,
  0xC3, 0xFC, 0x07, 0x8F, 0xF0, 0x0F, 0x3F, 0xE0, 0x3E, 0xFF, 0xC0, 0x7D,
  0xF9, 0x80, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xFE, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xF0,
  0x0C, 0x07, 0xE0, 0x04, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xE0, 0x80, 0x07, 0xE0, 0xC0, 0x0F, 0xE0, 0xF0, 0x3F, 0xC0, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8,
  0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x03, 0xFF, 0xF3,
  0xFF, 0xFC, 0xFF, 0xFF, 0x7F, 0xFF, 0x81, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x10, 0x1F, 0xFC, 0x07,
  0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x01, 0xC0, 0x00, 0x03, 0xF0, 0x01,
  0xF8, 0x1F, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x7C, 0x0F, 0xC0, 0x07, 0xE0,
  0x7E, 0x00, 0x3F, 0x03, 0xE0, 0x01, 0xF0, 0x1F, 0x00, 0x0F, 0x81, 0xF8,
  0x00, 0x7C, 0x0F, 0xC0, 0x07, 0xE0, 0x7C, 0x00, 0x3F, 0x03, 0xE0, 0x01,
  0xF0, 0x1F, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xE0,
  0x7C, 0x00, 0x3F, 0x03, 0xE0, 0x01, 0xF0, 0x3F, 0x00, 0x0F, 0x81, 0xF8,
  0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0x7C, 0x00, 0x3E, 0x03, 0xE0, 0x01,
  0xF0, 0x3F, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0xFC, 0x0F, 0x80, 0x07, 0xE0,
  0x7C, 0x00, 0x7E, 0x03, 0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x81, 0xF8,
  0x01, 0xFC, 0x0F, 0xC0, 0x1F, 0xE0, 0x7E, 0x01, 0xFE, 0x03, 0xF8, 0x1F,
  0xF0, 0x0F, 0xE3, 0xEF, 0x80, 0x7F, 0xFE, 0x7C, 0x03, 0xFF, 0xF3, 0xC0,
  0x0F, 0xFE, 0x1E, 0x00, 0x3F, 0xE0, 0xF0, 0x00, 0x38, 0x08, 0x00, 0x00,
  0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xBE, 0x00, 0x0F, 0xDF, 0x00, 0x0F,
  0xCF, 0x80, 0x07, 0xE7, 0xC0, 0x07, 0xE3, 0xE0, 0x03, 0xF1, 0xF0, 0x01,
  0xF0, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x80,
  0x7C, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x3F, 0x00, 0xF8,
  0x1F, 0x00, 0x7C, 0x1F, 0x80, 0x3E, 0x0F, 0xC0, 0x1F, 0x07, 0xC0, 0x0F,
  0x87, 0xE0, 0x07, 0xC3, 0xE0, 0x03, 0xE3, 0xF0, 0x01, 0xF1, 0xF0, 0x00,
  0xF9, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x3E, 0xFC, 0x00, 0x1F, 0x7C, 0x00,
  0x0F, 0xBE, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xF8, 0x00,
  0xFE, 0x00, 0x7E, 0xF8, 0x00, 0xFE, 0x00, 0x7C, 0xF8, 0x01, 0xFE, 0x00,
  0xFC, 0xF8, 0x01, 0xFE, 0x00, 0xFC, 0xF8, 0x03, 0xFE, 0x00, 0xF8, 0xF8,
  0x03, 0xFE, 0x01, 0xF8, 0xF8, 0x07, 0xFE, 0x01, 0xF0, 0xF8, 0x07, 0xFE,
  0x03, 0xF0, 0xF8, 0x07, 0xBE, 0x03, 0xE0, 0xF8, 0x0F, 0xBE, 0x03, 0xE0,
  0xF8, 0x0F, 0x3E, 0x07, 0xE0, 0xF8, 0x1F, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x3E, 0x0F, 0xC0, 0xF8, 0x1E, 0x3E, 0x0F, 0x80, 0xF8, 0x3E, 0x3E, 0x0F,
  0x80, 0xF8, 0x3C, 0x3E, 0x1F, 0x80, 0xF8, 0x7C, 0x3E, 0x1F, 0x00, 0xF8,
  0x7C, 0x3E, 0x3F, 0x00, 0xF8, 0x78, 0x3E, 0x3E, 0x00, 0xF8, 0xF8, 0x3E,
  0x3E, 0x00, 0xF8, 0xF0, 0x3E, 0x7C, 0x00, 0xF9, 0xF0, 0x3E, 0x7C, 0x00,
  0xF9, 0xF0, 0x3E, 0xFC, 0x00, 0xFB, 0xE0, 0x3E, 0xF8, 0x00, 0xFB, 0xE0,
  0x3E, 0xF8, 0x00, 0xFB, 0xC0, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x3D, 0xF0,
  0x00, 0xFF, 0xC0, 0x3D, 0xF0, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x7C, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x3E, 0x03,
  0xF0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x0F,
  0xC0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x1F, 0xBF,
  0x00, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x01, 0xF8, 0xF8,
  0x00, 0x01, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x07, 0xE0, 0x7C,
  0x00, 0x07, 0xC0, 0x7E, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0x80, 0x3E,
  0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0xFC, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x07, 0xE0,
  0x00, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x0F, 0xC0,
  0x00, 0xF8, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x0F,
  0x80, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x01, 0xF0,
  0x0F, 0x80, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00,
  0xF8, 0x1F, 0x80, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0xFC, 0x00,
  0x00, 0x7C, 0x1F, 0x00, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x01, 0xF0, 0xF8,
  0x00, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x00, 0x78,
  0xF8, 0x00, 0x00, 0x0F, 0x3E, 0x00, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x00,
  0x3D, 0xF0, 0x00, 0x00, 0x07, 0xBE, 0x00, 0x00, 0x00, 0xF7, 0xC0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x0C, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x13,
  0xFF, 0xC0, 0x03, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x7F, 0xFC, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0xC0, 0x03, 0xFF, 0xC8, 0x00, 0x0F, 0xF0,
};

const GFXglyph NotoSans_Condensed_Italic68pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 16, 50, 17, 1, -49 },
  { 101, 19, 18, 24, 7, -49 },
  { 144, 34, 49, 33, 1, -49 },
  { 353, 29, 56, 30, 1, -52 },
  { 556, 39, 50, 45, 4, -49 },
  { 800, 33, 50, 34, 0, -49 },
  { 1007, 9, 18, 13, 7, -49 },
  { 1028, 21, 60, 18, 2, -49 },
  { 1186, 21, 60, 18, -5, -49 },
  { 1344, 23, 25, 28, 7, -52 },
  { 1416, 27, 32, 32, 3, -40 },
  { 1524, 12, 17, 15, -3, -8 },
  { 1550, 16, 5, 19, 1, -21 },
  { 1560, 8, 9, 15, 1, -8 },
  { 1569, 31, 49, 23, -3, -49 },
  { 1759, 27, 50, 30, 2, -49 },
  { 1928, 18, 49, 30, 8, -49 },
  { 2039, 31, 49, 30, -2, -49 },
  { 2229, 30, 50, 30, 0, -49 },
  { 2417, 31, 49, 30, -1, -49 },
  { 2607, 30, 50, 30, 0, -49 },
  { 2795, 29, 50, 30, 2, -49 },
  { 2977, 29, 49, 30, 3, -49 },
  { 3155, 29, 50, 30, 1, -49 },
  { 3337, 28, 50, 30, 1, -49 },
  { 3512, 14, 38, 15, 0, -37 },
  { 3579, 17, 46, 15, -3, -37 },
  { 3677, 28, 31, 32, 3, -40 },
  { 3786, 27, 19, 32, 3, -33 },
  { 3851, 28, 31, 32, 3, -40 },
  { 3960, 23, 50, 23, 2, -49 },
  { 4104, 42, 55, 45, 2, -49 },
  { 4393, 31, 49, 31, -4, -49 },
  { 4583, 32, 49, 33, 1, -49 },
  { 4779, 32, 50, 30, 3, -49 },
  { 4979, 33, 49, 36, 1, -49 },
  { 5182, 30, 49, 28, 1, -49 },
  { 5366, 30, 49, 26, 1, -49 },
  { 5550, 35, 50, 37, 3, -49 },
  { 5769, 37, 49, 37, 1, -49 },
  { 5996, 27, 49, 19, -3, -49 },
  { 6162, 27, 62, 15, -10, -49 },
  { 6372, 35, 49, 31, 1, -49 },
  { 6587, 20, 49, 26, 1, -49 },
  { 6710, 48, 49, 48, 1, -49 },
  { 7004, 39, 49, 39, 1, -49 },
  { 7243, 34, 50, 38, 3, -49 },
  { 7456, 31, 49, 31, 1, -49 },
  { 7646, 34, 61, 38, 3, -49 },
  { 7906, 31, 49, 32, 1, -49 },
  { 8096, 31, 50, 28, -1, -49 },
  { 8290, 26, 49, 27, 6, -49 },
  { 8450, 35, 50, 36, 3, -49 },
  { 8669, 30, 49, 30, 6, -49 },
  { 8853, 48, 49, 49, 6, -49 },
  { 9147, 37, 49, 28, -4, -49 },
  { 9374, 27, 49, 27, 6, -49 },
  { 9540, 33, 49, 27, -2, -49 },
  { 9743, 26, 60, 19, -2, -49 },
  { 9938, 12, 49, 23, 7, -49 },
  { 10012, 26, 60, 19, -5, -49 },
  { 10207, 29, 28, 31, 1, -49 },
  { 10309, 23, 4, 23, -6, 6 },
  { 10321, 10, 11, 18, 10, -52 },
  { 10335, 29, 38, 32, 2, -37 },
  { 10473, 29, 53, 32, 1, -52 },
  { 10666, 24, 38, 24, 2, -37 },
  { 10780, 32, 53, 32, 2, -52 },
  { 10992, 25, 38, 28, 2, -37 },
  { 11111, 34, 68, 17, -8, -52 },
  { 11400, 32, 53, 32, -1, -37 },
  { 11612, 28, 52, 31, 1, -52 },
  { 11794, 15, 50, 14, 1, -50 },
  { 11888, 25, 66, 14, -9, -50 },
  { 12095, 29, 52, 27, 1, -52 },
  { 12284, 16, 52, 14, 1, -52 },
  { 12388, 44, 37, 47, 1, -37 },
  { 12592, 29, 37, 31, 0, -37 },
  { 12727, 27, 38, 31, 2, -37 },
  { 12856, 33, 53, 32, -3, -37 },
  { 13075, 29, 53, 32, 2, -37 },
  { 13268, 23, 37, 21, 1, -37 },
  { 13375, 24, 38, 24, 0, -37 },
  { 13489, 18, 46, 18, 2, -45 },
  { 13593, 29, 37, 31, 2, -36 },
  { 13728, 25, 36, 26, 4, -36 },
  { 13841, 40, 36, 41, 4, -36 },
  { 14021, 32, 36, 26, -3, -36 },
  { 14165, 35, 52, 26, -6, -36 },
  { 14393, 26, 36, 23, -2, -36 },
  { 14510, 26, 60, 23, 1, -49 },
  { 14705, 5, 68, 29, 12, -52 },
  { 14748, 25, 60, 23, -4, -49 },
  { 14936, 28, 8, 32, 3, -28 },
};

const GFXfont NotoSans_Condensed_Italic68pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Italic68pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Italic68pt7bGlyphs,
  0x20, 0x7E, 93
};

#endif // _NOTOSANS_CONDENSED_ITALIC68PT7B_H_
