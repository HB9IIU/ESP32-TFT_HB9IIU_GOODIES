#ifndef _NOTOSANS_CONDENSED_ITALIC45PT7B_H_
#define _NOTOSANS_CONDENSED_ITALIC45PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Italic.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Italic45pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x03, 0xC0, 0x70, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x0F, 0x81, 0xF0, 0x3C, 0x07, 0x80, 0x78, 0xF7, 0x8F,
  0x78, 0xF7, 0x0E, 0x70, 0xEF, 0x0E, 0xF1, 0xEE, 0x1C, 0xE1, 0xCE, 0x1C,
  0xC1, 0xC0, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x70, 0x00, 0xE0, 0xE0, 0x01,
  0xC1, 0xC0, 0x03, 0x87, 0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x38,
  0x30, 0x00, 0x60, 0xE0, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF0, 0x1C, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x70, 0xE0, 0x01, 0xC1, 0xC0,
  0x03, 0x83, 0x80, 0x07, 0x0E, 0x00, 0x0C, 0x1C, 0x03, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x03, 0x83, 0x80, 0x07, 0x06, 0x00, 0x0E,
  0x1C, 0x00, 0x38, 0x38, 0x00, 0x70, 0x70, 0x00, 0xE1, 0xC0, 0x03, 0x83,
  0x80, 0x07, 0x07, 0x00, 0x0E, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x7F, 0xC0, 0x1F,
  0xFF, 0x03, 0xFF, 0xE0, 0x78, 0xC6, 0x07, 0x18, 0x00, 0xF1, 0x80, 0x0F,
  0x18, 0x00, 0xF1, 0x80, 0x0F, 0x38, 0x00, 0xF3, 0x00, 0x07, 0xB0, 0x00,
  0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0,
  0x00, 0x6F, 0x00, 0x06, 0x78, 0x00, 0xC7, 0x80, 0x0C, 0x78, 0x00, 0xC7,
  0x80, 0x0C, 0x78, 0x01, 0xC7, 0x04, 0x18, 0xF0, 0x79, 0xFE, 0x07, 0xFF,
  0xC0, 0xFF, 0xF8, 0x00, 0xFC, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x01, 0x00, 0x00, 0x07, 0xE0,
  0x07, 0x07, 0xF8, 0x07, 0x03, 0x9C, 0x03, 0x83, 0x86, 0x03, 0x81, 0xC3,
  0x81, 0xC1, 0xC1, 0xC1, 0xC0, 0xE0, 0xC1, 0xC0, 0x60, 0xE0, 0xE0, 0x70,
  0x70, 0xE0, 0x38, 0x38, 0x70, 0x1C, 0x1C, 0x70, 0x0E, 0x0E, 0x78, 0x07,
  0x0E, 0x38, 0x63, 0x07, 0x38, 0xFD, 0x83, 0x9C, 0xFF, 0xE3, 0x9C, 0xF3,
  0xF3, 0x8E, 0x71, 0xFF, 0xCE, 0x70, 0xEF, 0xCE, 0x38, 0x71, 0x07, 0x38,
  0x38, 0x07, 0x1C, 0x1C, 0x03, 0x8E, 0x0E, 0x03, 0x87, 0x07, 0x03, 0xC3,
  0x83, 0x01, 0xC3, 0x83, 0x81, 0xC1, 0xC1, 0xC0, 0xE0, 0xE0, 0xE0, 0xE0,
  0x70, 0xE0, 0xF0, 0x38, 0x70, 0x70, 0x0E, 0xF0, 0x70, 0x07, 0xF0, 0x78,
  0x01, 0xF0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x3C, 0xF0, 0x01, 0xE1, 0xC0, 0x07, 0x07, 0x80, 0x3C, 0x1E, 0x00, 0xF0,
  0x70, 0x03, 0xC1, 0xC0, 0x0F, 0x0F, 0x00, 0x3C, 0x78, 0x00, 0xF1, 0xE0,
  0x01, 0xCF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0xF7, 0x83, 0xC7, 0x9E, 0x0E, 0x3C, 0x3C,
  0x79, 0xE0, 0xF1, 0xC7, 0x81, 0xEF, 0x1C, 0x07, 0xB8, 0xF0, 0x0F, 0xE3,
  0xC0, 0x3F, 0x0F, 0x00, 0x78, 0x3C, 0x03, 0xE0, 0xF0, 0x1F, 0xC1, 0xE0,
  0xFF, 0x07, 0xFF, 0xBE, 0x0F, 0xFC, 0x78, 0x1F, 0xE1, 0xF0, 0x7B, 0xDE,
  0xF7, 0x3B, 0xDC, 0xE7, 0x38, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x38,
  0x01, 0xE0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0,
  0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0xC0, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x78, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80,
  0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00,
  0x38, 0x01, 0xE0, 0x0F, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x40, 0xE0, 0x71, 0xC0, 0x7D, 0xC0, 0xFF,
  0xDF, 0x1F, 0xFF, 0x03, 0xFF, 0x07, 0xC0, 0x0F, 0xE0, 0x1E, 0xE0, 0x3C,
  0x70, 0x78, 0x70, 0x18, 0x78, 0x10, 0x30, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x0F, 0x1E,
  0x1E, 0x1C, 0x3C, 0x38, 0x78, 0x70, 0x70, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x77, 0xFF, 0xEF, 0x00, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x1F, 0xC0, 0x0F, 0xF8,
  0x07, 0xFF, 0x03, 0xC3, 0xC1, 0xE0, 0xF0, 0x78, 0x1C, 0x3C, 0x07, 0x0F,
  0x01, 0xC7, 0x80, 0x71, 0xE0, 0x1C, 0x70, 0x07, 0x3C, 0x01, 0xCF, 0x00,
  0x73, 0xC0, 0x3C, 0xE0, 0x0F, 0x78, 0x03, 0xDE, 0x00, 0xF7, 0x80, 0x39,
  0xE0, 0x1E, 0x70, 0x07, 0x9C, 0x01, 0xE7, 0x00, 0x73, 0xC0, 0x3C, 0xF0,
  0x0F, 0x3C, 0x07, 0x8F, 0x01, 0xE1, 0xC0, 0xF0, 0x78, 0x3C, 0x1E, 0x1E,
  0x07, 0xFF, 0x00, 0xFF, 0x80, 0x1F, 0xC0, 0x00, 0x00, 0xF0, 0x1F, 0x03,
  0xF0, 0xFE, 0x1F, 0xE3, 0xFE, 0xF9, 0xE7, 0x1E, 0x61, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0x80, 0x38, 0x07, 0x80, 0x78, 0x07, 0x80, 0x70, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1C,
  0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x07,
  0xFC, 0x01, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xC1, 0xF0, 0x18, 0x0F, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0x00, 0x08, 0x00, 0x0F, 0xF8,
  0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0x81, 0xE0, 0x20, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x3F, 0xC0, 0x03,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x80, 0x1E, 0x0C, 0x07, 0xE0, 0xFF, 0xFC,
  0x0F, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3B,
  0x80, 0x03, 0xBC, 0x00, 0x3D, 0xE0, 0x01, 0xCF, 0x00, 0x1C, 0x70, 0x01,
  0xE3, 0x80, 0x0E, 0x3C, 0x00, 0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0x70, 0x70,
  0x07, 0x07, 0x80, 0x70, 0x3C, 0x07, 0x81, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0x70, 0x3C, 0x07, 0x89, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE0,
  0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01,
  0xFF, 0xE0, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00,
  0x0E, 0xF0, 0x00, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0xF7, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x0F, 0x08, 0x01, 0xE0, 0xC0, 0x7E, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x07,
  0xFE, 0x00, 0x00, 0x07, 0x80, 0x0F, 0xF0, 0x07, 0xFC, 0x07, 0xFF, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x7E, 0x07, 0xBF, 0xC1,
  0xDF, 0xF8, 0x7E, 0x1F, 0x3F, 0x03, 0xCF, 0x80, 0xF3, 0xC0, 0x3C, 0xF0,
  0x0F, 0x3C, 0x03, 0xCE, 0x00, 0xF3, 0x80, 0x3C, 0xE0, 0x0E, 0x38, 0x07,
  0x8E, 0x01, 0xE3, 0xC0, 0xF0, 0xF0, 0x3C, 0x3E, 0x1E, 0x07, 0xFF, 0x80,
  0xFF, 0xC0, 0x1F, 0xC0, 0x00, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0xFF, 0xFF,
  0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38,
  0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0,
  0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0x00, 0x04, 0x00,
  0x07, 0xF8, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x03, 0xC1, 0xF0, 0x78, 0x0F,
  0x07, 0x80, 0xF0, 0x78, 0x0F, 0x07, 0x00, 0xF0, 0x70, 0x0F, 0x07, 0x80,
  0xE0, 0x78, 0x1E, 0x03, 0x83, 0xC0, 0x3C, 0x78, 0x01, 0xFF, 0x00, 0x0F,
  0xC0, 0x01, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0x9E, 0x01, 0xE0, 0xF0, 0x3C,
  0x0F, 0x07, 0x80, 0x78, 0x78, 0x07, 0x87, 0x00, 0x38, 0xF0, 0x03, 0x8F,
  0x00, 0x78, 0xF0, 0x07, 0x8F, 0x00, 0x78, 0x78, 0x0F, 0x07, 0xC1, 0xF0,
  0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x00, 0x10, 0x00, 0x3F,
  0x80, 0x3F, 0xF0, 0x1F, 0xFE, 0x07, 0x87, 0xC3, 0xC0, 0xF1, 0xE0, 0x3C,
  0x78, 0x07, 0x1C, 0x01, 0xCF, 0x00, 0x73, 0xC0, 0x1C, 0xF0, 0x0F, 0x3C,
  0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x7C, 0xF0, 0x1F, 0x3C, 0x0F, 0x8F, 0x87,
  0xE1, 0xFF, 0xF8, 0x3F, 0xDE, 0x07, 0xC7, 0x00, 0x01, 0xC0, 0x00, 0xF0,
  0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF8, 0x00, 0x7C, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0x83, 0xC3, 0xE1, 0xF0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x07, 0x87, 0xC3,
  0xE0, 0xE0, 0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xF0, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x81, 0xF0, 0x3C, 0x07, 0x81, 0xE0, 0x3C,
  0x07, 0x01, 0xE0, 0x38, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0xF0, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xF0, 0x00, 0x1C, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3C, 0x00,
  0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x00,
  0x0F, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x07, 0xF8, 0x1F, 0xFC, 0x1F,
  0xFE, 0x08, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0x0F, 0x80, 0x07, 0x80,
  0x3C, 0x00, 0xE0, 0x01, 0xE0, 0x1C, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x70,
  0x70, 0x00, 0x07, 0x07, 0x00, 0x80, 0x70, 0xE0, 0x7F, 0xC7, 0x1C, 0x0F,
  0xF8, 0x71, 0xC1, 0xE3, 0x87, 0x1C, 0x3C, 0x38, 0x73, 0x83, 0x83, 0x87,
  0x38, 0x70, 0x70, 0x73, 0x07, 0x07, 0x07, 0x70, 0xE0, 0x70, 0x77, 0x0E,
  0x07, 0x0E, 0x70, 0xE0, 0xE0, 0xE7, 0x0E, 0x0E, 0x0E, 0x60, 0xE0, 0xE0,
  0xC6, 0x1C, 0x1E, 0x1C, 0xE0, 0xE1, 0xE1, 0x8E, 0x0E, 0x3E, 0x38, 0xE0,
  0xFE, 0xFF, 0x06, 0x0F, 0xE7, 0xE0, 0x70, 0x78, 0x3C, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3B, 0xC0,
  0x03, 0xDE, 0x00, 0x1C, 0xF0, 0x01, 0xE7, 0x80, 0x0E, 0x3C, 0x00, 0xF1,
  0xE0, 0x07, 0x8F, 0x00, 0x38, 0x78, 0x03, 0xC3, 0xC0, 0x1C, 0x1E, 0x01,
  0xE0, 0xF0, 0x0F, 0x07, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFF,
  0x03, 0xFF, 0xF8, 0x3C, 0x03, 0xC1, 0xE0, 0x0E, 0x0F, 0x00, 0x70, 0xF0,
  0x03, 0x87, 0x80, 0x1C, 0x78, 0x00, 0xE3, 0xC0, 0x07, 0x3C, 0x00, 0x39,
  0xE0, 0x01, 0xFF, 0x00, 0x0F, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF,
  0xFC, 0x07, 0x03, 0xE0, 0x78, 0x0F, 0x83, 0xC0, 0x3C, 0x1E, 0x01, 0xE0,
  0xE0, 0x0F, 0x0F, 0x00, 0x78, 0x78, 0x07, 0x83, 0xC0, 0x3C, 0x1E, 0x03,
  0xC0, 0xE0, 0x3E, 0x0F, 0x07, 0xE0, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F,
  0xFF, 0x00, 0xE0, 0x3C, 0x0F, 0x00, 0xF0, 0x78, 0x07, 0x83, 0xC0, 0x3C,
  0x1E, 0x01, 0xE0, 0xE0, 0x0F, 0x0F, 0x00, 0x78, 0x78, 0x03, 0xC3, 0xC0,
  0x3E, 0x1C, 0x01, 0xE1, 0xE0, 0x1F, 0x0F, 0x03, 0xF0, 0x7F, 0xFF, 0x03,
  0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0x00, 0x01, 0xFF, 0x80, 0x1F,
  0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0x03, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x02, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x0F,
  0xFF, 0x00, 0x3F, 0xFE, 0x00, 0xE0, 0xFC, 0x07, 0x80, 0xF8, 0x1E, 0x01,
  0xE0, 0x78, 0x07, 0x81, 0xC0, 0x1F, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0xF0,
  0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x0E, 0x00, 0x3C, 0x78, 0x00, 0xF1, 0xE0,
  0x03, 0x87, 0x80, 0x1E, 0x1E, 0x00, 0x78, 0x70, 0x01, 0xE3, 0xC0, 0x07,
  0x8F, 0x00, 0x3C, 0x3C, 0x00, 0xF0, 0xF0, 0x03, 0xC3, 0x80, 0x1E, 0x1E,
  0x00, 0xF8, 0x78, 0x03, 0xC1, 0xE0, 0x1F, 0x07, 0x00, 0xF8, 0x3C, 0x07,
  0xC0, 0xF0, 0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xFF, 0xC0,
  0xFF, 0xF8, 0x1F, 0xFE, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xFF, 0xF0, 0x3F,
  0xFE, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xFF, 0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0x01, 0xC0, 0xFC,
  0x00, 0x81, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x0F, 0xF9, 0xE0, 0x1F, 0xF3,
  0xC0, 0x3F, 0xC7, 0x80, 0x07, 0x8F, 0x00, 0x0F, 0x1E, 0x00, 0x1E, 0x3C,
  0x00, 0x38, 0x78, 0x00, 0x70, 0xF0, 0x01, 0xE1, 0xE0, 0x03, 0xC3, 0xE0,
  0x07, 0x83, 0xC0, 0x0E, 0x07, 0xC0, 0x3C, 0x07, 0xC0, 0x78, 0x0F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x03, 0xC0, 0x0F, 0x03, 0xC0,
  0x0F, 0x03, 0xC0, 0x0F, 0x03, 0x80, 0x0E, 0x07, 0x80, 0x1E, 0x07, 0x80,
  0x1E, 0x07, 0x80, 0x1E, 0x07, 0x00, 0x1E, 0x07, 0x00, 0x1C, 0x0F, 0x00,
  0x3C, 0x0F, 0x00, 0x3C, 0x0F, 0x00, 0x3C, 0x0E, 0x00, 0x38, 0x1F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1C, 0x00,
  0x70, 0x3C, 0x00, 0xF0, 0x3C, 0x00, 0xF0, 0x3C, 0x00, 0xF0, 0x3C, 0x00,
  0xF0, 0x38, 0x00, 0xE0, 0x78, 0x01, 0xE0, 0x78, 0x01, 0xE0, 0x78, 0x01,
  0xE0, 0x70, 0x01, 0xC0, 0x70, 0x01, 0xC0, 0xF0, 0x03, 0xC0, 0xF0, 0x03,
  0xC0, 0xF0, 0x03, 0xC0, 0xE0, 0x03, 0x80, 0x01, 0xFF, 0xC0, 0xFF, 0xE0,
  0x07, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00,
  0x07, 0xE0, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xF8,
  0x00, 0x30, 0x00, 0x00, 0x03, 0xC0, 0x3E, 0x07, 0x80, 0x78, 0x0F, 0x01,
  0xE0, 0x1C, 0x07, 0x80, 0x78, 0x1F, 0x00, 0xF0, 0x7C, 0x01, 0xE0, 0xF0,
  0x03, 0x83, 0xC0, 0x0F, 0x0F, 0x00, 0x1E, 0x3E, 0x00, 0x3C, 0x78, 0x00,
  0x79, 0xE0, 0x00, 0xE7, 0x80, 0x03, 0xDF, 0x00, 0x07, 0xBC, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0xF9, 0xE0, 0x01, 0xE3,
  0xC0, 0x03, 0xC3, 0xC0, 0x07, 0x87, 0x80, 0x0E, 0x0F, 0x00, 0x3C, 0x1E,
  0x00, 0x78, 0x1E, 0x00, 0xF0, 0x3C, 0x01, 0xC0, 0x78, 0x07, 0x80, 0xF0,
  0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x70, 0x03, 0xC0,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0xFC,
  0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xC0,
  0xFE, 0x00, 0x3F, 0x81, 0xDC, 0x00, 0x7F, 0x03, 0xB8, 0x01, 0xFE, 0x0F,
  0x70, 0x03, 0xBC, 0x1E, 0xE0, 0x0F, 0x70, 0x3D, 0xC0, 0x1C, 0xE0, 0x73,
  0x80, 0x7B, 0xC0, 0xE7, 0x00, 0xE7, 0x83, 0xCE, 0x03, 0xCF, 0x07, 0x9C,
  0x07, 0x1C, 0x0F, 0x3C, 0x1E, 0x78, 0x1C, 0x78, 0x38, 0xF0, 0x38, 0xF0,
  0xF1, 0xE0, 0xF1, 0xE1, 0xC3, 0xC1, 0xE3, 0xC7, 0x87, 0x03, 0xC3, 0x8E,
  0x1E, 0x07, 0x07, 0x3C, 0x3C, 0x0E, 0x0E, 0x70, 0x78, 0x3C, 0x1C, 0xE0,
  0xE0, 0x78, 0x3B, 0x81, 0xC0, 0xE0, 0x77, 0x07, 0x81, 0xC0, 0xFC, 0x0F,
  0x07, 0x81, 0xF8, 0x1E, 0x0F, 0x03, 0xF0, 0x38, 0x1E, 0x07, 0xC0, 0xF0,
  0x38, 0x0F, 0x81, 0xE0, 0x70, 0x1E, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xC0,
  0xF8, 0x00, 0xE0, 0x3E, 0x00, 0x78, 0x0F, 0x80, 0x1E, 0x07, 0xF0, 0x07,
  0x81, 0xFC, 0x01, 0xC0, 0x77, 0x00, 0xF0, 0x1D, 0xC0, 0x3C, 0x0F, 0x78,
  0x0F, 0x03, 0xDE, 0x03, 0x80, 0xF3, 0x80, 0xE0, 0x38, 0xE0, 0x78, 0x0E,
  0x38, 0x1E, 0x07, 0x8F, 0x07, 0x81, 0xE3, 0xC1, 0xC0, 0x78, 0x70, 0x70,
  0x1C, 0x1C, 0x3C, 0x07, 0x07, 0x8F, 0x03, 0xC1, 0xE3, 0xC0, 0xF0, 0x38,
  0xE0, 0x3C, 0x0E, 0x38, 0x0E, 0x03, 0xDE, 0x03, 0x80, 0xF7, 0x81, 0xE0,
  0x1D, 0xC0, 0x78, 0x07, 0x70, 0x1C, 0x01, 0xDC, 0x07, 0x00, 0x7F, 0x03,
  0xC0, 0x1F, 0xC0, 0xF0, 0x03, 0xE0, 0x3C, 0x00, 0xF8, 0x0E, 0x00, 0x3E,
  0x03, 0x80, 0x0F, 0x80, 0x00, 0x06, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xFF,
  0x00, 0x7F, 0xFE, 0x03, 0xE0, 0xF8, 0x1F, 0x01, 0xF0, 0xF8, 0x03, 0xC3,
  0xC0, 0x0F, 0x1E, 0x00, 0x3C, 0x78, 0x00, 0x73, 0xE0, 0x01, 0xCF, 0x00,
  0x07, 0x3C, 0x00, 0x1D, 0xE0, 0x00, 0xF7, 0x80, 0x03, 0xDE, 0x00, 0x0F,
  0x78, 0x00, 0x3D, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1E, 0xF0,
  0x00, 0x7B, 0xC0, 0x01, 0xEF, 0x00, 0x0F, 0x3C, 0x00, 0x3C, 0xF0, 0x01,
  0xF3, 0xC0, 0x07, 0x8F, 0x00, 0x3E, 0x1E, 0x00, 0xF0, 0x78, 0x07, 0x81,
  0xF0, 0x7E, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x38, 0x3E, 0x07, 0x81, 0xF0,
  0x78, 0x0F, 0x07, 0x80, 0xF0, 0x70, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x0F,
  0x0F, 0x00, 0xF0, 0xF0, 0x1E, 0x0E, 0x01, 0xE1, 0xE0, 0x3E, 0x1E, 0x07,
  0xC1, 0xE0, 0xF8, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xF8, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xE0, 0xF8, 0x1F, 0x01, 0xF0,
  0xF8, 0x03, 0xC3, 0xC0, 0x0F, 0x1E, 0x00, 0x3C, 0x78, 0x00, 0x73, 0xE0,
  0x01, 0xCF, 0x00, 0x07, 0x3C, 0x00, 0x1D, 0xE0, 0x00, 0xF7, 0x80, 0x03,
  0xDE, 0x00, 0x0F, 0x78, 0x00, 0x3D, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x1E, 0xF0, 0x00, 0x7B, 0xC0, 0x01, 0xEF, 0x00, 0x0F, 0x3C, 0x00,
  0x3C, 0xF0, 0x01, 0xF3, 0xC0, 0x07, 0x8F, 0x00, 0x3E, 0x1E, 0x00, 0xF0,
  0x78, 0x07, 0x81, 0xF0, 0x7E, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00,
  0x03, 0xFF, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x38, 0x3E, 0x07, 0x81,
  0xF0, 0x78, 0x0F, 0x07, 0x80, 0xF0, 0x70, 0x0F, 0x0F, 0x00, 0xF0, 0xF0,
  0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x1E, 0x0E, 0x01, 0xE1, 0xE0, 0x3C, 0x1E,
  0x07, 0xC1, 0xFF, 0xF8, 0x1F, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x03,
  0xC3, 0x80, 0x3C, 0x3C, 0x03, 0xC3, 0xC0, 0x38, 0x3C, 0x07, 0x81, 0xC0,
  0x78, 0x1E, 0x07, 0x81, 0xE0, 0x70, 0x1E, 0x0F, 0x01, 0xE0, 0xF0, 0x0F,
  0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x0E, 0x00, 0xF8, 0x00, 0x0C, 0x00, 0x07,
  0xFE, 0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xC0, 0xE0, 0x78, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x80, 0x3E, 0x0E, 0x07, 0xE0, 0xFF,
  0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x1E, 0x0E, 0x00, 0x3C, 0x1C, 0x00, 0x70,
  0x78, 0x01, 0xE0, 0xF0, 0x03, 0xC1, 0xE0, 0x07, 0x83, 0x80, 0x0F, 0x0F,
  0x00, 0x1C, 0x1E, 0x00, 0x78, 0x3C, 0x00, 0xF0, 0x78, 0x01, 0xE0, 0xE0,
  0x03, 0x83, 0xC0, 0x07, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0x3C, 0x1E, 0x00,
  0x78, 0x38, 0x00, 0xE0, 0xF0, 0x03, 0xC1, 0xE0, 0x07, 0x83, 0xC0, 0x0F,
  0x07, 0x00, 0x1E, 0x1E, 0x00, 0x38, 0x3C, 0x00, 0xF0, 0x78, 0x01, 0xE0,
  0xF0, 0x03, 0xC1, 0xE0, 0x0F, 0x03, 0xC0, 0x1E, 0x07, 0xC0, 0x78, 0x07,
  0xC1, 0xF0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xF0,
  0x00, 0xFF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x3C, 0xF0, 0x03, 0xCF,
  0x00, 0x78, 0xF0, 0x07, 0x8F, 0x00, 0x78, 0xF0, 0x0F, 0x0F, 0x00, 0xF0,
  0xF0, 0x1E, 0x0F, 0x01, 0xE0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x78,
  0x07, 0x07, 0x80, 0x70, 0x70, 0x07, 0x0F, 0x00, 0x70, 0xE0, 0x07, 0x1E,
  0x00, 0x71, 0xE0, 0x07, 0x3C, 0x00, 0x73, 0xC0, 0x07, 0x38, 0x00, 0x77,
  0x80, 0x07, 0x70, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0xF0,
  0x03, 0xC0, 0x1E, 0xF0, 0x07, 0xC0, 0x1E, 0xF0, 0x07, 0xC0, 0x3C, 0xF0,
  0x0F, 0xC0, 0x3C, 0xF0, 0x0F, 0xC0, 0x38, 0xF0, 0x1F, 0xC0, 0x78, 0xF0,
  0x1D, 0xC0, 0x78, 0xF0, 0x1D, 0xC0, 0xF0, 0xF0, 0x39, 0xC0, 0xF0, 0xF0,
  0x39, 0xC0, 0xE0, 0xF0, 0x7B, 0xC1, 0xE0, 0xF0, 0x73, 0xC1, 0xE0, 0xF0,
  0x73, 0xC3, 0xC0, 0xF0, 0xE3, 0xC3, 0xC0, 0xF0, 0xE3, 0xC3, 0x80, 0xF1,
  0xE3, 0xC7, 0x80, 0xF1, 0xC3, 0xC7, 0x80, 0xF1, 0xC3, 0xCF, 0x00, 0xF3,
  0x83, 0xCF, 0x00, 0xF3, 0x83, 0xCE, 0x00, 0xF7, 0x83, 0xDE, 0x00, 0xF7,
  0x03, 0xDC, 0x00, 0xE7, 0x03, 0xBC, 0x00, 0xEE, 0x03, 0xBC, 0x00, 0xEE,
  0x03, 0xB8, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0xFC,
  0x03, 0xF0, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0xF0,
  0x03, 0xE0, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x07, 0x80, 0x3C, 0x03,
  0xC0, 0x0E, 0x03, 0xC0, 0x07, 0x83, 0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xE1,
  0xE0, 0x00, 0x70, 0xE0, 0x00, 0x38, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x0F,
  0x70, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x1E, 0xE0, 0x00, 0x0E, 0x70, 0x00, 0x0F, 0x3C, 0x00,
  0x0F, 0x1E, 0x00, 0x07, 0x8F, 0x00, 0x07, 0x83, 0x80, 0x03, 0x81, 0xC0,
  0x03, 0xC0, 0xF0, 0x03, 0xC0, 0x78, 0x01, 0xE0, 0x3C, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x07, 0x01, 0xF0, 0x03, 0xC0, 0xF0, 0x03, 0xFC, 0x01, 0xEF,
  0x00, 0x7B, 0xC0, 0x3C, 0x70, 0x1E, 0x1C, 0x07, 0x87, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x78, 0x1E, 0x1E, 0x03, 0x8F, 0x00, 0xE3, 0x80, 0x39, 0xE0,
  0x0E, 0x70, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xC0, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x1F, 0xFF,
  0xC0, 0xFF, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7F,
  0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x3F, 0xC0, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0xE1, 0xC3, 0x87, 0x0F, 0x1E, 0x1C,
  0x38, 0x70, 0xE1, 0xC3, 0xC7, 0x8F, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xE3,
  0xC7, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xF1, 0xE1, 0xC3, 0x87, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0,
  0x00, 0x70, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x00, 0x38, 0x00,
  0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xB8, 0x00,
  0xE7, 0x80, 0x1C, 0x70, 0x07, 0x0E, 0x00, 0xE1, 0xE0, 0x38, 0x1C, 0x0F,
  0x03, 0x81, 0xC0, 0x78, 0x78, 0x07, 0x0E, 0x00, 0xE3, 0xC0, 0x0E, 0x70,
  0x01, 0xDE, 0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xF3, 0xC7,
  0x9E, 0x38, 0x70, 0xC0, 0x00, 0x20, 0x00, 0x1F, 0xCF, 0x03, 0xFE, 0xE0,
  0x7F, 0xEE, 0x0F, 0x87, 0xE0, 0xF0, 0x3E, 0x1E, 0x03, 0xE1, 0xE0, 0x3C,
  0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x38, 0x03, 0xC7, 0x80, 0x38, 0x78, 0x03,
  0x87, 0x80, 0x78, 0x70, 0x07, 0x87, 0x00, 0x78, 0xF0, 0x0F, 0x0F, 0x00,
  0xF0, 0xF0, 0x0F, 0x0F, 0x01, 0xF0, 0x70, 0x3F, 0x07, 0x87, 0xE0, 0x7F,
  0xEE, 0x03, 0xFC, 0xE0, 0x1F, 0x8E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x20, 0x07, 0x9F, 0xC0, 0x7B,
  0xFC, 0x07, 0x7F, 0xE0, 0x7E, 0x1E, 0x0F, 0xC0, 0xE0, 0xF8, 0x0F, 0x0F,
  0x00, 0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0xF1, 0xE0, 0x0E, 0x1E, 0x00, 0xE1,
  0xE0, 0x1E, 0x1C, 0x01, 0xE1, 0xC0, 0x1E, 0x3C, 0x01, 0xC3, 0xC0, 0x3C,
  0x3C, 0x03, 0xC3, 0xC0, 0x78, 0x3C, 0x07, 0x87, 0xC0, 0xF0, 0x7E, 0x1F,
  0x07, 0x7F, 0xE0, 0x77, 0xFC, 0x0E, 0x3F, 0x80, 0x00, 0x18, 0x01, 0xFF,
  0x03, 0xFF, 0x07, 0xFE, 0x0F, 0x82, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00,
  0x78, 0x00, 0x78, 0x10, 0x7F, 0xF0, 0x3F, 0xF0, 0x1F, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00,
  0xC3, 0xC0, 0x1F, 0xCF, 0x00, 0xFF, 0xB8, 0x07, 0xFE, 0xE0, 0x3E, 0x1F,
  0x80, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0xF0, 0x0F, 0x03,
  0xC0, 0x3C, 0x0E, 0x00, 0xF0, 0x78, 0x03, 0x81, 0xE0, 0x0E, 0x07, 0x80,
  0x78, 0x1C, 0x01, 0xE0, 0x70, 0x07, 0x83, 0xC0, 0x3C, 0x0F, 0x00, 0xF0,
  0x3C, 0x07, 0xC0, 0xF0, 0x1F, 0x01, 0xC0, 0xF8, 0x07, 0x87, 0xE0, 0x1F,
  0xFB, 0x80, 0x3F, 0xCE, 0x00, 0x7E, 0x38, 0x00, 0x00, 0x30, 0x00, 0xFF,
  0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0xF0, 0x78, 0x78, 0x3C, 0x78, 0x1E, 0x78,
  0x0F, 0x3C, 0x07, 0x1C, 0x07, 0x9E, 0x0F, 0x8F, 0xFF, 0x87, 0xFF, 0x83,
  0xFF, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x0E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x40, 0xFF, 0xE0, 0x7F, 0xF0, 0x0F,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0xC0, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x02, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x10, 0x00, 0x07, 0xF3, 0xC0,
  0x7F, 0xDC, 0x07, 0xFE, 0xE0, 0x7C, 0x3F, 0x03, 0xC0, 0xF8, 0x3C, 0x07,
  0x81, 0xE0, 0x3C, 0x1E, 0x01, 0xE0, 0xF0, 0x0F, 0x07, 0x00, 0x78, 0x78,
  0x03, 0x83, 0xC0, 0x1C, 0x1E, 0x01, 0xE0, 0xE0, 0x0F, 0x07, 0x00, 0x78,
  0x78, 0x07, 0x83, 0xC0, 0x3C, 0x1E, 0x03, 0xE0, 0xF0, 0x1F, 0x03, 0x81,
  0xF8, 0x1E, 0x1F, 0x80, 0xFF, 0xDC, 0x03, 0xFD, 0xE0, 0x0F, 0xCF, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xF0, 0x10, 0x0F, 0x00, 0xF1, 0xF8, 0x07, 0xFF, 0x80, 0x3F,
  0xF8, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x40, 0x1E, 0x7F, 0x03, 0xDF, 0xE0, 0x77, 0xFE,
  0x0F, 0xC3, 0xC3, 0xF0, 0x78, 0x7C, 0x0F, 0x0F, 0x01, 0xE1, 0xE0, 0x3C,
  0x38, 0x07, 0x8F, 0x00, 0xE1, 0xE0, 0x1C, 0x3C, 0x07, 0x87, 0x00, 0xF0,
  0xE0, 0x1E, 0x3C, 0x03, 0x87, 0x80, 0xF0, 0xF0, 0x1E, 0x1C, 0x03, 0xC3,
  0x80, 0x70, 0xF0, 0x0E, 0x1E, 0x03, 0xC3, 0xC0, 0x78, 0x70, 0x0F, 0x1E,
  0x01, 0xC0, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0xC0, 0x78,
  0x0E, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x38, 0x07, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xE0, 0x1C, 0x07, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x9F, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07,
  0x81, 0xF0, 0x78, 0x3E, 0x07, 0x83, 0xC0, 0x70, 0x78, 0x07, 0x0F, 0x00,
  0xF1, 0xE0, 0x0F, 0x3C, 0x00, 0xE3, 0xC0, 0x0E, 0x78, 0x01, 0xEF, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xF7, 0x80, 0x3E, 0x78,
  0x03, 0xC7, 0x80, 0x3C, 0x38, 0x03, 0x83, 0xC0, 0x38, 0x3C, 0x07, 0x83,
  0xC0, 0x78, 0x1C, 0x07, 0x81, 0xE0, 0x70, 0x1E, 0x0F, 0x01, 0xE0, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0x80,
  0x70, 0x1E, 0x03, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0xC0,
  0x38, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1C, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0x70, 0x1E, 0x00, 0x00, 0x02,
  0x00, 0x80, 0x1C, 0x7E, 0x1F, 0xC0, 0x73, 0xFC, 0xFF, 0x81, 0xDF, 0xF7,
  0xFE, 0x07, 0xE1, 0xF8, 0x78, 0x3E, 0x07, 0xC0, 0xF0, 0xF8, 0x1F, 0x03,
  0x83, 0xC0, 0x78, 0x0E, 0x0F, 0x01, 0xE0, 0x38, 0x38, 0x07, 0x01, 0xE1,
  0xE0, 0x3C, 0x07, 0x87, 0x80, 0xF0, 0x1E, 0x1E, 0x03, 0xC0, 0x70, 0x70,
  0x0E, 0x03, 0xC1, 0xC0, 0x38, 0x0F, 0x0F, 0x01, 0xE0, 0x3C, 0x3C, 0x07,
  0x80, 0xE0, 0xF0, 0x1C, 0x03, 0x83, 0x80, 0x70, 0x1E, 0x0E, 0x03, 0xC0,
  0x78, 0x78, 0x0F, 0x01, 0xE1, 0xE0, 0x3C, 0x07, 0x07, 0x80, 0xE0, 0x1C,
  0x1C, 0x03, 0x80, 0xF0, 0xF0, 0x1E, 0x03, 0xC0, 0x00, 0x07, 0x00, 0xE3,
  0xF8, 0x1C, 0xFF, 0x03, 0xBF, 0xF0, 0x7E, 0x1E, 0x1F, 0x83, 0xC3, 0xE0,
  0x78, 0x78, 0x0F, 0x0F, 0x01, 0xE1, 0xE0, 0x3C, 0x78, 0x07, 0x0F, 0x01,
  0xE1, 0xE0, 0x3C, 0x38, 0x07, 0x8F, 0x00, 0xF1, 0xE0, 0x1C, 0x3C, 0x07,
  0x87, 0x80, 0xF0, 0xE0, 0x1E, 0x3C, 0x03, 0x87, 0x80, 0x70, 0xF0, 0x1E,
  0x1E, 0x03, 0xC3, 0x80, 0x78, 0xF0, 0x0E, 0x00, 0x00, 0x10, 0x00, 0x7F,
  0x80, 0x3F, 0xF0, 0x1F, 0xFE, 0x0F, 0x87, 0x83, 0xC0, 0xF1, 0xE0, 0x3C,
  0x70, 0x0F, 0x3C, 0x03, 0xCE, 0x00, 0xF7, 0x80, 0x3D, 0xE0, 0x0F, 0x78,
  0x03, 0xDC, 0x00, 0xE7, 0x00, 0x79, 0xC0, 0x1E, 0xF0, 0x07, 0xBC, 0x03,
  0xCF, 0x00, 0xF1, 0xC0, 0x78, 0x78, 0x1E, 0x1E, 0x0F, 0x03, 0xFF, 0x80,
  0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0x00, 0x20, 0x80, 0x07, 0x1F, 0xC0, 0x1C,
  0xFF, 0x00, 0x77, 0xFE, 0x01, 0xF8, 0x78, 0x0F, 0xC0, 0xE0, 0x3E, 0x03,
  0xC0, 0xF8, 0x0F, 0x03, 0xC0, 0x3C, 0x0F, 0x00, 0xF0, 0x78, 0x03, 0x81,
  0xE0, 0x0E, 0x07, 0x80, 0x78, 0x1C, 0x01, 0xE0, 0x70, 0x07, 0x83, 0xC0,
  0x1C, 0x0F, 0x00, 0xF0, 0x3C, 0x03, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x1F, 0x03, 0xC0, 0x7E, 0x1F, 0x01, 0xDF, 0xF8, 0x07, 0x7F, 0xC0, 0x1C,
  0xFE, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x1F,
  0xCF, 0x03, 0xFE, 0xE0, 0x7F, 0xEE, 0x0F, 0x87, 0xE0, 0xF0, 0x3E, 0x1E,
  0x03, 0xC1, 0xE0, 0x3C, 0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x38, 0x03, 0xC7,
  0x80, 0x38, 0x78, 0x03, 0x87, 0x80, 0x78, 0x70, 0x07, 0x87, 0x00, 0x78,
  0xF0, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x1F, 0x0F, 0x01, 0xF0, 0x70, 0x3F,
  0x07, 0x87, 0xE0, 0x7F, 0xEE, 0x03, 0xFD, 0xE0, 0x1F, 0x9E, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x00, 0x00, 0x06, 0x07, 0x1F, 0x07, 0x3E, 0x07, 0x7E, 0x07, 0xE0,
  0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x70, 0x00, 0xF0, 0x00, 0x00, 0x40, 0x03, 0xFE, 0x0F, 0xFF, 0x0F, 0xFE,
  0x1E, 0x02, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x80, 0xF0,
  0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0xC0, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0xE0, 0x1C, 0x0F, 0xFB, 0xFF, 0xFF, 0xE3, 0x80, 0x70, 0x1E, 0x03, 0xC0,
  0x78, 0x0E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x7F, 0x0F, 0xE0, 0xFC, 0x00,
  0x1E, 0x01, 0xC7, 0x80, 0xF1, 0xC0, 0x3C, 0x70, 0x0F, 0x3C, 0x03, 0x8F,
  0x01, 0xE3, 0xC0, 0x78, 0xE0, 0x1E, 0x38, 0x07, 0x1E, 0x01, 0xC7, 0x80,
  0xF1, 0xE0, 0x3C, 0x70, 0x0F, 0x3C, 0x03, 0x8F, 0x01, 0xE3, 0xC0, 0x78,
  0xE0, 0x1E, 0x38, 0x0F, 0x8E, 0x03, 0xC3, 0x81, 0xF0, 0xF0, 0xFC, 0x3F,
  0xFF, 0x0F, 0xFB, 0xC1, 0xFC, 0xE0, 0xE0, 0x0F, 0xE0, 0x0E, 0xE0, 0x1E,
  0xE0, 0x1C, 0xE0, 0x3C, 0xE0, 0x3C, 0xE0, 0x78, 0xE0, 0x78, 0xE0, 0xF0,
  0xE0, 0xF0, 0xE0, 0xE0, 0xE1, 0xE0, 0xE1, 0xC0, 0xE3, 0xC0, 0xE3, 0x80,
  0xF7, 0x80, 0xF7, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xEE, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xE0, 0x3E, 0x03, 0xF8, 0x0F, 0x81,
  0xEE, 0x03, 0xE0, 0x7B, 0x81, 0xF8, 0x1C, 0xE0, 0x7E, 0x0F, 0x38, 0x3B,
  0x83, 0xCE, 0x0E, 0xE1, 0xE3, 0x83, 0xB8, 0x78, 0xE1, 0xCE, 0x1C, 0x38,
  0x73, 0x8F, 0x0E, 0x38, 0xE3, 0x83, 0x8E, 0x39, 0xE0, 0xE3, 0x8E, 0x78,
  0x39, 0xC3, 0x9C, 0x0E, 0x70, 0xEF, 0x03, 0xB8, 0x3B, 0x80, 0xEE, 0x0E,
  0xE0, 0x3B, 0x83, 0xF8, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0xF8,
  0x0F, 0x80, 0x3E, 0x03, 0xE0, 0x0F, 0x80, 0xF0, 0x03, 0xC0, 0x7C, 0x00,
  0x07, 0x80, 0xF8, 0x1E, 0x07, 0x80, 0xF0, 0x78, 0x07, 0x83, 0x80, 0x1C,
  0x3C, 0x00, 0xF3, 0xC0, 0x07, 0x9C, 0x00, 0x1D, 0xE0, 0x00, 0xFE, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x7F, 0x80, 0x07, 0x9C, 0x00, 0x78, 0xE0, 0x03,
  0xC7, 0x80, 0x3C, 0x3C, 0x03, 0xC0, 0xE0, 0x1E, 0x07, 0x01, 0xE0, 0x3C,
  0x1E, 0x01, 0xE0, 0x01, 0xC0, 0x1E, 0x03, 0x80, 0x3C, 0x07, 0x00, 0xF0,
  0x0E, 0x01, 0xE0, 0x1C, 0x07, 0x80, 0x3C, 0x0F, 0x00, 0x78, 0x3C, 0x00,
  0xF0, 0x78, 0x01, 0xE0, 0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x87, 0x00, 0x0F,
  0x1E, 0x00, 0x1E, 0x38, 0x00, 0x1C, 0xF0, 0x00, 0x39, 0xC0, 0x00, 0x77,
  0x80, 0x00, 0xEE, 0x00, 0x01, 0xDC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x4F, 0x80, 0x00, 0xFE,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x83, 0xFF,
  0x81, 0xFF, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x07, 0xFF, 0xC3, 0xFF, 0xC1, 0xFF, 0xE0, 0x00,
  0x0F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x0F,
  0x80, 0x3F, 0x80, 0x1E, 0x00, 0x0F, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x1E, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x01, 0xE0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x7C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x78, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x7F, 0x00, 0xF8, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x1E, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x5F,
  0xE0, 0x1F, 0xFF, 0x1F, 0xDF, 0xFF, 0xC0, 0xFF, 0xA0, 0x07, 0xC0,
};

const GFXglyph NotoSans_Condensed_Italic45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 11, 32, 11, 1, -32 },
  { 45, 12, 11, 16, 5, -32 },
  { 62, 23, 32, 22, 0, -32 },
  { 154, 20, 37, 20, 0, -34 },
  { 247, 25, 33, 30, 3, -33 },
  { 351, 22, 33, 23, 0, -33 },
  { 442, 5, 11, 9, 5, -32 },
  { 449, 14, 39, 12, 1, -32 },
  { 518, 14, 39, 12, -3, -32 },
  { 587, 16, 16, 19, 4, -34 },
  { 619, 18, 22, 21, 2, -27 },
  { 669, 8, 11, 10, -2, -5 },
  { 680, 10, 4, 12, 1, -14 },
  { 685, 5, 5, 10, 1, -5 },
  { 689, 21, 32, 15, -2, -32 },
  { 773, 18, 33, 20, 1, -33 },
  { 848, 12, 32, 20, 5, -32 },
  { 896, 20, 33, 20, -1, -33 },
  { 979, 20, 33, 20, 0, -33 },
  { 1062, 21, 32, 20, -1, -32 },
  { 1146, 20, 32, 20, 0, -32 },
  { 1226, 18, 33, 20, 2, -33 },
  { 1301, 19, 32, 20, 2, -32 },
  { 1377, 20, 33, 20, 0, -33 },
  { 1460, 18, 33, 20, 1, -33 },
  { 1535, 9, 24, 10, 0, -24 },
  { 1562, 11, 30, 10, -2, -24 },
  { 1604, 18, 20, 21, 2, -26 },
  { 1649, 18, 12, 21, 2, -22 },
  { 1676, 18, 20, 21, 2, -26 },
  { 1721, 16, 33, 15, 1, -33 },
  { 1787, 28, 36, 30, 1, -32 },
  { 1913, 21, 32, 20, -3, -32 },
  { 1997, 21, 32, 22, 1, -32 },
  { 2081, 21, 33, 20, 2, -33 },
  { 2168, 22, 32, 24, 1, -32 },
  { 2256, 19, 32, 18, 1, -32 },
  { 2332, 19, 32, 17, 1, -32 },
  { 2408, 23, 33, 25, 2, -33 },
  { 2503, 24, 32, 24, 1, -32 },
  { 2599, 18, 32, 13, -2, -32 },
  { 2671, 18, 41, 10, -7, -32 },
  { 2764, 23, 32, 20, 1, -32 },
  { 2856, 13, 32, 17, 1, -32 },
  { 2908, 31, 32, 32, 1, -32 },
  { 3032, 26, 32, 26, 1, -32 },
  { 3136, 22, 33, 25, 2, -33 },
  { 3227, 20, 32, 20, 1, -32 },
  { 3307, 22, 41, 25, 2, -33 },
  { 3420, 20, 32, 21, 1, -32 },
  { 3500, 20, 33, 19, 0, -33 },
  { 3583, 17, 32, 18, 4, -32 },
  { 3651, 23, 32, 24, 2, -32 },
  { 3743, 20, 32, 20, 4, -32 },
  { 3823, 32, 32, 32, 4, -32 },
  { 3951, 25, 32, 19, -3, -32 },
  { 4051, 18, 32, 18, 4, -32 },
  { 4123, 21, 32, 18, -1, -32 },
  { 4207, 17, 39, 13, -1, -32 },
  { 4290, 7, 32, 16, 5, -32 },
  { 4318, 17, 39, 13, -3, -32 },
  { 4401, 19, 18, 20, 1, -32 },
  { 4444, 16, 3, 15, -4, 4 },
  { 4450, 6, 7, 12, 7, -34 },
  { 4456, 20, 25, 21, 1, -25 },
  { 4519, 20, 34, 21, 0, -34 },
  { 4604, 16, 25, 16, 1, -25 },
  { 4654, 22, 34, 21, 1, -34 },
  { 4748, 17, 25, 19, 1, -25 },
  { 4802, 22, 45, 12, -5, -34 },
  { 4926, 21, 36, 21, 0, -25 },
  { 5021, 19, 34, 21, 0, -34 },
  { 5102, 11, 33, 10, 0, -33 },
  { 5148, 17, 44, 10, -6, -33 },
  { 5242, 20, 34, 18, 0, -34 },
  { 5327, 11, 34, 9, 0, -34 },
  { 5374, 30, 25, 31, 0, -25 },
  { 5468, 19, 25, 21, 0, -25 },
  { 5528, 18, 25, 20, 1, -25 },
  { 5585, 22, 36, 21, -2, -25 },
  { 5684, 20, 36, 21, 1, -25 },
  { 5774, 16, 25, 14, 0, -25 },
  { 5824, 16, 25, 16, 0, -25 },
  { 5874, 11, 30, 12, 2, -30 },
  { 5916, 18, 24, 21, 2, -24 },
  { 5970, 16, 24, 17, 3, -24 },
  { 6018, 26, 24, 27, 3, -24 },
  { 6096, 21, 24, 17, -2, -24 },
  { 6159, 23, 35, 17, -4, -24 },
  { 6260, 17, 24, 15, -1, -24 },
  { 6311, 17, 39, 15, 1, -32 },
  { 6394, 3, 45, 19, 8, -34 },
  { 6411, 16, 39, 15, -2, -32 },
  { 6489, 18, 6, 21, 2, -19 },
};

const GFXfont NotoSans_Condensed_Italic45pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Italic45pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Italic45pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _NOTOSANS_CONDENSED_ITALIC45PT7B_H_
