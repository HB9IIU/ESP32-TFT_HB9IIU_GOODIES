#ifndef _NOTOSANS_CONDENSED_ITALIC62PT7B_H_
#define _NOTOSANS_CONDENSED_ITALIC62PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Italic.ttf
// Size: 62pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Italic62pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x1F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x02,
  0x00, 0x00, 0x1F, 0x0F, 0xCF, 0xC3, 0xF3, 0xF0, 0xF8, 0xF8, 0x3E, 0x3E,
  0x0F, 0x8F, 0x83, 0xC3, 0xC1, 0xF0, 0xF0, 0x7C, 0x7C, 0x1F, 0x1F, 0x07,
  0x87, 0x81, 0xE1, 0xE0, 0x78, 0x78, 0x1E, 0x1E, 0x0F, 0x0F, 0x03, 0xC3,
  0xC0, 0xF0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x78, 0x0E, 0x00, 0x00, 0xF0,
  0x3C, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x78, 0x0F, 0x00, 0x00, 0xF0, 0x3C,
  0x00, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x78, 0x0F, 0x00, 0x00, 0xF0, 0x1C, 0x00,
  0x01, 0xE0, 0x78, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0x78, 0x0F, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x01,
  0xE0, 0x78, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x01, 0xE0, 0x87, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0xF0, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x1E, 0x03,
  0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x70, 0x1E, 0x00, 0x01, 0xE0, 0x3C,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0x3C, 0x0F, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x01, 0xE0, 0x3C, 0x00,
  0x03, 0xC0, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFB, 0xF0, 0x0F, 0xC7, 0x0E, 0x01, 0xF0, 0xE0, 0x40, 0x7C, 0x38,
  0x00, 0x0F, 0x87, 0x00, 0x01, 0xF0, 0xE0, 0x00, 0x3C, 0x1C, 0x00, 0x07,
  0x83, 0x80, 0x00, 0xF8, 0xE0, 0x00, 0x1F, 0x1C, 0x00, 0x03, 0xF3, 0x80,
  0x00, 0x3F, 0x70, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xDF, 0x80, 0x00, 0x39, 0xF8, 0x00, 0x07,
  0x1F, 0x00, 0x01, 0xC3, 0xE0, 0x00, 0x38, 0x7C, 0x00, 0x07, 0x07, 0x80,
  0x00, 0xE1, 0xF0, 0x00, 0x1C, 0x3E, 0x00, 0x07, 0x07, 0xC1, 0x00, 0xE1,
  0xF0, 0x38, 0x1C, 0x7E, 0x07, 0xF3, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xE0, 0x1F, 0xF8, 0x00, 0x78, 0x07,
  0xFF, 0x00, 0x1F, 0x00, 0xF1, 0xF0, 0x03, 0xC0, 0x3C, 0x1E, 0x00, 0xF0,
  0x07, 0x83, 0xC0, 0x1E, 0x01, 0xE0, 0x78, 0x07, 0x80, 0x3C, 0x0F, 0x00,
  0xF0, 0x0F, 0x01, 0xE0, 0x3C, 0x01, 0xE0, 0x3C, 0x0F, 0x80, 0x3C, 0x07,
  0x81, 0xE0, 0x07, 0x80, 0xF0, 0x78, 0x01, 0xE0, 0x3C, 0x0F, 0x00, 0x3C,
  0x07, 0x83, 0xC0, 0x07, 0x80, 0xF0, 0xF8, 0x00, 0xF0, 0x1E, 0x1E, 0x00,
  0x1E, 0x07, 0xC7, 0x80, 0x03, 0xC0, 0xF0, 0xF0, 0xFC, 0x78, 0x1E, 0x3C,
  0x3F, 0xCF, 0x07, 0x8F, 0x8F, 0xFD, 0xE0, 0xF1, 0xE3, 0xFF, 0xBC, 0x3E,
  0x7C, 0xF8, 0xFF, 0x8F, 0x8F, 0x1E, 0x0F, 0xFF, 0xE3, 0xC7, 0x81, 0xEF,
  0xF8, 0x78, 0xF0, 0x3C, 0xFE, 0x1E, 0x3E, 0x07, 0x8F, 0x87, 0xC7, 0x80,
  0xF0, 0x00, 0xF0, 0xF0, 0x1E, 0x00, 0x3C, 0x1E, 0x03, 0xC0, 0x07, 0x87,
  0x80, 0xF0, 0x01, 0xE0, 0xF0, 0x1E, 0x00, 0x7C, 0x1E, 0x03, 0xC0, 0x0F,
  0x03, 0xC0, 0x78, 0x03, 0xE0, 0x78, 0x1F, 0x00, 0x78, 0x0F, 0x03, 0xC0,
  0x1E, 0x01, 0xE0, 0x78, 0x07, 0xC0, 0x78, 0x1F, 0x00, 0xF0, 0x07, 0x03,
  0xC0, 0x3E, 0x00, 0xF0, 0x78, 0x07, 0x80, 0x1E, 0x1E, 0x01, 0xE0, 0x03,
  0xE7, 0xC0, 0x3C, 0x00, 0x7F, 0xF0, 0x0F, 0x00, 0x07, 0xFC, 0x03, 0xE0,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x1F, 0x1F, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x1F,
  0x01, 0xF0, 0x00, 0x7C, 0x07, 0x80, 0x01, 0xF0, 0x1E, 0x00, 0x07, 0x80,
  0xF8, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x78, 0x0F, 0x00, 0x01, 0xE0, 0x7C,
  0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x7C, 0xFC, 0x00,
  0x01, 0xF7, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x7C, 0x1F, 0x1F, 0x01, 0xF0, 0xF8, 0x7C,
  0x0F, 0x87, 0xC0, 0xF8, 0x3E, 0x3F, 0x03, 0xE1, 0xF0, 0xF8, 0x0F, 0xC7,
  0xC7, 0xE0, 0x1F, 0x3E, 0x1F, 0x00, 0x7E, 0xF8, 0x7C, 0x00, 0xFF, 0xC1,
  0xF0, 0x03, 0xFF, 0x0F, 0x80, 0x07, 0xF8, 0x3E, 0x00, 0x1F, 0xC0, 0xF8,
  0x00, 0x7F, 0x03, 0xF0, 0x01, 0xFC, 0x0F, 0xC0, 0x0F, 0xF0, 0x1F, 0x00,
  0x7F, 0xE0, 0x7E, 0x07, 0xFF, 0x81, 0xFF, 0xFF, 0xBE, 0x03, 0xFF, 0xF8,
  0xFC, 0x07, 0xFF, 0xC1, 0xF0, 0x0F, 0xFC, 0x07, 0xE0, 0x07, 0x00, 0x00,
  0x00, 0x3E, 0x7D, 0xFB, 0xE7, 0xCF, 0x9F, 0x3C, 0x79, 0xF3, 0xE7, 0x8F,
  0x1E, 0x38, 0x70, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x01, 0x80, 0xF0,
  0x07, 0x83, 0xC0, 0x1F, 0x8E, 0x00, 0xFF, 0xB8, 0x3D, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0x01, 0xF8, 0xFC, 0x0F, 0xF0, 0x00, 0x7D,
  0xC0, 0x03, 0xE7, 0x80, 0x1F, 0x9E, 0x00, 0xFC, 0x3C, 0x07, 0xE0, 0xF8,
  0x07, 0x03, 0xE0, 0x0C, 0x07, 0xC0, 0x20, 0x1C, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0,
  0x3E, 0x07, 0xE0, 0x7C, 0x0F, 0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0x01,
  0xE0, 0x3E, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0xF0, 0x00, 0x7F, 0xFE, 0xFF,
  0xF9, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0xC0, 0x3C, 0xFF, 0xFF, 0xFF, 0xDF,
  0xBE, 0x10, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x07, 0xE1,
  0xF8, 0x07, 0xE0, 0x7C, 0x07, 0xE0, 0x3F, 0x03, 0xE0, 0x0F, 0x83, 0xF0,
  0x07, 0xC1, 0xF0, 0x03, 0xE1, 0xF8, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x7C,
  0x00, 0x7C, 0x7E, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x9F,
  0x80, 0x0F, 0xCF, 0x80, 0x07, 0xC7, 0xC0, 0x03, 0xE3, 0xE0, 0x01, 0xF3,
  0xF0, 0x00, 0xF9, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x7E, 0x7C, 0x00, 0x3E,
  0x3E, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0xCF, 0x80, 0x07,
  0xE7, 0xC0, 0x03, 0xE3, 0xE0, 0x01, 0xF1, 0xF0, 0x01, 0xF8, 0xF8, 0x00,
  0xF8, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x0F, 0x80,
  0x3F, 0x07, 0xC0, 0x1F, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x1F, 0x80, 0x7E,
  0x1F, 0x80, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF8, 0x7F, 0x7C, 0x7F,
  0x3E, 0x7F, 0x3F, 0x1E, 0x1F, 0x06, 0x0F, 0x82, 0x07, 0xC0, 0x03, 0xE0,
  0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F,
  0xC0, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xC0,
  0x7E, 0x00, 0x70, 0x03, 0xF0, 0x02, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01,
  0xE0, 0x1F, 0x80, 0x38, 0x01, 0xF8, 0x04, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x04, 0x00, 0x1F, 0xC0, 0xF0, 0x0F, 0xF0,
  0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7B, 0xC0, 0x00, 0x0F, 0x7C, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1E, 0x7C,
  0x00, 0x03, 0xC7, 0xC0, 0x00, 0x7C, 0xF8, 0x00, 0x07, 0x8F, 0x80, 0x00,
  0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x1F,
  0x00, 0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x1F, 0x00, 0x0F, 0x01, 0xF0, 0x01,
  0xF0, 0x3E, 0x00, 0x3E, 0x03, 0xE0, 0x03, 0xC0, 0x3E, 0x00, 0x7C, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x7C, 0x03,
  0xE0, 0x07, 0xC0, 0x3C, 0x00, 0x7C, 0x07, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0xC0,
  0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF8, 0x30, 0x00, 0xFE, 0x07, 0x80, 0x7F, 0x80, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xF0, 0x00,
  0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC3, 0xF0, 0x01, 0xF3, 0xFF, 0x00, 0xF9, 0xFF, 0xE0, 0x3E, 0xFF, 0xF8,
  0x0F, 0xFE, 0xFF, 0x03, 0xFC, 0x0F, 0xC1, 0xFE, 0x01, 0xF8, 0x7F, 0x00,
  0x7E, 0x1F, 0x80, 0x0F, 0x87, 0xE0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x7C,
  0x00, 0x3E, 0x3F, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0xE3, 0xE0, 0x01, 0xF0,
  0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0xC3, 0xE0, 0x03,
  0xE0, 0xF8, 0x00, 0xF8, 0x1F, 0x00, 0x7E, 0x07, 0xC0, 0x1F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7F, 0x0F, 0xE0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00,
  0x7F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x0F,
  0xF7, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x1F, 0x80, 0x3E,
  0x03, 0xE0, 0x07, 0xE0, 0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x81, 0xF0,
  0x03, 0xE0, 0x3E, 0x00, 0x7C, 0x07, 0xC0, 0x0F, 0x80, 0xF8, 0x03, 0xE0,
  0x1F, 0x00, 0xFC, 0x01, 0xF0, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xE3,
  0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x01, 0xFC, 0x7E,
  0x00, 0x7E, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x07, 0xE0, 0x07, 0xC0, 0xF8,
  0x00, 0xF8, 0x3F, 0x00, 0x1F, 0x87, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x3E,
  0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x3F, 0x0F, 0x80,
  0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x3F, 0x07, 0xE0, 0x0F, 0xC0,
  0x7E, 0x03, 0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF0, 0x0F, 0xC0, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xC0, 0x1F, 0x07, 0xC0,
  0x0F, 0x83, 0xE0, 0x07, 0xC3, 0xE0, 0x03, 0xE1, 0xF0, 0x00, 0xF0, 0xF8,
  0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x1F,
  0x00, 0x0F, 0x8F, 0x80, 0x07, 0xC7, 0xC0, 0x07, 0xE3, 0xE0, 0x03, 0xF1,
  0xF0, 0x03, 0xF8, 0xFC, 0x01, 0xFC, 0x7E, 0x01, 0xFC, 0x1F, 0x83, 0xFE,
  0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xEF, 0x81, 0xFF, 0xE7, 0x80, 0x3F, 0xC7,
  0xC0, 0x03, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x80, 0x7F, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x1F,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x0F,
  0x80, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x0F, 0xC0, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1F,
  0xC0, 0xFE, 0x03, 0xE0, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80,
  0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00,
  0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x10, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x1F,
  0xFE, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0x81, 0xF8,
  0x10, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x0F, 0x80, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x1F, 0x00, 0x00,
  0x03, 0xC0, 0xF8, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x1E,
  0x00, 0x7F, 0xC0, 0xF0, 0x78, 0x07, 0xFF, 0x83, 0xC3, 0xC0, 0x3F, 0xFE,
  0x0F, 0x0F, 0x01, 0xF0, 0xF0, 0x3C, 0x78, 0x0F, 0x83, 0xC0, 0xF1, 0xE0,
  0x7C, 0x0F, 0x03, 0xCF, 0x01, 0xE0, 0x3C, 0x0F, 0x3C, 0x0F, 0x01, 0xE0,
  0x3C, 0xF0, 0x3C, 0x07, 0x80, 0xF3, 0xC1, 0xE0, 0x1E, 0x03, 0xDE, 0x07,
  0x80, 0x78, 0x1E, 0x78, 0x1E, 0x03, 0xC0, 0x79, 0xE0, 0xF0, 0x0F, 0x01,
  0xE7, 0x83, 0xC0, 0x3C, 0x07, 0xBC, 0x0F, 0x01, 0xF0, 0x3C, 0xF0, 0x3C,
  0x07, 0x80, 0xF3, 0xC0, 0xF0, 0x1E, 0x03, 0x8F, 0x03, 0xC0, 0xF8, 0x1E,
  0x3C, 0x0F, 0x03, 0xE0, 0x78, 0xF0, 0x3C, 0x1F, 0x83, 0xC3, 0xC0, 0xF0,
  0xEE, 0x1E, 0x0F, 0x03, 0xF7, 0xBF, 0xF8, 0x3C, 0x07, 0xFC, 0xFF, 0xC0,
  0xF0, 0x1F, 0xE1, 0xFE, 0x03, 0xC0, 0x3F, 0x03, 0xE0, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x0C, 0x00, 0x00,
  0xFF, 0x83, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xBE, 0x00,
  0x00, 0xFB, 0xE0, 0x00, 0x0F, 0x3E, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x1F,
  0x3E, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x3E, 0x3E, 0x00, 0x03, 0xC3, 0xE0,
  0x00, 0x7C, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x0F,
  0x83, 0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x03, 0xE0, 0x03, 0xE0, 0x1E,
  0x00, 0x3E, 0x01, 0xE0, 0x07, 0xE0, 0x1E, 0x00, 0x7C, 0x01, 0xE0, 0x07,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0x03, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x07,
  0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x0F, 0xC0, 0x01, 0xF0, 0xFC, 0x00,
  0x1F, 0x0F, 0x80, 0x01, 0xF1, 0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x01, 0xF3,
  0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x1F, 0x7C, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x1F, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0x80, 0xFF, 0x00,
  0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x3F, 0x01, 0xF0,
  0x01, 0xF8, 0x0F, 0x80, 0x0F, 0xC0, 0x7C, 0x00, 0x7E, 0x03, 0xE0, 0x03,
  0xF0, 0x3F, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0xF8, 0x0F, 0x80, 0x0F, 0xC0,
  0x7C, 0x00, 0x7C, 0x03, 0xE0, 0x07, 0xE0, 0x3E, 0x00, 0xFE, 0x01, 0xF0,
  0x1F, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xF0, 0x0F, 0xE0, 0x0F, 0x80, 0x3F, 0x00,
  0x7C, 0x00, 0xFC, 0x07, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x1F, 0x01, 0xF0,
  0x00, 0xFC, 0x0F, 0x80, 0x07, 0xE0, 0x7C, 0x00, 0x3F, 0x07, 0xE0, 0x01,
  0xF0, 0x3E, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x07, 0xE0,
  0x7C, 0x00, 0x3F, 0x07, 0xC0, 0x03, 0xF0, 0x3E, 0x00, 0x3F, 0x01, 0xF0,
  0x03, 0xF8, 0x0F, 0x83, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFE, 0x00, 0x3F, 0x80, 0x70, 0x03, 0xF8, 0x00, 0x80, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x02, 0x00, 0x3F, 0xC0,
  0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0xF8, 0x1F, 0xF0, 0x03, 0xE0, 0x1F, 0xE0, 0x0F, 0x80, 0x1F, 0x80, 0x7E,
  0x00, 0x7E, 0x01, 0xF0, 0x00, 0xFC, 0x07, 0xC0, 0x03, 0xF0, 0x1F, 0x00,
  0x07, 0xC0, 0x7C, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x01,
  0xF0, 0x3E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7C,
  0x1F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x07,
  0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x0F, 0xC3, 0xE0,
  0x00, 0x3E, 0x0F, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xE1, 0xF8, 0x00,
  0x1F, 0x87, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x0F,
  0xC1, 0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xF8, 0x3E, 0x00, 0x0F, 0xC0,
  0xF8, 0x00, 0x7F, 0x03, 0xE0, 0x01, 0xF8, 0x0F, 0x80, 0x0F, 0xC0, 0x7C,
  0x00, 0x7F, 0x01, 0xF0, 0x07, 0xF8, 0x07, 0xC0, 0x7F, 0xC0, 0x1F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x01, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x7F, 0x80, 0x3C, 0x00, 0xFE, 0x00, 0x0C, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x08, 0x7C, 0x00, 0x7F, 0xF0, 0xFC,
  0x00, 0x7F, 0xF0, 0xFC, 0x00, 0xFF, 0xF0, 0xFC, 0x00, 0xFF, 0xF0, 0xF8,
  0x00, 0x03, 0xE0, 0xF8, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x03, 0xE0, 0xF8,
  0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x07, 0xC0, 0xF8,
  0x00, 0x07, 0xC0, 0xF8, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x07, 0xC0, 0xFC,
  0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x0F, 0x80, 0x7E,
  0x00, 0x0F, 0x80, 0x3F, 0x80, 0x0F, 0x80, 0x3F, 0xC0, 0x3F, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x0F, 0xC0,
  0x1F, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0xF8, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x01,
  0xF0, 0x03, 0xE0, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x7C, 0x00,
  0x0F, 0xC0, 0x1F, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0xF8, 0x03, 0xF0,
  0x00, 0x3E, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x07, 0xE0, 0x0F,
  0x80, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0x1F, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3E, 0x00, 0x07,
  0xE0, 0x0F, 0x80, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x03, 0xF0, 0x07, 0xC0,
  0x00, 0xF8, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x3E,
  0x00, 0x03, 0xE0, 0x0F, 0x80, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x03, 0xF0,
  0x07, 0xC0, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x3E, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x01, 0xF8, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0xFF,
  0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7C,
  0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0xF8,
  0x03, 0xF0, 0x00, 0xF8, 0x07, 0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x01, 0xF0,
  0x0F, 0x80, 0x01, 0xF0, 0x1F, 0x80, 0x01, 0xF0, 0x3F, 0x00, 0x01, 0xF0,
  0x7E, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x03, 0xE1,
  0xF8, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x07, 0xE7,
  0xC0, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x0F, 0xE7, 0xC0, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x1F, 0x87,
  0xE0, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x1F, 0x03,
  0xE0, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x3E, 0x01,
  0xF0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x3E, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x7C, 0x00,
  0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0xF8, 0x00,
  0x7E, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01,
  0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xF0, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0,
  0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x0F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x1F, 0xF8,
  0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x00,
  0x1F, 0x7C, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x1E, 0xF8, 0x00, 0x3E,
  0xF8, 0x03, 0xE7, 0x80, 0x03, 0xEF, 0x80, 0x3E, 0x78, 0x00, 0x7C, 0xF8,
  0x03, 0xE7, 0x80, 0x07, 0xCF, 0x80, 0x3E, 0x78, 0x00, 0xF9, 0xF0, 0x03,
  0xC7, 0x80, 0x0F, 0x9F, 0x00, 0x7C, 0x78, 0x01, 0xF1, 0xF0, 0x07, 0xC7,
  0x80, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x03, 0xE3, 0xF0, 0x07, 0xC7, 0xC0,
  0x3E, 0x3E, 0x00, 0xF8, 0x7C, 0x03, 0xC3, 0xE0, 0x0F, 0x87, 0xC0, 0x7C,
  0x3E, 0x00, 0xF8, 0x7C, 0x07, 0x83, 0xE0, 0x0F, 0x87, 0xC0, 0xF8, 0x7E,
  0x00, 0xF8, 0x7C, 0x0F, 0x07, 0xC0, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x01,
  0xF0, 0x7C, 0x1E, 0x07, 0xC0, 0x1F, 0x03, 0xC3, 0xE0, 0x7C, 0x01, 0xF0,
  0x3C, 0x3C, 0x0F, 0x80, 0x1E, 0x03, 0xC7, 0xC0, 0xF8, 0x03, 0xE0, 0x3C,
  0x78, 0x0F, 0x80, 0x3E, 0x03, 0xCF, 0x80, 0xF8, 0x03, 0xE0, 0x3C, 0xF0,
  0x1F, 0x80, 0x3E, 0x03, 0xDF, 0x01, 0xF0, 0x03, 0xC0, 0x3F, 0xF0, 0x1F,
  0x00, 0x7C, 0x03, 0xFE, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0xE0, 0x1F, 0x00,
  0x7C, 0x03, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x3F, 0xC0, 0x3E, 0x00, 0xF8,
  0x03, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x7F, 0x00, 0x03, 0xE0, 0x0F,
  0xF0, 0x00, 0x3E, 0x00, 0xFF, 0x00, 0x03, 0xE0, 0x0F, 0xF0, 0x00, 0x7C,
  0x00, 0xFF, 0x80, 0x07, 0xC0, 0x1F, 0xF8, 0x00, 0x7C, 0x01, 0xFF, 0x80,
  0x07, 0xC0, 0x1F, 0xF8, 0x00, 0xF8, 0x01, 0xF7, 0x80, 0x0F, 0x80, 0x1E,
  0x7C, 0x00, 0xF8, 0x03, 0xE7, 0xC0, 0x0F, 0x80, 0x3E, 0x7C, 0x00, 0xF8,
  0x03, 0xE3, 0xC0, 0x1F, 0x00, 0x3E, 0x3E, 0x01, 0xF0, 0x03, 0xC3, 0xE0,
  0x1F, 0x00, 0x7C, 0x3E, 0x01, 0xF0, 0x07, 0xC1, 0xE0, 0x1F, 0x00, 0x7C,
  0x1F, 0x03, 0xE0, 0x07, 0xC1, 0xF0, 0x3E, 0x00, 0xF8, 0x1F, 0x03, 0xE0,
  0x0F, 0x81, 0xF0, 0x3E, 0x00, 0xF8, 0x0F, 0x03, 0xC0, 0x0F, 0x80, 0xF8,
  0x7C, 0x00, 0xF8, 0x0F, 0x87, 0xC0, 0x1F, 0x00, 0xF8, 0x7C, 0x01, 0xF0,
  0x07, 0x87, 0xC0, 0x1F, 0x00, 0x7C, 0xF8, 0x01, 0xF0, 0x07, 0xCF, 0x80,
  0x1F, 0x00, 0x7C, 0xF8, 0x03, 0xE0, 0x07, 0xCF, 0x80, 0x3E, 0x00, 0x3C,
  0xF8, 0x03, 0xE0, 0x03, 0xEF, 0x00, 0x3E, 0x00, 0x3F, 0xF0, 0x03, 0xC0,
  0x03, 0xFF, 0x00, 0x7C, 0x00, 0x1F, 0xF0, 0x07, 0xC0, 0x01, 0xFE, 0x00,
  0x7C, 0x00, 0x1F, 0xE0, 0x07, 0xC0, 0x01, 0xFE, 0x00, 0xF8, 0x00, 0x0F,
  0xE0, 0x0F, 0x80, 0x00, 0xFE, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x0F, 0x80,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x1F,
  0xC0, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x7E, 0x03, 0xF0,
  0x00, 0xFC, 0x0F, 0xC0, 0x00, 0xF8, 0x1F, 0x00, 0x01, 0xF0, 0x7E, 0x00,
  0x03, 0xF0, 0xF8, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x0F, 0xC7, 0xE0, 0x00,
  0x1F, 0x8F, 0x80, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00,
  0xFC, 0xF8, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x07,
  0xCF, 0x80, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x7E,
  0xFC, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x03, 0xE7,
  0xC0, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0x3E, 0x3E,
  0x00, 0x00, 0xFC, 0x7C, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x07, 0xE1, 0xF0,
  0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7E, 0x0F, 0xC0,
  0x01, 0xF8, 0x0F, 0x80, 0x07, 0xF0, 0x1F, 0x80, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x80, 0x0F, 0xFF, 0xFC, 0x00, 0xF8, 0x3F, 0xE0, 0x0F, 0x80, 0x7E, 0x00,
  0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x3F, 0x01, 0xF0, 0x03, 0xF0, 0x1F, 0x00,
  0x1F, 0x01, 0xF0, 0x01, 0xF0, 0x1F, 0x00, 0x1F, 0x03, 0xF0, 0x03, 0xF0,
  0x3E, 0x00, 0x3F, 0x03, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x3E, 0x03, 0xE0,
  0x07, 0xE0, 0x7E, 0x00, 0x7C, 0x07, 0xC0, 0x0F, 0xC0, 0x7C, 0x01, 0xFC,
  0x07, 0xC0, 0x3F, 0x80, 0xFC, 0x0F, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFC, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xC0, 0x7F, 0x00,
  0x7F, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0xFC, 0x0F,
  0xC0, 0x00, 0xF8, 0x1F, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x03, 0xF0, 0xF8,
  0x00, 0x07, 0xE3, 0xF0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x1F, 0x8F, 0x80,
  0x00, 0x3F, 0x3F, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00, 0xFC, 0xF8, 0x00,
  0x01, 0xFB, 0xF0, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x07, 0xCF, 0x80, 0x00,
  0x0F, 0x9F, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00,
  0xFD, 0xF8, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x0F,
  0xCF, 0x80, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0xFC,
  0x7C, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x0F, 0xC3,
  0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xF8, 0x0F,
  0x80, 0x07, 0xF0, 0x1F, 0x80, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0x3F,
  0x83, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80,
  0x0F, 0xFF, 0xFC, 0x00, 0xF8, 0x3F, 0xE0, 0x0F, 0x80, 0x7E, 0x00, 0xF8,
  0x03, 0xF0, 0x1F, 0x80, 0x3F, 0x01, 0xF0, 0x03, 0xF0, 0x1F, 0x00, 0x1F,
  0x01, 0xF0, 0x01, 0xF0, 0x1F, 0x00, 0x3F, 0x03, 0xF0, 0x03, 0xF0, 0x3E,
  0x00, 0x3F, 0x03, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x3E, 0x03, 0xE0, 0x07,
  0xE0, 0x7E, 0x00, 0x7C, 0x07, 0xC0, 0x0F, 0xC0, 0x7C, 0x01, 0xF8, 0x07,
  0xC0, 0x7F, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0x83, 0xE0, 0x01,
  0xF0, 0x3E, 0x00, 0x1F, 0x03, 0xE0, 0x01, 0xF0, 0x3F, 0x00, 0x1F, 0x01,
  0xF0, 0x03, 0xF0, 0x1F, 0x00, 0x3E, 0x01, 0xF0, 0x03, 0xE0, 0x1F, 0x80,
  0x3E, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x00, 0xF8, 0x07, 0xC0,
  0x0F, 0xC0, 0x7C, 0x00, 0xFC, 0x07, 0xC0, 0x07, 0xC0, 0xFC, 0x00, 0x7C,
  0x0F, 0x80, 0x07, 0xE0, 0xF8, 0x00, 0x7E, 0x0F, 0x80, 0x07, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0x80, 0xF0, 0x03, 0xF0, 0x01,
  0x80, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3E, 0x02, 0x00, 0x03, 0xF0, 0x0C, 0x00, 0x7F, 0x80,
  0x7C, 0x0F, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x3E, 0x07, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x00,
  0x03, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0x1F, 0x03, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0xFC, 0x0F, 0x80, 0x01,
  0xF0, 0x3F, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F,
  0x81, 0xF0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0xF8,
  0x1F, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x0F, 0x80,
  0xF8, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x7C, 0x0F,
  0x80, 0x01, 0xF8, 0x1F, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x07, 0xC0, 0xF8,
  0x00, 0x0F, 0x81, 0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7C, 0x07, 0xC0,
  0x00, 0xF8, 0x1F, 0x80, 0x01, 0xF0, 0x3E, 0x00, 0x03, 0xE0, 0x7C, 0x00,
  0x0F, 0xC0, 0xF8, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x3E, 0x03, 0xE0, 0x00,
  0xFC, 0x07, 0xC0, 0x01, 0xF0, 0x0F, 0x80, 0x07, 0xE0, 0x1F, 0x80, 0x0F,
  0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x06, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x3E,
  0x7C, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0xC7, 0xC0,
  0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x87, 0xC0, 0x01, 0xF8, 0x7C, 0x00, 0x1F,
  0x07, 0xC0, 0x03, 0xF0, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0xE0, 0x7C,
  0x00, 0x7C, 0x07, 0xC0, 0x0F, 0xC0, 0x7C, 0x00, 0xF8, 0x07, 0xC0, 0x0F,
  0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x07,
  0xC0, 0x3E, 0x00, 0x7C, 0x07, 0xE0, 0x07, 0xC0, 0x7C, 0x00, 0x7C, 0x0F,
  0xC0, 0x07, 0xC0, 0xF8, 0x00, 0x7C, 0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x00,
  0x7C, 0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3C, 0x3E, 0x00, 0x03, 0xC7,
  0xC0, 0x00, 0x3C, 0x7C, 0x00, 0x03, 0xCF, 0xC0, 0x00, 0x3C, 0xF8, 0x00,
  0x03, 0xCF, 0x80, 0x00, 0x3D, 0xF0, 0x00, 0x03, 0xDF, 0x00, 0x00, 0x3D,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xE0,
  0x00, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x80, 0x07,
  0xEF, 0x80, 0x07, 0xF0, 0x00, 0xF9, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x3E,
  0x00, 0x3F, 0xC0, 0x07, 0xE7, 0xC0, 0x07, 0xF8, 0x00, 0xF8, 0xF8, 0x01,
  0xFF, 0x00, 0x3F, 0x1F, 0x00, 0x3D, 0xE0, 0x07, 0xC3, 0xE0, 0x07, 0xBC,
  0x00, 0xF8, 0x7C, 0x01, 0xF7, 0x80, 0x3E, 0x0F, 0x80, 0x3C, 0xF0, 0x07,
  0xC1, 0xF0, 0x0F, 0x9E, 0x01, 0xF8, 0x3E, 0x01, 0xE3, 0xC0, 0x3E, 0x07,
  0xC0, 0x3C, 0xF8, 0x07, 0xC0, 0xF8, 0x0F, 0x9F, 0x01, 0xF0, 0x1F, 0x01,
  0xE3, 0xE0, 0x3E, 0x03, 0xE0, 0x7C, 0x7C, 0x0F, 0xC0, 0x7C, 0x0F, 0x0F,
  0x81, 0xF0, 0x0F, 0x81, 0xE1, 0xF0, 0x3E, 0x01, 0xF0, 0x7C, 0x3E, 0x0F,
  0x80, 0x3E, 0x0F, 0x07, 0xC1, 0xF0, 0x07, 0xC3, 0xE0, 0xF8, 0x7C, 0x00,
  0xF8, 0x78, 0x1F, 0x0F, 0x80, 0x1F, 0x1F, 0x03, 0xE1, 0xF0, 0x03, 0xE3,
  0xE0, 0x7C, 0x7C, 0x00, 0x78, 0x78, 0x0F, 0x8F, 0x80, 0x0F, 0x1F, 0x01,
  0xF3, 0xE0, 0x01, 0xE3, 0xC0, 0x3E, 0x7C, 0x00, 0x3C, 0xF8, 0x07, 0xCF,
  0x80, 0x07, 0x9E, 0x00, 0xFB, 0xE0, 0x00, 0xF3, 0xC0, 0x1F, 0x7C, 0x00,
  0x1E, 0xF8, 0x03, 0xEF, 0x00, 0x03, 0xDE, 0x00, 0x7B, 0xE0, 0x00, 0x7B,
  0xC0, 0x0F, 0x7C, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0xFF,
  0x00, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0x1F,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x7C, 0x07, 0xE0, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x1F, 0x07, 0xC0,
  0x00, 0x03, 0xE1, 0xF0, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0x07, 0xCF,
  0x80, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F,
  0xBE, 0x00, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00,
  0x1F, 0x0F, 0x80, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x00, 0xF8, 0x3E, 0x00,
  0x00, 0x3E, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x01, 0xF0, 0x0F,
  0x80, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x03, 0xE0,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0xBE, 0x00, 0x0F, 0x9F, 0x00, 0x0F, 0xCF, 0x80,
  0x07, 0xC7, 0xC0, 0x07, 0xE3, 0xE0, 0x03, 0xE1, 0xF8, 0x03, 0xF0, 0x7C,
  0x01, 0xF0, 0x3E, 0x01, 0xF0, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0xF8, 0x07,
  0xC0, 0xFC, 0x03, 0xE0, 0x7C, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x3E, 0x00,
  0x3E, 0x3E, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0xCF, 0x80,
  0x03, 0xEF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xF8, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x1E, 0x03, 0xC0, 0x7C, 0x0F, 0x81, 0xF0, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x03, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xF3,
  0xC0, 0x00, 0x7C, 0xF0, 0x00, 0x1E, 0x3E, 0x00, 0x0F, 0x87, 0x80, 0x03,
  0xC1, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x0F, 0x00, 0x3C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0x80, 0x1E, 0x03, 0xE0, 0x07, 0xC0, 0xF0, 0x01,
  0xF0, 0x7C, 0x00, 0x3C, 0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xE7, 0xC0,
  0x00, 0x79, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xE0, 0xFC, 0x3E, 0x1F, 0x87,
  0xC3, 0xE0, 0xF8, 0x3C, 0x1E, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x20, 0x0F,
  0xF8, 0x78, 0x03, 0xFF, 0x8F, 0x00, 0xFF, 0xFB, 0xE0, 0x3F, 0xFF, 0x7C,
  0x0F, 0xE0, 0xFF, 0x81, 0xF8, 0x0F, 0xE0, 0x7E, 0x00, 0xFC, 0x0F, 0x80,
  0x1F, 0x83, 0xF0, 0x03, 0xF0, 0x7C, 0x00, 0x7C, 0x1F, 0x80, 0x0F, 0x83,
  0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x1F, 0x80, 0x07, 0xC3, 0xE0, 0x01,
  0xF0, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x7E,
  0x00, 0x3F, 0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x3F,
  0x07, 0xC0, 0x07, 0xE0, 0xF8, 0x00, 0xF8, 0x1F, 0x00, 0x3F, 0x03, 0xE0,
  0x0F, 0xE0, 0x7C, 0x01, 0xFC, 0x0F, 0xC0, 0x7F, 0x80, 0xFC, 0x1D, 0xE0,
  0x1F, 0xFF, 0xBC, 0x03, 0xFF, 0xE7, 0x80, 0x3F, 0xF8, 0xF0, 0x03, 0xFC,
  0x3E, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x7C, 0x7F, 0xC0, 0x0F, 0x9F, 0xFC,
  0x01, 0xF7, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x07, 0xF8, 0x1F, 0x01, 0xFE,
  0x03, 0xF0, 0x3F, 0x80, 0x3E, 0x07, 0xE0, 0x07, 0xC0, 0xFC, 0x00, 0xF8,
  0x3F, 0x00, 0x1F, 0x07, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x1F, 0x00,
  0x0F, 0x83, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x7E, 0x1F, 0x00, 0x0F, 0x83,
  0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x0F, 0x00, 0x07, 0xC3, 0xE0, 0x01,
  0xF8, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x01, 0xF8, 0x3E,
  0x00, 0x3E, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x01, 0xF0, 0x3F, 0x00, 0x7E,
  0x07, 0xF0, 0x1F, 0x81, 0xFF, 0x07, 0xE0, 0x3E, 0xFF, 0xFC, 0x07, 0x9F,
  0xFF, 0x00, 0xF1, 0xFF, 0xC0, 0x1E, 0x1F, 0xE0, 0x04, 0x00, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFE, 0x03,
  0xFF, 0xF0, 0x1F, 0xC0, 0x40, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x81, 0xF8, 0x0C, 0x07, 0xFF,
  0xF0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x07, 0x81, 0xF0, 0x01, 0xFF, 0x1F, 0x00, 0x1F, 0xFC, 0xF8, 0x01,
  0xFF, 0xF7, 0xC0, 0x1F, 0xFF, 0xBE, 0x01, 0xFC, 0x0F, 0xE0, 0x0F, 0xC0,
  0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0x7E,
  0x03, 0xE0, 0x03, 0xE0, 0x3F, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0xF8, 0x0F,
  0x80, 0x07, 0xC0, 0xFC, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0x3E, 0x00,
  0x1F, 0x01, 0xF0, 0x00, 0xF8, 0x1F, 0x80, 0x07, 0xC0, 0xFC, 0x00, 0x7C,
  0x07, 0xC0, 0x03, 0xE0, 0x3E, 0x00, 0x1F, 0x01, 0xF0, 0x01, 0xF8, 0x0F,
  0x80, 0x0F, 0xC0, 0x7C, 0x00, 0xFC, 0x03, 0xE0, 0x07, 0xE0, 0x1F, 0x00,
  0x7F, 0x00, 0xF8, 0x03, 0xF8, 0x07, 0xE0, 0x3F, 0xC0, 0x1F, 0x83, 0xBC,
  0x00, 0xFF, 0xF9, 0xE0, 0x07, 0xFF, 0xCF, 0x00, 0x1F, 0xF8, 0xF8, 0x00,
  0x7F, 0x87, 0xC0, 0x00, 0x60, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0x8F, 0xC0, 0xFC, 0x0F,
  0x81, 0xF0, 0x0F, 0x87, 0xC0, 0x1F, 0x1F, 0x80, 0x3C, 0x3E, 0x00, 0x78,
  0xFC, 0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0xC0, 0x7F, 0x1F,
  0x03, 0xFC, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x03, 0xFF,
  0xE0, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xC0, 0x04, 0x0F, 0xC0, 0x38, 0x1F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3E, 0x08, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x03, 0x7F, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0xC3,
  0xC0, 0x07, 0xFF, 0x1E, 0x00, 0x7F, 0xFD, 0xF0, 0x07, 0xFF, 0xEF, 0x80,
  0x7F, 0x03, 0xF8, 0x03, 0xF0, 0x1F, 0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xF0,
  0x03, 0xF0, 0x1F, 0x80, 0x1F, 0x80, 0xF8, 0x00, 0xF8, 0x0F, 0xC0, 0x07,
  0xC0, 0x7C, 0x00, 0x3E, 0x03, 0xE0, 0x01, 0xF0, 0x3F, 0x00, 0x1F, 0x81,
  0xF0, 0x00, 0xF8, 0x0F, 0x80, 0x07, 0xC0, 0x7C, 0x00, 0x3E, 0x07, 0xE0,
  0x01, 0xF0, 0x3F, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0xF8, 0x0F, 0x80, 0x07,
  0xC0, 0x7C, 0x00, 0x7E, 0x03, 0xE0, 0x03, 0xF0, 0x1F, 0x00, 0x3F, 0x00,
  0xF8, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0xC0, 0x3E, 0x01, 0xFE, 0x01, 0xF8,
  0x0F, 0xF0, 0x0F, 0xC1, 0xEF, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xF7,
  0xC0, 0x07, 0xFF, 0x3E, 0x00, 0x1F, 0xE1, 0xF0, 0x00, 0x18, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x20, 0x00, 0xFC, 0x01, 0xC0, 0x0F, 0xC0, 0x0F, 0xF3, 0xFC, 0x00,
  0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x1F,
  0x00, 0x1F, 0x1F, 0xF0, 0x07, 0xCF, 0xFE, 0x01, 0xF7, 0xFF, 0xC0, 0x7F,
  0xFF, 0xF0, 0x1F, 0xE0, 0xFC, 0x0F, 0xF0, 0x1F, 0x03, 0xF8, 0x07, 0xC0,
  0xFC, 0x01, 0xF0, 0x3F, 0x00, 0x7C, 0x1F, 0x80, 0x1F, 0x07, 0xE0, 0x07,
  0xC1, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x1F, 0x00, 0x3E, 0x0F, 0x80,
  0x0F, 0x83, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x0F,
  0x80, 0x1F, 0x07, 0xC0, 0x07, 0xC1, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0xFC,
  0x1F, 0x00, 0x3E, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x03, 0xE0, 0xF8, 0x00,
  0xF8, 0x3E, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x07, 0xC1, 0xF0,
  0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x0F, 0xC0, 0x0F, 0x80,
  0x00, 0x1C, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x01, 0xF8, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x03, 0xE0,
  0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x3F, 0x00, 0x3E, 0x0F, 0xC0, 0x07, 0xC3,
  0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0xC7, 0xE0, 0x00,
  0xF9, 0xF8, 0x00, 0x1F, 0x7E, 0x00, 0x03, 0xCF, 0x80, 0x00, 0xFB, 0xF0,
  0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F,
  0xEF, 0x80, 0x03, 0xF9, 0xF8, 0x00, 0x7E, 0x1F, 0x00, 0x0F, 0x83, 0xE0,
  0x01, 0xF0, 0x7C, 0x00, 0x3C, 0x0F, 0xC0, 0x0F, 0x80, 0xF8, 0x01, 0xF0,
  0x1F, 0x00, 0x3E, 0x03, 0xE0, 0x07, 0xC0, 0x7E, 0x01, 0xF0, 0x07, 0xC0,
  0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x80, 0xF8, 0x03, 0xF0, 0x3F, 0x00,
  0x3E, 0x00, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0xFF, 0x81, 0xFF, 0x00, 0x78,
  0xFF, 0xE3, 0xFF, 0x80, 0x3C, 0xFF, 0xF3, 0xFF, 0xE0, 0x1E, 0xFF, 0xFB,
  0xFF, 0xF0, 0x0F, 0xF0, 0x7F, 0xE0, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0x7E,
  0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x81, 0xF0,
  0x03, 0xE0, 0x0F, 0x81, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0xFC, 0x01, 0xF8,
  0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x81, 0xF0, 0x03, 0xE0, 0x0F, 0x81, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x03, 0xC0, 0x0F, 0x81, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x7E, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x7C,
  0x7F, 0xC0, 0x1E, 0x3F, 0xF8, 0x07, 0x9F, 0xFF, 0x01, 0xEF, 0xFF, 0xC0,
  0xFF, 0x83, 0xF0, 0x3F, 0xC0, 0x7C, 0x0F, 0xE0, 0x1F, 0x03, 0xF0, 0x07,
  0xC0, 0xFC, 0x01, 0xF0, 0x7E, 0x00, 0x7C, 0x1F, 0x80, 0x1F, 0x07, 0xC0,
  0x07, 0xC1, 0xF0, 0x03, 0xF0, 0x7C, 0x00, 0xF8, 0x3F, 0x00, 0x3E, 0x0F,
  0x80, 0x0F, 0x83, 0xE0, 0x07, 0xE0, 0xF8, 0x01, 0xF0, 0x7E, 0x00, 0x7C,
  0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x07, 0xC1, 0xF0, 0x03, 0xF0, 0x7C, 0x00,
  0xF8, 0x3F, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x03, 0xE0, 0xF8,
  0x01, 0xF8, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x07, 0xC1,
  0xF0, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x3F, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFD,
  0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0x3F, 0x0F, 0x80, 0x1F, 0x0F, 0x80,
  0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x3E, 0x00,
  0x1F, 0x3E, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00,
  0x1F, 0x7C, 0x00, 0x3F, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00,
  0x3E, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00,
  0xFC, 0xF8, 0x00, 0xF8, 0xF8, 0x01, 0xF8, 0xFC, 0x03, 0xF0, 0x7C, 0x03,
  0xE0, 0x7E, 0x0F, 0xE0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x03,
  0xE1, 0xFE, 0x00, 0x1F, 0x3F, 0xF8, 0x00, 0xF3, 0xFF, 0xE0, 0x07, 0xBE,
  0x7F, 0x00, 0x3D, 0xC0, 0xF8, 0x03, 0xFC, 0x07, 0xE0, 0x1F, 0xC0, 0x1F,
  0x00, 0xFE, 0x00, 0xF8, 0x07, 0xE0, 0x07, 0xC0, 0x3E, 0x00, 0x3E, 0x03,
  0xF0, 0x01, 0xF0, 0x1F, 0x80, 0x0F, 0x80, 0xF8, 0x00, 0x7C, 0x07, 0xC0,
  0x03, 0xE0, 0x7C, 0x00, 0x3F, 0x03, 0xE0, 0x01, 0xF0, 0x1F, 0x00, 0x0F,
  0x80, 0xF8, 0x00, 0x7C, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x3F, 0x03,
  0xE0, 0x01, 0xF0, 0x1F, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0xFC, 0x07, 0xC0,
  0x07, 0xC0, 0x7E, 0x00, 0x7E, 0x03, 0xF0, 0x03, 0xE0, 0x1F, 0x80, 0x3F,
  0x00, 0xFE, 0x03, 0xF0, 0x07, 0xF8, 0x3F, 0x00, 0x7D, 0xFF, 0xF8, 0x03,
  0xEF, 0xFF, 0x80, 0x1F, 0x3F, 0xF8, 0x00, 0xF8, 0xFF, 0x00, 0x0F, 0x80,
  0xC0, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xF0, 0xF0,
  0x0F, 0xFE, 0x3C, 0x07, 0xFF, 0xDF, 0x03, 0xFF, 0xF7, 0xC1, 0xFC, 0x1F,
  0xE0, 0x7E, 0x03, 0xF8, 0x3F, 0x00, 0x7E, 0x0F, 0x80, 0x1F, 0x87, 0xE0,
  0x07, 0xE1, 0xF0, 0x01, 0xF0, 0xFC, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x0F,
  0x80, 0x07, 0xC7, 0xE0, 0x01, 0xF1, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x3E,
  0x1F, 0x00, 0x0F, 0x8F, 0xC0, 0x03, 0xE3, 0xF0, 0x01, 0xF8, 0xF8, 0x00,
  0x7C, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0xC3, 0xE0, 0x03, 0xF0, 0xF8,
  0x01, 0xF8, 0x3E, 0x00, 0x7E, 0x0F, 0x80, 0x3F, 0x83, 0xE0, 0x1F, 0xE0,
  0xFC, 0x07, 0xF8, 0x3F, 0x87, 0xBC, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xF7,
  0xC0, 0x3F, 0xF9, 0xF0, 0x07, 0xF8, 0x7C, 0x00, 0x38, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x07, 0x87, 0xF0, 0x1E, 0x3F, 0x80, 0x79, 0xFE, 0x01, 0xEF, 0xF8, 0x07,
  0xBC, 0x20, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xFF,
  0xC0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xF9, 0xF8, 0x3F, 0x00, 0xC0,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0,
  0x80, 0x0F, 0x83, 0x80, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFC, 0x01, 0xFF, 0xE0, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0xF0,
  0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x1F, 0xFF, 0x3F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x07, 0xC0, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xFF, 0xE0,
  0x7F, 0xE0, 0x7F, 0xE0, 0x3F, 0xE0, 0x07, 0x00, 0x07, 0xC0, 0x07, 0xC1,
  0xF0, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x0F,
  0x83, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x0F, 0x80,
  0x1F, 0x07, 0xC0, 0x07, 0xC1, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x1F,
  0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0xF8,
  0x3E, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x07, 0xC1, 0xF0, 0x01,
  0xF0, 0x7C, 0x00, 0xFC, 0x1F, 0x00, 0x3E, 0x07, 0xC0, 0x0F, 0x83, 0xE0,
  0x07, 0xE0, 0xF8, 0x01, 0xF8, 0x3E, 0x00, 0xFE, 0x0F, 0x80, 0x7F, 0x03,
  0xF0, 0x3F, 0xC0, 0xFC, 0x1F, 0xF0, 0x3F, 0xFF, 0x7C, 0x07, 0xFF, 0x9E,
  0x00, 0xFF, 0xC7, 0x80, 0x1F, 0xE1, 0xE0, 0x01, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x3E, 0xF0, 0x00, 0xFD, 0xF0, 0x01, 0xF3, 0xE0, 0x07, 0xE7, 0xC0,
  0x0F, 0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x03,
  0xE0, 0xF8, 0x07, 0xC1, 0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0xF8,
  0x0F, 0x81, 0xF0, 0x1F, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x7C, 0x1F, 0x00,
  0xF8, 0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xE3, 0xE0, 0x07, 0xC7, 0xC0, 0x0F,
  0x9F, 0x00, 0x1F, 0x3E, 0x00, 0x1E, 0xF8, 0x00, 0x3D, 0xF0, 0x00, 0x7B,
  0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xFF, 0x80, 0x3F, 0x00, 0x3E, 0xF8, 0x03, 0xF0, 0x03, 0xEF,
  0x80, 0x7F, 0x00, 0x7C, 0xF8, 0x07, 0xF0, 0x07, 0xCF, 0x80, 0x7F, 0x00,
  0xF8, 0xF8, 0x0F, 0xF0, 0x0F, 0x8F, 0x80, 0xFF, 0x00, 0xF8, 0xF8, 0x1E,
  0xF0, 0x1F, 0x0F, 0x81, 0xEF, 0x01, 0xF0, 0xF8, 0x3E, 0xF0, 0x3E, 0x0F,
  0x83, 0xCF, 0x03, 0xE0, 0xF8, 0x3C, 0xF0, 0x3C, 0x0F, 0x87, 0x8F, 0x07,
  0xC0, 0xF0, 0x78, 0xF0, 0x7C, 0x0F, 0x0F, 0x8F, 0x0F, 0x80, 0xF0, 0xF0,
  0xF0, 0xF8, 0x0F, 0x0F, 0x0F, 0x0F, 0x00, 0xF1, 0xE0, 0xF1, 0xF0, 0x0F,
  0x1E, 0x0F, 0x1F, 0x00, 0xF3, 0xE0, 0xF3, 0xE0, 0x0F, 0x3C, 0x0F, 0x3E,
  0x00, 0xF3, 0xC0, 0xF3, 0xC0, 0x0F, 0x78, 0x0F, 0x7C, 0x00, 0xF7, 0x80,
  0xF7, 0x80, 0x0F, 0xF8, 0x0F, 0x78, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x0F,
  0xF0, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xF8, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0xF8, 0x00, 0xF8, 0x0F, 0x80, 0x07, 0xC0, 0xFC, 0x00, 0x3E, 0x07,
  0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x3E, 0x3E, 0x00,
  0x01, 0xF3, 0xE0, 0x00, 0x07, 0x9F, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x07,
  0xE7, 0xC0, 0x00, 0x3E, 0x3E, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x3F, 0x0F,
  0x80, 0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x01, 0xF0, 0x01, 0xF8, 0x0F, 0x80,
  0x0F, 0x80, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x0F, 0xC0, 0x0F, 0x80, 0xFC,
  0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x07, 0xC0,
  0x01, 0xF0, 0x03, 0xE0, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x7C, 0x01, 0xF0,
  0x00, 0x3E, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0xFC,
  0x00, 0x07, 0xC0, 0x7C, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0xF0, 0x3E,
  0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0x1E, 0x0F,
  0x80, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x03, 0xC7,
  0xC0, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x79,
  0xF0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x0F,
  0x78, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x07, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x7F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xC0, 0x00, 0xFE, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x9F,
  0xF8, 0x00, 0x5F, 0xFF, 0x00, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFB, 0x00, 0x3F, 0xF9, 0x00, 0x03, 0xF0,
};

const GFXglyph NotoSans_Condensed_Italic62pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 15, 45, 15, 1, -44 },
  { 86, 18, 16, 22, 6, -44 },
  { 122, 31, 44, 30, 1, -44 },
  { 293, 27, 51, 27, 1, -47 },
  { 466, 35, 46, 41, 4, -45 },
  { 668, 30, 46, 31, 0, -45 },
  { 841, 7, 16, 12, 7, -44 },
  { 855, 19, 55, 17, 2, -45 },
  { 986, 20, 55, 17, -5, -45 },
  { 1124, 22, 23, 26, 6, -47 },
  { 1188, 25, 30, 29, 3, -37 },
  { 1282, 12, 15, 14, -3, -7 },
  { 1305, 15, 5, 17, 1, -19 },
  { 1315, 7, 8, 14, 1, -7 },
  { 1322, 29, 44, 21, -3, -44 },
  { 1482, 25, 46, 27, 2, -45 },
  { 1626, 17, 44, 27, 7, -44 },
  { 1720, 28, 45, 27, -1, -45 },
  { 1878, 27, 46, 27, 0, -45 },
  { 2034, 28, 45, 27, -1, -45 },
  { 2192, 27, 45, 27, 0, -44 },
  { 2344, 26, 46, 27, 2, -45 },
  { 2494, 26, 44, 27, 3, -44 },
  { 2637, 27, 46, 27, 1, -45 },
  { 2793, 25, 46, 27, 1, -45 },
  { 2937, 13, 35, 14, 0, -34 },
  { 2994, 16, 42, 14, -3, -34 },
  { 3078, 25, 28, 29, 3, -36 },
  { 3166, 25, 17, 29, 3, -30 },
  { 3220, 25, 28, 29, 3, -36 },
  { 3308, 21, 46, 21, 2, -45 },
  { 3429, 38, 50, 41, 2, -45 },
  { 3667, 28, 44, 28, -4, -44 },
  { 3821, 29, 44, 30, 1, -44 },
  { 3981, 29, 46, 28, 3, -45 },
  { 4148, 30, 44, 33, 1, -44 },
  { 4313, 27, 44, 25, 1, -44 },
  { 4462, 27, 44, 24, 1, -44 },
  { 4611, 32, 46, 34, 3, -45 },
  { 4795, 34, 44, 34, 1, -44 },
  { 4982, 24, 44, 17, -3, -44 },
  { 5114, 24, 56, 14, -9, -44 },
  { 5282, 32, 44, 28, 1, -44 },
  { 5458, 19, 44, 24, 1, -44 },
  { 5563, 44, 44, 44, 1, -44 },
  { 5805, 36, 44, 35, 1, -44 },
  { 6003, 31, 46, 35, 3, -45 },
  { 6182, 28, 44, 28, 1, -44 },
  { 6336, 31, 56, 35, 3, -45 },
  { 6553, 28, 44, 29, 1, -44 },
  { 6707, 29, 46, 26, -1, -45 },
  { 6874, 24, 44, 24, 5, -44 },
  { 7006, 31, 45, 33, 3, -44 },
  { 7181, 28, 44, 28, 5, -44 },
  { 7335, 43, 44, 44, 6, -44 },
  { 7572, 35, 44, 26, -4, -44 },
  { 7765, 25, 44, 25, 5, -44 },
  { 7903, 30, 44, 24, -2, -44 },
  { 8068, 23, 55, 18, -1, -45 },
  { 8227, 11, 44, 21, 6, -44 },
  { 8288, 23, 55, 18, -4, -45 },
  { 8447, 26, 25, 28, 1, -44 },
  { 8529, 21, 4, 21, -5, 5 },
  { 8540, 9, 9, 16, 9, -47 },
  { 8551, 27, 35, 29, 2, -34 },
  { 8670, 27, 48, 29, 0, -47 },
  { 8832, 22, 35, 22, 2, -34 },
  { 8929, 29, 48, 29, 2, -47 },
  { 9103, 23, 35, 26, 2, -34 },
  { 9204, 30, 62, 16, -7, -47 },
  { 9437, 29, 49, 29, -1, -34 },
  { 9615, 26, 47, 29, 0, -47 },
  { 9768, 15, 46, 13, 0, -46 },
  { 9855, 23, 61, 13, -8, -46 },
  { 10031, 27, 47, 25, 0, -47 },
  { 10190, 16, 47, 13, 0, -47 },
  { 10284, 41, 34, 43, 0, -34 },
  { 10459, 26, 34, 29, 0, -34 },
  { 10570, 24, 35, 28, 2, -34 },
  { 10675, 29, 49, 29, -2, -34 },
  { 10853, 26, 49, 29, 2, -34 },
  { 11013, 22, 34, 19, 0, -34 },
  { 11107, 22, 35, 22, 0, -34 },
  { 11204, 16, 42, 16, 2, -41 },
  { 11288, 26, 34, 29, 2, -33 },
  { 11399, 23, 33, 23, 3, -33 },
  { 11494, 36, 33, 37, 4, -33 },
  { 11643, 29, 33, 24, -3, -33 },
  { 11763, 33, 48, 23, -6, -33 },
  { 11961, 24, 33, 21, -2, -33 },
  { 12060, 23, 54, 21, 1, -44 },
  { 12216, 5, 62, 26, 11, -47 },
  { 12255, 22, 54, 21, -3, -44 },
  { 12404, 25, 8, 29, 3, -26 },
};

const GFXfont NotoSans_Condensed_Italic62pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Italic62pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Italic62pt7bGlyphs,
  0x20, 0x7E, 84
};

#endif // _NOTOSANS_CONDENSED_ITALIC62PT7B_H_
