#ifndef _NOTOSANS_CONDENSED_ITALIC72PT7B_H_
#define _NOTOSANS_CONDENSED_ITALIC72PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Italic.ttf
// Size: 72pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Italic72pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x00, 0xC0, 0x00, 0x1F, 0xC3,
  0xF8, 0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x3F, 0x07, 0xE3, 0xF0, 0x3F, 0x1F,
  0x81, 0xF0, 0xFC, 0x1F, 0x87, 0xC0, 0xFC, 0x3E, 0x07, 0xE1, 0xF0, 0x3E,
  0x1F, 0x81, 0xF0, 0xF8, 0x0F, 0x87, 0xC0, 0x78, 0x3E, 0x07, 0xC1, 0xF0,
  0x3E, 0x0F, 0x01, 0xF0, 0x78, 0x0F, 0x07, 0xC0, 0x78, 0x00, 0x00, 0x00,
  0x7C, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x00, 0xF8, 0x0F, 0x80,
  0x00, 0x0F, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x1F, 0x01,
  0xF0, 0x00, 0x01, 0xE0, 0x1F, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x03,
  0xE0, 0x3E, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x3C, 0x00,
  0x00, 0x7C, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x78, 0x07,
  0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x01, 0xE0, 0x1F, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x3E,
  0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x7C,
  0x03, 0xC0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00,
  0x0F, 0x80, 0x78, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x0F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x7C, 0x03, 0xC0,
  0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x78, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x78, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x00,
  0xF0, 0x0F, 0x00, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x1F, 0x00,
  0x00, 0x1E, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x3E, 0x03,
  0xE0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFD, 0xCF, 0xE0, 0x1F,
  0xC7, 0x83, 0x80, 0x3F, 0x0F, 0x01, 0x00, 0x7C, 0x1E, 0x00, 0x01, 0xF8,
  0x38, 0x00, 0x03, 0xE0, 0x70, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x0F, 0x83,
  0xC0, 0x00, 0x1F, 0x07, 0x00, 0x00, 0x3E, 0x0E, 0x00, 0x00, 0x7E, 0x1C,
  0x00, 0x00, 0xFC, 0x78, 0x00, 0x00, 0xFC, 0xF0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0E, 0x7F, 0x00,
  0x00, 0x1C, 0x7E, 0x00, 0x00, 0x38, 0x7E, 0x00, 0x00, 0xF0, 0xFC, 0x00,
  0x01, 0xE1, 0xF8, 0x00, 0x03, 0x81, 0xF0, 0x00, 0x07, 0x07, 0xE0, 0x00,
  0x1E, 0x0F, 0xC0, 0x00, 0x3C, 0x1F, 0x80, 0x00, 0x70, 0x3E, 0x04, 0x00,
  0xE0, 0xFC, 0x0C, 0x01, 0xC3, 0xF0, 0x1F, 0x07, 0x8F, 0xE0, 0x3F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3E, 0x00,
  0x7F, 0xF0, 0x00, 0x3E, 0x00, 0x7F, 0xF8, 0x00, 0x1E, 0x00, 0x7E, 0x7E,
  0x00, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x0F,
  0x80, 0x3E, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x01, 0xE0, 0x07, 0xC0, 0x0F,
  0x00, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x07, 0xC0, 0x7C,
  0x03, 0xE0, 0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x03, 0xE0, 0x1F, 0x01, 0xF0,
  0x01, 0xF0, 0x0F, 0x81, 0xF0, 0x00, 0xF8, 0x07, 0xC0, 0xF0, 0x00, 0x7C,
  0x03, 0xC0, 0xF8, 0x00, 0x3C, 0x03, 0xE0, 0xF8, 0x00, 0x1E, 0x01, 0xF0,
  0x7C, 0x00, 0x1F, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x80, 0x78, 0x3C, 0x02,
  0x07, 0xC0, 0x7C, 0x3E, 0x0F, 0xE3, 0xE0, 0x3E, 0x3E, 0x1F, 0xF9, 0xF0,
  0x3E, 0x1F, 0x1F, 0xFE, 0xF8, 0x1F, 0x1F, 0x0F, 0xFF, 0xFC, 0x1F, 0x0F,
  0x8F, 0x87, 0xFE, 0x0F, 0x8F, 0x8F, 0x83, 0xEF, 0x9F, 0x8F, 0x87, 0xC1,
  0xF7, 0xFF, 0x87, 0xC7, 0xC0, 0x79, 0xFF, 0xC7, 0xC3, 0xE0, 0x3C, 0xFF,
  0x83, 0xE3, 0xE0, 0x1E, 0x1F, 0x83, 0xE1, 0xF0, 0x1F, 0x00, 0x01, 0xE0,
  0xF8, 0x0F, 0x80, 0x01, 0xF0, 0x78, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x03,
  0xE0, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x00, 0xF8, 0x1F, 0x00, 0xF0, 0x00,
  0x7C, 0x0F, 0x00, 0xF8, 0x00, 0x7C, 0x07, 0x80, 0x7C, 0x00, 0x7C, 0x07,
  0xC0, 0x3E, 0x00, 0x3E, 0x03, 0xE0, 0x1E, 0x00, 0x3E, 0x01, 0xF0, 0x1F,
  0x00, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x07, 0x80, 0x1F,
  0x00, 0x3E, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x0F, 0x80, 0x0F,
  0x83, 0xE0, 0x07, 0xC0, 0x03, 0xE3, 0xF0, 0x07, 0xC0, 0x01, 0xFF, 0xF0,
  0x03, 0xE0, 0x00, 0xFF, 0xF0, 0x03, 0xE0, 0x00, 0x3F, 0xF0, 0x03, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0x07, 0xE0, 0x3F, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x1F, 0x80,
  0x7C, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x7C, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x3F, 0x07, 0xE0, 0x00,
  0x07, 0xE1, 0xFC, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x0F, 0xCF, 0xC0,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xBF, 0x80, 0x7E, 0x0F, 0xE3, 0xF0, 0x1F, 0x83, 0xF8, 0x7E, 0x03,
  0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x1F, 0x80, 0xFC, 0x1F, 0x87, 0xE0, 0x0F,
  0xC3, 0xF0, 0xFC, 0x01, 0xF8, 0xFC, 0x3F, 0x00, 0x3F, 0x9F, 0x87, 0xE0,
  0x03, 0xF7, 0xE0, 0xFC, 0x00, 0x7F, 0xFC, 0x1F, 0x80, 0x07, 0xFF, 0x07,
  0xE0, 0x00, 0xFF, 0xC0, 0xFC, 0x00, 0x0F, 0xF8, 0x1F, 0x80, 0x01, 0xFE,
  0x03, 0xF0, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x0F, 0xF0, 0x07, 0xE0, 0x03,
  0xFF, 0x00, 0xFC, 0x00, 0xFF, 0xE0, 0x1F, 0xC0, 0x3F, 0xFE, 0x03, 0xFF,
  0x3F, 0xEF, 0xC0, 0x3F, 0xFF, 0xF9, 0xFC, 0x03, 0xFF, 0xFE, 0x1F, 0x80,
  0x3F, 0xFF, 0x03, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0x80, 0x0F, 0x00, 0x00,
  0x00, 0x3F, 0x9F, 0x8F, 0xC7, 0xE3, 0xE3, 0xF1, 0xF8, 0xFC, 0x7C, 0x3E,
  0x1F, 0x0F, 0x8F, 0x87, 0xC3, 0xE1, 0xE0, 0xF0, 0x78, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x78, 0x00, 0x80, 0x7C, 0x00, 0xF0, 0x3E, 0x00, 0x7E,
  0x1F, 0x00, 0x3F, 0xCF, 0x00, 0x3F, 0xFF, 0x83, 0xEF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x01, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xF7, 0xC0, 0x01, 0xF9, 0xE0, 0x01, 0xF8, 0xF8,
  0x01, 0xF8, 0x7C, 0x01, 0xFC, 0x1F, 0x00, 0x7C, 0x0F, 0xC0, 0x1C, 0x07,
  0xE0, 0x04, 0x01, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF8,
  0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0x7E, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x1F,
  0x80, 0xFC, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x00,
  0xF8, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xEF, 0xFF,
  0xF0, 0x3E, 0x7F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0x7C, 0x30, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xE3, 0xF8, 0x01, 0xFC, 0x0F, 0xC0, 0x1F,
  0xC0, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0x7E, 0x00,
  0x7E, 0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFC,
  0x1F, 0x80, 0x07, 0xE1, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF8, 0x7E,
  0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7E, 0x3F, 0x00, 0x03, 0xF1, 0xF8, 0x00,
  0x1F, 0x8F, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E,
  0x3F, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0xFC, 0xFC,
  0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x03, 0xF1, 0xF8, 0x00,
  0x1F, 0x8F, 0xC0, 0x00, 0xFC, 0x7E, 0x00, 0x0F, 0xE3, 0xE0, 0x00, 0x7E,
  0x3F, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xF8, 0x7E,
  0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00,
  0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x1F, 0x80, 0xFC, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x01, 0xFC, 0x01, 0xFC, 0x1F, 0xC0, 0x07,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x01, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF,
  0x81, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0xEF, 0xC7, 0xF9, 0xF3, 0xFC, 0x7E,
  0x3F, 0x0F, 0xC3, 0xC1, 0xF8, 0x60, 0x3E, 0x04, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0x07,
  0xF8, 0x00, 0x7C, 0x01, 0xFE, 0x00, 0x1C, 0x00, 0x7F, 0x00, 0x08, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xE0, 0x7F, 0x80, 0x1F,
  0x00, 0x3F, 0x80, 0x18, 0x00, 0x7F, 0x00, 0x20, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x10, 0x00, 0x0F, 0xE0, 0x3C, 0x00, 0x7F,
  0x80, 0x7F, 0x8F, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x3E,
  0x7C, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x00, 0xF8,
  0xF8, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x03, 0xE1,
  0xF8, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x83,
  0xF0, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3E, 0x03,
  0xF0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0xF8, 0x07,
  0xE0, 0x01, 0xF0, 0x07, 0xE0, 0x03, 0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x0F,
  0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0xC0, 0x1F, 0x80, 0x0F,
  0xC0, 0x1F, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x1F,
  0x80, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0xC0,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xF9, 0xFF, 0xC0, 0x01, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0xC0, 0x00, 0x7F, 0x00, 0xF0, 0x01, 0xFF, 0x00, 0xFF, 0x1F, 0xFE,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xC0, 0x60, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x07, 0xF8, 0x00, 0xFC, 0x7F, 0xF8, 0x03, 0xF7, 0xFF, 0xE0, 0x0F,
  0xBF, 0xFF, 0xC0, 0x7E, 0xFF, 0xFF, 0x81, 0xFF, 0x80, 0xFE, 0x07, 0xFC,
  0x01, 0xF8, 0x1F, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xC3, 0xF8, 0x00,
  0x3F, 0x0F, 0xE0, 0x00, 0xFC, 0x3F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF0,
  0xF8, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x7E, 0x0F, 0x80, 0x01, 0xF8, 0x3E,
  0x00, 0x07, 0xE0, 0xF8, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0xFC, 0x0F, 0xC0,
  0x07, 0xF0, 0x3F, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x07,
  0xF0, 0x07, 0xF0, 0x3F, 0x80, 0x1F, 0xF7, 0xFE, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0x80,
  0x3F, 0x80, 0x7E, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x7E, 0x03, 0xF0, 0x00,
  0xFC, 0x07, 0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0x80, 0x07,
  0xE0, 0x3F, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x7E,
  0x01, 0xF8, 0x00, 0xFC, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x0F, 0xC0,
  0x07, 0xE0, 0x3F, 0x80, 0x07, 0xE0, 0xFE, 0x00, 0x0F, 0xE7, 0xF8, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F,
  0xCF, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xC0, 0x3F, 0x80, 0x1F, 0xC0, 0xFE, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x3F, 0x03, 0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x00,
  0xFC, 0x3F, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x07,
  0xC1, 0xF8, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7E,
  0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0xC0, 0x07, 0xF0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x3F, 0xE1, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFE, 0x1F, 0xC0, 0x0F,
  0xE0, 0x3F, 0x80, 0x7F, 0x00, 0x7E, 0x01, 0xF8, 0x01, 0xF8, 0x0F, 0xC0,
  0x03, 0xE0, 0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x00,
  0xFC, 0x1F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3F,
  0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0xC3,
  0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x3F, 0x83, 0xF0, 0x01, 0xFE, 0x0F, 0xC0, 0x07, 0xF8, 0x3F, 0x80,
  0x3F, 0xE0, 0xFE, 0x01, 0xFF, 0x01, 0xFE, 0x1F, 0xFC, 0x07, 0xFF, 0xFB,
  0xF0, 0x0F, 0xFF, 0xEF, 0xC0, 0x1F, 0xFE, 0x3E, 0x00, 0x3F, 0xF1, 0xF8,
  0x00, 0x7F, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x08, 0x00, 0xFE, 0x00, 0x3F, 0x7F, 0xF0, 0x00,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x01, 0xF8, 0x03,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x00, 0xFC, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x3F, 0x00, 0xFF, 0x01, 0xFE,
  0x03, 0xF8, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x1C, 0x00, 0x00, 0x03,
  0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03,
  0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F,
  0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xF0, 0x3F, 0x07, 0xF8, 0x1C, 0x01, 0xFC, 0x04, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x78, 0x07, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x7C, 0x00, 0x7F,
  0xF0, 0x1F, 0x03, 0xE0, 0x0F, 0xFF, 0xC0, 0xF8, 0x3E, 0x00, 0xFF, 0xFE,
  0x07, 0xC1, 0xE0, 0x0F, 0xE7, 0xF0, 0x3E, 0x1F, 0x00, 0xFC, 0x1F, 0x01,
  0xF0, 0xF8, 0x0F, 0xC0, 0xF8, 0x0F, 0x8F, 0x80, 0x7C, 0x07, 0xC0, 0x7C,
  0x7C, 0x07, 0xC0, 0x3E, 0x03, 0xE3, 0xC0, 0x3C, 0x03, 0xE0, 0x1E, 0x3E,
  0x03, 0xE0, 0x1F, 0x00, 0xF1, 0xF0, 0x1E, 0x00, 0xF8, 0x0F, 0x8F, 0x81,
  0xF0, 0x07, 0x80, 0x7C, 0x78, 0x0F, 0x80, 0x7C, 0x03, 0xE7, 0xC0, 0x78,
  0x03, 0xE0, 0x1E, 0x3E, 0x07, 0xC0, 0x1F, 0x00, 0xF1, 0xF0, 0x3E, 0x00,
  0xF0, 0x0F, 0x8F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x78, 0x0F, 0x80, 0x7C,
  0x03, 0xC3, 0xC0, 0x78, 0x03, 0xE0, 0x3E, 0x1E, 0x03, 0xC0, 0x3F, 0x01,
  0xE1, 0xF0, 0x1E, 0x01, 0xF0, 0x1F, 0x0F, 0x80, 0xF0, 0x1F, 0x80, 0xF0,
  0x7C, 0x07, 0xC0, 0xFC, 0x0F, 0x83, 0xE0, 0x3E, 0x0E, 0xF0, 0xF8, 0x1F,
  0x01, 0xF8, 0xF7, 0x8F, 0xC0, 0xF8, 0x0F, 0xFF, 0x3F, 0xFC, 0x07, 0xC0,
  0x3F, 0xF1, 0xFF, 0xC0, 0x1E, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0xF0, 0x03,
  0xF0, 0x0F, 0x80, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0x80, 0x00, 0x03, 0xFC, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xBE,
  0x00, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x03, 0xE7,
  0xE0, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x00, 0xF8,
  0xFC, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0x7E,
  0x1F, 0x80, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1F,
  0x83, 0xF0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x0F,
  0xC0, 0x7E, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x03, 0xE0, 0x1F, 0x80, 0x03,
  0xF0, 0x07, 0xC0, 0x01, 0xF8, 0x03, 0xE0, 0x01, 0xF8, 0x01, 0xF0, 0x00,
  0xFC, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xC0, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0xFC,
  0x07, 0xE0, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x1F,
  0x83, 0xF8, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x03,
  0xF0, 0xFC, 0x00, 0x01, 0xF8, 0xFE, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00,
  0x7E, 0x3F, 0x00, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x1F, 0x9F, 0x80, 0x00,
  0x0F, 0xDF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0x80, 0x3F, 0xE0,
  0x07, 0xE0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x1F,
  0xC0, 0x1F, 0x80, 0x07, 0xF0, 0x0F, 0xC0, 0x01, 0xFC, 0x03, 0xF0, 0x00,
  0x7F, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x07, 0xE0, 0x0F, 0xC0,
  0x01, 0xF8, 0x07, 0xE0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x7E,
  0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x07, 0xF0, 0x07, 0xC0, 0x03, 0xF8, 0x03,
  0xF0, 0x03, 0xFC, 0x00, 0xFC, 0x0F, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0x80, 0x3F, 0xC0, 0x07, 0xE0, 0x03,
  0xF8, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x3F, 0x00,
  0x07, 0xF0, 0x0F, 0xC0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x3F, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x01, 0xFC, 0x07,
  0xE0, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x07, 0xE0,
  0x3F, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x7F,
  0x01, 0xF8, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x3F, 0xE0, 0x1F, 0x80, 0x7F,
  0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0x07,
  0xC0, 0x03, 0xFE, 0x00, 0x60, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFE, 0x03, 0xFF, 0x00,
  0x1F, 0x80, 0x1F, 0xE0, 0x03, 0xF0, 0x01, 0xFE, 0x00, 0x7E, 0x00, 0x1F,
  0xC0, 0x0F, 0xC0, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x7E, 0x00,
  0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x3F,
  0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x3F, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x03,
  0xF0, 0x3F, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0xFC, 0x00,
  0x01, 0xF8, 0x1F, 0x80, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0xFC,
  0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x07,
  0xE0, 0x7E, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x81, 0xF8, 0x00,
  0x07, 0xE0, 0x7E, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x81, 0xF8,
  0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x7F, 0x01,
  0xF8, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x07, 0xF8, 0x07, 0xE0, 0x01, 0xFE,
  0x00, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0x00, 0x1F, 0xE0, 0x07, 0xE0, 0x0F,
  0xFC, 0x00, 0xFC, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x40, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0x80, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFE, 0x07, 0xF8, 0x00, 0xFF, 0x80,
  0x07, 0x80, 0x0F, 0xF8, 0x00, 0x0C, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x7F, 0xFE, 0x1F, 0x80, 0x03, 0xFF, 0xE0, 0xFC, 0x00,
  0x1F, 0xFF, 0x07, 0xE0, 0x01, 0xFF, 0xF8, 0x3F, 0x00, 0x0F, 0xFF, 0xC1,
  0xF8, 0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x00,
  0x3F, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00, 0x0F, 0xC1, 0xFC,
  0x00, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x00, 0x3F,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x7E, 0x00,
  0x00, 0xFC, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x1F, 0xC0, 0x00, 0x3F, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x1F, 0xE0, 0x00,
  0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x07, 0xC0, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xFC, 0x00, 0xFC, 0x00, 0x1F,
  0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x3F,
  0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x07, 0xF0,
  0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x01, 0xF8,
  0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x00, 0x3F, 0x01, 0xFC, 0x00,
  0x00, 0xFC, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x00, 0x0F, 0xC1,
  0xFC, 0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00,
  0x07, 0xE1, 0xFC, 0x00, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x00, 0x7E, 0x7F,
  0x00, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x00,
  0x3F, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xEF, 0xF0,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x7E, 0x00, 0x00, 0x07, 0xF9, 0xF8, 0x00, 0x00, 0x3F, 0xC7, 0xE0,
  0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0xFC, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x0F, 0xE0,
  0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x7E,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x1F, 0xC0,
  0x01, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0x3F, 0x80,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x1F,
  0x7E, 0x00, 0x7E, 0xF8, 0x00, 0x07, 0xEF, 0x80, 0x0F, 0xDF, 0x00, 0x00,
  0xFB, 0xF0, 0x01, 0xF3, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x3E, 0x7C, 0x00,
  0x07, 0xCF, 0xC0, 0x0F, 0xCF, 0x80, 0x01, 0xF9, 0xF8, 0x01, 0xF9, 0xF0,
  0x00, 0x3E, 0x7E, 0x00, 0x3F, 0x3E, 0x00, 0x0F, 0xCF, 0xC0, 0x07, 0xC7,
  0xC0, 0x01, 0xF1, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x3F,
  0x1F, 0x00, 0x0F, 0x87, 0xE0, 0x07, 0xE3, 0xE0, 0x03, 0xF1, 0xF8, 0x00,
  0xFC, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x0F, 0xC0, 0x1F, 0x87, 0xE0,
  0x07, 0xE1, 0xF8, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x7C, 0x1F,
  0x00, 0x1F, 0x83, 0xE0, 0x1F, 0x87, 0xE0, 0x03, 0xF0, 0x7C, 0x03, 0xE0,
  0xFC, 0x00, 0x7C, 0x0F, 0x80, 0xFC, 0x1F, 0x80, 0x1F, 0x81, 0xF0, 0x1F,
  0x03, 0xF0, 0x03, 0xF0, 0x3E, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x07, 0xC0,
  0xF8, 0x1F, 0x80, 0x0F, 0x80, 0xF8, 0x3F, 0x03, 0xF0, 0x01, 0xF0, 0x1F,
  0x07, 0xC0, 0x7E, 0x00, 0x7E, 0x03, 0xE1, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0,
  0x7C, 0x3E, 0x03, 0xF0, 0x01, 0xF8, 0x0F, 0x8F, 0xC0, 0x7E, 0x00, 0x3E,
  0x01, 0xF1, 0xF0, 0x0F, 0xC0, 0x0F, 0xC0, 0x3F, 0x7E, 0x01, 0xF8, 0x01,
  0xF8, 0x07, 0xEF, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0xFF, 0xF0, 0x0F, 0xC0,
  0x07, 0xE0, 0x1F, 0xFC, 0x01, 0xF8, 0x00, 0xF8, 0x01, 0xFF, 0x80, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xFC, 0x00,
  0xF8, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0xE0,
  0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x1F,
  0xE0, 0x00, 0x0F, 0xC0, 0x0F, 0xF0, 0x00, 0x07, 0xE0, 0x07, 0xF8, 0x00,
  0x03, 0xF0, 0x03, 0xFE, 0x00, 0x01, 0xF0, 0x03, 0xFF, 0x00, 0x01, 0xF8,
  0x01, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x7E, 0x00, 0x7F,
  0xF0, 0x00, 0x3F, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0x00, 0x3F, 0x7C, 0x00,
  0x1F, 0x80, 0x1F, 0xBE, 0x00, 0x0F, 0xC0, 0x0F, 0x9F, 0x80, 0x07, 0xE0,
  0x07, 0xCF, 0xC0, 0x03, 0xE0, 0x03, 0xE7, 0xE0, 0x03, 0xF0, 0x03, 0xF1,
  0xF0, 0x01, 0xF8, 0x01, 0xF8, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x7E, 0x00,
  0x7E, 0x00, 0x7C, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x3F, 0x00,
  0x3F, 0x07, 0xC0, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x0F, 0xC0, 0x0F, 0xC1,
  0xF8, 0x07, 0xE0, 0x07, 0xC0, 0xFC, 0x03, 0xE0, 0x07, 0xE0, 0x3E, 0x03,
  0xF0, 0x03, 0xF0, 0x1F, 0x01, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0xFC, 0x00,
  0xFC, 0x07, 0xE0, 0x7C, 0x00, 0x7C, 0x01, 0xF0, 0x3E, 0x00, 0x7E, 0x00,
  0xF8, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x0F,
  0xC0, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0xC0, 0x07, 0xC7, 0xE0, 0x07,
  0xE0, 0x03, 0xF3, 0xF0, 0x03, 0xF0, 0x01, 0xF9, 0xF8, 0x01, 0xF8, 0x00,
  0xFC, 0xFC, 0x00, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0xFC, 0x00, 0x1F, 0x3E,
  0x00, 0x7E, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0x80, 0x1F,
  0x80, 0x01, 0xFF, 0xC0, 0x0F, 0x80, 0x00, 0xFF, 0xC0, 0x0F, 0xC0, 0x00,
  0x7F, 0xE0, 0x07, 0xE0, 0x00, 0x3F, 0xF0, 0x03, 0xF0, 0x00, 0x0F, 0xF8,
  0x01, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0x0F, 0xFC, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x7E,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x3F, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x7F, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0xFE,
  0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x3F,
  0x1F, 0xC0, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00,
  0x03, 0xF3, 0xF8, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x07, 0xF3, 0xF0,
  0x00, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x00, 0x7E,
  0x7F, 0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00,
  0x0F, 0xE7, 0xE0, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0x0F, 0xCF, 0xE0,
  0x00, 0x00, 0xFC, 0xFE, 0x00, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x01, 0xF8,
  0xFE, 0x00, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00,
  0x3F, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0x7E, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x1F, 0xC0,
  0x7F, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x07,
  0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7E,
  0x01, 0xFE, 0x00, 0x7E, 0x00, 0xFF, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0xFC,
  0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3F, 0x01, 0xF8,
  0x00, 0x3F, 0x01, 0xF8, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x7E, 0x03, 0xF0,
  0x00, 0xFE, 0x03, 0xF0, 0x00, 0xFC, 0x03, 0xF0, 0x01, 0xFC, 0x03, 0xF0,
  0x07, 0xF8, 0x07, 0xE0, 0x0F, 0xF8, 0x07, 0xE1, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0x0F, 0xFC, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x7E, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x7F, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0xFE, 0x00,
  0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x3F, 0x1F,
  0xC0, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x03,
  0xF3, 0xF8, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x03, 0xF3, 0xF0, 0x00,
  0x00, 0x7F, 0x3F, 0x00, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x00, 0x7E, 0x7F,
  0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x0F,
  0xE7, 0xE0, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0x0F, 0xCF, 0xE0, 0x00,
  0x00, 0xFC, 0xFE, 0x00, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x01, 0xF8, 0xFE,
  0x00, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00, 0x3F,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x7E, 0x00, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x7F,
  0x00, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x07, 0xF0,
  0x03, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x03,
  0xF0, 0x0F, 0xF0, 0x01, 0xF8, 0x03, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x0F, 0xE0,
  0x1F, 0x80, 0x07, 0xF0, 0x0F, 0xC0, 0x03, 0xF8, 0x07, 0xE0, 0x01, 0xFC,
  0x03, 0xF0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0xFC, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x0F,
  0xC0, 0x3F, 0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F,
  0xE0, 0x07, 0xE0, 0x1F, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x1F, 0x81,
  0xF8, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x07, 0xE0,
  0x1F, 0x80, 0x03, 0xF0, 0x0F, 0xC0, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0xFC,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x0F,
  0xC0, 0x03, 0xF0, 0x07, 0xE0, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0xFE, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x0F, 0xE0,
  0x7E, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0x87, 0xF8, 0x01, 0xFF,
  0x00, 0x78, 0x00, 0xFE, 0x00, 0x04, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x08, 0x00,
  0x03, 0xF8, 0x03, 0x00, 0x03, 0xFC, 0x01, 0xF0, 0x07, 0xFC, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00,
  0xFC, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0xFC,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0xFC, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0xFC, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x7E, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x07, 0xF0, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7E,
  0xFC, 0x00, 0x00, 0xFE, 0x7C, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x01, 0xFC,
  0x7E, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x03, 0xF0,
  0x7E, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x07, 0xE0,
  0x7E, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0xC0,
  0x7E, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x3F, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x7E, 0x01, 0xF8, 0x00,
  0x7E, 0x01, 0xF8, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x00,
  0x7E, 0x03, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7E, 0x07, 0xE0, 0x00,
  0x7E, 0x0F, 0xC0, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x3E, 0x1F, 0x80, 0x00,
  0x3E, 0x1F, 0x80, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x3E, 0x3F, 0x00, 0x00,
  0x3E, 0x3F, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00,
  0x3E, 0xFC, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xF9, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x3E, 0x00, 0x01, 0xFC, 0x00,
  0x0F, 0xE7, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xF8, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0x1F, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x7F,
  0xC0, 0x01, 0xF8, 0x7C, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0x0F, 0x80, 0x03,
  0xFF, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xF8, 0x3E, 0x00,
  0x1F, 0x7C, 0x00, 0x7E, 0x07, 0xC0, 0x03, 0xEF, 0x80, 0x0F, 0xC0, 0xF8,
  0x00, 0xFD, 0xF0, 0x03, 0xF8, 0x1F, 0x00, 0x1F, 0x3E, 0x00, 0x7E, 0x03,
  0xE0, 0x03, 0xE7, 0xC0, 0x0F, 0xC0, 0x7C, 0x00, 0xF8, 0xF8, 0x03, 0xF0,
  0x0F, 0x80, 0x1F, 0x1F, 0x00, 0x7E, 0x01, 0xF0, 0x07, 0xE3, 0xE0, 0x1F,
  0x80, 0x3E, 0x00, 0xF8, 0x7C, 0x03, 0xF0, 0x07, 0xC0, 0x3F, 0x0F, 0x80,
  0x7E, 0x00, 0xF8, 0x07, 0xC1, 0xF0, 0x1F, 0x80, 0x1F, 0x00, 0xF8, 0x3E,
  0x03, 0xF0, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0xFC, 0x00, 0x7C, 0x07, 0xC0,
  0xF8, 0x1F, 0x80, 0x0F, 0x81, 0xF8, 0x3F, 0x03, 0xF0, 0x01, 0xF0, 0x3E,
  0x07, 0xE0, 0xFC, 0x00, 0x3E, 0x07, 0xC0, 0xFC, 0x1F, 0x80, 0x07, 0xC1,
  0xF0, 0x1F, 0x87, 0xE0, 0x00, 0xF8, 0x3E, 0x03, 0xF0, 0xFC, 0x00, 0x1F,
  0x0F, 0xC0, 0x7C, 0x1F, 0x00, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xE0, 0x00,
  0x7C, 0x3E, 0x01, 0xF0, 0xFC, 0x00, 0x0F, 0x8F, 0x80, 0x3E, 0x3F, 0x00,
  0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xE0, 0x00, 0x3E, 0x7E, 0x00, 0xF8, 0xF8,
  0x00, 0x07, 0xCF, 0x80, 0x1F, 0x3F, 0x00, 0x00, 0xF9, 0xF0, 0x03, 0xE7,
  0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x7C, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x0F,
  0xBF, 0x00, 0x00, 0x7F, 0xF0, 0x01, 0xF7, 0xC0, 0x00, 0x0F, 0xFC, 0x00,
  0x3E, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x01, 0xF9, 0xF8,
  0x00, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xE7,
  0xC0, 0x00, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0xF8, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0xFE,
  0x00, 0x03, 0xFB, 0xF0, 0x00, 0x1F, 0x9F, 0x80, 0x01, 0xFC, 0xFC, 0x00,
  0x0F, 0xC7, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x7E,
  0x0F, 0xC0, 0x07, 0xF0, 0x3F, 0x00, 0x3F, 0x01, 0xF8, 0x03, 0xF8, 0x0F,
  0xC0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80,
  0xFC, 0x00, 0x7C, 0x07, 0xE0, 0x03, 0xE0, 0x7E, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0xFC, 0x3F, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x3F, 0x1F, 0x80, 0x01,
  0xF9, 0xF8, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x3E, 0xFC, 0x00, 0x01, 0xF7,
  0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xFC, 0x07, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x10, 0x0F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0xFF, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x0F, 0xBE, 0x00,
  0x00, 0x7C, 0x7C, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x0F, 0x87, 0xE0, 0x00,
  0x7E, 0x0F, 0x80, 0x01, 0xF0, 0x3E, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x3E,
  0x01, 0xF0, 0x01, 0xF0, 0x07, 0xC0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00,
  0x3E, 0x01, 0xF8, 0x00, 0xF8, 0x07, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x07,
  0xC0, 0xF8, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x7E, 0x1F, 0x00, 0x00, 0xF8,
  0xFC, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0x8F, 0xE1, 0xF8, 0x3E,
  0x0F, 0xC1, 0xF0, 0x7E, 0x0F, 0x81, 0xE0, 0x7C, 0x00, 0x07, 0xF0, 0x3E,
  0x00, 0x3F, 0xF8, 0x7C, 0x00, 0xFF, 0xF8, 0xF8, 0x03, 0xFF, 0xF3, 0xE0,
  0x0F, 0xFF, 0xF7, 0xC0, 0x3F, 0xC1, 0xEF, 0x80, 0xFE, 0x01, 0xFF, 0x01,
  0xF8, 0x01, 0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x0F, 0xC0, 0x07, 0xF0, 0x3F,
  0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x3F, 0x83, 0xF0,
  0x00, 0x7E, 0x0F, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x0F, 0x83, 0xF0, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x03,
  0xF0, 0x3F, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3F,
  0x83, 0xF0, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF8,
  0x1F, 0x80, 0x07, 0xF0, 0x3F, 0x00, 0x1F, 0xE0, 0x3F, 0x00, 0x7F, 0xC0,
  0x7E, 0x01, 0xFF, 0x00, 0xFE, 0x07, 0xBE, 0x01, 0xFF, 0x3F, 0x7C, 0x01,
  0xFF, 0xFC, 0xF8, 0x03, 0xFF, 0xF3, 0xE0, 0x03, 0xFF, 0xC7, 0xC0, 0x03,
  0xFE, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x3F, 0xC0, 0x03,
  0xE1, 0xFF, 0x80, 0x1F, 0x9F, 0xFF, 0x00, 0x7E, 0xFF, 0xFE, 0x01, 0xF7,
  0xFF, 0xF8, 0x07, 0xDE, 0x07, 0xF0, 0x3F, 0xF0, 0x1F, 0xC0, 0xFF, 0x80,
  0x3F, 0x03, 0xFC, 0x00, 0xFC, 0x0F, 0xE0, 0x03, 0xF0, 0x3F, 0x80, 0x0F,
  0xC1, 0xFC, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x03, 0xF0,
  0x7E, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xFC, 0x3F,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x7F, 0x1F, 0x80,
  0x01, 0xF8, 0x7E, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x1F, 0x87, 0xE0, 0x00,
  0xFE, 0x1F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7F,
  0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x07,
  0xF0, 0x01, 0xFC, 0x1F, 0xE0, 0x07, 0xE0, 0x7F, 0x80, 0x3F, 0x81, 0xFF,
  0x01, 0xFC, 0x07, 0xFF, 0x1F, 0xE0, 0x3E, 0x7F, 0xFF, 0x00, 0xF8, 0xFF,
  0xF8, 0x03, 0xE3, 0xFF, 0xC0, 0x0F, 0x07, 0xFE, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F, 0xF0, 0x18, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x30, 0x0F,
  0xF0, 0xF8, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x07, 0xFF, 0x1F, 0x80, 0x03,
  0xFF, 0xE7, 0xE0, 0x01, 0xFF, 0xF9, 0xF0, 0x00, 0xFF, 0xFF, 0x7C, 0x00,
  0x7F, 0x83, 0xFF, 0x00, 0x3F, 0x80, 0x7F, 0xC0, 0x0F, 0xC0, 0x0F, 0xF0,
  0x07, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x3F,
  0x80, 0x3F, 0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x03, 0xF0, 0x07, 0xE0, 0x00,
  0xFC, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x3F, 0x00,
  0x03, 0xF0, 0x0F, 0xC0, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0x7E, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x7E, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x01, 0xF8, 0x07,
  0xE0, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x3F, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0xFE,
  0x00, 0xFC, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x1F, 0xE0, 0x0F, 0xC0, 0x07,
  0xF8, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0x7E, 0x01, 0xFF, 0x00, 0x1F, 0xC0,
  0xF7, 0xC0, 0x07, 0xF8, 0xF9, 0xF0, 0x00, 0xFF, 0xFE, 0xFC, 0x00, 0x3F,
  0xFF, 0x3E, 0x00, 0x07, 0xFF, 0x8F, 0x80, 0x00, 0xFF, 0x83, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x03, 0xF8, 0x1F,
  0x80, 0xFE, 0x01, 0xF0, 0x3F, 0x80, 0x3F, 0x07, 0xE0, 0x07, 0xE1, 0xF8,
  0x00, 0xF8, 0x3F, 0x00, 0x1F, 0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFC,
  0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xE1, 0xF8, 0x03, 0xF8, 0x3F, 0x03,
  0xFE, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x07,
  0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x04, 0x0F, 0xE0, 0x03, 0x00, 0xFF,
  0x03, 0xE0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0,
  0x00, 0xFF, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0x04, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x07, 0xC0,
  0x00, 0xFF, 0xE1, 0xF0, 0x00, 0x7F, 0xFC, 0x7C, 0x00, 0x3F, 0xFF, 0x3E,
  0x00, 0x1F, 0xFF, 0xEF, 0x80, 0x0F, 0xF0, 0x7B, 0xE0, 0x07, 0xF0, 0x0F,
  0xF8, 0x01, 0xF8, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x1F, 0x80, 0x07, 0xF0, 0x07, 0xE0, 0x01, 0xFC, 0x03, 0xF0,
  0x00, 0x7F, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x07, 0xE0, 0x1F,
  0x80, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x1F, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0xFC,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x07,
  0xE0, 0x1F, 0x80, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0xFE, 0x01, 0xF8, 0x00,
  0x3F, 0x80, 0x7E, 0x00, 0x1F, 0xC0, 0x1F, 0x80, 0x07, 0xF0, 0x07, 0xE0,
  0x03, 0xFC, 0x01, 0xF8, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0xC0, 0x0F,
  0xC0, 0x3F, 0xE0, 0x03, 0xF8, 0x1E, 0xF8, 0x00, 0xFF, 0x1F, 0xFE, 0x00,
  0x1F, 0xFF, 0xDF, 0x80, 0x07, 0xFF, 0xE7, 0xC0, 0x00, 0xFF, 0xF3, 0xF0,
  0x00, 0x1F, 0xF0, 0xFC, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x80, 0x00, 0xFE, 0x00, 0x30,
  0x00, 0x7F, 0x00, 0x0F, 0x80, 0x3F, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x3F, 0xC0, 0x03, 0xE3, 0xFF,
  0x80, 0x1F, 0x9F, 0xFF, 0x00, 0x7E, 0xFF, 0xFE, 0x01, 0xF7, 0xFF, 0xF8,
  0x07, 0xFE, 0x0F, 0xE0, 0x3F, 0xF0, 0x1F, 0xC0, 0xFF, 0x00, 0x7F, 0x03,
  0xFC, 0x00, 0xFC, 0x0F, 0xE0, 0x03, 0xE0, 0x3F, 0x00, 0x0F, 0x81, 0xFC,
  0x00, 0x7E, 0x07, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0x7E, 0x00,
  0x1F, 0x81, 0xF0, 0x00, 0x7C, 0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x0F,
  0xC0, 0xFC, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x03, 0xE0,
  0x7E, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x01, 0xF8, 0x1F,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xC0,
  0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x01,
  0xF8, 0x1F, 0x80, 0x07, 0xE0, 0x7E, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x7E,
  0x07, 0xC0, 0x01, 0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3E, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0,
  0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0xFE,
  0x01, 0xF0, 0x03, 0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x1F, 0x80, 0x7E, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0xFC, 0x07, 0xF0, 0x01,
  0xF8, 0x1F, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F,
  0x83, 0xF0, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0xFC,
  0x7E, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x0F, 0xDF,
  0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3E, 0xFF, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFE, 0xFC, 0x00, 0x07, 0xF9, 0xF8,
  0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7E, 0x07, 0xE0,
  0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0x80,
  0x07, 0xC0, 0x3F, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x3F, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x07,
  0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x07, 0xE0, 0x1F, 0x80, 0x0F, 0xC0, 0x3F,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0,
  0x00, 0x00, 0xF0, 0x3F, 0x80, 0x1F, 0xE0, 0x03, 0xC3, 0xFF, 0x81, 0xFF,
  0xC0, 0x1F, 0x1F, 0xFF, 0x0F, 0xFF, 0x80, 0x7C, 0xFF, 0xFC, 0x7F, 0xFE,
  0x01, 0xF7, 0xFF, 0xF3, 0xFF, 0xFC, 0x07, 0xFE, 0x0F, 0xFF, 0x07, 0xF0,
  0x3F, 0xE0, 0x1F, 0xF8, 0x0F, 0xC0, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x3F,
  0x00, 0x1F, 0xC0, 0x0F, 0xC1, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x07, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x03,
  0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x7E,
  0x00, 0x1F, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xE0,
  0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC1, 0xF8, 0x00, 0x7C, 0x00,
  0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x1F, 0x00, 0x0F, 0xC0, 0x07,
  0xE0, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x00, 0x7E,
  0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x1F,
  0x80, 0x07, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0x81, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x3F, 0x00,
  0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x83, 0xF0, 0x01,
  0xF8, 0x00, 0x7C, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0x7C,
  0x1F, 0xE0, 0x01, 0xF0, 0xFF, 0xE0, 0x03, 0xE3, 0xFF, 0xE0, 0x07, 0xCF,
  0xFF, 0xE0, 0x0F, 0xBF, 0xFF, 0xC0, 0x1F, 0xF8, 0x3F, 0x80, 0x7F, 0xE0,
  0x3F, 0x80, 0xFF, 0x80, 0x7F, 0x01, 0xFE, 0x00, 0x7E, 0x03, 0xF8, 0x00,
  0xFC, 0x07, 0xF0, 0x03, 0xF0, 0x1F, 0xC0, 0x07, 0xE0, 0x3F, 0x80, 0x0F,
  0xC0, 0x7E, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x7E,
  0x07, 0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0x80, 0x07, 0xE0,
  0x3F, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x7E, 0x03,
  0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xF0, 0x3F,
  0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x3F, 0x01, 0xF8,
  0x00, 0x7E, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0x80,
  0x07, 0xE0, 0x3F, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x3E, 0x03, 0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x03,
  0xF0, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0,
  0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x07, 0xE0, 0x7F, 0x00, 0x3F, 0x07, 0xE0,
  0x03, 0xF0, 0xFE, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x3F,
  0x1F, 0x80, 0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x03, 0xF3, 0xF0,
  0x00, 0x3F, 0x3F, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x03,
  0xF7, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x7E, 0x7C,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xEF, 0xC0, 0x00,
  0xFC, 0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xFC, 0xFC, 0x00, 0x1F, 0x8F,
  0xC0, 0x03, 0xF8, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xF0, 0x7E, 0x00,
  0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0xE7, 0xF8, 0x03, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0F, 0x83, 0xFC, 0x00, 0x03, 0xC1, 0xFF, 0x80, 0x01,
  0xF1, 0xFF, 0xF0, 0x00, 0x7C, 0xFF, 0xFE, 0x00, 0x1F, 0x7F, 0xFF, 0x80,
  0x07, 0xDE, 0x07, 0xF0, 0x03, 0xFF, 0x01, 0xFC, 0x00, 0xFF, 0x80, 0x3F,
  0x00, 0x3F, 0xC0, 0x0F, 0xC0, 0x0F, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x00,
  0xFC, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x1F, 0x80,
  0x03, 0xF0, 0x07, 0xE0, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0xFC, 0x03,
  0xE0, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x07, 0xE0,
  0x1F, 0x80, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x01,
  0xF8, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x1F, 0xE0, 0x07, 0xE0, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xFF,
  0x01, 0xFC, 0x00, 0x7D, 0xF1, 0xFE, 0x00, 0x3F, 0x7F, 0xFF, 0x80, 0x0F,
  0xCF, 0xFF, 0xC0, 0x03, 0xF1, 0xFF, 0xC0, 0x00, 0xFC, 0x3F, 0xE0, 0x00,
  0x3E, 0x03, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x3E, 0x00, 0x3F, 0xF8, 0x7C, 0x00, 0xFF, 0xF8, 0xF8,
  0x03, 0xFF, 0xF3, 0xE0, 0x0F, 0xFF, 0xF7, 0xC0, 0x3F, 0xC1, 0xEF, 0x80,
  0xFE, 0x01, 0xFF, 0x01, 0xF8, 0x01, 0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x1F,
  0xC0, 0x07, 0xF0, 0x3F, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x1F, 0xC1, 0xF8,
  0x00, 0x3F, 0x83, 0xF0, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0xFC, 0x1F, 0x80,
  0x01, 0xF8, 0x3F, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xC1, 0xF8, 0x00,
  0x1F, 0x83, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x00,
  0xFC, 0x1F, 0x80, 0x03, 0xF0, 0x7F, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x7F, 0x07, 0xE0, 0x01, 0xFC,
  0x0F, 0xC0, 0x03, 0xF8, 0x1F, 0x80, 0x0F, 0xF0, 0x3F, 0x00, 0x1F, 0xE0,
  0x7F, 0x00, 0x7F, 0x80, 0x7E, 0x01, 0xFF, 0x00, 0xFE, 0x07, 0xBE, 0x01,
  0xFE, 0x3F, 0xFC, 0x01, 0xFF, 0xFD, 0xF8, 0x03, 0xFF, 0xF3, 0xE0, 0x03,
  0xFF, 0xCF, 0xC0, 0x03, 0xFE, 0x1F, 0x80, 0x01, 0xF0, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xF0, 0x3F, 0x00, 0xF0, 0xFF, 0x01, 0xF1, 0xFF, 0x01, 0xF3,
  0xFF, 0x01, 0xF7, 0xFE, 0x01, 0xF7, 0xFE, 0x03, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF0, 0x3F, 0x80, 0x78, 0x1F, 0x80, 0x08, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x80, 0x03, 0xF0, 0x60, 0x07, 0xF8, 0x3F, 0x0F, 0xF8, 0x1F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xFF,
  0xE1, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xF3, 0xFF, 0xFE, 0x07, 0xE0,
  0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x60, 0x3F, 0xFC, 0x07,
  0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00,
  0x7C, 0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x03, 0xE0, 0x7E, 0x00, 0x1F, 0x81,
  0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x01, 0xF8, 0x1F, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x1F, 0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x00,
  0x0F, 0xC0, 0xF8, 0x00, 0x3E, 0x07, 0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x07,
  0xE0, 0x7E, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xF0,
  0x3F, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0xFC, 0x0F,
  0x80, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x7E, 0x07, 0xE0,
  0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xE0, 0x7E, 0x00, 0x3F, 0x81, 0xF0, 0x01,
  0xFC, 0x0F, 0xC0, 0x0F, 0xF0, 0x3F, 0x00, 0x3F, 0xC0, 0xFE, 0x01, 0xFF,
  0x01, 0xF8, 0x0F, 0xF8, 0x07, 0xF9, 0xFB, 0xE0, 0x1F, 0xFF, 0xCF, 0x80,
  0x3F, 0xFE, 0x3E, 0x00, 0xFF, 0xF0, 0xF8, 0x00, 0xFF, 0x83, 0xC0, 0x00,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFB, 0xF0, 0x00,
  0x3F, 0x7E, 0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x7E, 0x3F,
  0x00, 0x0F, 0xC7, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x1F,
  0x83, 0xF0, 0x03, 0xF0, 0x3E, 0x00, 0x7C, 0x07, 0xC0, 0x1F, 0x80, 0xF8,
  0x03, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x07, 0xE0,
  0x0F, 0x80, 0xFC, 0x01, 0xF0, 0x3F, 0x00, 0x3E, 0x07, 0xE0, 0x07, 0xC1,
  0xF8, 0x00, 0xF8, 0x3F, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE1, 0xF8, 0x00,
  0x7C, 0x3E, 0x00, 0x0F, 0x8F, 0xC0, 0x01, 0xF1, 0xF0, 0x00, 0x3E, 0x7E,
  0x00, 0x07, 0xCF, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x1F, 0x7E, 0x00, 0x03,
  0xEF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xC0,
  0x03, 0xFF, 0xC0, 0x07, 0xF0, 0x01, 0xFB, 0xF0, 0x01, 0xFC, 0x00, 0x7E,
  0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xBF, 0x00, 0x3F, 0xC0, 0x0F, 0xCF, 0xC0,
  0x1F, 0xF0, 0x03, 0xF3, 0xF0, 0x07, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xEF,
  0x00, 0x7E, 0x3F, 0x00, 0xFB, 0xC0, 0x1F, 0x0F, 0xC0, 0x3E, 0xF0, 0x0F,
  0xC3, 0xF0, 0x1F, 0x3C, 0x03, 0xF0, 0xFC, 0x07, 0xCF, 0x01, 0xF8, 0x3F,
  0x01, 0xE3, 0xC0, 0x7E, 0x0F, 0xC0, 0xF8, 0xF0, 0x1F, 0x03, 0xF0, 0x3E,
  0x3C, 0x0F, 0xC0, 0xFC, 0x1F, 0x0F, 0x03, 0xE0, 0x3F, 0x07, 0xC3, 0xC1,
  0xF8, 0x0F, 0xC3, 0xE0, 0xF0, 0x7E, 0x03, 0xF0, 0xF8, 0x7C, 0x1F, 0x00,
  0xFC, 0x3E, 0x1F, 0x0F, 0xC0, 0x3F, 0x1F, 0x07, 0xC3, 0xE0, 0x0F, 0xC7,
  0xC1, 0xF1, 0xF8, 0x03, 0xF3, 0xE0, 0x7C, 0x7E, 0x00, 0xFC, 0xF8, 0x1F,
  0x1F, 0x00, 0x3F, 0x3E, 0x07, 0xCF, 0xC0, 0x0F, 0xDF, 0x01, 0xF3, 0xE0,
  0x03, 0xF7, 0xC0, 0x7C, 0xF8, 0x00, 0xFB, 0xE0, 0x1F, 0x7C, 0x00, 0x3E,
  0xF8, 0x07, 0xDF, 0x00, 0x0F, 0xBE, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x07, 0xFC,
  0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x03, 0xE0, 0x0F,
  0xC0, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x07, 0xE3,
  0xF0, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0x7E, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x1F, 0x8F, 0x80, 0x00,
  0x1F, 0x87, 0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0x0F, 0xC0, 0x7E, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x07, 0xE0, 0x1F, 0x80,
  0x07, 0xE0, 0x0F, 0xC0, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8,
  0x03, 0xF0, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x3E, 0x00,
  0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x01, 0xF8, 0x00,
  0x0F, 0x80, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x07, 0xC1, 0xF0,
  0x00, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x01,
  0xF1, 0xF8, 0x00, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x00, 0x1F, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0xFC, 0x00, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x00, 0x07,
  0xDF, 0x80, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x00, 0x7D, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x08,
  0xFF, 0xE0, 0x00, 0x4F, 0xFF, 0xC0, 0x06, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xD8, 0x00, 0x3F,
  0xFC, 0x80, 0x00, 0x3F, 0x80,
};

const GFXglyph NotoSans_Condensed_Italic72pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 18, 52, 18, 1, -51 },
  { 118, 21, 18, 25, 7, -51 },
  { 166, 36, 51, 35, 1, -51 },
  { 396, 31, 59, 32, 1, -55 },
  { 625, 41, 53, 48, 4, -52 },
  { 897, 35, 53, 36, 0, -52 },
  { 1129, 9, 18, 14, 8, -51 },
  { 1150, 22, 63, 19, 2, -52 },
  { 1324, 22, 63, 19, -5, -52 },
  { 1498, 25, 27, 30, 7, -55 },
  { 1583, 28, 34, 34, 4, -42 },
  { 1702, 13, 17, 16, -3, -8 },
  { 1730, 17, 5, 20, 1, -22 },
  { 1741, 8, 9, 16, 1, -8 },
  { 1750, 33, 52, 25, -3, -52 },
  { 1965, 29, 53, 32, 2, -52 },
  { 2158, 19, 51, 32, 8, -51 },
  { 2280, 33, 52, 32, -2, -52 },
  { 2495, 31, 53, 32, 0, -52 },
  { 2701, 32, 52, 32, -1, -52 },
  { 2909, 32, 52, 32, 0, -51 },
  { 3117, 30, 53, 32, 3, -52 },
  { 3316, 31, 51, 32, 3, -51 },
  { 3514, 31, 53, 32, 1, -52 },
  { 3720, 30, 53, 32, 1, -52 },
  { 3919, 15, 40, 16, 0, -39 },
  { 3994, 19, 48, 16, -4, -39 },
  { 4108, 29, 33, 34, 3, -42 },
  { 4228, 28, 20, 34, 4, -35 },
  { 4298, 28, 33, 34, 4, -42 },
  { 4414, 25, 53, 24, 2, -52 },
  { 4580, 45, 58, 48, 2, -52 },
  { 4907, 33, 52, 32, -5, -52 },
  { 5122, 34, 51, 35, 1, -51 },
  { 5339, 34, 53, 32, 3, -52 },
  { 5565, 35, 51, 38, 1, -51 },
  { 5789, 32, 51, 30, 1, -51 },
  { 5993, 32, 51, 28, 1, -51 },
  { 6197, 37, 53, 39, 3, -52 },
  { 6443, 39, 51, 39, 1, -51 },
  { 6692, 28, 51, 20, -3, -51 },
  { 6871, 29, 65, 16, -11, -51 },
  { 7107, 38, 51, 33, 1, -51 },
  { 7350, 22, 51, 27, 1, -51 },
  { 7491, 51, 51, 51, 1, -51 },
  { 7817, 41, 51, 41, 1, -51 },
  { 8079, 36, 53, 41, 3, -52 },
  { 8318, 32, 51, 33, 1, -51 },
  { 8522, 36, 64, 41, 3, -52 },
  { 8810, 33, 51, 33, 1, -51 },
  { 9021, 33, 53, 30, -1, -52 },
  { 9240, 28, 51, 28, 6, -51 },
  { 9419, 37, 52, 38, 3, -51 },
  { 9660, 32, 51, 32, 6, -51 },
  { 9864, 51, 51, 51, 6, -51 },
  { 10190, 39, 51, 30, -4, -51 },
  { 10439, 29, 51, 29, 6, -51 },
  { 10624, 34, 51, 28, -2, -51 },
  { 10841, 28, 64, 20, -2, -52 },
  { 11065, 13, 52, 25, 7, -52 },
  { 11150, 27, 64, 20, -5, -52 },
  { 11366, 30, 29, 32, 1, -51 },
  { 11475, 24, 5, 24, -6, 6 },
  { 11490, 10, 11, 19, 11, -55 },
  { 11504, 31, 40, 34, 2, -39 },
  { 11659, 30, 56, 34, 1, -55 },
  { 11869, 25, 40, 26, 2, -39 },
  { 11994, 34, 56, 34, 2, -55 },
  { 12232, 27, 40, 30, 2, -39 },
  { 12367, 36, 72, 18, -9, -55 },
  { 12691, 34, 56, 34, -1, -39 },
  { 12929, 30, 55, 33, 1, -55 },
  { 13136, 16, 53, 15, 1, -53 },
  { 13242, 26, 70, 15, -9, -53 },
  { 13470, 31, 55, 29, 1, -55 },
  { 13684, 17, 55, 15, 1, -55 },
  { 13801, 46, 39, 50, 1, -39 },
  { 14026, 31, 39, 33, 0, -39 },
  { 14178, 28, 40, 33, 2, -39 },
  { 14318, 34, 56, 34, -3, -39 },
  { 14556, 31, 56, 34, 2, -39 },
  { 14773, 24, 39, 23, 1, -39 },
  { 14890, 25, 40, 25, 0, -39 },
  { 15015, 19, 48, 19, 2, -47 },
  { 15129, 30, 40, 33, 2, -39 },
  { 15279, 27, 39, 27, 4, -39 },
  { 15411, 42, 39, 43, 4, -39 },
  { 15616, 33, 39, 28, -3, -39 },
  { 15777, 38, 56, 27, -7, -39 },
  { 16043, 27, 39, 24, -2, -39 },
  { 16175, 27, 62, 24, 1, -51 },
  { 16385, 5, 72, 30, 13, -55 },
  { 16430, 27, 62, 24, -4, -51 },
  { 16640, 29, 9, 34, 3, -30 },
};

const GFXfont NotoSans_Condensed_Italic72pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Italic72pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Italic72pt7bGlyphs,
  0x20, 0x7E, 98
};

#endif // _NOTOSANS_CONDENSED_ITALIC72PT7B_H_
