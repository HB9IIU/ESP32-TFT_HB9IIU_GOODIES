#ifndef _NOTOSANS_CONDENSED_ITALIC49PT7B_H_
#define _NOTOSANS_CONDENSED_ITALIC49PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Italic.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Italic49pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x03, 0xC0,
  0x3C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x00, 0x3C, 0x3C, 0xF1, 0xF3, 0xC7, 0x9E,
  0x1E, 0x78, 0x79, 0xE1, 0xE7, 0x87, 0x1C, 0x3C, 0x70, 0xF3, 0xC3, 0x8E,
  0x0E, 0x38, 0x38, 0xE0, 0xE0, 0x00, 0x0E, 0x0F, 0x00, 0x07, 0x07, 0x00,
  0x07, 0x83, 0x80, 0x03, 0x83, 0xC0, 0x01, 0xC1, 0xC0, 0x00, 0xE0, 0xE0,
  0x00, 0xE0, 0x70, 0x00, 0x70, 0x70, 0x00, 0x38, 0x38, 0x00, 0x38, 0x1C,
  0x03, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x07, 0x07,
  0x00, 0x03, 0x83, 0x80, 0x03, 0xC1, 0xC0, 0x01, 0xC1, 0xE0, 0x00, 0xE0,
  0xE0, 0x00, 0x70, 0x70, 0x00, 0x70, 0x38, 0x00, 0x38, 0x38, 0x03, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x87, 0x07, 0x00, 0x07,
  0x83, 0x80, 0x03, 0x83, 0xC0, 0x01, 0xC1, 0xC0, 0x00, 0xE0, 0xE0, 0x00,
  0xE0, 0xF0, 0x00, 0x70, 0x70, 0x00, 0x38, 0x38, 0x00, 0x38, 0x1C, 0x00,
  0x1C, 0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0xF0,
  0x1F, 0xFF, 0x80, 0xFD, 0x9E, 0x03, 0xCE, 0x10, 0x1E, 0x38, 0x00, 0x70,
  0xC0, 0x01, 0xC3, 0x00, 0x07, 0x0C, 0x00, 0x1C, 0x70, 0x00, 0x79, 0xC0,
  0x01, 0xF6, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x07, 0x7C, 0x00, 0x1C,
  0xF0, 0x00, 0x63, 0xC0, 0x01, 0x87, 0x00, 0x06, 0x1C, 0x00, 0x38, 0xF0,
  0x00, 0xE3, 0xC1, 0x03, 0x1F, 0x07, 0x0C, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF,
  0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0xE0, 0x03,
  0xC0, 0xFF, 0x00, 0x78, 0x1F, 0xF0, 0x07, 0x01, 0xC7, 0x80, 0xF0, 0x38,
  0x38, 0x0E, 0x03, 0x83, 0x81, 0xC0, 0x78, 0x38, 0x1C, 0x07, 0x03, 0x83,
  0x80, 0x70, 0x78, 0x78, 0x07, 0x07, 0x07, 0x00, 0xF0, 0x70, 0xF0, 0x0E,
  0x07, 0x0E, 0x00, 0xE0, 0x71, 0xC0, 0x0E, 0x0F, 0x3C, 0x00, 0xE0, 0xE3,
  0x8F, 0xCE, 0x0E, 0x79, 0xFE, 0xE1, 0xC7, 0x3F, 0xEE, 0x3C, 0xE3, 0x8F,
  0xFF, 0x9E, 0x70, 0x77, 0xF1, 0xC7, 0x07, 0x7E, 0x3C, 0xF0, 0x70, 0x03,
  0x8E, 0x0F, 0x00, 0x78, 0xE0, 0xF0, 0x07, 0x1E, 0x0E, 0x00, 0xE1, 0xE0,
  0xE0, 0x1E, 0x1C, 0x0E, 0x01, 0xC1, 0xC0, 0xE0, 0x3C, 0x1C, 0x1C, 0x03,
  0x81, 0xC1, 0xC0, 0x70, 0x1C, 0x3C, 0x0F, 0x01, 0xC3, 0x80, 0xE0, 0x1C,
  0x78, 0x1E, 0x01, 0xFF, 0x01, 0xC0, 0x0F, 0xE0, 0x38, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0xF0, 0xF0,
  0x00, 0xE0, 0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0xF0,
  0x01, 0xE0, 0xF0, 0x01, 0xE1, 0xE0, 0x01, 0xE1, 0xE0, 0x01, 0xE3, 0xC0,
  0x01, 0xE7, 0x80, 0x01, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xFC, 0x0F, 0x0F, 0x3C, 0x1E,
  0x1E, 0x3E, 0x1E, 0x3C, 0x1E, 0x1E, 0x3C, 0x1F, 0x3C, 0x78, 0x0F, 0x3C,
  0x78, 0x0F, 0x78, 0xF0, 0x07, 0xF8, 0xF0, 0x07, 0xF0, 0xF0, 0x07, 0xE0,
  0xF0, 0x03, 0xE0, 0xF8, 0x07, 0xE0, 0xF8, 0x0F, 0xE0, 0x7C, 0x3F, 0xF0,
  0x7F, 0xFC, 0xF0, 0x3F, 0xF8, 0xF8, 0x1F, 0xE0, 0x78, 0x3C, 0xF3, 0xCE,
  0x79, 0xE7, 0x9C, 0x71, 0xCF, 0x38, 0xE0, 0x00, 0x1E, 0x00, 0x78, 0x00,
  0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0,
  0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x78, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0,
  0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x06, 0x0E, 0x07, 0xCE, 0x03, 0xFF, 0x06, 0xFF, 0xFF, 0x0F,
  0xFF, 0x81, 0xFF, 0xC1, 0xF8, 0x01, 0xFC, 0x01, 0xE7, 0x01, 0xE3, 0x81,
  0xE1, 0xE0, 0x70, 0x70, 0x10, 0x3C, 0x00, 0x10, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x87, 0xC3, 0xC3, 0xE1,
  0xE0, 0xF0, 0xF0, 0x78, 0x78, 0x3C, 0x1C, 0x1C, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x33, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x01, 0xF1, 0xE0, 0x7C, 0x1E,
  0x1F, 0x03, 0xC3, 0xC0, 0x78, 0xF8, 0x0F, 0x1E, 0x01, 0xE3, 0xC0, 0x3C,
  0xF0, 0x07, 0x9E, 0x00, 0xF3, 0xC0, 0x1E, 0xF8, 0x03, 0xDE, 0x00, 0x7B,
  0xC0, 0x0F, 0x78, 0x03, 0xFF, 0x00, 0x7B, 0xC0, 0x0F, 0x78, 0x01, 0xEF,
  0x00, 0x3D, 0xE0, 0x0F, 0x3C, 0x01, 0xE7, 0x80, 0x3C, 0xF0, 0x0F, 0x9E,
  0x01, 0xE3, 0x80, 0x3C, 0x78, 0x0F, 0x0F, 0x01, 0xE1, 0xE0, 0x78, 0x3C,
  0x1F, 0x07, 0xC7, 0xC0, 0x7F, 0xF0, 0x0F, 0xFC, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xF8, 0x0F, 0x80, 0xFC, 0x0F, 0xE1, 0xFF, 0x1F, 0x79, 0xF7, 0x9F,
  0x3C, 0xF1, 0xE2, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x3F, 0xE0,
  0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x7C, 0x3F, 0x00, 0xC0, 0x7C, 0x02,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0xFF,
  0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0x83, 0xF0, 0x10, 0x0F, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x3F, 0xE0, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x78, 0x00, 0x07, 0xC2, 0x00, 0x7C, 0x1C, 0x07, 0xE0, 0xFF, 0xFE,
  0x07, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0E, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xDE, 0x00, 0x0E, 0x78, 0x00, 0x7B, 0xC0, 0x03, 0xCF,
  0x00, 0x0E, 0x3C, 0x00, 0x78, 0xF0, 0x03, 0xC3, 0x80, 0x0E, 0x1E, 0x00,
  0x78, 0x78, 0x03, 0xC1, 0xE0, 0x0E, 0x07, 0x80, 0x78, 0x1C, 0x03, 0xC0,
  0xF0, 0x0E, 0x03, 0xC0, 0x70, 0x0F, 0x03, 0xC0, 0x3C, 0x1E, 0x01, 0xE0,
  0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xA0, 0x01, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x03, 0xFF,
  0xE0, 0x0F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x10, 0x3F, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x08, 0x01, 0xF8, 0x38, 0x0F, 0xC0, 0xFF,
  0xFE, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x03,
  0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0x81, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC7, 0xC0, 0x79, 0xFF, 0x07, 0xBF, 0xF0,
  0x7F, 0x9F, 0x87, 0xE0, 0x78, 0x7C, 0x07, 0x8F, 0x80, 0x7C, 0xF8, 0x03,
  0xCF, 0x00, 0x3C, 0xF0, 0x07, 0xCF, 0x00, 0x78, 0xF0, 0x07, 0x8F, 0x00,
  0x78, 0xF0, 0x07, 0x8F, 0x00, 0xF0, 0xF0, 0x0F, 0x0F, 0x01, 0xF0, 0xF8,
  0x1E, 0x07, 0xC7, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0x80, 0x1F, 0xE0, 0x00,
  0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x03,
  0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x7C, 0x3E, 0x03, 0xC0, 0x7C, 0x0F, 0x00,
  0xF0, 0x78, 0x03, 0xC1, 0xE0, 0x0F, 0x07, 0x80, 0x3C, 0x1E, 0x01, 0xE0,
  0x78, 0x07, 0x80, 0xF0, 0x3C, 0x03, 0xC1, 0xF0, 0x0F, 0x8F, 0x80, 0x1F,
  0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xF0,
  0x03, 0xE3, 0xE0, 0x1F, 0x07, 0xC0, 0xF8, 0x0F, 0x03, 0xC0, 0x3C, 0x1E,
  0x00, 0xF8, 0x78, 0x01, 0xE1, 0xE0, 0x07, 0x8F, 0x00, 0x1E, 0x3C, 0x00,
  0x78, 0xF8, 0x03, 0xC1, 0xE0, 0x0F, 0x07, 0x80, 0x7C, 0x1F, 0x83, 0xE0,
  0x3F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x1F, 0xFC, 0x03, 0xFF, 0xE0, 0x7E, 0x3E, 0x07, 0x81, 0xE0, 0xF0, 0x0F,
  0x0F, 0x00, 0xF1, 0xE0, 0x0F, 0x1E, 0x00, 0xF1, 0xE0, 0x0F, 0x3C, 0x00,
  0xF3, 0xC0, 0x0F, 0x3C, 0x00, 0xF3, 0xC0, 0x1F, 0x3C, 0x01, 0xF3, 0xC0,
  0x3E, 0x3E, 0x03, 0xE1, 0xE0, 0x7E, 0x1F, 0xBF, 0xE1, 0xFF, 0xDE, 0x0F,
  0xFB, 0xC0, 0x3E, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x7C, 0x08, 0x1F, 0x80, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0x80, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xE0, 0x20, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x06, 0x07, 0xC1, 0xF0, 0xFC, 0x3E, 0x07, 0x80, 0x00,
  0x60, 0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x0F, 0x01, 0xF0, 0x1E,
  0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0xF0, 0x00, 0x3F, 0x00,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x10, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x00,
  0xF8, 0x00, 0x0E, 0x00, 0x00, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x1F, 0xFE,
  0x3F, 0xFE, 0x1C, 0x1F, 0x10, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00,
  0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0x00, 0x78, 0x00, 0xF0, 0x00,
  0xF0, 0x07, 0x80, 0x01, 0xC0, 0x3C, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0x38, 0x38, 0x03, 0x80, 0x71, 0xE0, 0x3F, 0xE1, 0xC7,
  0x03, 0xFF, 0x07, 0x3C, 0x1E, 0x1C, 0x1C, 0xE0, 0x70, 0x70, 0x73, 0x83,
  0x83, 0xC1, 0xDC, 0x1E, 0x0E, 0x0F, 0x70, 0x70, 0x38, 0x39, 0xC3, 0xC0,
  0xE0, 0xEF, 0x0E, 0x07, 0x83, 0xB8, 0x38, 0x1C, 0x0E, 0xE0, 0xE0, 0x70,
  0x73, 0x87, 0x83, 0xC1, 0xCE, 0x1E, 0x0F, 0x07, 0x38, 0x78, 0x38, 0x38,
  0xE1, 0xE1, 0xE0, 0xE3, 0x87, 0x8F, 0x87, 0x0E, 0x0E, 0x77, 0x3C, 0x38,
  0x3F, 0x9F, 0xE0, 0xE0, 0x7C, 0x3F, 0x03, 0x80, 0x40, 0x20, 0x0E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x18, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xDE, 0x00, 0x0F, 0x78, 0x00, 0x38,
  0xE0, 0x01, 0xE3, 0x80, 0x07, 0x0E, 0x00, 0x3C, 0x38, 0x00, 0xF0, 0xE0,
  0x07, 0x83, 0x80, 0x1E, 0x0E, 0x00, 0xF0, 0x38, 0x03, 0xC0, 0xE0, 0x1F,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC1, 0xFF, 0xFF, 0x07, 0x80, 0x3C, 0x3E, 0x00, 0xF0, 0xF0, 0x03, 0xC7,
  0xC0, 0x0F, 0x1E, 0x00, 0x3C, 0xF8, 0x00, 0xF3, 0xC0, 0x03, 0xDF, 0x00,
  0x0F, 0x78, 0x00, 0x3D, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xC0, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x3C, 0x07,
  0xC0, 0x78, 0x07, 0xC0, 0xF0, 0x0F, 0x83, 0xC0, 0x1F, 0x07, 0x80, 0x3E,
  0x0F, 0x00, 0x78, 0x1E, 0x00, 0xF0, 0x3C, 0x03, 0xE0, 0xF0, 0x07, 0x81,
  0xE0, 0x1F, 0x03, 0xC0, 0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x3F,
  0xFF, 0x00, 0x78, 0x7F, 0x00, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x07, 0xC0,
  0x1E, 0x0F, 0x00, 0x3C, 0x1E, 0x00, 0x78, 0x3C, 0x00, 0xF0, 0x78, 0x01,
  0xE1, 0xE0, 0x07, 0xC3, 0xC0, 0x0F, 0x07, 0x80, 0x3E, 0x0F, 0x00, 0x7C,
  0x1E, 0x03, 0xF0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xF8,
  0x03, 0xFF, 0xE0, 0x1F, 0xC1, 0xC0, 0x3E, 0x00, 0x80, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x07, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x03,
  0xC0, 0xFC, 0x03, 0xC0, 0x3E, 0x03, 0xC0, 0x3E, 0x07, 0xC0, 0x1E, 0x07,
  0x80, 0x1F, 0x07, 0x80, 0x1F, 0x07, 0x80, 0x1F, 0x07, 0x80, 0x1F, 0x0F,
  0x00, 0x1F, 0x0F, 0x00, 0x1F, 0x0F, 0x00, 0x1F, 0x0F, 0x00, 0x1F, 0x1F,
  0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x3E, 0x1E,
  0x00, 0x3E, 0x3E, 0x00, 0x3C, 0x3C, 0x00, 0x7C, 0x3C, 0x00, 0x7C, 0x3C,
  0x00, 0x78, 0x3C, 0x00, 0xF8, 0x78, 0x01, 0xF0, 0x78, 0x01, 0xF0, 0x78,
  0x03, 0xE0, 0x78, 0x0F, 0xC0, 0x78, 0x1F, 0x80, 0xFF, 0xFF, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0xFF, 0xFC, 0x07, 0xFF,
  0xE0, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE,
  0x07, 0xFF, 0xF0, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0xFF,
  0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x01, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF0, 0x0F, 0xE0, 0xF0, 0x0F, 0x80, 0x18, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0xFF, 0x8F,
  0x00, 0xFF, 0x87, 0x80, 0x7F, 0xC7, 0xC0, 0x01, 0xE3, 0xE0, 0x00, 0xF1,
  0xF0, 0x00, 0x78, 0xF8, 0x00, 0x78, 0x7C, 0x00, 0x3C, 0x3E, 0x00, 0x1E,
  0x1F, 0x00, 0x0F, 0x07, 0x80, 0x0F, 0x83, 0xC0, 0x07, 0x81, 0xF0, 0x03,
  0xC0, 0x7C, 0x01, 0xE0, 0x3F, 0x83, 0xF0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF,
  0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x78, 0x00, 0xF0,
  0x3E, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x03, 0xC0, 0x07, 0x80, 0xF0, 0x01,
  0xE0, 0x3C, 0x00, 0x78, 0x1E, 0x00, 0x1E, 0x07, 0x80, 0x07, 0x81, 0xE0,
  0x03, 0xC0, 0x78, 0x00, 0xF0, 0x1E, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x03,
  0xC0, 0x07, 0xC0, 0xF0, 0x01, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x78, 0x00, 0xF0, 0x1E, 0x00,
  0x3C, 0x0F, 0x80, 0x0F, 0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x01, 0xE0, 0x3C,
  0x00, 0x78, 0x0F, 0x00, 0x1E, 0x07, 0x80, 0x07, 0x81, 0xE0, 0x03, 0xE0,
  0x78, 0x00, 0xF0, 0x1E, 0x00, 0x3C, 0x07, 0x80, 0x0F, 0x03, 0xC0, 0x03,
  0xC0, 0xF0, 0x01, 0xE0, 0x3C, 0x00, 0x78, 0x0F, 0x00, 0x1E, 0x00, 0x01,
  0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFE, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x7C, 0x00, 0x3F, 0xE0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x8F, 0xC0,
  0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xE0, 0x0F, 0x80,
  0xF0, 0x0F, 0x80, 0xF8, 0x07, 0x80, 0x78, 0x07, 0xC0, 0x3C, 0x07, 0xC0,
  0x1E, 0x07, 0xC0, 0x0F, 0x03, 0xC0, 0x0F, 0x03, 0xC0, 0x07, 0x83, 0xE0,
  0x03, 0xC3, 0xE0, 0x01, 0xE3, 0xE0, 0x00, 0xF1, 0xE0, 0x00, 0xF1, 0xF0,
  0x00, 0x79, 0xF0, 0x00, 0x3D, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xF7, 0x80, 0x01, 0xF3,
  0xC0, 0x01, 0xF1, 0xF0, 0x00, 0xF0, 0x78, 0x00, 0x78, 0x3C, 0x00, 0x3C,
  0x1E, 0x00, 0x1E, 0x0F, 0x80, 0x1E, 0x03, 0xC0, 0x0F, 0x01, 0xE0, 0x07,
  0x80, 0xF0, 0x03, 0xC0, 0x7C, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x0F, 0x00,
  0xF0, 0x07, 0xC0, 0x78, 0x03, 0xE0, 0x3C, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x07, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x01,
  0xFC, 0x0F, 0xE0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0xFE, 0x00,
  0x0F, 0xE0, 0x3F, 0x80, 0x07, 0xF8, 0x1E, 0xE0, 0x01, 0xDE, 0x07, 0xB8,
  0x00, 0xF7, 0x81, 0xEE, 0x00, 0x3B, 0xC0, 0x7B, 0x80, 0x1E, 0xF0, 0x1C,
  0xE0, 0x07, 0xBC, 0x0F, 0x38, 0x03, 0xCF, 0x03, 0xCF, 0x00, 0xF7, 0xC0,
  0xF3, 0xC0, 0x79, 0xE0, 0x3C, 0xF0, 0x1E, 0x78, 0x1E, 0x3C, 0x0F, 0x1E,
  0x07, 0x8F, 0x03, 0xC7, 0x81, 0xE3, 0xC1, 0xE3, 0xC0, 0x78, 0xF0, 0x78,
  0xF0, 0x1E, 0x3C, 0x3C, 0x3C, 0x0F, 0x0F, 0x0F, 0x0F, 0x03, 0xC3, 0xC7,
  0x83, 0xC0, 0xF0, 0x71, 0xE1, 0xE0, 0x3C, 0x1C, 0xF0, 0x78, 0x0E, 0x07,
  0x3C, 0x1E, 0x07, 0x81, 0xCE, 0x07, 0x81, 0xE0, 0x77, 0x83, 0xE0, 0x78,
  0x1D, 0xC0, 0xF0, 0x1E, 0x07, 0xF0, 0x3C, 0x07, 0x01, 0xF8, 0x0F, 0x03,
  0xC0, 0x7E, 0x03, 0xC0, 0xF0, 0x1F, 0x01, 0xF0, 0x3C, 0x07, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0xF0, 0x1F, 0x00, 0x0F,
  0x03, 0xF0, 0x01, 0xE0, 0x3F, 0x00, 0x1E, 0x03, 0xF8, 0x01, 0xE0, 0x3F,
  0x80, 0x1E, 0x03, 0xF8, 0x01, 0xC0, 0x7B, 0x80, 0x3C, 0x07, 0xBC, 0x03,
  0xC0, 0x7B, 0xC0, 0x3C, 0x07, 0xBC, 0x03, 0xC0, 0x73, 0xC0, 0x78, 0x0F,
  0x1C, 0x07, 0x80, 0xF1, 0xE0, 0x78, 0x0F, 0x1E, 0x07, 0x80, 0xF1, 0xE0,
  0x78, 0x1E, 0x0E, 0x0F, 0x01, 0xE0, 0xF0, 0xF0, 0x1E, 0x0F, 0x0F, 0x01,
  0xE0, 0xF0, 0xF0, 0x1E, 0x07, 0x0F, 0x03, 0xC0, 0x79, 0xE0, 0x3C, 0x07,
  0x9E, 0x03, 0xC0, 0x79, 0xE0, 0x3C, 0x07, 0x9E, 0x03, 0x80, 0x39, 0xC0,
  0x78, 0x03, 0xFC, 0x07, 0x80, 0x3F, 0xC0, 0x78, 0x03, 0xFC, 0x07, 0x80,
  0x1F, 0xC0, 0x70, 0x01, 0xF8, 0x0F, 0x00, 0x1F, 0x80, 0xF0, 0x01, 0xF8,
  0x0F, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0x0F, 0xC0, 0x3E, 0x01, 0xF0,
  0x1E, 0x00, 0xF8, 0x1F, 0x00, 0x3C, 0x1F, 0x00, 0x1E, 0x0F, 0x00, 0x0F,
  0x8F, 0x80, 0x07, 0xC7, 0x80, 0x03, 0xE7, 0xC0, 0x01, 0xF3, 0xE0, 0x00,
  0xF9, 0xE0, 0x00, 0x7C, 0xF0, 0x00, 0x3C, 0xF8, 0x00, 0x1E, 0x78, 0x00,
  0x0F, 0x3C, 0x00, 0x07, 0x9E, 0x00, 0x07, 0xCF, 0x00, 0x03, 0xEF, 0x80,
  0x01, 0xE7, 0xC0, 0x00, 0xF3, 0xE0, 0x00, 0xF9, 0xF0, 0x00, 0x78, 0xF8,
  0x00, 0x3C, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x1E, 0x1F, 0x00, 0x1F, 0x07,
  0x80, 0x1F, 0x03, 0xE0, 0x0F, 0x81, 0xF0, 0x1F, 0x80, 0x7E, 0x1F, 0x80,
  0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0xFF, 0xFE, 0x03, 0xC0, 0xF8,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0xC1, 0xE0, 0x0F, 0x07, 0x80, 0x3C, 0x1E,
  0x00, 0xF0, 0x78, 0x07, 0xC1, 0xE0, 0x1E, 0x0F, 0x00, 0x78, 0x3C, 0x01,
  0xE0, 0xF0, 0x0F, 0x83, 0xC0, 0x7C, 0x1F, 0x03, 0xE0, 0x78, 0x7F, 0x81,
  0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xF8, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0x0F, 0xC0,
  0x3E, 0x01, 0xF0, 0x1E, 0x00, 0xF8, 0x1F, 0x00, 0x3C, 0x1F, 0x00, 0x1E,
  0x0F, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0xC7, 0x80, 0x03, 0xE7, 0xC0, 0x01,
  0xF3, 0xE0, 0x00, 0xF9, 0xE0, 0x00, 0x7C, 0xF0, 0x00, 0x3C, 0xF8, 0x00,
  0x1E, 0x78, 0x00, 0x0F, 0x3C, 0x00, 0x07, 0x9E, 0x00, 0x03, 0xCF, 0x00,
  0x03, 0xEF, 0x80, 0x01, 0xE7, 0xC0, 0x00, 0xF3, 0xE0, 0x00, 0xF9, 0xF0,
  0x00, 0x78, 0xF8, 0x00, 0x3C, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x1E, 0x1F,
  0x00, 0x1F, 0x07, 0x80, 0x1F, 0x03, 0xE0, 0x0F, 0x81, 0xF0, 0x1F, 0x80,
  0x7E, 0x1F, 0x80, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0xFF,
  0xFE, 0x03, 0xC0, 0xF8, 0x0F, 0x01, 0xF0, 0x3C, 0x07, 0xC1, 0xF0, 0x0F,
  0x07, 0x80, 0x3C, 0x1E, 0x00, 0xF0, 0x78, 0x07, 0xC1, 0xE0, 0x1E, 0x0F,
  0x00, 0x78, 0x3C, 0x03, 0xE0, 0xF0, 0x0F, 0x03, 0xC0, 0x7C, 0x1F, 0x07,
  0xE0, 0x7F, 0xFF, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x1E, 0x3C, 0x00,
  0xF8, 0x78, 0x03, 0xC1, 0xE0, 0x0F, 0x07, 0x80, 0x3C, 0x1E, 0x00, 0xF0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3E,
  0x07, 0x80, 0x78, 0x3C, 0x01, 0xE0, 0xF0, 0x07, 0xC3, 0xC0, 0x1F, 0x0F,
  0x00, 0x3C, 0x00, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80,
  0xFE, 0x3E, 0x07, 0xE0, 0x10, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x3E, 0x08, 0x01, 0xF0, 0x3C, 0x3F, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xF0,
  0x07, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x07, 0x83, 0xC0, 0x03, 0xC1, 0xE0,
  0x01, 0xE0, 0xF0, 0x01, 0xE0, 0x78, 0x00, 0xF0, 0x3C, 0x00, 0x78, 0x3C,
  0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x07, 0x80, 0x0F, 0x07,
  0xC0, 0x07, 0x83, 0xC0, 0x03, 0xC1, 0xE0, 0x03, 0xE0, 0xF0, 0x01, 0xE0,
  0x78, 0x00, 0xF0, 0x78, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x3C,
  0x0F, 0x00, 0x1E, 0x07, 0x80, 0x0F, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x03,
  0xC1, 0xE0, 0x03, 0xC0, 0xF0, 0x01, 0xE0, 0x78, 0x00, 0xF0, 0x78, 0x00,
  0x78, 0x3C, 0x00, 0x78, 0x1E, 0x00, 0x3C, 0x0F, 0x80, 0x3E, 0x07, 0xC0,
  0x1E, 0x01, 0xE0, 0x1F, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0xFF, 0x00, 0x1F,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xEF,
  0x00, 0x07, 0xBE, 0x00, 0x3E, 0xF8, 0x00, 0xF1, 0xE0, 0x07, 0xC7, 0x80,
  0x1E, 0x1E, 0x00, 0xF8, 0x78, 0x03, 0xC1, 0xE0, 0x0F, 0x07, 0x80, 0x78,
  0x1E, 0x01, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x81, 0xF0, 0x1E,
  0x07, 0x80, 0x78, 0x3E, 0x01, 0xE0, 0xF0, 0x07, 0x83, 0xC0, 0x1E, 0x1E,
  0x00, 0x78, 0x78, 0x01, 0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x1E, 0x78, 0x00,
  0x79, 0xE0, 0x01, 0xE7, 0x00, 0x07, 0xBC, 0x00, 0x1E, 0xF0, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xEF,
  0x00, 0x3E, 0x00, 0x79, 0xE0, 0x07, 0xC0, 0x0F, 0x3C, 0x01, 0xF8, 0x03,
  0xE7, 0x80, 0x3F, 0x00, 0x78, 0xE0, 0x07, 0xE0, 0x0F, 0x1C, 0x01, 0xFC,
  0x03, 0xC3, 0x80, 0x3F, 0x80, 0x78, 0x70, 0x0F, 0xF0, 0x1E, 0x0E, 0x01,
  0xDE, 0x03, 0xC3, 0xC0, 0x7B, 0xC0, 0x78, 0x78, 0x0F, 0x78, 0x1E, 0x0F,
  0x01, 0xCF, 0x03, 0xC1, 0xE0, 0x79, 0xE0, 0xF0, 0x3C, 0x0E, 0x3C, 0x1E,
  0x07, 0x83, 0xC7, 0x87, 0xC0, 0xF0, 0x78, 0xF0, 0xF0, 0x1E, 0x0E, 0x1E,
  0x1E, 0x03, 0xC3, 0xC3, 0xC7, 0x80, 0x78, 0x70, 0x78, 0xF0, 0x0F, 0x1E,
  0x0E, 0x3E, 0x01, 0xE3, 0xC1, 0xC7, 0x80, 0x3C, 0x70, 0x38, 0xF0, 0x07,
  0x9E, 0x07, 0x3C, 0x00, 0xF3, 0x80, 0xE7, 0x80, 0x1E, 0xF0, 0x1C, 0xE0,
  0x03, 0xDC, 0x03, 0xBC, 0x00, 0x7B, 0x80, 0x77, 0x80, 0x0F, 0xF0, 0x0E,
  0xE0, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x07, 0xE0,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0x03,
  0xE0, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x78,
  0x01, 0xE0, 0x1F, 0x00, 0x3C, 0x03, 0xC0, 0x07, 0x80, 0xF0, 0x00, 0xF8,
  0x3E, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0x3C, 0x3C, 0x00,
  0x07, 0x8F, 0x00, 0x00, 0x73, 0xE0, 0x00, 0x0F, 0x78, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x0F,
  0x9E, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x78, 0x78, 0x00, 0x0F, 0x0F, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0xF8, 0x1E, 0x00, 0x1E, 0x03, 0xC0, 0x07, 0x80,
  0x78, 0x01, 0xF0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x0F, 0x00, 0x1E, 0x03,
  0xE0, 0x03, 0xC0, 0x00, 0xF0, 0x01, 0xFF, 0x80, 0x1E, 0x78, 0x03, 0xE7,
  0x80, 0x3C, 0x78, 0x07, 0x87, 0x80, 0x78, 0x78, 0x0F, 0x07, 0x81, 0xF0,
  0x3C, 0x1E, 0x03, 0xC3, 0xE0, 0x3C, 0x3C, 0x03, 0xC7, 0x80, 0x3C, 0x78,
  0x03, 0xCF, 0x00, 0x3C, 0xF0, 0x01, 0xDE, 0x00, 0x1F, 0xE0, 0x01, 0xFC,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xFF,
  0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x00, 0xF0, 0xF0, 0xF0, 0x70, 0x70, 0x70,
  0x78, 0x78, 0x78, 0x78, 0x78, 0x38, 0x38, 0x38, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x1C, 0x1C, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x0E, 0x0E, 0x0E, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x07, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC,
  0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0E, 0xE0, 0x01, 0xEF, 0x00,
  0x1C, 0x70, 0x03, 0xC7, 0x00, 0x38, 0x78, 0x07, 0x83, 0x80, 0x70, 0x3C,
  0x0F, 0x03, 0xC1, 0xE0, 0x1C, 0x1E, 0x01, 0xE3, 0xC0, 0x1E, 0x38, 0x00,
  0xE7, 0x80, 0x0F, 0x70, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xC0, 0xF8, 0xF1, 0xF1, 0xE1, 0xC3, 0xC3, 0x80, 0x00, 0x78,
  0x08, 0x0F, 0xE3, 0x80, 0xFF, 0x9C, 0x0F, 0xFF, 0xE0, 0xF8, 0x7F, 0x0F,
  0x81, 0xF8, 0x78, 0x0F, 0x87, 0xC0, 0x3C, 0x3C, 0x01, 0xE3, 0xE0, 0x0F,
  0x1E, 0x00, 0xF0, 0xF0, 0x07, 0x8F, 0x80, 0x3C, 0x78, 0x01, 0xE3, 0xC0,
  0x0F, 0x1E, 0x00, 0xF0, 0xF0, 0x07, 0x87, 0x80, 0x3C, 0x3C, 0x03, 0xE1,
  0xE0, 0x1F, 0x0F, 0x01, 0xF0, 0x78, 0x0F, 0x83, 0xC0, 0xFC, 0x1F, 0x0F,
  0xE0, 0xFF, 0xEF, 0x03, 0xFE, 0x70, 0x0F, 0xE3, 0x80, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0xE0, 0x07, 0x9F, 0xC0, 0x39, 0xFF, 0x03, 0xDF, 0xFC, 0x1F, 0xC3,
  0xE0, 0xFC, 0x0F, 0x07, 0xC0, 0x78, 0x3C, 0x03, 0xC3, 0xE0, 0x1E, 0x1E,
  0x00, 0xF0, 0xF0, 0x07, 0x87, 0x80, 0x3C, 0x78, 0x01, 0xE3, 0xC0, 0x0F,
  0x1E, 0x00, 0xF8, 0xF0, 0x07, 0x87, 0x80, 0x3C, 0x78, 0x01, 0xE3, 0xC0,
  0x1E, 0x1E, 0x00, 0xF0, 0xF0, 0x0F, 0x87, 0x80, 0x78, 0x7E, 0x07, 0xC3,
  0xF8, 0x7C, 0x1D, 0xFF, 0xC0, 0xE7, 0xFC, 0x0F, 0x1F, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xE0, 0xF8, 0x10, 0xF8, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xF0, 0x60, 0x7F, 0xF0, 0x1F, 0xF8, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x01, 0xC1, 0xE0, 0x0F, 0xE7, 0x80, 0x7F, 0xEF, 0x00, 0xFF,
  0xFE, 0x03, 0xE1, 0xFC, 0x0F, 0x81, 0xF0, 0x1E, 0x03, 0xE0, 0x78, 0x03,
  0xC0, 0xF0, 0x07, 0x83, 0xE0, 0x0F, 0x07, 0x80, 0x3C, 0x0F, 0x00, 0x78,
  0x3E, 0x00, 0xF0, 0x78, 0x01, 0xE0, 0xF0, 0x03, 0xC1, 0xE0, 0x0F, 0x03,
  0xC0, 0x1E, 0x07, 0x80, 0x3C, 0x0F, 0x00, 0xF8, 0x1E, 0x01, 0xF0, 0x3C,
  0x07, 0xC0, 0x78, 0x0F, 0x80, 0xF0, 0x3F, 0x01, 0xF0, 0xFE, 0x03, 0xFF,
  0xB8, 0x03, 0xFE, 0x70, 0x03, 0xF8, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0xFF,
  0x80, 0xFF, 0xE0, 0xFF, 0xF0, 0xF8, 0x78, 0xF0, 0x1C, 0xF8, 0x0E, 0x78,
  0x0F, 0x3C, 0x07, 0xBC, 0x03, 0xDE, 0x07, 0xDF, 0x07, 0xCF, 0xFF, 0xC7,
  0xFF, 0xC3, 0xFF, 0x81, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x18, 0x7F,
  0xFC, 0x1F, 0xFE, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x08, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x01, 0xFC, 0x70, 0x0F, 0xF9, 0xC0, 0x7F, 0xFF, 0x03, 0xE1, 0xFC, 0x1F,
  0x03, 0xF0, 0x78, 0x0F, 0x83, 0xE0, 0x1E, 0x0F, 0x00, 0x78, 0x7C, 0x03,
  0xE1, 0xE0, 0x0F, 0x07, 0x80, 0x3C, 0x3E, 0x00, 0xF0, 0xF0, 0x03, 0xC3,
  0xC0, 0x0F, 0x0F, 0x00, 0x78, 0x3C, 0x01, 0xE0, 0xF0, 0x07, 0x83, 0xC0,
  0x3E, 0x0F, 0x00, 0xF8, 0x3C, 0x07, 0xC0, 0xF0, 0x3F, 0x03, 0xC0, 0xFC,
  0x0F, 0x8F, 0xF0, 0x3F, 0xFB, 0x80, 0x7F, 0xDE, 0x00, 0xFE, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x02, 0x00, 0xF8, 0x0C, 0x07, 0xC0, 0x3F, 0xFF, 0x00,
  0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0xE0, 0x07, 0x9F, 0xC0, 0x39, 0xFF, 0x03, 0xDF, 0xFC, 0x1F, 0xC3,
  0xE0, 0xFC, 0x0F, 0x07, 0xC0, 0x78, 0x3C, 0x03, 0xC3, 0xE0, 0x1E, 0x1E,
  0x01, 0xE0, 0xF0, 0x0F, 0x07, 0x80, 0x78, 0x78, 0x03, 0xC3, 0xC0, 0x1E,
  0x1E, 0x01, 0xE0, 0xF0, 0x0F, 0x07, 0x80, 0x78, 0x78, 0x03, 0xC3, 0xC0,
  0x3C, 0x1E, 0x01, 0xE0, 0xF0, 0x0F, 0x07, 0x80, 0x78, 0x78, 0x03, 0xC3,
  0xC0, 0x3C, 0x1E, 0x01, 0xE0, 0xF0, 0x0F, 0x0F, 0x00, 0x78, 0x00, 0x00,
  0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78,
  0x07, 0x80, 0x78, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0xFF, 0x00, 0x3F, 0x80,
  0x0F, 0xC0, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x40,
  0xF0, 0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x07, 0x80, 0x78, 0x3E, 0x01, 0xE1,
  0xF0, 0x07, 0x8F, 0x80, 0x1C, 0x3C, 0x00, 0xF1, 0xE0, 0x03, 0xCF, 0x00,
  0x0F, 0x7C, 0x00, 0x3B, 0xE0, 0x01, 0xEF, 0x80, 0x07, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x7C, 0xF0, 0x01, 0xE3, 0xC0, 0x0F, 0x0F, 0x00, 0x3C, 0x3E,
  0x00, 0xF0, 0x78, 0x03, 0xC1, 0xE0, 0x0E, 0x07, 0x80, 0x78, 0x1F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0xF0, 0x0F, 0x80, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x07,
  0x80, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x78,
  0x07, 0x80, 0x78, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x78, 0x03,
  0x8F, 0xE1, 0xFE, 0x03, 0xBF, 0xF3, 0xFE, 0x07, 0xBF, 0xF7, 0xFF, 0x07,
  0xF0, 0xFE, 0x1F, 0x07, 0xE0, 0xFC, 0x0F, 0x07, 0xC0, 0xF8, 0x0F, 0x07,
  0x80, 0xF8, 0x0F, 0x0F, 0x80, 0xF0, 0x0F, 0x0F, 0x00, 0xF0, 0x0F, 0x0F,
  0x00, 0xF0, 0x1E, 0x0F, 0x00, 0xF0, 0x1E, 0x1E, 0x01, 0xE0, 0x1E, 0x1E,
  0x01, 0xE0, 0x1E, 0x1E, 0x01, 0xE0, 0x1E, 0x1E, 0x01, 0xE0, 0x3C, 0x1E,
  0x01, 0xC0, 0x3C, 0x3C, 0x03, 0xC0, 0x3C, 0x3C, 0x03, 0xC0, 0x3C, 0x3C,
  0x03, 0xC0, 0x3C, 0x3C, 0x03, 0xC0, 0x78, 0x3C, 0x07, 0x80, 0x78, 0x78,
  0x07, 0x80, 0x78, 0x78, 0x07, 0x80, 0x78, 0x78, 0x07, 0x80, 0x70, 0x78,
  0x07, 0x80, 0xF0, 0xF0, 0x0F, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x1C, 0x7F,
  0x00, 0xEF, 0xFC, 0x0F, 0x7F, 0xF0, 0x7F, 0x0F, 0x83, 0xF0, 0x3C, 0x1F,
  0x01, 0xE1, 0xF0, 0x0F, 0x0F, 0x80, 0x78, 0x78, 0x07, 0x83, 0xC0, 0x3C,
  0x1E, 0x01, 0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0x78, 0x78, 0x07, 0x83, 0xC0,
  0x3C, 0x1E, 0x01, 0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0xF8, 0x78, 0x07, 0x83,
  0xC0, 0x3C, 0x3E, 0x01, 0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0xF0, 0x78, 0x07,
  0x83, 0xC0, 0x3C, 0x3C, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3F, 0xE0, 0x0F,
  0xFE, 0x03, 0xFF, 0xC0, 0xF8, 0x7C, 0x3E, 0x07, 0x87, 0x80, 0xF1, 0xE0,
  0x0F, 0x3C, 0x01, 0xEF, 0x00, 0x3D, 0xE0, 0x07, 0xBC, 0x01, 0xFF, 0x00,
  0x3D, 0xE0, 0x07, 0xBC, 0x00, 0xF7, 0x80, 0x1E, 0xF0, 0x07, 0xDE, 0x00,
  0xF3, 0xC0, 0x1E, 0x78, 0x07, 0xCF, 0x00, 0xF1, 0xE0, 0x3E, 0x3C, 0x0F,
  0x87, 0xC3, 0xE0, 0x7F, 0xF8, 0x07, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0xE0, 0x01, 0xC7, 0xF0, 0x03, 0x9F, 0xF0, 0x0F, 0x7F, 0xF0, 0x1F,
  0xC3, 0xE0, 0x3F, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0xF8, 0x0F, 0x03, 0xE0,
  0x1E, 0x07, 0xC0, 0x3C, 0x0F, 0x00, 0x78, 0x1E, 0x00, 0xF0, 0x78, 0x01,
  0xE0, 0xF0, 0x03, 0xC1, 0xE0, 0x07, 0x83, 0xC0, 0x1E, 0x07, 0x80, 0x3C,
  0x1E, 0x00, 0x78, 0x3C, 0x01, 0xF0, 0x78, 0x03, 0xC0, 0xF0, 0x0F, 0x81,
  0xF0, 0x1E, 0x07, 0xE0, 0x7C, 0x0F, 0xE1, 0xF0, 0x1F, 0xFF, 0xC0, 0x3D,
  0xFF, 0x00, 0x71, 0xFC, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x1F, 0xC7, 0x03, 0xFE, 0x70,
  0x7F, 0xFF, 0x0F, 0x87, 0xF1, 0xF0, 0x3E, 0x1E, 0x03, 0xE3, 0xC0, 0x1E,
  0x3C, 0x01, 0xE7, 0xC0, 0x3E, 0x78, 0x03, 0xC7, 0x80, 0x3C, 0xF8, 0x03,
  0xCF, 0x00, 0x3C, 0xF0, 0x03, 0xCF, 0x00, 0x78, 0xF0, 0x07, 0x8F, 0x00,
  0x78, 0xF0, 0x0F, 0x8F, 0x00, 0xF8, 0xF0, 0x1F, 0x0F, 0x01, 0xF0, 0xF0,
  0x3F, 0x0F, 0x87, 0xF0, 0xFF, 0xEE, 0x07, 0xFD, 0xE0, 0x3F, 0x9E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x00, 0x07, 0x81, 0xC7, 0xC0, 0xE7,
  0xE0, 0xF7, 0xF0, 0x7F, 0x88, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F,
  0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x01, 0xFF, 0x81, 0xFF, 0xE1, 0xFF,
  0xF0, 0xF0, 0x10, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x80, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE2, 0x01, 0xF1, 0x81, 0xF0, 0xFF, 0xF8, 0x7F, 0xF8, 0x3F,
  0xF0, 0x00, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x84,
  0xFF, 0xCF, 0xFE, 0xFF, 0xF0, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x7F, 0x83, 0xFC, 0x0F, 0xE0, 0x0F, 0x00, 0xF1, 0xE0, 0x0F, 0x1E,
  0x00, 0xF1, 0xE0, 0x1E, 0x1E, 0x01, 0xE1, 0xE0, 0x1E, 0x3C, 0x01, 0xE3,
  0xC0, 0x1C, 0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x3C, 0x03, 0xC7, 0x80, 0x3C,
  0x78, 0x07, 0x87, 0x80, 0x78, 0x78, 0x07, 0x8F, 0x00, 0x78, 0xF0, 0x0F,
  0x8F, 0x00, 0xF0, 0xF0, 0x0F, 0x0F, 0x01, 0xF0, 0xF0, 0x3F, 0x0F, 0x03,
  0xE0, 0xF8, 0xEE, 0x0F, 0xFE, 0xE0, 0x7F, 0xDE, 0x03, 0xF1, 0xE0, 0xF0,
  0x07, 0xFC, 0x01, 0xEF, 0x00, 0xFB, 0xC0, 0x3C, 0xF0, 0x0F, 0x3C, 0x07,
  0x8F, 0x01, 0xE3, 0xC0, 0xF0, 0xF0, 0x3C, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC3, 0xC0, 0xF0, 0xF0, 0x3C, 0x78, 0x0F, 0x1E, 0x03, 0xC7, 0x00, 0x73,
  0xC0, 0x1C, 0xF0, 0x07, 0x78, 0x01, 0xDE, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x0F,
  0x00, 0xFF, 0x01, 0xF0, 0x0F, 0xF0, 0x1F, 0x01, 0xEF, 0x03, 0xF0, 0x1E,
  0xF0, 0x3F, 0x03, 0xCF, 0x03, 0xF0, 0x3C, 0xF0, 0x77, 0x03, 0xCF, 0x07,
  0x70, 0x78, 0xF0, 0xF7, 0x07, 0x8F, 0x0E, 0x70, 0xF0, 0xF1, 0xE7, 0x0F,
  0x0F, 0x1C, 0x70, 0xF0, 0xF1, 0xC7, 0x1E, 0x0F, 0x3C, 0x71, 0xE0, 0xF3,
  0x87, 0x1C, 0x0F, 0x78, 0x73, 0xC0, 0xF7, 0x07, 0x38, 0x0F, 0x70, 0x77,
  0x80, 0xEF, 0x07, 0x78, 0x0E, 0xE0, 0x77, 0x00, 0xEE, 0x07, 0xF0, 0x0F,
  0xC0, 0x7E, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0x7C, 0x00, 0xF8, 0x07,
  0xC0, 0x0F, 0x80, 0x7C, 0x00, 0x03, 0xC0, 0x3E, 0x07, 0x80, 0xF0, 0x0F,
  0x83, 0xE0, 0x0F, 0x07, 0x80, 0x1E, 0x1E, 0x00, 0x3C, 0x7C, 0x00, 0x38,
  0xF0, 0x00, 0x7B, 0xC0, 0x00, 0xF7, 0x80, 0x01, 0xFE, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0xFE, 0x00, 0x03, 0xDE, 0x00, 0x07, 0xBC, 0x00, 0x1E, 0x78, 0x00,
  0x78, 0x78, 0x00, 0xF0, 0xF0, 0x03, 0xC1, 0xE0, 0x0F, 0x83, 0xC0, 0x1E,
  0x03, 0xC0, 0x78, 0x07, 0x81, 0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x03, 0xC0,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3C, 0x00, 0xF0, 0x0F,
  0x00, 0x3C, 0x07, 0x80, 0x0F, 0x01, 0xE0, 0x03, 0xC0, 0xF0, 0x00, 0xF0,
  0x3C, 0x00, 0x1C, 0x1E, 0x00, 0x07, 0x07, 0x80, 0x01, 0xC1, 0xC0, 0x00,
  0x70, 0xF0, 0x00, 0x1C, 0x3C, 0x00, 0x07, 0x1E, 0x00, 0x01, 0xC7, 0x80,
  0x00, 0x73, 0xC0, 0x00, 0x1C, 0xF0, 0x00, 0x07, 0xB8, 0x00, 0x01, 0xDE,
  0x00, 0x00, 0x77, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F,
  0x00, 0x07, 0x80, 0x03, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xFE, 0x00, 0x00,
  0x03, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x3E, 0x00,
  0x0F, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xE0, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x1C, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x02, 0xFC, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF0, 0x01, 0xFC, 0x00,
  0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x03, 0xFE,
  0x00, 0xFF, 0x00, 0x3F, 0x00, 0x0E, 0x00, 0x00, 0x3F, 0xC0, 0x17, 0xFF,
  0x03, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0x3F, 0xE8, 0x00, 0xF8,
};

const GFXglyph NotoSans_Condensed_Italic49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 12, 35, 12, 1, -35 },
  { 54, 14, 13, 17, 5, -35 },
  { 77, 25, 35, 24, 0, -35 },
  { 187, 22, 40, 22, 0, -37 },
  { 297, 28, 35, 33, 3, -35 },
  { 420, 24, 35, 25, 0, -35 },
  { 525, 6, 13, 10, 5, -35 },
  { 535, 15, 43, 13, 1, -35 },
  { 616, 16, 43, 13, -4, -35 },
  { 702, 17, 18, 20, 5, -37 },
  { 741, 20, 23, 23, 2, -29 },
  { 799, 9, 12, 11, -2, -6 },
  { 813, 11, 4, 13, 1, -15 },
  { 819, 5, 6, 11, 1, -6 },
  { 823, 23, 35, 17, -2, -35 },
  { 924, 19, 35, 22, 2, -35 },
  { 1008, 13, 35, 22, 6, -35 },
  { 1065, 22, 35, 22, -1, -35 },
  { 1162, 21, 35, 22, 0, -35 },
  { 1254, 22, 35, 22, -1, -35 },
  { 1351, 22, 35, 22, 0, -35 },
  { 1448, 20, 35, 22, 2, -35 },
  { 1536, 21, 35, 22, 2, -35 },
  { 1628, 22, 35, 22, 0, -35 },
  { 1725, 20, 35, 22, 1, -35 },
  { 1813, 10, 27, 11, 0, -27 },
  { 1847, 12, 33, 11, -2, -27 },
  { 1897, 20, 23, 23, 2, -29 },
  { 1955, 20, 14, 23, 2, -24 },
  { 1990, 20, 23, 23, 2, -29 },
  { 2048, 16, 35, 16, 2, -35 },
  { 2118, 30, 39, 33, 2, -35 },
  { 2265, 22, 35, 22, -3, -35 },
  { 2362, 23, 35, 24, 1, -35 },
  { 2463, 23, 36, 22, 2, -36 },
  { 2567, 24, 35, 26, 1, -35 },
  { 2672, 21, 35, 20, 1, -35 },
  { 2764, 21, 35, 19, 1, -35 },
  { 2856, 25, 36, 27, 2, -36 },
  { 2969, 26, 35, 27, 1, -35 },
  { 3083, 19, 35, 14, -2, -35 },
  { 3167, 19, 44, 11, -7, -35 },
  { 3272, 25, 35, 22, 1, -35 },
  { 3382, 14, 35, 19, 1, -35 },
  { 3444, 34, 35, 35, 1, -35 },
  { 3593, 28, 35, 28, 1, -35 },
  { 3716, 25, 35, 28, 2, -35 },
  { 3826, 22, 35, 22, 1, -35 },
  { 3923, 25, 43, 28, 2, -35 },
  { 4058, 22, 35, 23, 1, -35 },
  { 4155, 22, 35, 20, 0, -35 },
  { 4252, 19, 35, 19, 4, -35 },
  { 4336, 25, 35, 26, 2, -35 },
  { 4446, 22, 35, 22, 4, -35 },
  { 4543, 35, 35, 35, 4, -35 },
  { 4697, 27, 35, 20, -3, -35 },
  { 4816, 20, 35, 20, 4, -35 },
  { 4904, 24, 35, 19, -2, -35 },
  { 5009, 18, 43, 14, -1, -35 },
  { 5106, 8, 35, 17, 5, -35 },
  { 5141, 18, 43, 14, -3, -35 },
  { 5238, 20, 20, 22, 1, -35 },
  { 5288, 17, 3, 16, -4, 4 },
  { 5295, 7, 7, 13, 7, -37 },
  { 5302, 21, 27, 23, 2, -27 },
  { 5373, 21, 37, 23, 0, -37 },
  { 5471, 17, 27, 18, 2, -27 },
  { 5529, 23, 37, 23, 2, -37 },
  { 5636, 17, 27, 20, 2, -27 },
  { 5694, 24, 49, 13, -6, -37 },
  { 5841, 22, 39, 23, 0, -27 },
  { 5949, 21, 37, 23, 0, -37 },
  { 6047, 12, 36, 10, 0, -36 },
  { 6101, 18, 48, 10, -6, -36 },
  { 6209, 22, 37, 20, 0, -37 },
  { 6311, 12, 37, 10, 0, -37 },
  { 6367, 32, 27, 34, 0, -27 },
  { 6475, 21, 27, 23, 0, -27 },
  { 6546, 19, 27, 22, 2, -27 },
  { 6611, 23, 39, 23, -2, -27 },
  { 6724, 20, 39, 23, 2, -27 },
  { 6822, 17, 27, 15, 0, -27 },
  { 6880, 17, 27, 17, 0, -27 },
  { 6938, 13, 32, 13, 2, -32 },
  { 6990, 20, 26, 23, 2, -26 },
  { 7055, 18, 26, 18, 3, -26 },
  { 7114, 28, 26, 29, 3, -26 },
  { 7205, 23, 26, 19, -2, -26 },
  { 7280, 26, 38, 19, -5, -26 },
  { 7404, 18, 26, 16, -1, -26 },
  { 7463, 18, 43, 16, 1, -35 },
  { 7560, 3, 49, 21, 9, -37 },
  { 7579, 18, 43, 16, -3, -35 },
  { 7676, 20, 6, 23, 2, -20 },
};

const GFXfont NotoSans_Condensed_Italic49pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Italic49pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Italic49pt7bGlyphs,
  0x20, 0x7E, 67
};

#endif // _NOTOSANS_CONDENSED_ITALIC49PT7B_H_
