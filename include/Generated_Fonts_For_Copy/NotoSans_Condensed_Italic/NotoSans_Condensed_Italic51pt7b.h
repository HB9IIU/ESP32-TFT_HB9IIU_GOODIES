#ifndef _NOTOSANS_CONDENSED_ITALIC51PT7B_H_
#define _NOTOSANS_CONDENSED_ITALIC51PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Italic.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Italic51pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01,
  0xC0, 0x1C, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0x40, 0x00, 0x3E, 0x3E, 0x78,
  0x78, 0xF0, 0xF1, 0xE1, 0xE7, 0x87, 0x8F, 0x0F, 0x1E, 0x1E, 0x3C, 0x3C,
  0x70, 0x70, 0xE0, 0xE1, 0xC1, 0xC7, 0x87, 0x8E, 0x0E, 0x00, 0x00, 0x0F,
  0x07, 0x80, 0x03, 0x81, 0xC0, 0x00, 0xE0, 0xF0, 0x00, 0x38, 0x38, 0x00,
  0x1C, 0x0E, 0x00, 0x07, 0x03, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0xF0, 0x70,
  0x00, 0x38, 0x1C, 0x00, 0x0E, 0x0F, 0x00, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xC0, 0x3C, 0x1C, 0x00, 0x0E, 0x07, 0x00, 0x03,
  0x83, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x78, 0x38, 0x00, 0x1C, 0x0E, 0x00,
  0x07, 0x07, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0xE0, 0x70, 0x07, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x01, 0xC1, 0xE0, 0x00, 0xF0,
  0x70, 0x00, 0x38, 0x1C, 0x00, 0x0E, 0x07, 0x00, 0x03, 0x83, 0x80, 0x01,
  0xE0, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x1C, 0x1E, 0x00, 0x0F, 0x07, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0xE0, 0xF0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x01, 0xFF, 0xC0,
  0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xEE, 0x78, 0x1E, 0x30, 0x40, 0xF0,
  0xC0, 0x03, 0xC3, 0x00, 0x0F, 0x1C, 0x00, 0x3C, 0x70, 0x00, 0xF1, 0x80,
  0x03, 0xC6, 0x00, 0x0F, 0xB8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1B,
  0xE0, 0x00, 0x67, 0xC0, 0x01, 0x8F, 0x00, 0x0E, 0x3C, 0x00, 0x38, 0xF0,
  0x00, 0xC3, 0xC0, 0x03, 0x0F, 0x00, 0x1C, 0x7C, 0x20, 0x71, 0xE0, 0xF1,
  0x9F, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x03, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x20, 0x3F, 0x80, 0x0E, 0x03, 0xFE,
  0x00, 0xF0, 0x3C, 0xF0, 0x07, 0x01, 0xC3, 0x80, 0x78, 0x1E, 0x1C, 0x03,
  0x80, 0xE0, 0xE0, 0x38, 0x0F, 0x07, 0x03, 0xC0, 0x78, 0x38, 0x1C, 0x03,
  0x81, 0xC1, 0xE0, 0x1C, 0x0E, 0x0E, 0x01, 0xE0, 0x70, 0xE0, 0x0F, 0x07,
  0x8F, 0x00, 0x70, 0x38, 0x70, 0x03, 0x81, 0xC7, 0x80, 0x1C, 0x1E, 0x38,
  0xFC, 0xE0, 0xF3, 0xCF, 0xF7, 0x07, 0x3C, 0xFF, 0xF8, 0x79, 0xC7, 0x1F,
  0xE7, 0x9E, 0x78, 0x77, 0xF8, 0xE3, 0x83, 0xBF, 0x8F, 0x3C, 0x1C, 0x78,
  0x71, 0xC0, 0xE0, 0x07, 0x0E, 0x07, 0x00, 0x78, 0xF0, 0x78, 0x03, 0x87,
  0x03, 0xC0, 0x3C, 0x38, 0x1C, 0x01, 0xC1, 0xC0, 0xE0, 0x1C, 0x0E, 0x07,
  0x01, 0xE0, 0x70, 0x78, 0x0E, 0x03, 0x83, 0x80, 0xF0, 0x1C, 0x3C, 0x07,
  0x00, 0xE1, 0xC0, 0x78, 0x07, 0x1E, 0x07, 0x80, 0x3F, 0xE0, 0x38, 0x01,
  0xFE, 0x03, 0xC0, 0x07, 0xE0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xBF, 0x00, 0x0F, 0x07,
  0x80, 0x07, 0x83, 0xC0, 0x07, 0x81, 0xE0, 0x03, 0xC0, 0xF0, 0x01, 0xE0,
  0x78, 0x00, 0xF0, 0x78, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x3E, 0x00, 0x1E,
  0x1E, 0x00, 0x0F, 0x9E, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0xFB, 0xE0, 0xF8, 0xF8, 0xF0, 0x78, 0x78, 0x7C, 0x3C, 0x78, 0x1E, 0x3C,
  0x7C, 0x0F, 0x1E, 0x3C, 0x07, 0xDE, 0x1E, 0x01, 0xEF, 0x1F, 0x00, 0xFF,
  0x0F, 0x00, 0x3F, 0x87, 0x80, 0x1F, 0x83, 0xE0, 0x0F, 0x81, 0xF0, 0x0F,
  0xE0, 0x78, 0x0F, 0xF0, 0x3F, 0x1F, 0xFC, 0x1F, 0xFF, 0xBE, 0x07, 0xFF,
  0x0F, 0x81, 0xFF, 0x07, 0xC0, 0x18, 0x00, 0x00, 0x3E, 0x78, 0xF1, 0xE3,
  0xCF, 0x1E, 0x3C, 0x70, 0xE1, 0xC3, 0x8E, 0x00, 0x00, 0x0F, 0x00, 0x1E,
  0x00, 0x1C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00,
  0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x40, 0xE0, 0x1C, 0x38, 0x07, 0xCE, 0x03,
  0xFF, 0x8F, 0x3F, 0xFF, 0xC1, 0xFF, 0xF0, 0x3F, 0xFC, 0x1F, 0x80, 0x0F,
  0x70, 0x07, 0x9C, 0x03, 0xE7, 0x81, 0xF0, 0xF0, 0x38, 0x3C, 0x04, 0x0F,
  0x80, 0x01, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x0F, 0x87, 0xC3, 0xC3, 0xE1, 0xE0,
  0xF0, 0xF0, 0x78, 0x78, 0x3C, 0x1C, 0x1E, 0x0E, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF8, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x07, 0xFC,
  0x00, 0xFF, 0xC0, 0x1F, 0xFE, 0x03, 0xE1, 0xE0, 0x7C, 0x1F, 0x07, 0x80,
  0xF0, 0xF8, 0x0F, 0x0F, 0x00, 0xF1, 0xF0, 0x0F, 0x1E, 0x00, 0xF3, 0xE0,
  0x0F, 0x3C, 0x00, 0xF3, 0xC0, 0x0F, 0x3C, 0x00, 0xF7, 0xC0, 0x1F, 0x78,
  0x01, 0xF7, 0x80, 0x1E, 0x78, 0x01, 0xEF, 0x80, 0x1E, 0xF8, 0x01, 0xEF,
  0x00, 0x3E, 0xF0, 0x03, 0xCF, 0x00, 0x3C, 0xF0, 0x03, 0xCF, 0x00, 0x7C,
  0xF0, 0x07, 0x8F, 0x00, 0x78, 0xF0, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x1E,
  0x0F, 0x03, 0xE0, 0xF8, 0x3C, 0x0F, 0xCF, 0xC0, 0x7F, 0xF8, 0x03, 0xFF,
  0x00, 0x1F, 0xC0, 0x00, 0x20, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0xFE, 0x0F,
  0xF0, 0xFF, 0x1F, 0xF9, 0xFB, 0xDF, 0x1E, 0x71, 0xF3, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x1F, 0x07, 0xE0, 0x18, 0x07, 0xC0, 0x20,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0x80, 0x1F, 0xFF,
  0x80, 0xFF, 0xFE, 0x03, 0xC0, 0xFC, 0x04, 0x01, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x01, 0xF8,
  0x01, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x80, 0x0F, 0x83, 0xC1,
  0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xDE,
  0x00, 0x07, 0x3C, 0x00, 0x1E, 0xF0, 0x00, 0x39, 0xE0, 0x00, 0xF3, 0xC0,
  0x03, 0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x1C, 0x3C, 0x00, 0x78, 0x78, 0x01,
  0xE0, 0xF0, 0x03, 0x81, 0xE0, 0x0F, 0x07, 0x80, 0x3C, 0x0F, 0x00, 0x70,
  0x1E, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF8, 0x0E, 0x01, 0xE0, 0x3C, 0x03,
  0xC0, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0x80, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x18,
  0x3F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x7C, 0x20, 0x03, 0xE0, 0xF0, 0x3F, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0,
  0x1F, 0xFC, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0xF8, 0x07, 0x9F, 0xE0,
  0x7B, 0xFF, 0x83, 0xDF, 0xFE, 0x1F, 0xC1, 0xF0, 0xFC, 0x07, 0x8F, 0xC0,
  0x3C, 0x7C, 0x01, 0xE3, 0xE0, 0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x03, 0xC7,
  0x80, 0x1E, 0x3C, 0x00, 0xF1, 0xE0, 0x0F, 0x8F, 0x00, 0x78, 0x78, 0x03,
  0xC3, 0xC0, 0x3E, 0x1F, 0x01, 0xE0, 0xF8, 0x1F, 0x03, 0xE3, 0xF0, 0x1F,
  0xFF, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0x80, 0x00, 0x0F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF,
  0xE0, 0x1F, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0xF0, 0x0F, 0x81, 0xE0, 0x0F,
  0x03, 0xC0, 0x1E, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0x7C, 0x1F, 0x00, 0x78, 0x7C, 0x00, 0xFB, 0xF0, 0x00,
  0xFF, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7C,
  0xF8, 0x01, 0xF0, 0xF8, 0x07, 0x80, 0xF8, 0x1F, 0x00, 0xF0, 0x7C, 0x01,
  0xE0, 0xF0, 0x03, 0xC1, 0xE0, 0x07, 0xC3, 0xC0, 0x0F, 0x8F, 0x80, 0x1E,
  0x1F, 0x00, 0x3C, 0x3E, 0x00, 0x78, 0x3C, 0x01, 0xF0, 0x7C, 0x07, 0xC0,
  0xFC, 0x1F, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xF8, 0x07,
  0xFF, 0xE0, 0x7E, 0x1F, 0x03, 0xE0, 0x78, 0x3E, 0x03, 0xE1, 0xE0, 0x0F,
  0x1F, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x00, 0xF3, 0xE0,
  0x0F, 0x9F, 0x00, 0x7C, 0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x3E, 0x01, 0xF1,
  0xF0, 0x1F, 0x87, 0x80, 0xFC, 0x3E, 0x1F, 0xE1, 0xFF, 0xFE, 0x07, 0xFE,
  0xF0, 0x1F, 0xC7, 0x80, 0x18, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x04, 0x0F, 0xC0, 0x3F, 0xFC, 0x01, 0xFF,
  0xC0, 0x0F, 0xF8, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x78, 0x1F, 0x83,
  0xE0, 0x7C, 0x0F, 0x80, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0x03, 0xE0, 0x7C, 0x1F, 0x83, 0xF0, 0x3C, 0x02, 0x00, 0x00,
  0x30, 0x01, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0,
  0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x01, 0xC0, 0x00, 0x3E, 0x00, 0x07, 0xF0,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x3C, 0x00,
  0x00, 0x60, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7C, 0x00,
  0x03, 0x80, 0x00, 0x10, 0x00, 0x00, 0x01, 0xF8, 0x07, 0xFF, 0x0F, 0xFF,
  0xC3, 0xFF, 0xE1, 0xC1, 0xF8, 0x80, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x01, 0xFE, 0x3F, 0x80, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x0F, 0x00, 0x78, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0E, 0x03, 0x80,
  0x00, 0x1E, 0x0E, 0x00, 0x00, 0x3C, 0x3C, 0x01, 0xE0, 0x38, 0x70, 0x1F,
  0xF8, 0x71, 0xE0, 0x7F, 0xE0, 0xE3, 0x81, 0xE1, 0xC1, 0xCF, 0x07, 0x87,
  0x83, 0x9C, 0x0E, 0x0F, 0x07, 0x38, 0x38, 0x1C, 0x0E, 0xE0, 0xF0, 0x38,
  0x1D, 0xC1, 0xC0, 0xF0, 0x7B, 0x83, 0x81, 0xE0, 0xEF, 0x0F, 0x03, 0x81,
  0xDC, 0x1C, 0x07, 0x03, 0xB8, 0x38, 0x1E, 0x0F, 0x70, 0x70, 0x3C, 0x1C,
  0xE0, 0xE0, 0x70, 0x39, 0xC1, 0xC1, 0xE0, 0xE3, 0x83, 0x83, 0xC1, 0xC7,
  0x07, 0x0D, 0x87, 0x0E, 0x0F, 0xFB, 0xFC, 0x1C, 0x0F, 0xE7, 0xF0, 0x38,
  0x1F, 0x87, 0xC0, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xE0, 0x06, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xEF, 0x00, 0x03, 0xDE, 0x00, 0x07, 0xBC, 0x00, 0x1E, 0x78, 0x00,
  0x3C, 0xF0, 0x00, 0xF1, 0xE0, 0x01, 0xE3, 0xC0, 0x07, 0xC7, 0x80, 0x0F,
  0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x78, 0x3C, 0x00, 0xF0, 0x78, 0x03, 0xC0,
  0xF0, 0x07, 0x81, 0xE0, 0x1F, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0xFF, 0xFF,
  0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0x80, 0x78, 0x1E, 0x00, 0xF8,
  0x7C, 0x01, 0xF0, 0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xC7, 0x80, 0x0F, 0x9F,
  0x00, 0x1F, 0x3C, 0x00, 0x3E, 0xF8, 0x00, 0x3D, 0xF0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x80, 0x01, 0xE0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x01,
  0xFF, 0xFC, 0x03, 0xE0, 0xFE, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x1F, 0x03,
  0xC0, 0x1F, 0x03, 0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0x80, 0x1E, 0x07,
  0x80, 0x1E, 0x07, 0x80, 0x3E, 0x07, 0x80, 0x3C, 0x0F, 0x80, 0x7C, 0x0F,
  0x01, 0xF8, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F,
  0xFF, 0xE0, 0x1E, 0x03, 0xF0, 0x1E, 0x01, 0xF0, 0x1E, 0x00, 0xF8, 0x3E,
  0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x3C, 0x00, 0xF8, 0x3C, 0x00, 0xF8, 0x3C,
  0x00, 0xF8, 0x7C, 0x00, 0xF0, 0x78, 0x01, 0xF0, 0x78, 0x01, 0xF0, 0x78,
  0x03, 0xE0, 0x78, 0x07, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF,
  0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFC, 0x0E, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x80, 0x3F, 0x87, 0x80, 0x1F,
  0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x00, 0x20, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x7C, 0x3F, 0xC0,
  0x3E, 0x03, 0xE0, 0x1E, 0x00, 0xF8, 0x0F, 0x00, 0x7C, 0x07, 0x80, 0x1E,
  0x07, 0xC0, 0x0F, 0x83, 0xC0, 0x07, 0xC1, 0xE0, 0x03, 0xE0, 0xF0, 0x01,
  0xF0, 0x78, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x3C, 0x00, 0x3E, 0x1E, 0x00,
  0x1F, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x87, 0xC0, 0x03, 0xC3, 0xC0,
  0x03, 0xE1, 0xE0, 0x01, 0xF0, 0xF0, 0x00, 0xF0, 0xF8, 0x00, 0xF8, 0x78,
  0x00, 0x7C, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x3E, 0x0F, 0x00, 0x3E, 0x0F,
  0x80, 0x1F, 0x07, 0x80, 0x1F, 0x03, 0xC0, 0x1F, 0x01, 0xE0, 0x1F, 0x80,
  0xF0, 0x3F, 0x80, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x3F, 0xFE, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF,
  0xC0, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xFF, 0xF0,
  0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0xFE, 0x03, 0xFF,
  0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x07, 0xFF,
  0xF0, 0x1F, 0xFF, 0xC0, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0,
  0x0F, 0xC0, 0x38, 0x03, 0xF0, 0x01, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0,
  0x0F, 0xFC, 0x3C, 0x01, 0xFF, 0x87, 0x80, 0x3F, 0xE0, 0xF0, 0x07, 0xFC,
  0x3E, 0x00, 0x07, 0x87, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x3C, 0x1F, 0x00,
  0x07, 0x83, 0xE0, 0x00, 0xF0, 0x7C, 0x00, 0x1E, 0x07, 0x80, 0x07, 0xC0,
  0xF0, 0x00, 0xF0, 0x1F, 0x00, 0x1E, 0x03, 0xE0, 0x03, 0xC0, 0x3E, 0x00,
  0x78, 0x07, 0xF8, 0x7F, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0xF0, 0x01, 0xF0, 0x1E,
  0x00, 0x1E, 0x01, 0xE0, 0x01, 0xE0, 0x1E, 0x00, 0x3E, 0x03, 0xE0, 0x03,
  0xC0, 0x3C, 0x00, 0x3C, 0x03, 0xC0, 0x03, 0xC0, 0x3C, 0x00, 0x3C, 0x07,
  0xC0, 0x07, 0xC0, 0x78, 0x00, 0x78, 0x07, 0x80, 0x07, 0x80, 0x78, 0x00,
  0x78, 0x07, 0x80, 0x07, 0x80, 0xF8, 0x00, 0xF8, 0x0F, 0x00, 0x0F, 0x00,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFE, 0x01, 0xE0, 0x01, 0xE0, 0x1E, 0x00, 0x1E, 0x01, 0xE0, 0x01, 0xE0,
  0x3E, 0x00, 0x3E, 0x03, 0xC0, 0x03, 0xC0, 0x3C, 0x00, 0x3C, 0x03, 0xC0,
  0x03, 0xC0, 0x3C, 0x00, 0x3C, 0x07, 0xC0, 0x07, 0xC0, 0x78, 0x00, 0x78,
  0x07, 0x80, 0x07, 0x80, 0x78, 0x00, 0x78, 0x07, 0x80, 0x07, 0x80, 0xF8,
  0x00, 0xF8, 0x0F, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0xF0, 0x0F, 0x00, 0x0F,
  0x00, 0x01, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x7F, 0x00, 0x01, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07,
  0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x07,
  0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x02, 0x1F, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x07, 0xC0,
  0x78, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x03, 0xE0, 0x3C,
  0x00, 0xF0, 0x1F, 0x00, 0x3C, 0x0F, 0x80, 0x0F, 0x07, 0xC0, 0x07, 0xC1,
  0xE0, 0x01, 0xE0, 0xF8, 0x00, 0x78, 0x7C, 0x00, 0x1E, 0x3E, 0x00, 0x07,
  0x9F, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0xF3, 0xE0, 0x00, 0x3D, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0x1F, 0x3E, 0x00, 0x07, 0x87, 0x80, 0x03, 0xE1, 0xE0, 0x00, 0xF8,
  0x7C, 0x00, 0x3C, 0x1F, 0x00, 0x0F, 0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x01,
  0xF0, 0x3E, 0x00, 0x78, 0x0F, 0x80, 0x1E, 0x01, 0xE0, 0x07, 0x80, 0x7C,
  0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x03, 0xC0, 0x3C, 0x00, 0xF0, 0x0F, 0x00,
  0x3E, 0x03, 0xC0, 0x0F, 0x80, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0xFE, 0x01, 0xF8,
  0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x3F, 0xC0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x3B, 0xC0, 0x03,
  0xFC, 0x07, 0xBC, 0x00, 0x7B, 0xC0, 0x7B, 0xC0, 0x07, 0xBC, 0x07, 0xBC,
  0x00, 0xF7, 0x80, 0x7B, 0xC0, 0x0F, 0x78, 0x07, 0xBC, 0x01, 0xE7, 0x80,
  0xF3, 0xC0, 0x1E, 0x78, 0x0F, 0x3C, 0x03, 0xCF, 0x80, 0xF3, 0xC0, 0x3C,
  0xF0, 0x0F, 0x1C, 0x07, 0x8F, 0x00, 0xF1, 0xC0, 0x78, 0xF0, 0x1E, 0x1C,
  0x0F, 0x0F, 0x01, 0xE1, 0xC0, 0xF1, 0xF0, 0x1E, 0x1E, 0x1E, 0x1E, 0x01,
  0xE1, 0xE1, 0xE1, 0xE0, 0x3C, 0x1E, 0x3C, 0x1E, 0x03, 0xC1, 0xE3, 0xC1,
  0xE0, 0x3C, 0x1E, 0x78, 0x3E, 0x03, 0xC1, 0xE7, 0x83, 0xC0, 0x3C, 0x1E,
  0x70, 0x3C, 0x07, 0x81, 0xEF, 0x03, 0xC0, 0x78, 0x1E, 0xE0, 0x7C, 0x07,
  0x81, 0xFE, 0x07, 0xC0, 0x78, 0x1F, 0xC0, 0x78, 0x07, 0x80, 0xFC, 0x07,
  0x80, 0xF0, 0x0F, 0x80, 0x78, 0x0F, 0x00, 0xF8, 0x0F, 0x80, 0xF0, 0x0F,
  0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x78, 0x0F,
  0xC0, 0x03, 0xC0, 0x7E, 0x00, 0x3C, 0x07, 0xF0, 0x01, 0xE0, 0x3F, 0x80,
  0x0F, 0x01, 0xFC, 0x00, 0x78, 0x0F, 0xF0, 0x07, 0xC0, 0x77, 0x80, 0x3C,
  0x07, 0xBC, 0x01, 0xE0, 0x3D, 0xE0, 0x0F, 0x01, 0xE7, 0x80, 0x78, 0x0F,
  0x3C, 0x07, 0xC0, 0x79, 0xE0, 0x3C, 0x07, 0x8F, 0x01, 0xE0, 0x3C, 0x3C,
  0x0F, 0x01, 0xE1, 0xE0, 0x78, 0x0F, 0x0F, 0x07, 0x80, 0x78, 0x78, 0x3C,
  0x07, 0x81, 0xC1, 0xE0, 0x3C, 0x0F, 0x0F, 0x01, 0xE0, 0x78, 0x78, 0x0F,
  0x03, 0xC7, 0x80, 0xF8, 0x1E, 0x3C, 0x07, 0x80, 0x79, 0xE0, 0x3C, 0x03,
  0xCF, 0x01, 0xE0, 0x1E, 0x78, 0x0F, 0x00, 0xF7, 0x80, 0xF0, 0x03, 0xFC,
  0x07, 0x80, 0x1F, 0xE0, 0x3C, 0x00, 0xFF, 0x01, 0xE0, 0x07, 0xF0, 0x0F,
  0x00, 0x1F, 0x80, 0xF0, 0x00, 0xFC, 0x07, 0x80, 0x07, 0xE0, 0x3C, 0x00,
  0x3F, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFF,
  0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x01, 0xF8, 0x1F, 0x00, 0xFC,
  0x03, 0xE0, 0x3E, 0x00, 0xF8, 0x1F, 0x00, 0x1E, 0x0F, 0x80, 0x07, 0xC3,
  0xE0, 0x01, 0xF1, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x1E, 0x00, 0x07,
  0xCF, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0x7C, 0xF0, 0x00, 0x1F, 0x7C, 0x00,
  0x07, 0x9F, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x79, 0xE0, 0x00, 0x3E, 0x78,
  0x00, 0x0F, 0x9E, 0x00, 0x03, 0xCF, 0x80, 0x00, 0xF3, 0xE0, 0x00, 0x7C,
  0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0x8F, 0x80, 0x03, 0xE3, 0xE0, 0x00,
  0xF0, 0xF8, 0x00, 0x7C, 0x1E, 0x00, 0x1E, 0x07, 0xC0, 0x0F, 0x81, 0xF0,
  0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x0F, 0xE3, 0xF8, 0x01, 0xFF, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0x1F, 0xE0, 0x3E, 0x07,
  0xC0, 0x78, 0x07, 0x80, 0xF0, 0x0F, 0x81, 0xE0, 0x1F, 0x07, 0xC0, 0x3E,
  0x0F, 0x00, 0x7C, 0x1E, 0x00, 0xF8, 0x3C, 0x01, 0xE0, 0x78, 0x03, 0xC1,
  0xF0, 0x0F, 0x83, 0xC0, 0x1E, 0x07, 0x80, 0x7C, 0x0F, 0x01, 0xF0, 0x1E,
  0x0F, 0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x03, 0xFF,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFF,
  0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x01, 0xF8, 0x1F, 0x00, 0xFC,
  0x03, 0xE0, 0x3E, 0x00, 0xF8, 0x1F, 0x00, 0x1E, 0x0F, 0x80, 0x07, 0xC3,
  0xE0, 0x01, 0xF1, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x1E, 0x00, 0x07,
  0xCF, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0x7C, 0xF0, 0x00, 0x1F, 0x7C, 0x00,
  0x07, 0x9F, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x79, 0xE0, 0x00, 0x3E, 0x78,
  0x00, 0x0F, 0x9E, 0x00, 0x03, 0xCF, 0x80, 0x00, 0xF3, 0xE0, 0x00, 0x7C,
  0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0x8F, 0x80, 0x03, 0xE3, 0xE0, 0x00,
  0xF0, 0xF8, 0x00, 0x7C, 0x1E, 0x00, 0x1E, 0x07, 0xC0, 0x0F, 0x81, 0xF0,
  0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x0F, 0xE3, 0xF8, 0x01, 0xFF, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0x1F, 0xE0,
  0x3E, 0x07, 0xC0, 0x78, 0x07, 0xC0, 0xF0, 0x0F, 0x81, 0xE0, 0x1F, 0x07,
  0xC0, 0x3E, 0x0F, 0x00, 0x7C, 0x1E, 0x00, 0xF8, 0x3C, 0x01, 0xE0, 0x78,
  0x03, 0xC1, 0xF0, 0x0F, 0x83, 0xC0, 0x1E, 0x07, 0x80, 0x7C, 0x0F, 0x03,
  0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xE0,
  0x03, 0xC3, 0xC0, 0x0F, 0x87, 0x80, 0x1E, 0x0F, 0x80, 0x3C, 0x0F, 0x00,
  0x78, 0x1E, 0x00, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0x80, 0x78, 0x0F,
  0x00, 0xF0, 0x1E, 0x01, 0xF0, 0x3C, 0x03, 0xE0, 0xF8, 0x07, 0xC1, 0xE0,
  0x07, 0x83, 0xC0, 0x0F, 0x87, 0x80, 0x1F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xF8, 0x1C, 0x03,
  0xF0, 0x04, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x80, 0x07, 0xC0, 0x60, 0x0F, 0xC0, 0x7E,
  0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x01,
  0x00, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x00,
  0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F,
  0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01,
  0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x03, 0xC0,
  0xF0, 0x00, 0xF0, 0x7C, 0x00, 0x7C, 0x1E, 0x00, 0x1E, 0x07, 0x80, 0x07,
  0x81, 0xE0, 0x01, 0xE0, 0x78, 0x00, 0x78, 0x3E, 0x00, 0x3E, 0x0F, 0x00,
  0x0F, 0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x00, 0xF0, 0x7C, 0x00, 0x3C, 0x1F,
  0x00, 0x1F, 0x07, 0x80, 0x07, 0x81, 0xE0, 0x01, 0xE0, 0x78, 0x00, 0x78,
  0x3E, 0x00, 0x3E, 0x0F, 0x00, 0x0F, 0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x00,
  0xF0, 0x3C, 0x00, 0x3C, 0x1F, 0x00, 0x1F, 0x07, 0x80, 0x07, 0x81, 0xE0,
  0x01, 0xE0, 0x78, 0x00, 0x78, 0x1E, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x03,
  0xE0, 0x03, 0xC0, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x78, 0x07, 0x80, 0x3E,
  0x01, 0xF0, 0x1F, 0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xFF, 0xE0, 0x01, 0xFF,
  0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x3E,
  0xF0, 0x00, 0x79, 0xE0, 0x01, 0xF3, 0xC0, 0x03, 0xC7, 0x80, 0x0F, 0x8F,
  0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0xF8, 0x78, 0x01, 0xE0, 0xF0,
  0x07, 0xC1, 0xE0, 0x0F, 0x03, 0xC0, 0x3E, 0x07, 0x80, 0x78, 0x0F, 0x01,
  0xF0, 0x1E, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x1E, 0x00, 0xF0, 0x3C,
  0x01, 0xE0, 0xF8, 0x03, 0xC1, 0xE0, 0x07, 0x87, 0xC0, 0x0F, 0x0F, 0x00,
  0x1E, 0x1E, 0x00, 0x3C, 0x78, 0x00, 0x78, 0xF0, 0x00, 0xF3, 0xC0, 0x01,
  0xE7, 0x80, 0x01, 0xDE, 0x00, 0x03, 0xBC, 0x00, 0x07, 0x78, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xFF, 0x00, 0x1F,
  0x00, 0x3E, 0xF0, 0x03, 0xF0, 0x03, 0xCF, 0x00, 0x3F, 0x00, 0x3C, 0xF0,
  0x03, 0xF0, 0x07, 0xCF, 0x00, 0x7F, 0x00, 0x78, 0xF0, 0x07, 0xF0, 0x0F,
  0x8F, 0x00, 0xFF, 0x00, 0xF0, 0xF0, 0x0F, 0xF0, 0x0F, 0x0F, 0x00, 0xEF,
  0x01, 0xE0, 0xF0, 0x1E, 0xF0, 0x1E, 0x0F, 0x01, 0xCF, 0x03, 0xE0, 0xF0,
  0x3C, 0xF0, 0x3C, 0x0F, 0x03, 0xCF, 0x03, 0xC0, 0xF0, 0x78, 0xF0, 0x78,
  0x0F, 0x07, 0x8E, 0x07, 0x80, 0xF0, 0x70, 0xE0, 0xF8, 0x0F, 0x0F, 0x0E,
  0x0F, 0x00, 0xF0, 0xF0, 0xE0, 0xF0, 0x0F, 0x1E, 0x0E, 0x1E, 0x00, 0xF1,
  0xE0, 0xE1, 0xE0, 0x0F, 0x1C, 0x0E, 0x3E, 0x00, 0xF3, 0xC0, 0xE3, 0xC0,
  0x0F, 0x38, 0x0E, 0x3C, 0x00, 0xF7, 0x80, 0xE7, 0x80, 0x0F, 0x78, 0x0E,
  0x78, 0x00, 0xE7, 0x00, 0xEF, 0x00, 0x0E, 0xF0, 0x0E, 0xF0, 0x00, 0xEE,
  0x00, 0xEF, 0x00, 0x0E, 0xE0, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x0F,
  0xC0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x00, 0x00,
  0x78, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0x78, 0x03, 0xC0, 0x07, 0xC0,
  0x7C, 0x00, 0x3C, 0x07, 0x80, 0x03, 0xC0, 0xF0, 0x00, 0x3C, 0x1F, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x3E, 0x3E, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x1E,
  0x78, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x0F, 0x3C, 0x00, 0x01,
  0xF3, 0xE0, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x7C, 0x1E,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x0F, 0x01, 0xF0, 0x01,
  0xE0, 0x0F, 0x00, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x00,
  0xF8, 0x0F, 0x80, 0x0F, 0x80, 0xF8, 0x00, 0xFB, 0xC0, 0x0F, 0x9E, 0x00,
  0x78, 0xF0, 0x07, 0xC7, 0x80, 0x3C, 0x3E, 0x03, 0xE1, 0xF0, 0x1E, 0x07,
  0x81, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0xF0, 0x0F, 0x0F, 0x80, 0x78, 0x78,
  0x03, 0xC7, 0xC0, 0x0F, 0x3C, 0x00, 0x7B, 0xC0, 0x03, 0xDE, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xF8, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0xF0, 0x78, 0x1C, 0x0E,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x0E, 0x07, 0x03, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x07, 0x03, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x07, 0x03, 0x81, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x03, 0x81, 0xE0,
  0xF0, 0x78, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xF8,
  0x00, 0x00, 0x1C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0x9E, 0x00, 0x3C, 0xF0, 0x03, 0xC7,
  0x80, 0x1E, 0x1E, 0x01, 0xE0, 0xF0, 0x0F, 0x03, 0x80, 0xF0, 0x1E, 0x07,
  0x00, 0xF0, 0x78, 0x03, 0x83, 0x80, 0x1E, 0x3C, 0x00, 0xF3, 0xC0, 0x03,
  0x9E, 0x00, 0x1F, 0xE0, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0xF8, 0x7C, 0x7C, 0x3C, 0x1E, 0x1E, 0x0E, 0x07, 0x00,
  0x78, 0x00, 0x0F, 0xF1, 0xC0, 0xFF, 0xDE, 0x0F, 0xFE, 0xF0, 0xFC, 0x3F,
  0x8F, 0x80, 0xF8, 0x7C, 0x07, 0xC7, 0xC0, 0x3E, 0x3C, 0x01, 0xF1, 0xE0,
  0x0F, 0x9F, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x7C, 0x00, 0xF3,
  0xC0, 0x0F, 0x9E, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x01,
  0xF1, 0xE0, 0x0F, 0x0F, 0x00, 0xF8, 0x78, 0x07, 0xC3, 0xC0, 0x7E, 0x1F,
  0x07, 0xF0, 0xF8, 0x77, 0x03, 0xFF, 0x38, 0x1F, 0xF3, 0xC0, 0x7F, 0x1E,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0,
  0xF0, 0x03, 0xCF, 0xF0, 0x0F, 0x7F, 0xE0, 0x3F, 0xFF, 0x81, 0xFE, 0x1F,
  0x07, 0xE0, 0x3C, 0x1F, 0x80, 0xF0, 0x7C, 0x03, 0xC1, 0xE0, 0x0F, 0x0F,
  0x80, 0x3C, 0x3E, 0x00, 0xF0, 0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x1F, 0x00,
  0x7C, 0x78, 0x01, 0xF1, 0xE0, 0x07, 0x87, 0x80, 0x1E, 0x1E, 0x00, 0xF8,
  0xF8, 0x03, 0xC3, 0xE0, 0x0F, 0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xE0, 0xF8,
  0x0F, 0x87, 0xE0, 0x7C, 0x1F, 0xC3, 0xE0, 0x7B, 0xFF, 0x81, 0xCF, 0xFC,
  0x0F, 0x1F, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x3E, 0x00, 0xFF, 0xC0, 0xFF,
  0xE0, 0xFF, 0xF0, 0xF8, 0x10, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C,
  0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x10, 0xFC, 0x18, 0x3F,
  0xFC, 0x0F, 0xFE, 0x03, 0xFE, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x78, 0x78, 0x01, 0xFE, 0x78, 0x03,
  0xFF, 0x78, 0x07, 0xFF, 0x78, 0x0F, 0x83, 0xF8, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x3E, 0x01, 0xF0, 0x3C, 0x01, 0xF0, 0x3C, 0x01, 0xF0, 0x7C,
  0x01, 0xE0, 0x78, 0x01, 0xE0, 0x78, 0x01, 0xE0, 0xF8, 0x01, 0xE0, 0xF0,
  0x03, 0xC0, 0xF0, 0x03, 0xC0, 0xF0, 0x03, 0xC0, 0xF0, 0x07, 0xC0, 0xF0,
  0x07, 0xC0, 0xF0, 0x07, 0x80, 0xF0, 0x0F, 0x80, 0xF0, 0x0F, 0x80, 0xF0,
  0x1F, 0x80, 0xF0, 0x3F, 0x80, 0xF8, 0x77, 0x00, 0x7F, 0xEF, 0x00, 0x7F,
  0xCF, 0x00, 0x3F, 0x8F, 0x00, 0x04, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x7F,
  0xC0, 0x3F, 0xF8, 0x1F, 0xFF, 0x0F, 0x83, 0xC7, 0xC0, 0xF1, 0xE0, 0x3C,
  0xF8, 0x0F, 0x3C, 0x03, 0xDF, 0x01, 0xF7, 0x80, 0xF9, 0xE0, 0x7C, 0xFB,
  0xFE, 0x3F, 0xFF, 0x0F, 0xFF, 0x03, 0xFE, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xE0, 0x08, 0x7C, 0x0C, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xE0, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0xE0, 0x01, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x01, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0x1C,
  0x03, 0xFF, 0x78, 0x0F, 0xFE, 0xF0, 0x3E, 0x0F, 0xE0, 0xF8, 0x0F, 0x81,
  0xF0, 0x1F, 0x07, 0xC0, 0x3E, 0x0F, 0x00, 0x7C, 0x1E, 0x00, 0xF8, 0x7C,
  0x01, 0xE0, 0xF0, 0x03, 0xC1, 0xE0, 0x07, 0x87, 0xC0, 0x0F, 0x0F, 0x00,
  0x3E, 0x1E, 0x00, 0x78, 0x3C, 0x00, 0xF0, 0x78, 0x03, 0xE0, 0xF0, 0x07,
  0xC1, 0xE0, 0x0F, 0x03, 0xC0, 0x3E, 0x07, 0x80, 0xFC, 0x0F, 0x01, 0xF8,
  0x1E, 0x07, 0xF0, 0x3E, 0x1F, 0xC0, 0x3F, 0xF7, 0x80, 0x7F, 0xCF, 0x00,
  0x7F, 0x1E, 0x00, 0x10, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x04, 0x01,
  0xF0, 0x0F, 0x1F, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0xF0, 0x03, 0xCF,
  0xF0, 0x0F, 0x7F, 0xE0, 0x3F, 0xFF, 0x81, 0xFC, 0x1F, 0x07, 0xE0, 0x7C,
  0x1F, 0x01, 0xF0, 0x7C, 0x07, 0xC1, 0xE0, 0x1E, 0x0F, 0x80, 0x78, 0x3C,
  0x01, 0xE0, 0xF0, 0x07, 0x83, 0xC0, 0x3E, 0x1F, 0x00, 0xF0, 0x78, 0x03,
  0xC1, 0xE0, 0x0F, 0x07, 0x80, 0x3C, 0x1E, 0x01, 0xF0, 0xF8, 0x07, 0x83,
  0xC0, 0x1E, 0x0F, 0x00, 0x78, 0x3C, 0x01, 0xE0, 0xF0, 0x0F, 0x87, 0x80,
  0x3C, 0x1E, 0x00, 0xF0, 0x78, 0x03, 0xC1, 0xE0, 0x0F, 0x0F, 0x80, 0x78,
  0x00, 0x00, 0x20, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xF0, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0xC0,
  0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x01,
  0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x23,
  0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x7C, 0x0F, 0x03, 0xE0,
  0x3C, 0x0F, 0x01, 0xF0, 0x78, 0x07, 0x83, 0xE0, 0x1E, 0x1F, 0x00, 0x78,
  0xF8, 0x01, 0xE7, 0xC0, 0x0F, 0x1E, 0x00, 0x3C, 0xF0, 0x00, 0xF7, 0xC0,
  0x03, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFB, 0xC0, 0x07,
  0xCF, 0x00, 0x1E, 0x3E, 0x00, 0xF8, 0x78, 0x03, 0xC1, 0xE0, 0x0F, 0x07,
  0x80, 0x3C, 0x1F, 0x00, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xE0,
  0x78, 0x0F, 0x81, 0xE0, 0x1E, 0x0F, 0x80, 0x78, 0x00, 0x00, 0x78, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0,
  0x00, 0x00, 0x43, 0xC0, 0x3C, 0x01, 0xC7, 0xF8, 0x7F, 0x80, 0xE7, 0xFC,
  0x7F, 0xE0, 0x77, 0xFF, 0x7F, 0xF0, 0x7F, 0x0F, 0xF0, 0x78, 0x3F, 0x03,
  0xF0, 0x3C, 0x1F, 0x01, 0xF0, 0x1E, 0x0F, 0x80, 0xF8, 0x0F, 0x07, 0x80,
  0x78, 0x07, 0x87, 0xC0, 0x3C, 0x03, 0xC3, 0xC0, 0x3E, 0x01, 0xE1, 0xE0,
  0x1E, 0x01, 0xF0, 0xF0, 0x0F, 0x00, 0xF0, 0xF8, 0x07, 0x80, 0x78, 0x78,
  0x03, 0xC0, 0x3C, 0x3C, 0x03, 0xE0, 0x1E, 0x1E, 0x01, 0xE0, 0x1F, 0x0F,
  0x00, 0xF0, 0x0F, 0x0F, 0x80, 0x78, 0x07, 0x87, 0x80, 0x3C, 0x03, 0xC3,
  0xC0, 0x3C, 0x01, 0xE1, 0xE0, 0x1E, 0x01, 0xE0, 0xF0, 0x0F, 0x00, 0xF0,
  0xF8, 0x07, 0x80, 0x78, 0x78, 0x03, 0xC0, 0x3C, 0x3C, 0x03, 0xC0, 0x3E,
  0x1E, 0x01, 0xE0, 0x1E, 0x1F, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x43, 0xE0,
  0x0E, 0x3F, 0xC0, 0x39, 0xFF, 0x80, 0xEF, 0xFE, 0x07, 0xF8, 0x7C, 0x1F,
  0x81, 0xF0, 0x7E, 0x07, 0xC1, 0xF0, 0x1F, 0x0F, 0x80, 0x78, 0x3E, 0x01,
  0xE0, 0xF8, 0x07, 0x83, 0xC0, 0x1E, 0x0F, 0x00, 0xF8, 0x7C, 0x03, 0xC1,
  0xE0, 0x0F, 0x07, 0x80, 0x3C, 0x1E, 0x00, 0xF0, 0x78, 0x07, 0xC3, 0xE0,
  0x1E, 0x0F, 0x00, 0x78, 0x3C, 0x01, 0xE0, 0xF0, 0x07, 0x87, 0xC0, 0x3E,
  0x1F, 0x00, 0xF0, 0x78, 0x03, 0xC1, 0xE0, 0x0F, 0x07, 0x80, 0x7C, 0x3E,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x80, 0x7F, 0xFC,
  0x0F, 0x83, 0xE1, 0xF0, 0x1E, 0x1E, 0x01, 0xE3, 0xE0, 0x1E, 0x3C, 0x01,
  0xE7, 0xC0, 0x1F, 0x78, 0x01, 0xE7, 0x80, 0x1E, 0x78, 0x01, 0xEF, 0x80,
  0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x03, 0xEF, 0x00, 0x3C, 0xF0,
  0x03, 0xCF, 0x00, 0x7C, 0xF0, 0x07, 0x8F, 0x00, 0xF8, 0xF0, 0x0F, 0x0F,
  0x81, 0xF0, 0x7C, 0x7E, 0x07, 0xFF, 0xC0, 0x3F, 0xF8, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0xF3, 0xFC, 0x00, 0xE7, 0xFE, 0x00, 0xEF, 0xFE,
  0x01, 0xEE, 0x1F, 0x01, 0xF8, 0x0F, 0x01, 0xF8, 0x0F, 0x01, 0xF0, 0x0F,
  0x01, 0xF0, 0x0F, 0x03, 0xE0, 0x0F, 0x03, 0xE0, 0x0F, 0x03, 0xC0, 0x0F,
  0x03, 0xC0, 0x0F, 0x03, 0xC0, 0x0F, 0x07, 0x80, 0x1F, 0x07, 0x80, 0x1E,
  0x07, 0x80, 0x1E, 0x07, 0x80, 0x1E, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3C,
  0x0F, 0x80, 0x7C, 0x0F, 0x80, 0x78, 0x0F, 0x80, 0xF8, 0x1F, 0x81, 0xF0,
  0x1F, 0xC3, 0xF0, 0x1E, 0xFF, 0xE0, 0x1E, 0xFF, 0xC0, 0x1E, 0x7F, 0x00,
  0x3C, 0x08, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x0F, 0xF1, 0xC0, 0xFF, 0xDE, 0x0F, 0xFE, 0xF0, 0xF8,
  0x3F, 0x8F, 0x80, 0xF8, 0x7C, 0x07, 0xC7, 0xC0, 0x3E, 0x3C, 0x01, 0xF1,
  0xE0, 0x0F, 0x9F, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x7C, 0x00,
  0xF3, 0xC0, 0x0F, 0x9E, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x3E, 0x3C,
  0x01, 0xF1, 0xE0, 0x0F, 0x0F, 0x00, 0xF8, 0x78, 0x07, 0xC3, 0xC0, 0x7E,
  0x1E, 0x07, 0xF0, 0xF8, 0x7F, 0x03, 0xFF, 0x78, 0x1F, 0xF3, 0xC0, 0x7F,
  0x1E, 0x00, 0x41, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0xE3, 0xF0, 0x39, 0xFC, 0x0E, 0xFE, 0x07, 0xB8, 0x81, 0xFC, 0x00, 0x7E,
  0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xFE, 0x0F, 0x81, 0x87,
  0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE2, 0x00, 0xF0, 0xE0, 0xFC, 0x3F, 0xFE, 0x0F, 0xFF,
  0x03, 0xFF, 0x80, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x78, 0x03, 0xC0, 0x3C, 0x07, 0xFF, 0x7F, 0xFB, 0xFF, 0xC7, 0xC0,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC2, 0x1F, 0xE0, 0xFF, 0x03,
  0xF8, 0x02, 0x00, 0x0F, 0x00, 0x78, 0x78, 0x03, 0xC7, 0xC0, 0x3C, 0x3C,
  0x01, 0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0x78, 0x78, 0x07, 0xC7, 0xC0, 0x3C,
  0x3C, 0x01, 0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0x78, 0x78, 0x07, 0xC7, 0x80,
  0x3C, 0x3C, 0x01, 0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0xF8, 0xF8, 0x07, 0x87,
  0x80, 0x3C, 0x3C, 0x03, 0xE1, 0xE0, 0x1F, 0x0F, 0x01, 0xF8, 0x78, 0x0F,
  0x83, 0xC0, 0xFC, 0x1F, 0x1F, 0xE0, 0xFF, 0xEF, 0x03, 0xFE, 0x78, 0x0F,
  0xE3, 0x80, 0x18, 0x00, 0x00, 0xF0, 0x03, 0xFE, 0x00, 0x7B, 0xC0, 0x1E,
  0x78, 0x03, 0xCF, 0x00, 0xF1, 0xE0, 0x1E, 0x3C, 0x07, 0x87, 0x80, 0xF0,
  0xF0, 0x3E, 0x1E, 0x07, 0x83, 0xC1, 0xF0, 0x78, 0x3C, 0x0F, 0x07, 0x81,
  0xE1, 0xE0, 0x1C, 0x3C, 0x03, 0x8F, 0x00, 0x71, 0xE0, 0x0E, 0x78, 0x01,
  0xCF, 0x00, 0x3B, 0xC0, 0x07, 0x78, 0x00, 0xEE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x0F,
  0x80, 0x7F, 0xC0, 0x3E, 0x01, 0xEF, 0x01, 0xF8, 0x0F, 0xBC, 0x07, 0xE0,
  0x3C, 0xF0, 0x1F, 0x80, 0xF3, 0xC0, 0xEE, 0x07, 0x8F, 0x03, 0xB8, 0x1E,
  0x3C, 0x1E, 0xE0, 0xF0, 0xF0, 0x73, 0x83, 0xC3, 0xC3, 0xCE, 0x0F, 0x0F,
  0x0F, 0x38, 0x78, 0x3C, 0x38, 0xE1, 0xE0, 0xF1, 0xE3, 0x8F, 0x03, 0xC7,
  0x0E, 0x3C, 0x0F, 0x3C, 0x38, 0xF0, 0x3C, 0xF0, 0xE7, 0x80, 0xF3, 0x83,
  0x9E, 0x03, 0xDE, 0x0E, 0xF0, 0x0F, 0x70, 0x3B, 0xC0, 0x3F, 0xC0, 0xEE,
  0x00, 0xFE, 0x07, 0xF8, 0x03, 0xF8, 0x1F, 0xE0, 0x0F, 0xE0, 0x7F, 0x00,
  0x3F, 0x01, 0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x03, 0xE0, 0x1F, 0x80, 0x0F,
  0x80, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x3E, 0x07, 0xC0, 0x78, 0x07, 0x81,
  0xE0, 0x0F, 0x07, 0xC0, 0x1E, 0x0F, 0x00, 0x3E, 0x3C, 0x00, 0x3C, 0xF8,
  0x00, 0x79, 0xE0, 0x00, 0xF7, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xBC, 0x00, 0x0F, 0x3C, 0x00, 0x3C,
  0x78, 0x00, 0xF8, 0xF0, 0x01, 0xE1, 0xF0, 0x07, 0x81, 0xE0, 0x1F, 0x03,
  0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x0F, 0x83, 0xE0, 0x0F, 0x00, 0x00, 0xF0,
  0x03, 0xE0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xC0,
  0x0F, 0x00, 0xF8, 0x01, 0xE0, 0x1E, 0x00, 0x3C, 0x07, 0xC0, 0x03, 0x80,
  0xF0, 0x00, 0x70, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xE0, 0xF0, 0x00,
  0x3C, 0x3C, 0x00, 0x07, 0x87, 0x80, 0x00, 0xF1, 0xE0, 0x00, 0x1E, 0x3C,
  0x00, 0x03, 0xCF, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x0F, 0x38, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x27, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00,
  0x01, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xFC,
  0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x03, 0xF8,
  0x01, 0xFE, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01,
  0xF0, 0x00, 0x3C, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x80, 0x0B, 0xFF, 0x80, 0xFF, 0xFF, 0x9F, 0xE3, 0xFF,
  0xFC, 0x03, 0xFF, 0x40, 0x07, 0xF0,
};

const GFXglyph NotoSans_Condensed_Italic51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 12, 37, 12, 1, -36 },
  { 57, 15, 13, 18, 5, -36 },
  { 82, 26, 36, 25, 0, -36 },
  { 199, 22, 42, 22, 1, -39 },
  { 315, 29, 38, 34, 3, -37 },
  { 453, 25, 38, 26, 0, -37 },
  { 572, 7, 13, 10, 5, -36 },
  { 584, 16, 45, 14, 1, -37 },
  { 674, 16, 45, 14, -4, -37 },
  { 764, 18, 19, 21, 5, -39 },
  { 807, 21, 24, 24, 2, -30 },
  { 870, 9, 13, 11, -2, -6 },
  { 885, 12, 4, 14, 1, -16 },
  { 891, 5, 7, 11, 1, -6 },
  { 896, 23, 37, 17, -2, -37 },
  { 1003, 20, 38, 22, 2, -37 },
  { 1098, 13, 36, 22, 6, -36 },
  { 1157, 23, 37, 22, -1, -37 },
  { 1264, 22, 38, 22, 0, -37 },
  { 1369, 23, 37, 22, -1, -37 },
  { 1476, 22, 37, 22, 0, -36 },
  { 1578, 21, 38, 22, 2, -37 },
  { 1678, 22, 36, 22, 2, -36 },
  { 1777, 23, 38, 22, 0, -37 },
  { 1887, 21, 38, 22, 1, -37 },
  { 1987, 11, 29, 11, 0, -28 },
  { 2027, 14, 35, 11, -3, -28 },
  { 2089, 21, 24, 24, 2, -30 },
  { 2152, 20, 14, 24, 3, -25 },
  { 2187, 21, 24, 24, 2, -30 },
  { 2250, 17, 38, 17, 2, -37 },
  { 2331, 31, 41, 34, 2, -37 },
  { 2490, 23, 37, 23, -3, -37 },
  { 2597, 24, 36, 25, 1, -36 },
  { 2705, 24, 38, 23, 2, -37 },
  { 2819, 25, 36, 27, 1, -36 },
  { 2932, 22, 36, 21, 1, -36 },
  { 3031, 22, 36, 20, 1, -36 },
  { 3130, 27, 38, 28, 2, -37 },
  { 3259, 28, 36, 28, 1, -36 },
  { 3385, 20, 36, 14, -2, -36 },
  { 3475, 21, 46, 11, -8, -36 },
  { 3596, 26, 36, 23, 1, -36 },
  { 3713, 15, 36, 19, 1, -36 },
  { 3781, 36, 36, 36, 1, -36 },
  { 3943, 29, 36, 29, 1, -36 },
  { 4074, 26, 38, 29, 2, -37 },
  { 4198, 23, 36, 23, 1, -36 },
  { 4302, 26, 46, 29, 2, -37 },
  { 4452, 23, 36, 24, 1, -36 },
  { 4556, 24, 38, 21, -1, -37 },
  { 4670, 20, 36, 20, 4, -36 },
  { 4760, 26, 37, 27, 2, -36 },
  { 4881, 23, 36, 23, 4, -36 },
  { 4985, 36, 36, 36, 5, -36 },
  { 5147, 28, 36, 21, -3, -36 },
  { 5273, 21, 36, 21, 4, -36 },
  { 5368, 25, 36, 20, -2, -36 },
  { 5481, 19, 45, 14, -1, -37 },
  { 5588, 9, 37, 18, 5, -37 },
  { 5630, 19, 45, 14, -3, -37 },
  { 5737, 21, 20, 23, 1, -36 },
  { 5790, 17, 4, 17, -4, 4 },
  { 5799, 8, 8, 13, 7, -39 },
  { 5807, 21, 29, 24, 2, -28 },
  { 5884, 22, 40, 24, 0, -39 },
  { 5994, 17, 29, 18, 2, -28 },
  { 6056, 24, 40, 24, 2, -39 },
  { 6176, 18, 29, 21, 2, -28 },
  { 6242, 25, 51, 13, -6, -39 },
  { 6402, 23, 40, 24, 0, -28 },
  { 6517, 22, 39, 24, 0, -39 },
  { 6625, 12, 38, 11, 0, -38 },
  { 6682, 19, 50, 11, -7, -38 },
  { 6801, 22, 39, 20, 0, -39 },
  { 6909, 13, 39, 11, 0, -39 },
  { 6973, 33, 28, 35, 0, -28 },
  { 7089, 22, 28, 24, 0, -28 },
  { 7166, 20, 28, 23, 2, -28 },
  { 7236, 24, 40, 24, -2, -28 },
  { 7356, 21, 40, 24, 2, -28 },
  { 7461, 18, 28, 16, 0, -28 },
  { 7524, 18, 29, 18, 0, -28 },
  { 7590, 13, 35, 14, 2, -34 },
  { 7647, 21, 28, 24, 2, -27 },
  { 7721, 19, 27, 19, 3, -27 },
  { 7786, 30, 27, 30, 3, -27 },
  { 7888, 23, 27, 20, -2, -27 },
  { 7966, 27, 39, 19, -5, -27 },
  { 8098, 20, 27, 17, -2, -27 },
  { 8166, 19, 44, 17, 1, -36 },
  { 8271, 4, 51, 21, 9, -39 },
  { 8297, 19, 44, 17, -3, -36 },
  { 8402, 21, 6, 24, 2, -21 },
};

const GFXfont NotoSans_Condensed_Italic51pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Italic51pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Italic51pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _NOTOSANS_CONDENSED_ITALIC51PT7B_H_
