#ifndef _NOTOSANS_CONDENSED_ITALIC50PT7B_H_
#define _NOTOSANS_CONDENSED_ITALIC50PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Italic.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Italic50pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x01,
  0xC0, 0x1C, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0x40, 0x00, 0x3E, 0x3C, 0xF0,
  0xF3, 0xC3, 0xCF, 0x1F, 0x78, 0x79, 0xE1, 0xE7, 0x87, 0x9E, 0x1C, 0x70,
  0x71, 0xC1, 0xCF, 0x0F, 0x38, 0x38, 0xE0, 0xE0, 0x00, 0x0F, 0x07, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x78, 0x38, 0x00, 0x1C, 0x0E,
  0x00, 0x07, 0x07, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x38,
  0x3C, 0x00, 0x0E, 0x0E, 0x00, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x0E, 0x07, 0x00, 0x03, 0x83, 0x80,
  0x00, 0xE0, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x1C, 0x1E, 0x00, 0x07, 0x07,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0xE0, 0xF0, 0x07, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x21, 0xC1, 0xC0, 0x00, 0xF0, 0x70, 0x00,
  0x38, 0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x83, 0x80, 0x01, 0xC0, 0xE0,
  0x00, 0x70, 0x78, 0x00, 0x1C, 0x1C, 0x00, 0x0F, 0x07, 0x00, 0x03, 0x83,
  0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0xC0, 0x7F, 0xFE, 0x03, 0xE6, 0x18, 0x1E, 0x18, 0x00, 0x78, 0xE0, 0x01,
  0xE3, 0x80, 0x07, 0x0C, 0x00, 0x1C, 0x30, 0x00, 0x78, 0xC0, 0x01, 0xE7,
  0x00, 0x07, 0xDC, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0x7C, 0x00, 0x0C, 0xF0, 0x00,
  0x73, 0xE0, 0x01, 0xC7, 0x80, 0x06, 0x1E, 0x00, 0x18, 0x78, 0x00, 0x61,
  0xC0, 0x03, 0x8F, 0x04, 0x0E, 0x3C, 0x1C, 0x33, 0xE0, 0x7F, 0xFF, 0x03,
  0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x03, 0xE0,
  0x01, 0xC0, 0x7F, 0x00, 0x3C, 0x0F, 0xF8, 0x03, 0x81, 0xE7, 0x80, 0x70,
  0x3C, 0x38, 0x0F, 0x03, 0x83, 0x80, 0xE0, 0x38, 0x38, 0x1E, 0x07, 0x83,
  0x81, 0xC0, 0x70, 0x38, 0x38, 0x07, 0x03, 0x87, 0x80, 0x70, 0x78, 0x70,
  0x0F, 0x07, 0x8F, 0x00, 0xE0, 0x70, 0xE0, 0x0E, 0x07, 0x1E, 0x00, 0xE0,
  0xF1, 0xC3, 0xCE, 0x0E, 0x38, 0xFE, 0xE0, 0xE7, 0x9F, 0xFE, 0x1E, 0x73,
  0xCF, 0xF3, 0xCF, 0x38, 0x7F, 0xF8, 0xE7, 0x87, 0x7F, 0x1C, 0x70, 0x73,
  0xE3, 0xC7, 0x07, 0x00, 0x38, 0xF0, 0x70, 0x07, 0x8E, 0x07, 0x00, 0x70,
  0xE0, 0x70, 0x0F, 0x0E, 0x0F, 0x01, 0xE1, 0xE0, 0xF0, 0x1C, 0x1E, 0x0E,
  0x03, 0xC1, 0xC0, 0xE0, 0x38, 0x1C, 0x1E, 0x07, 0x81, 0xC1, 0xC0, 0x70,
  0x1C, 0x3C, 0x0E, 0x01, 0xE3, 0x81, 0xE0, 0x0F, 0xF8, 0x1C, 0x00, 0xFF,
  0x03, 0xC0, 0x07, 0xE0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0xF8, 0xF0, 0x00, 0xF0, 0xF8, 0x01,
  0xE0, 0x78, 0x01, 0xE0, 0x78, 0x01, 0xE0, 0x70, 0x01, 0xE0, 0xF0, 0x01,
  0xE0, 0xF0, 0x01, 0xE1, 0xE0, 0x01, 0xE1, 0xE0, 0x01, 0xE3, 0xC0, 0x01,
  0xE7, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xBC, 0x0F, 0x0F, 0x3E, 0x0F, 0x1E,
  0x1E, 0x1E, 0x3C, 0x1F, 0x1E, 0x7C, 0x0F, 0x3C, 0x78, 0x0F, 0x3C, 0x78,
  0x07, 0xF8, 0xF8, 0x07, 0xF8, 0xF0, 0x07, 0xF0, 0xF0, 0x03, 0xF0, 0xF0,
  0x03, 0xE0, 0xF8, 0x07, 0xE0, 0xF8, 0x0F, 0xF0, 0x7C, 0x3F, 0xF0, 0x7F,
  0xFE, 0xF8, 0x3F, 0xF8, 0x78, 0x1F, 0xF0, 0x7C, 0x01, 0x00, 0x00, 0x3E,
  0x78, 0xF1, 0xE3, 0xCF, 0x1E, 0x3C, 0x70, 0xE1, 0xC7, 0x8E, 0x00, 0x00,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x01,
  0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F,
  0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1C, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1C, 0x04, 0x0E, 0x03, 0x87, 0x03, 0xF3, 0x01, 0xFF, 0xBF,
  0x1F, 0xFF, 0x81, 0xFF, 0xC1, 0xF8, 0x01, 0xFC, 0x01, 0xE7, 0x01, 0xF3,
  0x81, 0xF1, 0xE0, 0x70, 0x70, 0x10, 0x3C, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x0F, 0x87,
  0xC3, 0xC3, 0xE1, 0xE0, 0xF0, 0xF0, 0x78, 0x78, 0x3C, 0x1C, 0x1E, 0x0E,
  0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xE0, 0x37, 0xFF, 0xFF, 0xF9, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xF8,
  0x01, 0xFF, 0xC0, 0x3F, 0x7E, 0x07, 0xC1, 0xE0, 0x78, 0x1E, 0x0F, 0x81,
  0xF0, 0xF0, 0x0F, 0x1F, 0x00, 0xF1, 0xE0, 0x0F, 0x1E, 0x00, 0xF3, 0xC0,
  0x0F, 0x3C, 0x01, 0xE3, 0xC0, 0x1E, 0x7C, 0x01, 0xE7, 0x80, 0x1E, 0x78,
  0x01, 0xE7, 0x80, 0x1E, 0xF8, 0x01, 0xEF, 0x00, 0x3C, 0xF0, 0x03, 0xCF,
  0x00, 0x3C, 0xF0, 0x03, 0xCF, 0x00, 0x7C, 0xF0, 0x07, 0x8F, 0x00, 0x78,
  0xF0, 0x0F, 0x8F, 0x00, 0xF0, 0xF0, 0x1F, 0x0F, 0x01, 0xE0, 0xF0, 0x3E,
  0x0F, 0x07, 0xC0, 0xFC, 0xF8, 0x07, 0xFF, 0x00, 0x3F, 0xE0, 0x01, 0xFC,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x78, 0x07, 0xC0, 0x7E, 0x0F, 0xE0, 0xFF,
  0x0F, 0xF8, 0xFB, 0xDF, 0xBE, 0xF9, 0xE3, 0x0F, 0x10, 0x78, 0x03, 0xC0,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xE0,
  0x0F, 0xEF, 0xE0, 0x1E, 0x07, 0xC0, 0x10, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7F,
  0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0xFC, 0xFE, 0x01, 0x80,
  0xF8, 0x04, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x01, 0xFF, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x8F, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78,
  0x20, 0x07, 0xE0, 0xF0, 0x3F, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F,
  0xFC, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0xEE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0x78, 0x00, 0x1C, 0xF0, 0x00, 0x79,
  0xE0, 0x01, 0xE7, 0x80, 0x03, 0x8F, 0x00, 0x0F, 0x1E, 0x00, 0x3C, 0x3C,
  0x00, 0x70, 0x78, 0x01, 0xC1, 0xE0, 0x07, 0x83, 0xC0, 0x1E, 0x07, 0x80,
  0x38, 0x0F, 0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x07, 0x00, 0xF0, 0x1E,
  0x01, 0xE0, 0x78, 0x03, 0xC4, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xC0, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFE,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x80,
  0x3F, 0xFF, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x78, 0x20, 0x07, 0xE0, 0xF0, 0x3F, 0x03, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0x1F, 0xFC, 0x00, 0x02, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0xFF,
  0x80, 0x1F, 0xFC, 0x01, 0xFC, 0x60, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x08, 0x00, 0xF3, 0xF8, 0x0F, 0x3F,
  0xE0, 0x7B, 0xFF, 0x83, 0xF8, 0x7C, 0x1F, 0x81, 0xF1, 0xF8, 0x07, 0x8F,
  0x80, 0x3C, 0x7C, 0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x03,
  0xC7, 0x80, 0x3E, 0x3C, 0x01, 0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0x78, 0x78,
  0x07, 0x83, 0xC0, 0x3C, 0x1F, 0x03, 0xC0, 0x7C, 0x7E, 0x03, 0xFF, 0xE0,
  0x0F, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x10, 0x00, 0x00, 0x0F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x7E, 0x3F, 0x03,
  0xE0, 0x7C, 0x0F, 0x00, 0xF0, 0x3C, 0x03, 0xC1, 0xF0, 0x0F, 0x07, 0x80,
  0x3C, 0x1E, 0x00, 0xF0, 0x7C, 0x03, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0xF8,
  0x0F, 0x87, 0xC0, 0x1F, 0x3E, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x00, 0x03,
  0xF8, 0x00, 0x3F, 0xF0, 0x01, 0xFB, 0xE0, 0x0F, 0x87, 0x80, 0x7C, 0x1F,
  0x03, 0xE0, 0x3C, 0x0F, 0x00, 0x78, 0x78, 0x01, 0xE1, 0xE0, 0x07, 0x87,
  0x80, 0x1E, 0x3E, 0x00, 0x78, 0xF8, 0x01, 0xE3, 0xE0, 0x07, 0x87, 0x80,
  0x3C, 0x1F, 0x01, 0xF0, 0x7E, 0x0F, 0x80, 0xFF, 0xFC, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0x00, 0x00, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xFC, 0x01,
  0xFF, 0xE0, 0x3F, 0x7E, 0x07, 0xC1, 0xF0, 0xF8, 0x0F, 0x0F, 0x00, 0xF0,
  0xF0, 0x0F, 0x1E, 0x00, 0xF1, 0xE0, 0x0F, 0x1E, 0x00, 0xF3, 0xE0, 0x0F,
  0x3C, 0x00, 0xF3, 0xC0, 0x0F, 0x3C, 0x00, 0xF3, 0xC0, 0x1F, 0x3E, 0x03,
  0xF1, 0xE0, 0x3F, 0x1F, 0x0F, 0xE1, 0xFF, 0xFE, 0x0F, 0xFD, 0xE0, 0x7F,
  0x9E, 0x03, 0xC3, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x81, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xF8, 0x00,
  0x18, 0x00, 0x00, 0x03, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x07, 0xC1, 0xF0, 0xFC, 0x3F, 0x07,
  0x80, 0x80, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x01,
  0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x10, 0x00, 0x07, 0x00, 0x01, 0xF0, 0x00, 0x7F,
  0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x10,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x3F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x01,
  0xFC, 0x00, 0x0F, 0x80, 0x00, 0x70, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x1F, 0xFE, 0x3F, 0xFE, 0x1F, 0x7F, 0x18, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x40,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x01, 0xE0,
  0x1E, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x1C, 0x3C,
  0x00, 0x00, 0x70, 0xE0, 0x1F, 0xC1, 0xC7, 0x81, 0xFF, 0x87, 0x1C, 0x0F,
  0xFE, 0x1C, 0xF0, 0x78, 0x70, 0x73, 0x81, 0xC1, 0xC1, 0xCE, 0x0E, 0x07,
  0x07, 0x70, 0x78, 0x3C, 0x1D, 0xC1, 0xC0, 0xE0, 0x77, 0x07, 0x03, 0x81,
  0xFC, 0x3C, 0x0E, 0x0F, 0xE0, 0xE0, 0x78, 0x3B, 0x83, 0x81, 0xC0, 0xEE,
  0x0E, 0x07, 0x03, 0xB8, 0x78, 0x3C, 0x1C, 0xE1, 0xE0, 0xF0, 0x73, 0x87,
  0x87, 0xC3, 0x8E, 0x0E, 0x1F, 0x1E, 0x38, 0x3D, 0xDE, 0xF0, 0xE0, 0xFF,
  0x3F, 0x83, 0x81, 0xF8, 0xFC, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x60, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x77,
  0x00, 0x01, 0xEE, 0x00, 0x03, 0xDC, 0x00, 0x0F, 0x38, 0x00, 0x1E, 0x78,
  0x00, 0x78, 0xF0, 0x00, 0xF1, 0xE0, 0x01, 0xC3, 0xC0, 0x07, 0x87, 0x80,
  0x0F, 0x0F, 0x00, 0x3C, 0x1E, 0x00, 0x78, 0x3C, 0x01, 0xE0, 0x78, 0x03,
  0xC0, 0xF0, 0x0F, 0x81, 0xE0, 0x1E, 0x03, 0xC0, 0x7F, 0xFF, 0x80, 0xFF,
  0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0x00, 0x78, 0x3E, 0x00,
  0xF0, 0x78, 0x01, 0xE1, 0xF0, 0x03, 0xC3, 0xC0, 0x07, 0x8F, 0x80, 0x0F,
  0x1E, 0x00, 0x1E, 0x7C, 0x00, 0x3C, 0xF8, 0x00, 0x79, 0xE0, 0x00, 0xF7,
  0xC0, 0x01, 0xF0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0xE0, 0x3C, 0x07, 0xE0, 0x78, 0x07, 0xC0, 0xF0, 0x07, 0x81,
  0xE0, 0x0F, 0x07, 0xC0, 0x1E, 0x0F, 0x00, 0x3C, 0x1E, 0x00, 0xF8, 0x3C,
  0x01, 0xF0, 0x78, 0x03, 0xC1, 0xF0, 0x0F, 0x83, 0xC0, 0x3E, 0x07, 0x83,
  0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0xF0, 0x3F,
  0x01, 0xE0, 0x1F, 0x03, 0xC0, 0x1E, 0x0F, 0x80, 0x3C, 0x1E, 0x00, 0x78,
  0x3C, 0x00, 0xF0, 0x78, 0x01, 0xE0, 0xF0, 0x03, 0xC3, 0xE0, 0x07, 0x87,
  0x80, 0x1F, 0x0F, 0x00, 0x3C, 0x1E, 0x00, 0xF8, 0x3C, 0x07, 0xE0, 0xFF,
  0xFF, 0x81, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01,
  0xF8, 0x04, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x80, 0x3F,
  0x87, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x40, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x03,
  0xFF, 0xFC, 0x03, 0xC0, 0xFE, 0x03, 0xC0, 0x3E, 0x03, 0xC0, 0x1E, 0x03,
  0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0x80, 0x0F, 0x07, 0x80, 0x0F, 0x07,
  0x80, 0x0F, 0x07, 0x80, 0x0F, 0x0F, 0x80, 0x0F, 0x0F, 0x00, 0x0F, 0x0F,
  0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x1F, 0x1E, 0x00, 0x1F, 0x1E,
  0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3C,
  0x00, 0x3C, 0x3C, 0x00, 0x7C, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0xF8, 0x7C,
  0x00, 0xF0, 0x78, 0x01, 0xF0, 0x78, 0x03, 0xE0, 0x78, 0x07, 0xC0, 0x78,
  0x1F, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0xFF,
  0xFE, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x0F, 0xFF,
  0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xF8, 0x03,
  0x80, 0xFC, 0x00, 0x20, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1E, 0x00, 0xFF, 0x87, 0x80, 0x3F, 0xE1, 0xE0, 0x0F,
  0xF8, 0x78, 0x07, 0xFE, 0x3E, 0x00, 0x0F, 0x0F, 0x80, 0x03, 0xC3, 0xE0,
  0x00, 0xF0, 0xF8, 0x00, 0x3C, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0x81,
  0xE0, 0x01, 0xE0, 0x78, 0x00, 0x78, 0x1F, 0x00, 0x1E, 0x07, 0xC0, 0x0F,
  0x80, 0xF8, 0x03, 0xC0, 0x3F, 0x83, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xE0, 0x01,
  0xE0, 0x3C, 0x00, 0x3C, 0x07, 0x80, 0x0F, 0x00, 0xF0, 0x01, 0xE0, 0x3C,
  0x00, 0x3C, 0x07, 0x80, 0x07, 0x80, 0xF0, 0x01, 0xF0, 0x1E, 0x00, 0x3C,
  0x07, 0xC0, 0x07, 0x80, 0xF0, 0x00, 0xF0, 0x1E, 0x00, 0x1E, 0x03, 0xC0,
  0x07, 0xC0, 0x78, 0x00, 0xF0, 0x1F, 0x00, 0x1E, 0x03, 0xC0, 0x03, 0xC0,
  0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF8, 0x0F, 0x00, 0x0F, 0x01, 0xE0, 0x03, 0xE0, 0x3C, 0x00, 0x78, 0x0F,
  0x80, 0x0F, 0x01, 0xE0, 0x01, 0xE0, 0x3C, 0x00, 0x3C, 0x07, 0x80, 0x0F,
  0x80, 0xF0, 0x01, 0xE0, 0x3E, 0x00, 0x3C, 0x07, 0x80, 0x07, 0x80, 0xF0,
  0x00, 0xF0, 0x1E, 0x00, 0x3E, 0x03, 0xC0, 0x07, 0x80, 0xF8, 0x00, 0xF0,
  0x1E, 0x00, 0x1E, 0x03, 0xC0, 0x03, 0xC0, 0x78, 0x00, 0xF0, 0x00, 0x01,
  0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0x0F, 0x00, 0x03, 0xE0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x0F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xF8,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F,
  0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x04, 0x3E, 0x00, 0x7F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x03, 0x00, 0x00, 0x01, 0xE0, 0x07, 0xC0,
  0x78, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x3E,
  0x00, 0xF0, 0x1F, 0x00, 0x3C, 0x0F, 0x80, 0x0F, 0x07, 0xC0, 0x07, 0xC1,
  0xE0, 0x01, 0xE0, 0xF8, 0x00, 0x78, 0x7C, 0x00, 0x1E, 0x3E, 0x00, 0x07,
  0x8F, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0xF3, 0xE0, 0x00, 0x3D, 0xF0, 0x00,
  0x0F, 0x78, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0x1F, 0xBC, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xE1, 0xE0, 0x00, 0xF0,
  0x78, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x07, 0xC0, 0x03, 0xC0, 0xF0, 0x01,
  0xF0, 0x3C, 0x00, 0x78, 0x0F, 0x80, 0x1E, 0x03, 0xE0, 0x07, 0x80, 0x78,
  0x01, 0xE0, 0x1E, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xF0, 0x0F, 0x00,
  0x3C, 0x03, 0xC0, 0x0F, 0x80, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1F,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xE0, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x01, 0xFC, 0x07, 0xE0,
  0x00, 0x3F, 0x81, 0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x01, 0xFC, 0x07,
  0xF0, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x0F, 0xF0, 0x1D, 0xC0, 0x03, 0xDE,
  0x07, 0xB8, 0x00, 0x7F, 0x80, 0xF7, 0x80, 0x1E, 0xF0, 0x1E, 0xF0, 0x03,
  0xDE, 0x03, 0xDE, 0x00, 0xF3, 0xC0, 0x7B, 0xC0, 0x1E, 0xF0, 0x1E, 0x78,
  0x07, 0x9E, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x79, 0xE0, 0x1C, 0x78, 0x0F,
  0x3C, 0x07, 0x8F, 0x01, 0xC7, 0x80, 0xE3, 0xC0, 0x78, 0xF0, 0x3C, 0x78,
  0x0F, 0x1E, 0x07, 0x0F, 0x01, 0xE1, 0xC1, 0xE1, 0xE0, 0x3C, 0x38, 0x38,
  0x7C, 0x0F, 0x07, 0x0F, 0x0F, 0x01, 0xE0, 0xE1, 0xE1, 0xE0, 0x3C, 0x1C,
  0x78, 0x3C, 0x07, 0x83, 0xCF, 0x07, 0x80, 0xF0, 0x7B, 0xC1, 0xF0, 0x3C,
  0x0F, 0x78, 0x3C, 0x07, 0x81, 0xFE, 0x07, 0x80, 0xF0, 0x3F, 0xC0, 0xF0,
  0x1E, 0x07, 0xF0, 0x1E, 0x03, 0x80, 0xFE, 0x07, 0xC0, 0xF0, 0x1F, 0x80,
  0xF0, 0x1E, 0x03, 0xF0, 0x1E, 0x03, 0xC0, 0x7C, 0x03, 0xC0, 0x78, 0x07,
  0x80, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0xF0, 0x1F, 0x00, 0x0F, 0x01, 0xF0,
  0x00, 0xF0, 0x3F, 0x80, 0x0F, 0x03, 0xF8, 0x00, 0xF0, 0x3F, 0x80, 0x1E,
  0x03, 0xF8, 0x01, 0xE0, 0x3B, 0xC0, 0x1E, 0x07, 0xBC, 0x01, 0xE0, 0x7B,
  0xC0, 0x3E, 0x07, 0xBC, 0x03, 0xC0, 0x79, 0xC0, 0x3C, 0x07, 0x1E, 0x03,
  0xC0, 0xF1, 0xE0, 0x3C, 0x0F, 0x1E, 0x07, 0x80, 0xF0, 0xE0, 0x78, 0x0F,
  0x0F, 0x07, 0x80, 0xE0, 0xF0, 0x78, 0x1E, 0x0F, 0x07, 0x81, 0xE0, 0xF0,
  0xF0, 0x1E, 0x07, 0x8F, 0x01, 0xE0, 0x78, 0xF0, 0x3C, 0x07, 0x8F, 0x03,
  0xC0, 0x78, 0xF0, 0x3C, 0x03, 0x9E, 0x03, 0xC0, 0x3D, 0xE0, 0x3C, 0x03,
  0xDE, 0x07, 0x80, 0x3D, 0xE0, 0x78, 0x03, 0xDC, 0x07, 0x80, 0x1F, 0xC0,
  0x78, 0x01, 0xFC, 0x07, 0x80, 0x1F, 0xC0, 0xF0, 0x01, 0xFC, 0x0F, 0x00,
  0x0F, 0x80, 0xF0, 0x00, 0xF8, 0x0F, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x1F, 0x01,
  0xF0, 0x1F, 0x00, 0x78, 0x1F, 0x00, 0x3E, 0x0F, 0x00, 0x1F, 0x0F, 0x80,
  0x07, 0x87, 0x80, 0x03, 0xC7, 0xC0, 0x01, 0xE3, 0xC0, 0x00, 0xF3, 0xE0,
  0x00, 0x79, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x1E, 0xF8, 0x00, 0x0F, 0x7C,
  0x00, 0x0F, 0xBC, 0x00, 0x07, 0xDE, 0x00, 0x03, 0xCF, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0xF7, 0xC0, 0x00, 0xFB, 0xE0, 0x00, 0x79, 0xF0, 0x00, 0x3C,
  0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x1E, 0x3E, 0x00, 0x1F, 0x1F, 0x00, 0x0F,
  0x87, 0x80, 0x0F, 0x83, 0xC0, 0x07, 0x81, 0xF0, 0x07, 0xC0, 0xFC, 0x07,
  0xC0, 0x3F, 0x0F, 0xC0, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x1F,
  0xFF, 0x00, 0xFF, 0xFE, 0x03, 0xC0, 0xF8, 0x0F, 0x01, 0xF0, 0x3C, 0x03,
  0xC0, 0xF0, 0x0F, 0x07, 0xC0, 0x3C, 0x1E, 0x00, 0xF0, 0x78, 0x03, 0xC1,
  0xE0, 0x0F, 0x07, 0x80, 0x3C, 0x3E, 0x01, 0xF0, 0xF0, 0x07, 0x83, 0xC0,
  0x3E, 0x0F, 0x01, 0xF0, 0x3C, 0x0F, 0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xF0,
  0x1F, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x1F, 0x01, 0xF0,
  0x1F, 0x00, 0x78, 0x1F, 0x00, 0x3E, 0x0F, 0x00, 0x1F, 0x0F, 0x80, 0x07,
  0x87, 0x80, 0x03, 0xC7, 0xC0, 0x01, 0xE3, 0xC0, 0x00, 0xF3, 0xE0, 0x00,
  0x79, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x1E, 0xF8, 0x00, 0x0F, 0x7C, 0x00,
  0x0F, 0xBC, 0x00, 0x07, 0xDE, 0x00, 0x03, 0xCF, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0xF7, 0xC0, 0x00, 0xFB, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x3C, 0xF8,
  0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x87,
  0x80, 0x0F, 0x83, 0xC0, 0x07, 0xC1, 0xF0, 0x07, 0xC0, 0xFC, 0x07, 0xC0,
  0x3F, 0x0F, 0xC0, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x1F,
  0xFF, 0x00, 0xFF, 0xFE, 0x03, 0xC0, 0xFC, 0x0F, 0x01, 0xF0, 0x3C, 0x03,
  0xC0, 0xF0, 0x0F, 0x07, 0xC0, 0x3C, 0x1E, 0x00, 0xF0, 0x78, 0x03, 0xC1,
  0xE0, 0x0F, 0x07, 0x80, 0x7C, 0x3E, 0x01, 0xF0, 0xF0, 0x07, 0x83, 0xC0,
  0x3E, 0x0F, 0x03, 0xF0, 0x3C, 0x7F, 0x81, 0xFF, 0xFC, 0x07, 0xFF, 0xE0,
  0x1F, 0xFE, 0x00, 0x78, 0x78, 0x03, 0xE1, 0xE0, 0x0F, 0x07, 0x80, 0x3C,
  0x1F, 0x00, 0xF0, 0x3C, 0x03, 0xC0, 0xF0, 0x1F, 0x03, 0xC0, 0x78, 0x0F,
  0x81, 0xE0, 0x1E, 0x07, 0x80, 0x78, 0x1E, 0x01, 0xE0, 0xF0, 0x07, 0xC3,
  0xC0, 0x1F, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0xFC, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0x00, 0xC0, 0x7C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xF0, 0x30, 0x07, 0xE0, 0x7C, 0x7F, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8,
  0x01, 0xFF, 0xC0, 0x00, 0x10, 0x00, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFE,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x78, 0x1E,
  0x00, 0x1E, 0x07, 0x80, 0x07, 0x81, 0xE0, 0x03, 0xE0, 0x78, 0x00, 0xF0,
  0x3C, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x01,
  0xF0, 0x7C, 0x00, 0x78, 0x1E, 0x00, 0x1E, 0x07, 0x80, 0x07, 0x81, 0xE0,
  0x01, 0xE0, 0x78, 0x00, 0xF8, 0x3E, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x03,
  0xC0, 0x03, 0xC0, 0xF0, 0x01, 0xF0, 0x3C, 0x00, 0x78, 0x1F, 0x00, 0x1E,
  0x07, 0x80, 0x07, 0x81, 0xE0, 0x01, 0xE0, 0x78, 0x00, 0xF8, 0x1E, 0x00,
  0x3C, 0x0F, 0x80, 0x0F, 0x03, 0xE0, 0x03, 0xC0, 0xF8, 0x01, 0xE0, 0x3E,
  0x00, 0x78, 0x07, 0x80, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0x7F, 0x1F, 0x80,
  0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7B, 0xE0, 0x01, 0xF3, 0xC0,
  0x03, 0xC7, 0x80, 0x0F, 0x8F, 0x00, 0x1E, 0x1E, 0x00, 0x7C, 0x3C, 0x00,
  0xF0, 0x78, 0x01, 0xE0, 0xF0, 0x07, 0x81, 0xE0, 0x0F, 0x03, 0xC0, 0x3E,
  0x07, 0x80, 0x78, 0x0F, 0x01, 0xF0, 0x1E, 0x03, 0xC0, 0x3C, 0x0F, 0x80,
  0x78, 0x1E, 0x00, 0xF0, 0x3C, 0x01, 0xE0, 0xF0, 0x03, 0xC1, 0xE0, 0x07,
  0x87, 0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x3E, 0x00, 0x3C, 0x78, 0x00, 0x79,
  0xF0, 0x00, 0xF3, 0xC0, 0x01, 0xE7, 0x80, 0x03, 0xDE, 0x00, 0x07, 0xBC,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xF7, 0x80, 0x0F, 0x00, 0x1E, 0x78, 0x01, 0xF0, 0x01, 0xE7,
  0x80, 0x1F, 0x00, 0x3C, 0x78, 0x03, 0xF0, 0x03, 0xC7, 0x80, 0x3F, 0x00,
  0x7C, 0x78, 0x03, 0xF0, 0x07, 0x87, 0x80, 0x7F, 0x00, 0x78, 0x78, 0x07,
  0x70, 0x0F, 0x07, 0x80, 0xF7, 0x00, 0xF0, 0x78, 0x0F, 0x70, 0x1F, 0x07,
  0x80, 0xE7, 0x01, 0xE0, 0x78, 0x1E, 0x70, 0x1E, 0x07, 0x81, 0xC7, 0x03,
  0xC0, 0x78, 0x3C, 0x70, 0x3C, 0x07, 0x83, 0xC7, 0x07, 0x80, 0x78, 0x38,
  0xF0, 0x78, 0x07, 0x87, 0x8F, 0x07, 0x80, 0x78, 0x70, 0xF0, 0xF0, 0x07,
  0x8F, 0x0F, 0x0F, 0x00, 0x70, 0xF0, 0xF1, 0xE0, 0x07, 0x1E, 0x0F, 0x1E,
  0x00, 0x71, 0xE0, 0xF1, 0xE0, 0x07, 0x1C, 0x0F, 0x3C, 0x00, 0x73, 0xC0,
  0xF3, 0xC0, 0x07, 0x38, 0x0F, 0x78, 0x00, 0x77, 0x80, 0xF7, 0x80, 0x07,
  0x78, 0x0F, 0x78, 0x00, 0x77, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x0F, 0xF0,
  0x00, 0x7E, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x0F,
  0x80, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00,
  0x78, 0x03, 0xC0, 0x07, 0x80, 0x7C, 0x00, 0x78, 0x07, 0x80, 0x03, 0xC0,
  0xF0, 0x00, 0x3C, 0x1F, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x3C, 0x3C, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x1E,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x7B, 0xC0,
  0x00, 0x0F, 0x3C, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x1E, 0x3C, 0x00, 0x03,
  0xC3, 0xE0, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x81, 0xE0, 0x00, 0xF8, 0x1E,
  0x00, 0x0F, 0x01, 0xE0, 0x01, 0xE0, 0x1F, 0x00, 0x3E, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x7C, 0x00, 0xF0, 0x0F, 0x80, 0x0F, 0x80, 0xF8, 0x00,
  0xFB, 0xC0, 0x0F, 0x9E, 0x00, 0x78, 0xF0, 0x07, 0xC7, 0x80, 0x3C, 0x3C,
  0x03, 0xE1, 0xE0, 0x1E, 0x0F, 0x81, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0xF0,
  0x0F, 0x0F, 0x80, 0x78, 0x78, 0x03, 0xC7, 0xC0, 0x1E, 0x3C, 0x00, 0x73,
  0xC0, 0x03, 0xDE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03,
  0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x10, 0x01,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x38, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x70, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0xF0,
  0x78, 0x3C, 0x0E, 0x07, 0x03, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x07,
  0x03, 0x81, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x07, 0x03, 0x81, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x03, 0x81, 0xC0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x03, 0x81, 0xC0, 0xF0, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x0F, 0xFC, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x00, 0x1C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x80, 0x03,
  0xBC, 0x00, 0x3C, 0xE0, 0x01, 0xC7, 0x80, 0x1E, 0x3C, 0x01, 0xE0, 0xE0,
  0x0F, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x80, 0xE0, 0x78, 0x07, 0x83, 0x80,
  0x3C, 0x3C, 0x00, 0xE1, 0xC0, 0x07, 0x9E, 0x00, 0x1D, 0xE0, 0x00, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x78, 0x7C, 0x3C, 0x1C,
  0x1E, 0x0E, 0x07, 0x00, 0xFC, 0x38, 0x1F, 0xF3, 0xC1, 0xFF, 0xDE, 0x1F,
  0x8E, 0xE0, 0xF8, 0x3F, 0x0F, 0x80, 0xF8, 0x78, 0x07, 0xC7, 0x80, 0x3C,
  0x3C, 0x01, 0xE3, 0xE0, 0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x03, 0xCF, 0x80,
  0x3C, 0x78, 0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x07, 0xC7,
  0x80, 0x3C, 0x3C, 0x01, 0xE1, 0xE0, 0x1F, 0x0F, 0x00, 0xF8, 0x78, 0x0F,
  0x83, 0xC0, 0xFC, 0x1F, 0x0F, 0xE0, 0x7F, 0xEF, 0x03, 0xFE, 0x78, 0x0F,
  0xE3, 0x80, 0x08, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF1, 0xF8, 0x03, 0xDF, 0xF0, 0x0F, 0xFF, 0xE0, 0x7B, 0x8F, 0x81, 0xFC,
  0x1E, 0x07, 0xE0, 0x7C, 0x1F, 0x00, 0xF0, 0x78, 0x03, 0xC3, 0xE0, 0x0F,
  0x0F, 0x80, 0x3C, 0x3C, 0x01, 0xF0, 0xF0, 0x07, 0xC7, 0xC0, 0x1E, 0x1E,
  0x00, 0x78, 0x78, 0x01, 0xE1, 0xE0, 0x07, 0x87, 0x80, 0x3C, 0x3E, 0x00,
  0xF0, 0xF0, 0x07, 0xC3, 0xC0, 0x1E, 0x0F, 0x00, 0x78, 0x3E, 0x03, 0xC1,
  0xF8, 0x1F, 0x07, 0xF0, 0xF8, 0x1F, 0xFF, 0xC0, 0x73, 0xFE, 0x03, 0xC7,
  0xF0, 0x00, 0x02, 0x00, 0x00, 0x00, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xC1,
  0xF8, 0x60, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x70, 0x7F, 0xF8, 0x1F, 0xFC,
  0x07, 0xFC, 0x00, 0x60, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x07, 0xE3, 0xC0, 0x3F, 0xE7, 0x80, 0xFF, 0xEE, 0x03, 0xF1, 0xFC,
  0x07, 0xC1, 0xF8, 0x1F, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0xF0, 0x07, 0x81,
  0xE0, 0x0F, 0x07, 0xC0, 0x1E, 0x0F, 0x00, 0x3C, 0x1E, 0x00, 0x78, 0x7C,
  0x01, 0xE0, 0xF0, 0x03, 0xC1, 0xE0, 0x07, 0x83, 0xC0, 0x0F, 0x07, 0x80,
  0x3C, 0x0F, 0x00, 0x78, 0x1E, 0x01, 0xF0, 0x3C, 0x03, 0xE0, 0x78, 0x0F,
  0xC0, 0xF0, 0x1F, 0x01, 0xE0, 0x7E, 0x03, 0xE1, 0xFC, 0x03, 0xFF, 0x78,
  0x07, 0xFC, 0xF0, 0x07, 0xF1, 0xC0, 0x01, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0x1F, 0x0F, 0x03, 0xC7, 0x80, 0xF3,
  0xE0, 0x3C, 0xF0, 0x0F, 0x7C, 0x07, 0x9E, 0x03, 0xE7, 0x81, 0xF3, 0xE1,
  0xF8, 0xFF, 0xFC, 0x3F, 0xFE, 0x0F, 0xFC, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x80, 0x43, 0xF0, 0x30, 0x7F, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0x80, 0x04,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x3E, 0x20, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x0E, 0x01, 0xFF, 0x3C, 0x07, 0xFF, 0x70, 0x1F,
  0x8E, 0xE0, 0x3E, 0x0F, 0xC0, 0xF8, 0x0F, 0x81, 0xE0, 0x1F, 0x07, 0x80,
  0x3C, 0x0F, 0x00, 0x78, 0x3E, 0x00, 0xF0, 0x78, 0x01, 0xE0, 0xF0, 0x07,
  0xC3, 0xE0, 0x0F, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0x3C, 0x1E, 0x00, 0x78,
  0x3C, 0x01, 0xF0, 0x78, 0x03, 0xC0, 0xF0, 0x0F, 0x81, 0xE0, 0x1F, 0x03,
  0xC0, 0x7E, 0x07, 0x80, 0xF8, 0x0F, 0x03, 0xF0, 0x1F, 0x0F, 0xE0, 0x3F,
  0xFB, 0xC0, 0x3F, 0xE7, 0x80, 0x3F, 0x9E, 0x00, 0x08, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3C, 0x02, 0x00, 0xF8, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x80,
  0x1F, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x8F, 0xC0, 0x3D, 0xFF, 0x01, 0xDF, 0xFC, 0x1E, 0xE3, 0xE0, 0xFC,
  0x0F, 0x07, 0xC0, 0x78, 0x3E, 0x03, 0xC1, 0xE0, 0x1E, 0x1F, 0x00, 0xF0,
  0xF0, 0x07, 0x87, 0x80, 0x7C, 0x3C, 0x03, 0xC3, 0xE0, 0x1E, 0x1E, 0x00,
  0xF0, 0xF0, 0x07, 0x87, 0x80, 0x78, 0x3C, 0x03, 0xC3, 0xC0, 0x1E, 0x1E,
  0x00, 0xF0, 0xF0, 0x07, 0x87, 0x80, 0x78, 0x3C, 0x03, 0xC3, 0xC0, 0x1E,
  0x1E, 0x00, 0xF0, 0xF0, 0x0F, 0x87, 0x80, 0x78, 0x7C, 0x03, 0xC0, 0x00,
  0x60, 0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x07,
  0x80, 0x78, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x78,
  0x07, 0x80, 0x78, 0x07, 0x80, 0xF8, 0x00, 0x00, 0x01, 0x80, 0x00, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x1F, 0x03, 0xC0, 0xF8, 0x0F, 0x03,
  0xC0, 0x78, 0x1E, 0x01, 0xE0, 0xF8, 0x07, 0x87, 0xC0, 0x1E, 0x3E, 0x00,
  0x78, 0xF0, 0x03, 0xC7, 0x80, 0x0F, 0x3C, 0x00, 0x3D, 0xF0, 0x00, 0xFF,
  0x80, 0x07, 0xBE, 0x00, 0x1F, 0xFC, 0x00, 0x7E, 0xF0, 0x01, 0xF3, 0xC0,
  0x07, 0x8F, 0x00, 0x3C, 0x3E, 0x00, 0xF0, 0x78, 0x03, 0xC1, 0xE0, 0x0F,
  0x07, 0x80, 0x3C, 0x1F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x83, 0xE0, 0x1E, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x00, 0x03, 0x87, 0xE0,
  0xFE, 0x01, 0xCF, 0xF8, 0xFF, 0x80, 0xEF, 0xFC, 0xFF, 0xC0, 0xFF, 0x3F,
  0xF3, 0xF0, 0x7E, 0x0F, 0xE0, 0xF8, 0x3E, 0x03, 0xE0, 0x3C, 0x1F, 0x01,
  0xF0, 0x1E, 0x0F, 0x00, 0xF0, 0x0F, 0x0F, 0x80, 0xF8, 0x0F, 0x07, 0x80,
  0x78, 0x07, 0x83, 0xC0, 0x3C, 0x03, 0xC1, 0xE0, 0x1E, 0x01, 0xE1, 0xF0,
  0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x00, 0xF0, 0x78, 0x07, 0x80, 0x78, 0x3C,
  0x03, 0xC0, 0x3C, 0x1E, 0x01, 0xE0, 0x1E, 0x1E, 0x00, 0xF0, 0x1F, 0x0F,
  0x00, 0xF0, 0x0F, 0x07, 0x80, 0x78, 0x07, 0x83, 0xC0, 0x3C, 0x03, 0xC1,
  0xE0, 0x1E, 0x01, 0xE1, 0xE0, 0x1F, 0x01, 0xE0, 0xF0, 0x0F, 0x00, 0xF0,
  0x78, 0x07, 0x80, 0x78, 0x3C, 0x03, 0xC0, 0x3C, 0x3E, 0x01, 0xE0, 0x3E,
  0x00, 0x03, 0x87, 0xE0, 0x1C, 0xFF, 0x80, 0xEF, 0xFE, 0x0F, 0xF9, 0xF0,
  0x7F, 0x07, 0x83, 0xF0, 0x3C, 0x1F, 0x01, 0xE1, 0xF0, 0x0F, 0x0F, 0x80,
  0x78, 0x78, 0x03, 0xC3, 0xC0, 0x3E, 0x1E, 0x01, 0xE1, 0xF0, 0x0F, 0x0F,
  0x00, 0x78, 0x78, 0x03, 0xC3, 0xC0, 0x3C, 0x1E, 0x01, 0xE1, 0xE0, 0x0F,
  0x0F, 0x00, 0x78, 0x78, 0x07, 0xC3, 0xC0, 0x3C, 0x3E, 0x01, 0xE1, 0xE0,
  0x0F, 0x0F, 0x00, 0x78, 0x78, 0x07, 0xC3, 0xC0, 0x3C, 0x3E, 0x01, 0xE0,
  0x00, 0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xFE, 0x07, 0xE3, 0xE0, 0xF0, 0x3C,
  0x3C, 0x03, 0xCF, 0x80, 0x79, 0xE0, 0x0F, 0x3C, 0x01, 0xEF, 0x00, 0x3D,
  0xE0, 0x07, 0xBC, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x00, 0xF7,
  0x80, 0x1E, 0xF0, 0x03, 0xDE, 0x00, 0xFB, 0xC0, 0x1E, 0x78, 0x03, 0xCF,
  0x00, 0xF9, 0xE0, 0x3E, 0x3E, 0x07, 0x87, 0xE3, 0xF0, 0x7F, 0xFC, 0x07,
  0xFF, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xE1, 0xF8, 0x00, 0xE3, 0xFC, 0x00,
  0xE7, 0xFE, 0x01, 0xEE, 0x3E, 0x01, 0xFC, 0x1E, 0x01, 0xF8, 0x1F, 0x01,
  0xF0, 0x0F, 0x01, 0xF0, 0x0F, 0x03, 0xE0, 0x0F, 0x03, 0xE0, 0x0F, 0x03,
  0xC0, 0x0F, 0x03, 0xC0, 0x1F, 0x07, 0xC0, 0x1E, 0x07, 0x80, 0x1E, 0x07,
  0x80, 0x1E, 0x07, 0x80, 0x1E, 0x07, 0x80, 0x3C, 0x0F, 0x80, 0x3C, 0x0F,
  0x00, 0x3C, 0x0F, 0x00, 0x78, 0x0F, 0x00, 0x78, 0x0F, 0x80, 0xF0, 0x1F,
  0x81, 0xF0, 0x1F, 0xC3, 0xE0, 0x1E, 0xFF, 0xC0, 0x1E, 0xFF, 0x80, 0x1E,
  0x7F, 0x00, 0x3C, 0x08, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x38, 0x1F, 0xF3, 0xC1, 0xFF, 0xDC, 0x1F, 0x8E,
  0xE0, 0xF8, 0x3F, 0x0F, 0x80, 0xF8, 0x78, 0x07, 0xC7, 0x80, 0x3C, 0x3C,
  0x01, 0xE3, 0xE0, 0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x03, 0xCF, 0x80, 0x3C,
  0x78, 0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x07, 0xC7, 0x80,
  0x3C, 0x3C, 0x03, 0xE1, 0xE0, 0x1F, 0x0F, 0x01, 0xF8, 0x78, 0x0F, 0x83,
  0xC0, 0xFC, 0x1F, 0x0F, 0xE0, 0xFF, 0xEF, 0x03, 0xFE, 0x78, 0x0F, 0xE7,
  0x80, 0x08, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x8F, 0xC0,
  0xE7, 0xE0, 0x3B, 0xF8, 0x1E, 0xFE, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7C,
  0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xFF,
  0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x3E, 0x0E, 0x1F, 0x01, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x08,
  0x07, 0xC3, 0x83, 0xF0, 0xFF, 0xF8, 0x3F, 0xFC, 0x0F, 0xFE, 0x00, 0x10,
  0x00, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x7F,
  0xEF, 0xFF, 0x7F, 0xF7, 0xFF, 0x87, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x43, 0xFC, 0x1F, 0xE0, 0x7F, 0x00, 0x40, 0x00, 0x0F, 0x00, 0xF8,
  0x78, 0x07, 0x87, 0xC0, 0x3C, 0x3C, 0x01, 0xE1, 0xE0, 0x0F, 0x0F, 0x00,
  0xF0, 0x78, 0x07, 0x87, 0x80, 0x3C, 0x3C, 0x01, 0xE1, 0xE0, 0x0F, 0x0F,
  0x00, 0xF0, 0x78, 0x07, 0x87, 0x80, 0x3C, 0x3C, 0x01, 0xE1, 0xE0, 0x1F,
  0x0F, 0x00, 0xF0, 0xF8, 0x07, 0x87, 0x80, 0x3C, 0x3C, 0x03, 0xE1, 0xE0,
  0x1E, 0x0F, 0x01, 0xF0, 0x78, 0x0F, 0x83, 0xC0, 0xFC, 0x1F, 0x1F, 0xE0,
  0xFF, 0xEE, 0x03, 0xFE, 0x70, 0x0F, 0xC3, 0x80, 0x18, 0x00, 0x00, 0xF0,
  0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7B, 0xC0, 0x1E, 0xF0, 0x0F, 0x3C, 0x03,
  0xCF, 0x01, 0xE3, 0xC0, 0x78, 0xF0, 0x3C, 0x3C, 0x0F, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0xF8, 0x3C, 0x3C, 0x0F, 0x0F, 0x03, 0xC7, 0x80, 0x71,
  0xE0, 0x1C, 0xF0, 0x07, 0x3C, 0x01, 0xDE, 0x00, 0x77, 0x80, 0x1D, 0xC0,
  0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00,
  0xF0, 0x0F, 0x80, 0x7F, 0x80, 0x7C, 0x07, 0xFC, 0x07, 0xE0, 0x3D, 0xE0,
  0x3F, 0x01, 0xEF, 0x03, 0xF8, 0x1E, 0x78, 0x1D, 0xC0, 0xF3, 0xC0, 0xFE,
  0x0F, 0x1E, 0x0F, 0xF0, 0x78, 0xF0, 0x77, 0x83, 0xC7, 0x87, 0xBC, 0x3C,
  0x3C, 0x39, 0xE1, 0xE1, 0xE1, 0xCF, 0x1E, 0x0F, 0x1E, 0x78, 0xF0, 0x78,
  0xE3, 0xC7, 0x83, 0xCF, 0x1E, 0x78, 0x1E, 0x70, 0xF3, 0xC0, 0xF3, 0x87,
  0xBC, 0x07, 0xBC, 0x3D, 0xE0, 0x3D, 0xC1, 0xEE, 0x01, 0xFE, 0x0F, 0xF0,
  0x0F, 0xE0, 0x77, 0x80, 0x77, 0x03, 0xB8, 0x03, 0xF8, 0x1F, 0xC0, 0x1F,
  0x80, 0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x07, 0xC0, 0x3E, 0x00, 0x3E, 0x01,
  0xF0, 0x00, 0x03, 0xC0, 0x3E, 0x07, 0x80, 0x78, 0x0F, 0x81, 0xE0, 0x0F,
  0x07, 0xC0, 0x1E, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0xF8, 0x00, 0x79,
  0xE0, 0x00, 0xF7, 0x80, 0x01, 0xEF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00,
  0x01, 0xFE, 0x00, 0x07, 0xBC, 0x00, 0x0F, 0x78, 0x00, 0x3C, 0x78, 0x00,
  0xF8, 0xF0, 0x01, 0xE1, 0xE0, 0x07, 0x83, 0xC0, 0x1F, 0x03, 0xC0, 0x3C,
  0x07, 0x80, 0xF0, 0x0F, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0xF0, 0x03, 0xC0,
  0x3C, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F,
  0x00, 0x3C, 0x03, 0xC0, 0x0F, 0x01, 0xF0, 0x03, 0xC0, 0x78, 0x00, 0xF0,
  0x3E, 0x00, 0x1C, 0x0F, 0x00, 0x07, 0x03, 0xC0, 0x01, 0xC1, 0xE0, 0x00,
  0x70, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x07, 0x8F, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x79, 0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x07, 0xBC, 0x00, 0x01, 0xEE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F,
  0xFE, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xC0, 0x00, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x00, 0x00,
  0x01, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x3F, 0x00, 0x01, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x70, 0x00,
  0x0F, 0x80, 0x01, 0xF8, 0x00, 0x7F, 0x80, 0x01, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xFC, 0x00,
  0x0F, 0xC0, 0x01, 0xF0, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03,
  0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x7F, 0x80, 0x1F, 0xE0,
  0x03, 0xF8, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x09, 0xFF, 0x00, 0xDF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0x60, 0x0F, 0xF2, 0x00, 0x04,
  0x00,
};

const GFXglyph NotoSans_Condensed_Italic50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 12, 37, 12, 1, -36 },
  { 57, 14, 13, 18, 5, -36 },
  { 80, 26, 36, 25, 0, -36 },
  { 197, 22, 41, 22, 0, -38 },
  { 310, 28, 37, 33, 3, -36 },
  { 440, 24, 37, 25, 0, -36 },
  { 551, 7, 13, 10, 5, -36 },
  { 563, 16, 44, 13, 1, -36 },
  { 651, 16, 44, 13, -4, -36 },
  { 739, 17, 18, 21, 5, -38 },
  { 778, 20, 24, 24, 2, -30 },
  { 838, 9, 13, 11, -2, -6 },
  { 853, 12, 3, 14, 1, -15 },
  { 858, 5, 7, 11, 1, -6 },
  { 863, 23, 36, 17, -2, -36 },
  { 967, 20, 37, 22, 2, -36 },
  { 1060, 13, 36, 22, 6, -36 },
  { 1119, 23, 36, 22, -1, -36 },
  { 1223, 22, 37, 22, 0, -36 },
  { 1325, 23, 36, 22, -1, -36 },
  { 1429, 22, 37, 22, 0, -36 },
  { 1531, 21, 37, 22, 2, -36 },
  { 1629, 22, 36, 22, 2, -36 },
  { 1728, 22, 37, 22, 0, -36 },
  { 1830, 20, 37, 22, 1, -36 },
  { 1923, 10, 28, 11, 0, -27 },
  { 1958, 14, 34, 11, -3, -27 },
  { 2018, 20, 23, 24, 2, -29 },
  { 2076, 19, 14, 24, 3, -25 },
  { 2110, 21, 23, 24, 2, -29 },
  { 2171, 16, 37, 17, 2, -36 },
  { 2245, 30, 40, 33, 2, -36 },
  { 2395, 23, 36, 23, -3, -36 },
  { 2499, 23, 36, 24, 1, -36 },
  { 2603, 24, 37, 22, 2, -36 },
  { 2714, 24, 36, 26, 1, -36 },
  { 2822, 22, 36, 21, 1, -36 },
  { 2921, 22, 36, 19, 1, -36 },
  { 3020, 26, 37, 27, 2, -36 },
  { 3141, 27, 36, 27, 1, -36 },
  { 3263, 19, 36, 14, -2, -36 },
  { 3349, 20, 46, 11, -8, -36 },
  { 3464, 26, 36, 23, 1, -36 },
  { 3581, 15, 36, 19, 1, -36 },
  { 3649, 35, 36, 35, 1, -36 },
  { 3807, 28, 36, 29, 1, -36 },
  { 3933, 25, 37, 28, 2, -36 },
  { 4049, 22, 36, 23, 1, -36 },
  { 4148, 25, 45, 28, 2, -36 },
  { 4289, 22, 36, 23, 1, -36 },
  { 4388, 23, 37, 21, -1, -36 },
  { 4495, 20, 36, 20, 4, -36 },
  { 4585, 26, 37, 27, 2, -36 },
  { 4706, 23, 36, 22, 4, -36 },
  { 4810, 36, 36, 36, 4, -36 },
  { 4972, 28, 36, 21, -3, -36 },
  { 5098, 21, 36, 20, 4, -36 },
  { 5193, 25, 36, 20, -2, -36 },
  { 5306, 19, 44, 14, -1, -36 },
  { 5411, 9, 36, 17, 5, -36 },
  { 5452, 18, 44, 14, -3, -36 },
  { 5551, 21, 20, 23, 1, -36 },
  { 5604, 17, 3, 17, -4, 4 },
  { 5611, 8, 8, 13, 7, -38 },
  { 5619, 21, 28, 23, 2, -27 },
  { 5693, 22, 39, 23, 0, -38 },
  { 5801, 17, 28, 18, 2, -27 },
  { 5861, 23, 39, 23, 2, -38 },
  { 5974, 18, 28, 21, 2, -27 },
  { 6037, 25, 50, 13, -6, -38 },
  { 6194, 23, 39, 24, 0, -27 },
  { 6307, 21, 38, 23, 0, -38 },
  { 6407, 12, 37, 11, 0, -37 },
  { 6463, 18, 49, 11, -6, -37 },
  { 6574, 22, 38, 20, 0, -38 },
  { 6679, 13, 38, 11, 0, -38 },
  { 6741, 33, 27, 35, 0, -27 },
  { 6853, 21, 27, 23, 0, -27 },
  { 6924, 19, 27, 23, 2, -27 },
  { 6989, 24, 39, 23, -2, -27 },
  { 7106, 21, 39, 23, 2, -27 },
  { 7209, 18, 27, 16, 0, -27 },
  { 7270, 18, 28, 18, 0, -27 },
  { 7333, 13, 34, 13, 2, -33 },
  { 7389, 21, 28, 23, 2, -27 },
  { 7463, 18, 27, 19, 3, -27 },
  { 7524, 29, 27, 30, 3, -27 },
  { 7622, 23, 27, 19, -2, -27 },
  { 7700, 26, 39, 19, -5, -27 },
  { 7827, 20, 27, 17, -2, -27 },
  { 7895, 19, 44, 17, 1, -36 },
  { 8000, 4, 50, 21, 9, -38 },
  { 8025, 19, 44, 17, -3, -36 },
  { 8130, 21, 7, 24, 2, -21 },
};

const GFXfont NotoSans_Condensed_Italic50pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Italic50pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Italic50pt7bGlyphs,
  0x20, 0x7E, 68
};

#endif // _NOTOSANS_CONDENSED_ITALIC50PT7B_H_
