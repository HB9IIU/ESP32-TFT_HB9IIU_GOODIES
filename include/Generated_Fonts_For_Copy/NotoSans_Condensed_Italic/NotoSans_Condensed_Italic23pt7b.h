#ifndef _NOTOSANS_CONDENSED_ITALIC23PT7B_H_
#define _NOTOSANS_CONDENSED_ITALIC23PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Italic.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Italic23pt7bBitmaps[] PROGMEM = {
  0x00, 0x0C, 0x61, 0x86, 0x18, 0x43, 0x0C, 0x30, 0x82, 0x00, 0x01, 0x0E,
  0x38, 0x66, 0xC9, 0xB2, 0x6C, 0xD9, 0x00, 0x06, 0x60, 0x66, 0x04, 0x40,
  0x4C, 0x3F, 0xF3, 0xFF, 0x08, 0x81, 0x98, 0x11, 0x01, 0x10, 0xFF, 0xC3,
  0x20, 0x22, 0x06, 0x60, 0x66, 0x04, 0x40, 0x01, 0x00, 0xC1, 0xFC, 0x69,
  0x32, 0x0D, 0x83, 0x40, 0x70, 0x0E, 0x01, 0xC0, 0xB0, 0x26, 0x09, 0xA2,
  0xCF, 0xF1, 0xF0, 0x10, 0x04, 0x00, 0x18, 0x01, 0xE1, 0x89, 0x08, 0xC8,
  0xC4, 0x44, 0x22, 0x63, 0x36, 0x19, 0xA7, 0xCB, 0x6B, 0xD6, 0x49, 0xA2,
  0x19, 0x10, 0x88, 0x8C, 0xCC, 0x46, 0x46, 0x36, 0x60, 0xE0, 0x03, 0x01,
  0xF0, 0x22, 0x0C, 0x41, 0x98, 0x33, 0x06, 0xC0, 0x70, 0x1C, 0x06, 0xCD,
  0x99, 0xA3, 0x6C, 0x3D, 0x87, 0x30, 0xE7, 0x7C, 0x7C, 0xC0, 0x6D, 0xA5,
  0x80, 0x06, 0x18, 0x60, 0xC3, 0x04, 0x18, 0x30, 0xC1, 0x83, 0x06, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x83, 0x06, 0x04, 0x00, 0x04, 0x0C, 0x18, 0x30,
  0x60, 0x40, 0x81, 0x02, 0x0C, 0x18, 0x30, 0x61, 0x83, 0x04, 0x18, 0x20,
  0xC3, 0x0C, 0x00, 0x08, 0x0C, 0x88, 0xE8, 0x3F, 0x18, 0x3C, 0x64, 0x26,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC7, 0xFF, 0xFE, 0x18, 0x0C, 0x06, 0x03,
  0x00, 0x33, 0x66, 0x4C, 0x7F, 0xE0, 0x5F, 0x80, 0x00, 0xE0, 0x18, 0x06,
  0x00, 0x80, 0x30, 0x04, 0x01, 0x80, 0x20, 0x0C, 0x03, 0x00, 0x60, 0x18,
  0x03, 0x00, 0xC0, 0x18, 0x06, 0x00, 0x06, 0x0F, 0x8E, 0x66, 0x36, 0x1B,
  0x0D, 0x87, 0x83, 0xC1, 0xE0, 0xB0, 0xD8, 0x6C, 0x36, 0x33, 0x19, 0xF8,
  0x78, 0x00, 0x1C, 0xEF, 0xB6, 0x18, 0x63, 0x0C, 0x30, 0xC2, 0x18, 0x61,
  0x86, 0x30, 0x03, 0x81, 0xF8, 0x33, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x30,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x07, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0xFC,
  0xFF, 0x80, 0x07, 0x07, 0xE1, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x18, 0x0C,
  0x1C, 0x01, 0xC0, 0x30, 0x06, 0x01, 0x00, 0xC0, 0x33, 0x38, 0xFC, 0x00,
  0x00, 0xC0, 0x70, 0x1C, 0x0A, 0x07, 0x83, 0x60, 0x98, 0x66, 0x31, 0x08,
  0xC6, 0x33, 0x0D, 0xFF, 0x81, 0x80, 0x60, 0x18, 0x06, 0x00, 0x0F, 0xC6,
  0x01, 0x80, 0x60, 0x10, 0x0C, 0x03, 0xE0, 0xFC, 0x03, 0x80, 0x60, 0x18,
  0x06, 0x03, 0x00, 0xCC, 0xE3, 0xF0, 0x03, 0x87, 0xC7, 0x06, 0x03, 0x03,
  0x01, 0x80, 0xBC, 0xF3, 0x71, 0xB0, 0xD8, 0x6C, 0x36, 0x1B, 0x19, 0xDC,
  0x7C, 0x00, 0x7F, 0xC0, 0x60, 0x18, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x30,
  0x0C, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x06, 0x03, 0x00, 0x03, 0x03,
  0xF1, 0x8C, 0x43, 0x30, 0xC4, 0x31, 0x98, 0x7C, 0x0E, 0x0F, 0xC6, 0x31,
  0x86, 0xC1, 0xB0, 0x6C, 0x31, 0x9C, 0x3E, 0x00, 0x07, 0x03, 0xE1, 0x9C,
  0xC3, 0x30, 0xCC, 0x32, 0x0D, 0x87, 0x31, 0x8F, 0xE1, 0xD8, 0x06, 0x03,
  0x00, 0xC0, 0x62, 0x70, 0xF8, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x00, 0x02,
  0x39, 0x80, 0x1C, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC3, 0x18, 0x61,
  0x0C, 0x00, 0x00, 0x80, 0xC1, 0xE1, 0xC3, 0x87, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xC0, 0x20, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x80, 0x60,
  0x1C, 0x03, 0x80, 0x70, 0x0C, 0x0E, 0x1C, 0x38, 0x70, 0x20, 0x00, 0x1C,
  0xFD, 0x18, 0x10, 0x60, 0xC3, 0x0E, 0x18, 0x61, 0x83, 0x00, 0x00, 0x10,
  0x60, 0xC0, 0x00, 0x80, 0x1F, 0xC0, 0xC1, 0x86, 0x02, 0x30, 0x0C, 0x8F,
  0xB6, 0x64, 0xD1, 0x33, 0xCC, 0xCF, 0x23, 0x39, 0x88, 0xA6, 0x66, 0x99,
  0x92, 0x3B, 0xC8, 0x00, 0x30, 0x00, 0x40, 0x01, 0xC6, 0x01, 0xF0, 0x00,
  0x01, 0x80, 0xE0, 0x28, 0x1B, 0x06, 0xC3, 0x30, 0xCC, 0x63, 0x18, 0xC7,
  0xF3, 0xFC, 0xC3, 0x60, 0xD8, 0x3C, 0x0F, 0x03, 0x0F, 0xC3, 0x1C, 0x61,
  0x8C, 0x31, 0x86, 0x61, 0x8C, 0x71, 0xF8, 0x31, 0x86, 0x19, 0x83, 0x30,
  0x66, 0x1C, 0xC3, 0x1F, 0xC7, 0xF0, 0x03, 0x81, 0xFC, 0x71, 0x1C, 0x03,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x38, 0x03, 0xB0, 0x3E, 0x00, 0x0F, 0xC1, 0x8E, 0x18, 0x61, 0x87,
  0x18, 0x33, 0x03, 0x30, 0x33, 0x06, 0x30, 0x63, 0x06, 0x60, 0x66, 0x0C,
  0x61, 0xC6, 0x38, 0x7F, 0x0F, 0xC0, 0x0F, 0xC6, 0x01, 0x80, 0x60, 0x18,
  0x0C, 0x03, 0x08, 0xFC, 0x30, 0x0C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x07,
  0xE3, 0xF8, 0x0F, 0xC6, 0x01, 0x80, 0x60, 0x18, 0x0C, 0x03, 0x00, 0xFE,
  0x3F, 0x0C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x03, 0x00, 0x01, 0xC0,
  0xFF, 0x1C, 0x23, 0x80, 0x30, 0x06, 0x00, 0x60, 0x06, 0x00, 0xC3, 0xEC,
  0x3C, 0xC0, 0xCC, 0x0C, 0xC0, 0xCC, 0x0C, 0x61, 0x87, 0xB8, 0x3F, 0x80,
  0x0C, 0x18, 0xC0, 0x86, 0x0C, 0x30, 0x61, 0x83, 0x08, 0x18, 0xC1, 0x87,
  0xFC, 0x30, 0x61, 0x83, 0x18, 0x18, 0xC1, 0x86, 0x0C, 0x30, 0x61, 0x83,
  0x18, 0x30, 0x1F, 0x83, 0x01, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x01, 0x80, 0xC1, 0xF8, 0x01, 0x81, 0x80, 0xC0,
  0x60, 0x30, 0x10, 0x18, 0x0C, 0x06, 0x03, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x30, 0x18, 0x0C, 0x2C, 0x1E, 0x00, 0x0C, 0x71, 0x86, 0x18, 0xC1,
  0x98, 0x1B, 0x03, 0x30, 0x36, 0x03, 0xE0, 0x3E, 0x03, 0x60, 0x63, 0x06,
  0x30, 0x63, 0x06, 0x30, 0x61, 0x8C, 0x18, 0x0C, 0x30, 0x60, 0xC1, 0x86,
  0x0C, 0x18, 0x30, 0x61, 0x83, 0x06, 0x0C, 0x1F, 0xFF, 0x0C, 0x07, 0x8F,
  0x03, 0x87, 0x83, 0xC3, 0xC1, 0xE1, 0xE1, 0xB1, 0xB0, 0xF0, 0xD8, 0xD8,
  0x6C, 0x6C, 0x36, 0x66, 0x13, 0x33, 0x19, 0xB3, 0x0C, 0xD9, 0x86, 0x28,
  0xC3, 0x1C, 0x61, 0x0C, 0x21, 0x86, 0x30, 0x0C, 0x0C, 0x70, 0x61, 0xE1,
  0x87, 0x86, 0x16, 0x10, 0xC8, 0xC3, 0x33, 0x0C, 0xCC, 0x33, 0x30, 0x8C,
  0x86, 0x16, 0x18, 0x78, 0x61, 0xE1, 0x87, 0x84, 0x0C, 0x30, 0x30, 0x03,
  0x80, 0xFC, 0x1C, 0x63, 0x06, 0x30, 0x66, 0x03, 0x60, 0x66, 0x06, 0xC0,
  0x6C, 0x06, 0xC0, 0x6C, 0x0C, 0xC0, 0xCC, 0x1C, 0xE1, 0x87, 0xF0, 0x3E,
  0x00, 0x0F, 0xC3, 0x18, 0x61, 0x8C, 0x31, 0x86, 0x61, 0x8C, 0x31, 0x8C,
  0x3F, 0x07, 0x81, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x06, 0x00, 0x03,
  0x80, 0xFC, 0x1C, 0x63, 0x06, 0x30, 0x66, 0x03, 0x60, 0x66, 0x06, 0xC0,
  0x6C, 0x06, 0xC0, 0x6C, 0x0E, 0xC0, 0xCC, 0x1C, 0xE1, 0x87, 0xF0, 0x3E,
  0x00, 0x60, 0x06, 0x00, 0x70, 0x03, 0x00, 0x0F, 0xC3, 0x18, 0x61, 0x8C,
  0x31, 0x86, 0x61, 0x8C, 0x31, 0x9C, 0x3F, 0x06, 0xC1, 0x8C, 0x31, 0x86,
  0x30, 0xC6, 0x18, 0x66, 0x0C, 0x07, 0x07, 0xF1, 0x84, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0x60, 0x1C, 0x01, 0x80, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x33,
  0xF8, 0xFC, 0x00, 0xFF, 0x8C, 0x06, 0x03, 0x01, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x03, 0x01, 0x80, 0x38, 0x33, 0x06,
  0x30, 0x63, 0x06, 0x20, 0x66, 0x04, 0x60, 0xC6, 0x0C, 0x60, 0xC4, 0x0C,
  0xC0, 0x8C, 0x18, 0xC1, 0x8C, 0x30, 0x7F, 0x07, 0xE0, 0xC0, 0xF0, 0x6C,
  0x1B, 0x0C, 0xC3, 0x30, 0xCC, 0x63, 0x18, 0xCC, 0x33, 0x0D, 0x83, 0x60,
  0xD0, 0x1C, 0x06, 0x01, 0x80, 0xC1, 0x83, 0xC1, 0x82, 0xC3, 0x86, 0xC2,
  0x86, 0xC7, 0x8C, 0xC7, 0x8C, 0xCD, 0x88, 0xCD, 0x98, 0xC9, 0x98, 0xD9,
  0xB0, 0xD1, 0xB0, 0xF1, 0xA0, 0xF1, 0xE0, 0xE1, 0xE0, 0xE1, 0xC0, 0xC1,
  0xC0, 0x1C, 0x30, 0xC6, 0x0C, 0x40, 0xCC, 0x05, 0x80, 0x78, 0x07, 0x00,
  0x60, 0x0F, 0x00, 0xF0, 0x1B, 0x01, 0x30, 0x33, 0x06, 0x18, 0x61, 0x8C,
  0x18, 0xC1, 0xE1, 0xB0, 0xC8, 0xC6, 0x43, 0x61, 0xE0, 0xF0, 0x70, 0x18,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x01, 0x80, 0x0F, 0xE0, 0x0C, 0x03, 0x00,
  0xE0, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x0C, 0x01, 0x80, 0x60, 0x1C, 0x03,
  0x00, 0xC0, 0x1F, 0xC7, 0xF8, 0x07, 0x83, 0xC3, 0x01, 0x80, 0xC0, 0x40,
  0x20, 0x30, 0x18, 0x0C, 0x04, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x40, 0x60,
  0x30, 0x18, 0x0F, 0x0F, 0x80, 0xC4, 0x46, 0x66, 0x66, 0x22, 0x33, 0x33,
  0x33, 0x07, 0x87, 0xC0, 0x60, 0x20, 0x10, 0x18, 0x0C, 0x06, 0x02, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x20, 0x30, 0x18, 0x0C, 0x04, 0x02, 0x0F, 0x0F,
  0x80, 0x06, 0x01, 0x80, 0xF0, 0x6C, 0x19, 0x8C, 0x62, 0x09, 0x83, 0xC0,
  0xC0, 0xFF, 0xC6, 0x63, 0x0C, 0x47, 0xA3, 0x39, 0x86, 0x61, 0xB0, 0x6C,
  0x13, 0x0C, 0xC3, 0x30, 0xCC, 0x63, 0x28, 0x76, 0x00, 0x0C, 0x06, 0x01,
  0x80, 0x60, 0x19, 0x05, 0xE3, 0xCC, 0xE3, 0x30, 0xCC, 0x32, 0x0D, 0x83,
  0x61, 0x98, 0x66, 0x31, 0xDC, 0xDE, 0x00, 0x04, 0x1F, 0x31, 0x60, 0x60,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xEC, 0x7C, 0x00, 0x60, 0x18, 0x03,
  0x00, 0x60, 0xCC, 0x3D, 0x0C, 0xE3, 0x0C, 0x61, 0x98, 0x33, 0x0C, 0x61,
  0x8C, 0x31, 0x8E, 0x31, 0x86, 0x50, 0x76, 0x00, 0x04, 0x1F, 0x33, 0x63,
  0x43, 0xC6, 0xFC, 0xE0, 0xC0, 0xC0, 0xC0, 0xE4, 0x7C, 0x00, 0x70, 0x1E,
  0x01, 0x80, 0x10, 0x03, 0x00, 0x30, 0x0F, 0xC0, 0x20, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x03, 0x00, 0xF0, 0x04, 0x00, 0x06, 0x21, 0xE8,
  0x67, 0x18, 0x63, 0x0C, 0xC1, 0x98, 0x63, 0x0C, 0x61, 0x8C, 0x71, 0x8C,
  0x33, 0x83, 0xB0, 0x06, 0x00, 0xC0, 0x30, 0x8E, 0x1F, 0x80, 0x80, 0x00,
  0x0C, 0x06, 0x01, 0x80, 0x60, 0x19, 0x05, 0xE3, 0x8C, 0xE3, 0x30, 0xCC,
  0x22, 0x19, 0x86, 0x61, 0x98, 0x66, 0x31, 0x0C, 0xC3, 0x00, 0x08, 0x70,
  0x80, 0x00, 0x63, 0x0C, 0x30, 0xC2, 0x18, 0x61, 0x86, 0x10, 0xC0, 0x01,
  0x01, 0xC0, 0x40, 0x00, 0x00, 0x18, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x10, 0x18, 0x0C, 0x06, 0x02, 0x03, 0x07, 0x81,
  0x00, 0x0C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x04, 0x73, 0x18, 0xCC, 0x36,
  0x0F, 0x03, 0xC1, 0xD0, 0x66, 0x19, 0x86, 0x61, 0x08, 0xC3, 0x00, 0x0C,
  0x61, 0x86, 0x18, 0x43, 0x0C, 0x30, 0xC2, 0x18, 0x61, 0x86, 0x10, 0xC0,
  0x01, 0x08, 0x2F, 0x7C, 0xE7, 0x99, 0xC6, 0x33, 0x0C, 0x66, 0x30, 0xC8,
  0x61, 0x30, 0xC6, 0x61, 0x8C, 0xC2, 0x19, 0x8C, 0x32, 0x18, 0x4C, 0x31,
  0x80, 0x01, 0x05, 0xE3, 0xCC, 0xE3, 0x30, 0xCC, 0x22, 0x19, 0x86, 0x61,
  0x98, 0x66, 0x33, 0x0C, 0xC3, 0x00, 0x04, 0x0F, 0x8C, 0xCC, 0x36, 0x1E,
  0x0F, 0x07, 0x86, 0xC3, 0x61, 0xB1, 0x9D, 0xC7, 0x80, 0x00, 0x81, 0x78,
  0x79, 0x8E, 0x31, 0x86, 0x30, 0xC4, 0x19, 0x83, 0x30, 0xC6, 0x18, 0xC6,
  0x1D, 0xC6, 0xF0, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x00, 0x0C, 0x47,
  0xA3, 0x39, 0x86, 0x61, 0xB0, 0x6C, 0x33, 0x0C, 0xC3, 0x31, 0xCC, 0x63,
  0x38, 0x76, 0x01, 0x80, 0x60, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x01, 0x17,
  0x3C, 0x38, 0x30, 0x30, 0x20, 0x60, 0x60, 0x60, 0x60, 0x40, 0xC0, 0x0C,
  0x3F, 0x31, 0x60, 0x60, 0x30, 0x38, 0x0C, 0x0E, 0x06, 0x06, 0xDC, 0xF8,
  0x10, 0xC3, 0x3F, 0x61, 0x86, 0x18, 0x43, 0x0C, 0x30, 0xC3, 0x4F, 0x00,
  0x31, 0xB0, 0xD8, 0x6C, 0x36, 0x16, 0x1B, 0x0D, 0x86, 0xC6, 0x63, 0x37,
  0x9E, 0xC0, 0xC3, 0xE1, 0xB0, 0x98, 0xC4, 0x62, 0x61, 0x30, 0xB0, 0x58,
  0x38, 0x1C, 0x0C, 0x00, 0xC3, 0x0F, 0x1C, 0x6C, 0x51, 0xB3, 0x4C, 0xCD,
  0x33, 0x24, 0x8D, 0xB6, 0x34, 0xD0, 0xF3, 0xC3, 0xCF, 0x0E, 0x38, 0x38,
  0xE0, 0x18, 0xE3, 0x30, 0x26, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0xF0,
  0x36, 0x06, 0x61, 0x8C, 0x61, 0x80, 0x18, 0x31, 0x86, 0x08, 0x60, 0x8C,
  0x08, 0xC0, 0x98, 0x09, 0x80, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xC0,
  0x0C, 0x01, 0x80, 0x18, 0x03, 0x00, 0xF0, 0x04, 0x00, 0x1F, 0x80, 0x80,
  0xC0, 0xC0, 0x60, 0x60, 0x60, 0x30, 0x30, 0x30, 0x1F, 0x9F, 0xC0, 0x03,
  0x83, 0x01, 0x01, 0x80, 0xC0, 0x60, 0x20, 0x30, 0x38, 0x30, 0x2C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x20, 0x18, 0x0E, 0x01, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x06, 0x06, 0x06, 0x06, 0x06, 0x04, 0x0C,
  0x06, 0x03, 0x0E, 0x08, 0x18, 0x18, 0x18, 0x10, 0x30, 0x30, 0xE0, 0x80,
  0x20, 0xFE, 0x63, 0xE0,
};

const GFXglyph NotoSans_Condensed_Italic23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 6, 16, 6, 0, -16 },
  { 13, 7, 6, 8, 2, -16 },
  { 19, 12, 16, 11, 0, -16 },
  { 43, 10, 18, 10, 0, -17 },
  { 66, 13, 17, 15, 1, -17 },
  { 94, 11, 17, 12, 0, -17 },
  { 118, 3, 6, 5, 2, -16 },
  { 121, 7, 21, 6, 1, -17 },
  { 140, 7, 21, 6, -2, -17 },
  { 159, 8, 9, 10, 2, -18 },
  { 168, 9, 11, 11, 1, -14 },
  { 181, 4, 6, 5, -1, -3 },
  { 184, 6, 2, 6, 0, -7 },
  { 186, 3, 3, 5, 0, -3 },
  { 188, 11, 16, 8, -1, -16 },
  { 210, 9, 17, 10, 1, -17 },
  { 230, 6, 16, 10, 3, -16 },
  { 242, 11, 17, 10, -1, -17 },
  { 266, 10, 17, 10, 0, -17 },
  { 288, 10, 17, 10, 0, -17 },
  { 310, 10, 16, 10, 0, -16 },
  { 330, 9, 17, 10, 1, -17 },
  { 350, 10, 16, 10, 1, -16 },
  { 370, 10, 17, 10, 0, -17 },
  { 392, 10, 17, 10, 0, -17 },
  { 414, 5, 12, 5, 0, -12 },
  { 422, 6, 15, 5, -1, -12 },
  { 434, 9, 11, 11, 1, -14 },
  { 447, 9, 6, 11, 1, -11 },
  { 454, 9, 11, 11, 1, -14 },
  { 467, 7, 17, 8, 1, -17 },
  { 482, 14, 19, 15, 1, -17 },
  { 516, 10, 16, 10, -1, -16 },
  { 536, 11, 16, 11, 0, -16 },
  { 558, 11, 17, 10, 1, -17 },
  { 582, 12, 16, 12, 0, -16 },
  { 606, 10, 16, 9, 0, -16 },
  { 626, 10, 16, 9, 0, -16 },
  { 646, 12, 17, 13, 1, -17 },
  { 672, 13, 16, 12, 0, -16 },
  { 698, 9, 16, 6, -1, -16 },
  { 716, 9, 20, 5, -3, -16 },
  { 739, 12, 16, 10, 0, -16 },
  { 763, 7, 16, 9, 0, -16 },
  { 777, 17, 16, 16, 0, -16 },
  { 811, 14, 16, 13, 0, -16 },
  { 839, 12, 17, 13, 1, -17 },
  { 865, 11, 16, 10, 0, -16 },
  { 887, 12, 21, 13, 1, -17 },
  { 919, 11, 16, 11, 0, -16 },
  { 941, 10, 17, 10, 0, -17 },
  { 963, 9, 16, 9, 2, -16 },
  { 981, 12, 16, 12, 1, -16 },
  { 1005, 10, 16, 10, 2, -16 },
  { 1025, 16, 16, 16, 2, -16 },
  { 1057, 12, 16, 10, -1, -16 },
  { 1081, 9, 16, 9, 2, -16 },
  { 1099, 11, 16, 9, -1, -16 },
  { 1121, 9, 21, 7, -1, -17 },
  { 1145, 4, 16, 8, 2, -16 },
  { 1153, 9, 21, 7, -2, -17 },
  { 1177, 10, 9, 10, 0, -16 },
  { 1189, 8, 1, 8, -2, 2 },
  { 1190, 4, 4, 6, 3, -18 },
  { 1192, 10, 13, 11, 1, -13 },
  { 1209, 10, 17, 11, 0, -17 },
  { 1231, 8, 13, 8, 1, -13 },
  { 1244, 11, 17, 11, 1, -17 },
  { 1268, 8, 13, 10, 1, -13 },
  { 1281, 12, 24, 6, -3, -18 },
  { 1317, 11, 19, 11, 0, -13 },
  { 1344, 10, 17, 11, 0, -17 },
  { 1366, 6, 17, 5, 0, -17 },
  { 1379, 9, 23, 5, -3, -17 },
  { 1405, 10, 17, 9, 0, -17 },
  { 1427, 6, 17, 5, 0, -17 },
  { 1440, 15, 13, 16, 0, -13 },
  { 1465, 10, 13, 11, 0, -13 },
  { 1482, 9, 13, 10, 1, -13 },
  { 1497, 11, 18, 11, -1, -13 },
  { 1522, 10, 19, 11, 1, -13 },
  { 1546, 8, 13, 7, 0, -13 },
  { 1559, 8, 13, 8, 0, -13 },
  { 1572, 6, 15, 6, 1, -15 },
  { 1584, 9, 12, 11, 1, -12 },
  { 1598, 9, 12, 9, 1, -12 },
  { 1612, 14, 12, 14, 1, -12 },
  { 1633, 11, 12, 9, -1, -12 },
  { 1650, 12, 18, 9, -2, -12 },
  { 1677, 9, 12, 8, -1, -12 },
  { 1691, 9, 20, 8, 0, -16 },
  { 1714, 2, 23, 10, 4, -18 },
  { 1720, 8, 20, 8, -1, -16 },
  { 1740, 9, 3, 11, 1, -10 },
};

const GFXfont NotoSans_Condensed_Italic23pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Italic23pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Italic23pt7bGlyphs,
  0x20, 0x7E, 31
};

#endif // _NOTOSANS_CONDENSED_ITALIC23PT7B_H_
