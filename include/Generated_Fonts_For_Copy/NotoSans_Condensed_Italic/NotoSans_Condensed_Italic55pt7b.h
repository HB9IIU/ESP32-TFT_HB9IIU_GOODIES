#ifndef _NOTOSANS_CONDENSED_ITALIC55PT7B_H_
#define _NOTOSANS_CONDENSED_ITALIC55PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Italic.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Italic55pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x03, 0xE0,
  0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7C, 0x03, 0xE0, 0x04, 0x00, 0x3E, 0x3E, 0xF8, 0x7D, 0xF0, 0xFB,
  0xE1, 0xE7, 0x83, 0xCF, 0x07, 0x9E, 0x1F, 0x3C, 0x3C, 0xF0, 0x79, 0xE0,
  0xF3, 0xC1, 0xC7, 0x03, 0x8E, 0x0F, 0x1C, 0x1E, 0x00, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0x78, 0x3C, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x70, 0x38, 0x00,
  0x0F, 0x03, 0x80, 0x00, 0xE0, 0x78, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xE0,
  0x70, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x3C, 0x0E, 0x00,
  0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x00, 0x78,
  0x3C, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x0F, 0x03, 0x80,
  0x00, 0xF0, 0x78, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x1E,
  0x0F, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x3C, 0x0E, 0x00, 0x7F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x08, 0x78, 0x1C, 0x00, 0x07,
  0x03, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x0F, 0x03, 0x80, 0x00, 0xF0, 0x78,
  0x00, 0x0E, 0x07, 0x80, 0x01, 0xE0, 0x70, 0x00, 0x1E, 0x0F, 0x00, 0x01,
  0xC0, 0xF0, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x38, 0x1E,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0xFF,
  0xFF, 0x03, 0xFF, 0xFE, 0x0F, 0xCE, 0x18, 0x1F, 0x1C, 0x10, 0x3C, 0x30,
  0x00, 0xF0, 0xE0, 0x01, 0xE1, 0xC0, 0x03, 0xC3, 0x80, 0x07, 0x86, 0x00,
  0x0F, 0x8C, 0x00, 0x0F, 0xB8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x6F, 0xC0, 0x01, 0xCF, 0x80, 0x03, 0x8F, 0x00, 0x07,
  0x1F, 0x00, 0x0C, 0x3E, 0x00, 0x18, 0x78, 0x00, 0x70, 0xF0, 0x00, 0xE1,
  0xE1, 0x01, 0xC7, 0xC3, 0x83, 0x1F, 0x07, 0xF7, 0xFC, 0x0F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x78, 0x07, 0xFC, 0x00, 0xF0,
  0x0F, 0xFC, 0x00, 0xF0, 0x0E, 0x1E, 0x01, 0xE0, 0x1E, 0x1E, 0x01, 0xC0,
  0x3C, 0x1E, 0x03, 0xC0, 0x3C, 0x1E, 0x07, 0x80, 0x38, 0x1E, 0x07, 0x80,
  0x78, 0x1E, 0x0F, 0x00, 0x78, 0x1C, 0x0E, 0x00, 0x78, 0x1C, 0x1E, 0x00,
  0x70, 0x1C, 0x1C, 0x00, 0x70, 0x3C, 0x3C, 0x00, 0xF0, 0x3C, 0x78, 0x00,
  0xF0, 0x38, 0x78, 0x00, 0xF0, 0x78, 0xF0, 0xF8, 0xF0, 0x78, 0xE3, 0xFC,
  0xF0, 0x71, 0xE7, 0xFE, 0xF0, 0xF3, 0xC7, 0x9E, 0xF1, 0xE3, 0xCF, 0x0E,
  0x7F, 0xE7, 0x8E, 0x0F, 0x7F, 0xC7, 0x1E, 0x0F, 0x3F, 0x8F, 0x1C, 0x0F,
  0x0E, 0x1E, 0x3C, 0x0E, 0x00, 0x1E, 0x3C, 0x0E, 0x00, 0x3C, 0x3C, 0x0E,
  0x00, 0x3C, 0x38, 0x1E, 0x00, 0x78, 0x78, 0x1E, 0x00, 0x70, 0x78, 0x1E,
  0x00, 0xF0, 0x78, 0x1C, 0x01, 0xE0, 0x78, 0x3C, 0x01, 0xE0, 0x78, 0x3C,
  0x03, 0xC0, 0x70, 0x38, 0x03, 0x80, 0x70, 0x78, 0x07, 0x80, 0x78, 0x78,
  0x0F, 0x00, 0x78, 0xF0, 0x0F, 0x00, 0x3F, 0xE0, 0x1E, 0x00, 0x3F, 0xE0,
  0x3C, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xC3,
  0xC0, 0x00, 0xF0, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0x81, 0xF0, 0x00,
  0xF0, 0x3C, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xC0, 0xF0, 0x00, 0x78, 0x3E,
  0x00, 0x0F, 0x0F, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0x3C, 0x7C, 0x00, 0x07,
  0xDF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFE, 0x07, 0xC3, 0xF7,
  0xC0, 0xF0, 0xF8, 0x78, 0x1E, 0x1F, 0x0F, 0x87, 0xC7, 0xC1, 0xF0, 0xF0,
  0xF0, 0x1F, 0x3E, 0x3E, 0x03, 0xE7, 0x87, 0x80, 0x3F, 0xF0, 0xF0, 0x07,
  0xFC, 0x3E, 0x00, 0x7F, 0x07, 0xC0, 0x0F, 0xE0, 0xF8, 0x00, 0xF8, 0x1F,
  0x00, 0x3F, 0x03, 0xE0, 0x0F, 0xE0, 0x3E, 0x07, 0xFE, 0x07, 0xF3, 0xFF,
  0xC0, 0x7F, 0xFE, 0x7C, 0x0F, 0xFF, 0x0F, 0x80, 0x7F, 0xC0, 0xF8, 0x01,
  0x00, 0x00, 0x00, 0x3E, 0x79, 0xF3, 0xE7, 0xCF, 0x1E, 0x3C, 0x71, 0xE3,
  0xC7, 0x8E, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01,
  0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0,
  0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E,
  0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x03, 0x07, 0x80, 0x7C, 0x70, 0x07, 0xF7, 0x01,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0x0F, 0x03, 0xF8,
  0x00, 0x7B, 0x80, 0x0F, 0x3C, 0x01, 0xF1, 0xC0, 0x3E, 0x1E, 0x01, 0xC1,
  0xE0, 0x08, 0x0F, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xC3, 0xE0,
  0xF8, 0x7C, 0x1F, 0x07, 0x83, 0xE0, 0xF0, 0x7C, 0x1E, 0x07, 0x83, 0xC0,
  0xE0, 0x00, 0x7F, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xE0, 0x7B, 0xFF, 0xFF,
  0xFB, 0xE2, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xF9, 0xF8,
  0x0F, 0x83, 0xE0, 0x7C, 0x07, 0x81, 0xF0, 0x1F, 0x0F, 0x80, 0x7C, 0x3E,
  0x01, 0xF0, 0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x1E, 0x00, 0x7C, 0xF8, 0x01,
  0xF3, 0xE0, 0x07, 0xCF, 0x80, 0x1F, 0x3C, 0x00, 0x79, 0xF0, 0x01, 0xE7,
  0xC0, 0x07, 0x9F, 0x00, 0x3E, 0x78, 0x00, 0xF9, 0xE0, 0x03, 0xEF, 0x80,
  0x0F, 0x3E, 0x00, 0x3C, 0xF8, 0x01, 0xF3, 0xE0, 0x07, 0xCF, 0x00, 0x1E,
  0x3C, 0x00, 0xF8, 0xF0, 0x03, 0xE3, 0xC0, 0x0F, 0x0F, 0x00, 0x7C, 0x3C,
  0x01, 0xF0, 0xF0, 0x0F, 0x83, 0xC0, 0x3E, 0x0F, 0x81, 0xF0, 0x3E, 0x0F,
  0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x07, 0xF8, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x3E, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0xE0, 0x7F,
  0xC1, 0xFF, 0x8F, 0xDF, 0x3F, 0x3C, 0xFC, 0x78, 0xF1, 0xF0, 0x83, 0xE0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xFE, 0x00,
  0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x1F, 0xC3, 0xF0, 0x07, 0x80, 0xF8,
  0x01, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xF0,
  0x7E, 0x01, 0xC0, 0x3F, 0x01, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x80, 0x07, 0xE0, 0xC0, 0x0F, 0xC0, 0xFC, 0x7F,
  0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0x78, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xBC, 0x00, 0x03, 0xDE, 0x00, 0x03, 0xCF, 0x00, 0x03, 0xCF, 0x80,
  0x01, 0xE7, 0x80, 0x01, 0xE3, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xF1, 0xF0,
  0x00, 0xF0, 0xF8, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0x3C, 0x00, 0x78, 0x1E,
  0x00, 0x78, 0x1F, 0x00, 0x78, 0x0F, 0x80, 0x3C, 0x07, 0x80, 0x3C, 0x03,
  0xC0, 0x3C, 0x01, 0xE0, 0x1E, 0x01, 0xF0, 0x1E, 0x00, 0xF8, 0x1F, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF2, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFE, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x07, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0,
  0x04, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x80, 0x07, 0xE0, 0xC0, 0x0F, 0xC0,
  0xF8, 0x7F, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xF8, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF8,
  0x01, 0xFF, 0xE0, 0x07, 0xE0, 0x40, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x0F,
  0x00, 0x3C, 0x7F, 0x80, 0x7B, 0xFF, 0x81, 0xF7, 0xFF, 0x83, 0xFE, 0x3F,
  0x07, 0xF0, 0x1F, 0x0F, 0xC0, 0x3E, 0x1F, 0x00, 0x7C, 0x7E, 0x00, 0xF8,
  0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F,
  0x00, 0x1F, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0xF8, 0x78, 0x01, 0xF0, 0xF8,
  0x03, 0xC1, 0xF0, 0x0F, 0x81, 0xE0, 0x3E, 0x03, 0xE0, 0xFC, 0x07, 0xF7,
  0xF0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x80,
  0x00, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xF8, 0x3F, 0x01, 0xF0, 0x1F,
  0x01, 0xE0, 0x0F, 0x03, 0xE0, 0x0F, 0x03, 0xE0, 0x0F, 0x03, 0xC0, 0x0F,
  0x03, 0xC0, 0x0F, 0x03, 0xC0, 0x1F, 0x03, 0xE0, 0x1F, 0x03, 0xE0, 0x3E,
  0x01, 0xE0, 0x7C, 0x01, 0xF0, 0xFC, 0x00, 0xF9, 0xF8, 0x00, 0xFF, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x07, 0xE7, 0xE0, 0x0F, 0x83, 0xF0, 0x1F, 0x01, 0xF0, 0x3E, 0x00, 0xF0,
  0x3C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x78, 0x00, 0x78, 0x78, 0x00, 0x78,
  0x78, 0x00, 0x78, 0xF8, 0x00, 0xF8, 0x78, 0x00, 0xF8, 0x78, 0x00, 0xF0,
  0x7C, 0x01, 0xF0, 0x7E, 0x03, 0xE0, 0x3F, 0x8F, 0xE0, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xF0, 0xF8, 0x0F,
  0x81, 0xF0, 0x7C, 0x07, 0xC3, 0xE0, 0x0F, 0x0F, 0x80, 0x3C, 0x3C, 0x00,
  0xF1, 0xF0, 0x03, 0xC7, 0xC0, 0x0F, 0x1E, 0x00, 0x3C, 0x78, 0x00, 0xF1,
  0xE0, 0x03, 0xC7, 0x80, 0x1F, 0x1E, 0x00, 0x7C, 0x78, 0x01, 0xF1, 0xE0,
  0x0F, 0xC7, 0xC0, 0x7F, 0x1F, 0x03, 0xF8, 0x7F, 0xFF, 0xE0, 0xFF, 0xF7,
  0x81, 0xFF, 0xBE, 0x03, 0xF8, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80,
  0xF3, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0xC0, 0x7C, 0x0F, 0x83, 0xF0, 0x7E, 0x0F, 0xC0, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x0F, 0x81, 0xF8, 0x7E, 0x0F, 0xC0, 0xF0, 0x08, 0x00, 0x00, 0x1C, 0x00,
  0xF8, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00,
  0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78,
  0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80,
  0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8,
  0x00, 0x3F, 0x80, 0x00, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7C, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x38, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x01, 0xFF, 0xC1,
  0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0x0F, 0xC2, 0x01, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C,
  0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x1F, 0x00, 0x00, 0x70, 0x07, 0x80,
  0x00, 0x1E, 0x03, 0xC0, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x00, 0xE0, 0x70,
  0x03, 0xC0, 0x38, 0x3C, 0x03, 0xFF, 0x0F, 0x0E, 0x03, 0xFF, 0x83, 0xC7,
  0x81, 0xF1, 0xE0, 0xF1, 0xC0, 0xF0, 0x78, 0x3C, 0xF0, 0x3C, 0x1E, 0x0F,
  0x38, 0x1E, 0x07, 0x03, 0xCE, 0x07, 0x03, 0xC0, 0xE7, 0x83, 0xC0, 0xF0,
  0x39, 0xE0, 0xE0, 0x3C, 0x0E, 0x70, 0x78, 0x0E, 0x07, 0x9C, 0x1E, 0x07,
  0x81, 0xEF, 0x07, 0x01, 0xE0, 0x73, 0xC1, 0xC0, 0x78, 0x3C, 0xF0, 0x70,
  0x3C, 0x0F, 0x38, 0x3C, 0x0F, 0x03, 0x8E, 0x0F, 0x03, 0xC1, 0xE3, 0x83,
  0xC1, 0xF0, 0x70, 0xE0, 0x70, 0xFC, 0x3C, 0x38, 0x1E, 0x77, 0x9E, 0x0E,
  0x07, 0xFC, 0xFF, 0x03, 0x80, 0xFE, 0x3F, 0x80, 0xF0, 0x1E, 0x07, 0x80,
  0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x60, 0x00, 0x0F, 0xF1, 0xF8, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x78, 0x00, 0x07, 0xBC,
  0x00, 0x07, 0xDE, 0x00, 0x03, 0xCF, 0x00, 0x01, 0xE7, 0x80, 0x01, 0xE3,
  0xC0, 0x00, 0xF1, 0xE0, 0x00, 0xF0, 0xF8, 0x00, 0x78, 0x7C, 0x00, 0x7C,
  0x3E, 0x00, 0x3C, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x1E, 0x07, 0xC0, 0x1F,
  0x03, 0xE0, 0x0F, 0x81, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xFF, 0xFC, 0x03,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0,
  0xF8, 0x03, 0xE0, 0xF8, 0x00, 0xF0, 0x7C, 0x00, 0x78, 0x7C, 0x00, 0x3C,
  0x3E, 0x00, 0x1E, 0x3E, 0x00, 0x0F, 0x1F, 0x00, 0x07, 0x8F, 0x80, 0x03,
  0xCF, 0x80, 0x01, 0xE7, 0xC0, 0x00, 0xF7, 0xC0, 0x00, 0x7B, 0xE0, 0x00,
  0x3E, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFE, 0x01, 0xF0, 0x1F, 0x80, 0x78, 0x03, 0xE0, 0x1E, 0x00, 0xF8,
  0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x07, 0xC0, 0xF0, 0x01, 0xE0, 0x3C, 0x00,
  0xF8, 0x1F, 0x00, 0x3E, 0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x07, 0xC0, 0x78,
  0x03, 0xF0, 0x1E, 0x01, 0xF8, 0x0F, 0x83, 0xFC, 0x03, 0xFF, 0xFC, 0x00,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0x07, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x07, 0xC0, 0x7C, 0x01, 0xF0, 0x1E, 0x00, 0x3C, 0x07, 0x80,
  0x0F, 0x83, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x3C, 0x00, 0x3C, 0x0F,
  0x00, 0x1F, 0x07, 0xC0, 0x07, 0xC1, 0xF0, 0x03, 0xF0, 0x7C, 0x00, 0xF8,
  0x1E, 0x00, 0x7E, 0x07, 0x80, 0x7F, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x0F, 0xF1, 0xF0,
  0x0F, 0xC0, 0x10, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x10,
  0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80,
  0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0x03, 0xF8, 0x03, 0xC0,
  0x1F, 0x80, 0x78, 0x03, 0xF0, 0x1F, 0x00, 0x3E, 0x03, 0xE0, 0x07, 0xC0,
  0x78, 0x00, 0x7C, 0x0F, 0x00, 0x0F, 0x83, 0xE0, 0x01, 0xF0, 0x7C, 0x00,
  0x3E, 0x0F, 0x80, 0x07, 0xC1, 0xE0, 0x00, 0xF8, 0x3C, 0x00, 0x1F, 0x0F,
  0x80, 0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x07, 0x80, 0x03,
  0xE0, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF0, 0xF8,
  0x00, 0x7C, 0x1E, 0x00, 0x0F, 0x83, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x7C,
  0x1F, 0x00, 0x0F, 0x83, 0xC0, 0x03, 0xE0, 0x78, 0x00, 0xFC, 0x1F, 0x00,
  0x1F, 0x03, 0xE0, 0x07, 0xC0, 0x7C, 0x01, 0xF8, 0x0F, 0x00, 0xFE, 0x01,
  0xE0, 0x7F, 0x80, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x01,
  0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x01,
  0xFF, 0xFE, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFE, 0x00, 0xFF, 0x87, 0xE0, 0x1F, 0xC0, 0x0C, 0x03, 0xF0, 0x00, 0x40,
  0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x1F, 0xF8, 0xF8, 0x03, 0xFF,
  0x8F, 0x80, 0x3F, 0xF0, 0xF8, 0x03, 0xFF, 0x0F, 0x00, 0x01, 0xF0, 0xF0,
  0x00, 0x1F, 0x0F, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x3E, 0x0F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x0F,
  0x80, 0x03, 0xC0, 0xF8, 0x00, 0x3C, 0x0F, 0xC0, 0x07, 0xC0, 0x7E, 0x00,
  0x7C, 0x07, 0xF0, 0x07, 0x80, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x7C, 0x03, 0xC0, 0x01, 0xE0, 0x1F, 0x00, 0x07, 0x80, 0x7C,
  0x00, 0x3E, 0x01, 0xF0, 0x00, 0xF8, 0x07, 0x80, 0x03, 0xE0, 0x1E, 0x00,
  0x0F, 0x00, 0xF8, 0x00, 0x3C, 0x03, 0xE0, 0x01, 0xF0, 0x0F, 0x00, 0x07,
  0xC0, 0x3C, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x78, 0x07, 0xC0, 0x03, 0xE0,
  0x1F, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0xF0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x7C, 0x00, 0x1E, 0x01, 0xF0, 0x00,
  0xF8, 0x07, 0xC0, 0x03, 0xE0, 0x1E, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x3C,
  0x03, 0xE0, 0x01, 0xF0, 0x0F, 0x80, 0x07, 0xC0, 0x3C, 0x00, 0x1F, 0x00,
  0xF0, 0x00, 0x78, 0x03, 0xC0, 0x01, 0xE0, 0x1F, 0x00, 0x0F, 0x80, 0x7C,
  0x00, 0x3E, 0x01, 0xE0, 0x00, 0xF8, 0x07, 0x80, 0x03, 0xC0, 0x3E, 0x00,
  0x0F, 0x00, 0xF8, 0x00, 0x7C, 0x03, 0xE0, 0x01, 0xF0, 0x0F, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0,
  0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0xF8, 0x01, 0xF0, 0x0F, 0x00, 0x3E, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x01, 0xF0, 0x0F, 0x80, 0x1E, 0x01, 0xF0,
  0x01, 0xE0, 0x3E, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0xFC, 0x00, 0x3C,
  0x0F, 0x80, 0x03, 0xC1, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0xC7, 0xE0,
  0x00, 0x7C, 0x7C, 0x00, 0x07, 0x8F, 0x80, 0x00, 0x79, 0xF0, 0x00, 0x0F,
  0xBE, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFD, 0xF0, 0x00, 0x1F, 0x9F, 0x00, 0x01,
  0xF0, 0xF0, 0x00, 0x1E, 0x0F, 0x80, 0x01, 0xE0, 0xF8, 0x00, 0x3E, 0x0F,
  0x80, 0x03, 0xE0, 0x78, 0x00, 0x3C, 0x07, 0xC0, 0x03, 0xC0, 0x7C, 0x00,
  0x7C, 0x07, 0xC0, 0x07, 0xC0, 0x3E, 0x00, 0x7C, 0x03, 0xE0, 0x07, 0x80,
  0x3E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0xF8, 0x01, 0xF0,
  0x0F, 0x80, 0x1F, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0xF0,
  0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00,
  0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xFC, 0x00, 0x01, 0xFE, 0x01, 0xF8, 0x00, 0x03, 0xF8,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x1F, 0xE0,
  0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x01, 0xFE,
  0x01, 0xEF, 0x00, 0x07, 0xBC, 0x03, 0xDE, 0x00, 0x0F, 0xF8, 0x07, 0xBC,
  0x00, 0x3D, 0xF0, 0x0F, 0x78, 0x00, 0x7B, 0xC0, 0x3E, 0xF0, 0x01, 0xE7,
  0x80, 0x7D, 0xE0, 0x03, 0xDF, 0x00, 0xF3, 0xC0, 0x0F, 0x3E, 0x01, 0xE7,
  0x80, 0x1E, 0x7C, 0x03, 0xCF, 0x00, 0x78, 0xF0, 0x0F, 0x9E, 0x00, 0xF1,
  0xE0, 0x1F, 0x3C, 0x03, 0xE7, 0xC0, 0x3C, 0x7C, 0x07, 0x8F, 0x80, 0x78,
  0x78, 0x1F, 0x1F, 0x00, 0xF0, 0xF0, 0x3C, 0x3C, 0x03, 0xE1, 0xE0, 0xF8,
  0x78, 0x07, 0x83, 0xC1, 0xE1, 0xF0, 0x0F, 0x07, 0x87, 0xC3, 0xE0, 0x1E,
  0x0F, 0x0F, 0x07, 0x80, 0x3C, 0x1E, 0x3E, 0x0F, 0x00, 0xF8, 0x3C, 0x78,
  0x3E, 0x01, 0xE0, 0x78, 0xF0, 0x7C, 0x03, 0xC0, 0xF3, 0xC0, 0xF8, 0x07,
  0x81, 0xE7, 0x81, 0xE0, 0x1F, 0x03, 0xDE, 0x03, 0xC0, 0x3E, 0x07, 0xBC,
  0x0F, 0x80, 0x78, 0x0F, 0xF0, 0x1F, 0x00, 0xF0, 0x1F, 0xE0, 0x3E, 0x01,
  0xE0, 0x1F, 0x80, 0x78, 0x07, 0xC0, 0x3F, 0x00, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1E, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x1E, 0x01, 0xF8, 0x00, 0x3C, 0x07, 0xF0, 0x00,
  0xF8, 0x0F, 0xE0, 0x01, 0xF0, 0x1F, 0xC0, 0x03, 0xC0, 0x3F, 0x80, 0x07,
  0x80, 0x7F, 0x80, 0x0F, 0x01, 0xEF, 0x00, 0x3E, 0x03, 0xDE, 0x00, 0x7C,
  0x07, 0xBC, 0x00, 0xF0, 0x0F, 0x7C, 0x01, 0xE0, 0x3E, 0x78, 0x07, 0xC0,
  0x7C, 0xF0, 0x0F, 0x80, 0xF1, 0xE0, 0x1E, 0x01, 0xE3, 0xE0, 0x3C, 0x03,
  0xC3, 0xC0, 0x78, 0x0F, 0x87, 0x81, 0xF0, 0x1F, 0x0F, 0x03, 0xE0, 0x3C,
  0x1E, 0x07, 0x80, 0x78, 0x3E, 0x0F, 0x00, 0xF0, 0x3C, 0x1E, 0x03, 0xE0,
  0x78, 0x7C, 0x07, 0xC0, 0xF0, 0xF8, 0x0F, 0x01, 0xF1, 0xE0, 0x1E, 0x01,
  0xE3, 0xC0, 0x3C, 0x03, 0xC7, 0x80, 0xF8, 0x07, 0x9F, 0x01, 0xE0, 0x0F,
  0xBE, 0x03, 0xC0, 0x0F, 0x78, 0x07, 0x80, 0x1E, 0xF0, 0x1F, 0x00, 0x3D,
  0xE0, 0x3E, 0x00, 0x7F, 0xC0, 0x78, 0x00, 0xFF, 0x00, 0xF0, 0x00, 0xFE,
  0x01, 0xE0, 0x01, 0xFC, 0x07, 0xC0, 0x03, 0xF8, 0x0F, 0x80, 0x07, 0xF0,
  0x1E, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x1F,
  0xE3, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x3E,
  0x0F, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x8F, 0x80,
  0x01, 0xF3, 0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x07, 0xCF, 0x80, 0x00, 0xFB,
  0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7D, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7D, 0xF0, 0x00, 0x0F, 0xBE,
  0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3C, 0xF0, 0x00, 0x0F, 0x9E, 0x00, 0x01,
  0xF3, 0xC0, 0x00, 0x3E, 0x78, 0x00, 0x0F, 0x8F, 0x00, 0x01, 0xF1, 0xE0,
  0x00, 0x7C, 0x3C, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x7C,
  0x1F, 0x00, 0x1F, 0x01, 0xF0, 0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x07, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0x03, 0xF0, 0x0F, 0x00, 0xF8, 0x07,
  0x80, 0x7C, 0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x0F, 0x81, 0xE0, 0x07, 0xC0,
  0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xE0, 0x7C, 0x00, 0xF0, 0x3E, 0x00, 0xF8,
  0x1E, 0x00, 0x7C, 0x0F, 0x00, 0x7C, 0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x3E,
  0x03, 0xE0, 0x7F, 0x01, 0xE1, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xE3, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x3E, 0x0F, 0xC0, 0x03,
  0xE1, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF3, 0xE0,
  0x00, 0x3E, 0x7C, 0x00, 0x07, 0xCF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x1F,
  0x7C, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7D, 0xE0, 0x00, 0x0F, 0x7C, 0x00,
  0x01, 0xEF, 0x80, 0x00, 0x7D, 0xF0, 0x00, 0x0F, 0xBE, 0x00, 0x01, 0xF7,
  0xC0, 0x00, 0x3E, 0xF0, 0x00, 0x0F, 0x9E, 0x00, 0x01, 0xF3, 0xC0, 0x00,
  0x3E, 0x78, 0x00, 0x0F, 0x8F, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x7E, 0x3C,
  0x00, 0x0F, 0x87, 0xC0, 0x03, 0xF0, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x1F,
  0x01, 0xF0, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0x03, 0xF0, 0x0F, 0x00, 0xF8, 0x07,
  0x80, 0x7C, 0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x0F, 0x81, 0xF0, 0x07, 0xC0,
  0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xE0, 0x7C, 0x01, 0xF0, 0x3E, 0x00, 0xF8,
  0x1E, 0x00, 0x7C, 0x0F, 0x00, 0x7C, 0x0F, 0x80, 0x7E, 0x07, 0xC0, 0x7E,
  0x03, 0xE0, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x3E, 0x1F, 0x00, 0x1E, 0x0F, 0x80, 0x0F, 0x07,
  0xC0, 0x0F, 0x81, 0xE0, 0x07, 0xC0, 0xF8, 0x03, 0xC0, 0x7C, 0x01, 0xE0,
  0x3E, 0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x3C,
  0x01, 0xF0, 0x1E, 0x00, 0xF8, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x07,
  0xC0, 0x0F, 0x83, 0xC0, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xFF,
  0x80, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x0F, 0xF1, 0xF0, 0x0F, 0xC0,
  0x18, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x10, 0x00, 0xFC, 0x0E, 0x01, 0xFC, 0x07, 0xFF,
  0xFC, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xE0, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x01, 0xF0, 0x7C, 0x00, 0x1E, 0x07, 0xC0, 0x03, 0xE0, 0x78, 0x00, 0x3E,
  0x07, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x3C, 0x0F, 0x80, 0x07, 0xC0, 0xF8,
  0x00, 0x7C, 0x0F, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x78, 0x1F, 0x00, 0x07,
  0x81, 0xF0, 0x00, 0xF8, 0x1F, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0xF8, 0x1E,
  0x00, 0x0F, 0x03, 0xE0, 0x00, 0xF0, 0x3E, 0x00, 0x1F, 0x03, 0xC0, 0x01,
  0xF0, 0x3C, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xE0, 0x7C, 0x00, 0x3E, 0x07,
  0xC0, 0x03, 0xE0, 0x78, 0x00, 0x3E, 0x07, 0x80, 0x03, 0xC0, 0xF8, 0x00,
  0x3C, 0x0F, 0x80, 0x07, 0xC0, 0xF8, 0x00, 0x7C, 0x0F, 0x00, 0x07, 0xC0,
  0xF0, 0x00, 0x78, 0x0F, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0xF8, 0x0F, 0x00,
  0x1F, 0x00, 0xF8, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xFC, 0x07, 0xE0,
  0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x08, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7C,
  0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF0,
  0xF8, 0x01, 0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x07, 0xC0,
  0xF8, 0x07, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x00,
  0x78, 0x1F, 0x00, 0x78, 0x1E, 0x00, 0x78, 0x3E, 0x00, 0x78, 0x3C, 0x00,
  0x78, 0x7C, 0x00, 0x78, 0x78, 0x00, 0x78, 0xF8, 0x00, 0x78, 0xF8, 0x00,
  0x78, 0xF0, 0x00, 0x79, 0xF0, 0x00, 0x79, 0xE0, 0x00, 0x7B, 0xE0, 0x00,
  0x7B, 0xC0, 0x00, 0x7B, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0xF0, 0x00, 0xF8, 0x00,
  0xFB, 0xE0, 0x03, 0xF0, 0x01, 0xF7, 0xC0, 0x07, 0xE0, 0x07, 0xCF, 0x80,
  0x1F, 0xC0, 0x0F, 0x9F, 0x00, 0x3F, 0x80, 0x1E, 0x3C, 0x00, 0xFF, 0x00,
  0x7C, 0x78, 0x01, 0xFE, 0x00, 0xF8, 0xF0, 0x03, 0xBC, 0x03, 0xE1, 0xE0,
  0x0F, 0x70, 0x07, 0xC3, 0xC0, 0x1E, 0xE0, 0x0F, 0x07, 0x80, 0x79, 0xC0,
  0x3E, 0x0F, 0x00, 0xF3, 0x80, 0x78, 0x1E, 0x01, 0xE7, 0x01, 0xF0, 0x3C,
  0x07, 0x8E, 0x03, 0xE0, 0x78, 0x0F, 0x1C, 0x07, 0x80, 0xF0, 0x3C, 0x38,
  0x1F, 0x01, 0xE0, 0x78, 0x70, 0x3C, 0x03, 0xC0, 0xE0, 0xE0, 0xF8, 0x07,
  0x83, 0xC1, 0xC1, 0xF0, 0x0F, 0x07, 0x83, 0x83, 0xC0, 0x1E, 0x1E, 0x07,
  0x0F, 0x80, 0x3C, 0x3C, 0x1E, 0x1E, 0x00, 0x78, 0xF0, 0x3C, 0x7C, 0x00,
  0xF1, 0xE0, 0x78, 0xF8, 0x01, 0xE3, 0xC0, 0xF1, 0xE0, 0x03, 0xCF, 0x01,
  0xE7, 0xC0, 0x07, 0x9E, 0x03, 0xCF, 0x00, 0x0F, 0x78, 0x07, 0x9E, 0x00,
  0x1E, 0xF0, 0x0F, 0x78, 0x00, 0x3D, 0xE0, 0x1E, 0xF0, 0x00, 0x7F, 0x80,
  0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0xFF, 0x00,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x0F, 0xC0,
  0x07, 0xF0, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xC0,
  0x0F, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0xF8, 0x0F,
  0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x1E, 0x0F, 0x80,
  0x00, 0x7C, 0x7C, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x07, 0xCF, 0x80, 0x00,
  0x0F, 0x3C, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x7D, 0xE0, 0x00,
  0x03, 0xE7, 0xC0, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x03,
  0xE0, 0xF0, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xE0,
  0x3E, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x7C, 0x03, 0xE0, 0x01, 0xF0, 0x07,
  0x80, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0x7C, 0x01, 0xF0, 0x01, 0xF0,
  0x0F, 0x80, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xEF, 0x80,
  0x1F, 0x3E, 0x00, 0x7C, 0x78, 0x03, 0xE1, 0xE0, 0x0F, 0x87, 0x80, 0x7C,
  0x1E, 0x01, 0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x07, 0xC1, 0xF0, 0x0F,
  0x07, 0x80, 0x3C, 0x3E, 0x00, 0xF1, 0xF0, 0x03, 0xC7, 0x80, 0x0F, 0x3E,
  0x00, 0x3E, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03,
  0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF8, 0x3C, 0x1E, 0x00, 0x3F, 0xF8, 0x01, 0xFF,
  0xC0, 0x0F, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x03, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xFC,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x79, 0xE0,
  0x01, 0xE3, 0xC0, 0x03, 0xC3, 0xC0, 0x0F, 0x07, 0x80, 0x1E, 0x0F, 0x00,
  0x78, 0x0F, 0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x3C, 0x1E,
  0x00, 0x78, 0x7C, 0x00, 0xF8, 0xF0, 0x00, 0xF3, 0xE0, 0x01, 0xE7, 0x80,
  0x01, 0xFE, 0x00, 0x03, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xF8, 0x7C, 0x7C, 0x3C, 0x3C, 0x1E, 0x1E, 0x0F, 0x07, 0x00, 0x3E,
  0x00, 0x01, 0xFE, 0x3C, 0x0F, 0xFE, 0x78, 0x3F, 0xFE, 0xF0, 0x7E, 0x1F,
  0xC1, 0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x0F, 0x80, 0x3E, 0x3E, 0x00, 0x7C,
  0x7C, 0x00, 0xF0, 0xF0, 0x01, 0xE3, 0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F,
  0x00, 0x1F, 0x1E, 0x00, 0x3C, 0x7C, 0x00, 0x78, 0xF8, 0x01, 0xF1, 0xF0,
  0x03, 0xE3, 0xE0, 0x07, 0x87, 0x80, 0x1F, 0x0F, 0x00, 0x3E, 0x1E, 0x00,
  0x7C, 0x3C, 0x01, 0xF8, 0x7C, 0x07, 0xE0, 0xF8, 0x0F, 0xC1, 0xF0, 0x3F,
  0x81, 0xF9, 0xEF, 0x03, 0xFF, 0x9E, 0x03, 0xFE, 0x38, 0x03, 0xF8, 0xF0,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE1, 0xF0, 0x03, 0xE7, 0xFC, 0x03, 0xEF,
  0xFC, 0x03, 0xDF, 0xFE, 0x03, 0xFC, 0x3E, 0x03, 0xF8, 0x1F, 0x07, 0xF0,
  0x1F, 0x07, 0xE0, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0x80,
  0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x00, 0x1F, 0x0F, 0x00,
  0x1E, 0x1F, 0x00, 0x1E, 0x1F, 0x00, 0x3E, 0x1E, 0x00, 0x3E, 0x1E, 0x00,
  0x3E, 0x1E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x78, 0x3E, 0x00,
  0xF8, 0x3E, 0x00, 0xF8, 0x3F, 0x01, 0xF0, 0x7F, 0x03, 0xE0, 0x7B, 0xCF,
  0xE0, 0x7B, 0xFF, 0xC0, 0x71, 0xFF, 0x80, 0xF0, 0xFE, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x3F, 0x80, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x7E,
  0x0C, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x80, 0x81, 0xF8, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x1F, 0xF0,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x7E, 0x1E, 0x00, 0x3F, 0xC7,
  0x80, 0x3F, 0xF9, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xE1, 0xFC, 0x03, 0xE0,
  0x3F, 0x01, 0xF0, 0x0F, 0xC0, 0x7C, 0x01, 0xF0, 0x3E, 0x00, 0x7C, 0x0F,
  0x80, 0x1E, 0x03, 0xC0, 0x07, 0x81, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0xF8,
  0x1E, 0x00, 0x3C, 0x0F, 0x80, 0x0F, 0x03, 0xE0, 0x03, 0xC0, 0xF8, 0x01,
  0xF0, 0x3E, 0x00, 0x7C, 0x0F, 0x00, 0x1E, 0x03, 0xC0, 0x0F, 0x80, 0xF0,
  0x03, 0xE0, 0x3C, 0x00, 0xF8, 0x0F, 0x00, 0x7E, 0x03, 0xC0, 0x3F, 0x00,
  0xF8, 0x0F, 0xC0, 0x3E, 0x07, 0xF0, 0x0F, 0xE7, 0xBC, 0x01, 0xFF, 0xCF,
  0x00, 0x3F, 0xE3, 0x80, 0x07, 0xF1, 0xE0, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xC1, 0xF0,
  0xF8, 0x1F, 0x1F, 0x00, 0xF1, 0xE0, 0x1F, 0x3E, 0x01, 0xF3, 0xC0, 0x1E,
  0x7C, 0x03, 0xE7, 0xC0, 0x7C, 0x78, 0x1F, 0xC7, 0xFF, 0xF8, 0xFF, 0xFE,
  0x0F, 0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0xC0, 0x10, 0x7E, 0x0F, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x00,
  0xFF, 0xC0, 0x00, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xE3,
  0xC0, 0x3F, 0xF9, 0xE0, 0x1F, 0xFE, 0xF0, 0x1F, 0x87, 0xF0, 0x1F, 0x01,
  0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x1F, 0x07, 0xC0,
  0x0F, 0x03, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x03, 0xE0, 0xF0,
  0x01, 0xF0, 0x78, 0x00, 0xF0, 0x7C, 0x00, 0x78, 0x3E, 0x00, 0x7C, 0x1F,
  0x00, 0x3E, 0x0F, 0x00, 0x1E, 0x07, 0x80, 0x1F, 0x03, 0xC0, 0x0F, 0x81,
  0xE0, 0x0F, 0xC0, 0xF0, 0x07, 0xE0, 0x78, 0x07, 0xE0, 0x3E, 0x07, 0xF0,
  0x1F, 0x07, 0xF8, 0x0F, 0xC7, 0xFC, 0x03, 0xFF, 0xBE, 0x01, 0xFF, 0x9E,
  0x00, 0x3F, 0x8F, 0x00, 0x02, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x04, 0x00, 0x7C, 0x03, 0x00, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0xFF,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x1F, 0x00, 0x7C,
  0xFF, 0x80, 0xFB, 0xFF, 0x81, 0xEF, 0xFF, 0x03, 0xFC, 0x3E, 0x07, 0xE0,
  0x3C, 0x1F, 0x80, 0x78, 0x3F, 0x00, 0xF0, 0x7C, 0x01, 0xE0, 0xF8, 0x03,
  0xC1, 0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x3C, 0x1E, 0x00, 0x78,
  0x3C, 0x00, 0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x07,
  0x80, 0x1E, 0x0F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0xF0,
  0x03, 0xC1, 0xE0, 0x07, 0x83, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0x00,
  0x78, 0x3C, 0x00, 0xF0, 0x78, 0x01, 0xE1, 0xF0, 0x07, 0xC0, 0x00, 0x10,
  0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x78,
  0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01,
  0xE0, 0x0F, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x20, 0x00, 0x0F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x01, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7C, 0x03, 0xC0, 0xF8, 0x03,
  0xC1, 0xF0, 0x07, 0xC3, 0xE0, 0x07, 0xC3, 0xE0, 0x07, 0x87, 0xC0, 0x07,
  0x8F, 0x80, 0x07, 0x9F, 0x00, 0x0F, 0xBE, 0x00, 0x0F, 0x3C, 0x00, 0x0F,
  0x7C, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xDE, 0x00, 0x1F,
  0x9F, 0x00, 0x1F, 0x1F, 0x00, 0x1E, 0x1F, 0x00, 0x3E, 0x0F, 0x00, 0x3E,
  0x0F, 0x80, 0x3C, 0x0F, 0x80, 0x3C, 0x0F, 0x80, 0x3C, 0x07, 0x80, 0x7C,
  0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x07, 0xC0, 0x78, 0x03, 0xC0, 0xF8,
  0x03, 0xE0, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x01,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00,
  0x78, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x3C, 0x7F, 0x83,
  0xFE, 0x03, 0xCF, 0xFC, 0x7F, 0xE0, 0x3D, 0xFF, 0xCF, 0xFF, 0x03, 0xF8,
  0x3F, 0xE1, 0xF0, 0x3F, 0x03, 0xF8, 0x1F, 0x07, 0xE0, 0x3F, 0x01, 0xF0,
  0x7E, 0x03, 0xF0, 0x1F, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x7C, 0x03, 0xE0,
  0x1F, 0x07, 0x80, 0x3E, 0x01, 0xE0, 0xF8, 0x03, 0xC0, 0x1E, 0x0F, 0x80,
  0x3C, 0x01, 0xE0, 0xF0, 0x07, 0xC0, 0x3E, 0x0F, 0x00, 0x7C, 0x03, 0xE0,
  0xF0, 0x07, 0x80, 0x3C, 0x1F, 0x00, 0x78, 0x03, 0xC1, 0xF0, 0x0F, 0x80,
  0x3C, 0x1E, 0x00, 0xF8, 0x07, 0xC1, 0xE0, 0x0F, 0x00, 0x7C, 0x3E, 0x00,
  0xF0, 0x07, 0x83, 0xE0, 0x0F, 0x00, 0x78, 0x3C, 0x01, 0xF0, 0x07, 0x83,
  0xC0, 0x1F, 0x00, 0xF8, 0x3C, 0x01, 0xE0, 0x0F, 0x87, 0xC0, 0x1E, 0x00,
  0xF0, 0x7C, 0x01, 0xE0, 0x0F, 0x07, 0x80, 0x3E, 0x01, 0xF0, 0x78, 0x03,
  0xE0, 0x1F, 0x0F, 0x80, 0x3C, 0x01, 0xE0, 0x01, 0xC1, 0xF0, 0x07, 0x8F,
  0xF8, 0x0F, 0x3F, 0xF8, 0x1E, 0xFF, 0xF0, 0x3F, 0xC3, 0xE0, 0x7E, 0x03,
  0xC1, 0xFC, 0x07, 0x83, 0xF0, 0x0F, 0x07, 0xC0, 0x1E, 0x0F, 0x80, 0x7C,
  0x3E, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xE1, 0xE0, 0x07, 0x83,
  0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF0, 0x78,
  0x01, 0xE0, 0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x80,
  0x3C, 0x1E, 0x00, 0x78, 0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x07,
  0x83, 0xC0, 0x0F, 0x07, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0x3F,
  0x00, 0x07, 0xFE, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0xE0, 0x7C, 0x1F, 0x07,
  0xC0, 0x7C, 0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x3E, 0x00, 0x79, 0xF0, 0x03,
  0xCF, 0x00, 0x1E, 0xF8, 0x00, 0xF7, 0x80, 0x07, 0xBC, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xF7, 0x80, 0x07, 0xBC, 0x00, 0x7D,
  0xE0, 0x03, 0xEF, 0x00, 0x1E, 0x78, 0x01, 0xF3, 0xC0, 0x0F, 0x1F, 0x00,
  0xF8, 0xF8, 0x0F, 0x87, 0xE0, 0xFC, 0x1F, 0x8F, 0xC0, 0xFF, 0xFC, 0x03,
  0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x3C, 0x7F, 0xC0, 0x0F, 0x3F, 0xF0, 0x03, 0xDF, 0xFE, 0x00, 0xFF, 0x0F,
  0x80, 0x3F, 0x81, 0xF0, 0x1F, 0xC0, 0x7C, 0x07, 0xE0, 0x1F, 0x01, 0xF0,
  0x07, 0xC0, 0x7C, 0x01, 0xF0, 0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x03,
  0xE0, 0x07, 0xC0, 0xF0, 0x01, 0xF0, 0x3C, 0x00, 0x78, 0x0F, 0x00, 0x1E,
  0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x03, 0xE0, 0x78, 0x00, 0xF8, 0x1E, 0x00,
  0x3C, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x07, 0x80, 0xF8, 0x03, 0xE0, 0x3E,
  0x00, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xF0, 0x3E, 0x01, 0xEF, 0x3F, 0x80,
  0x7B, 0xFF, 0xC0, 0x1E, 0x7F, 0xE0, 0x07, 0x8F, 0xE0, 0x03, 0xE0, 0xC0,
  0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFE, 0x3C, 0x0F, 0xFE,
  0x78, 0x3F, 0xFE, 0xF0, 0x7E, 0x1F, 0xC1, 0xF0, 0x1F, 0x87, 0xC0, 0x3F,
  0x0F, 0x80, 0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF0, 0xF0, 0x03, 0xE3,
  0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x00, 0x1F, 0x1E, 0x00, 0x3C, 0x7C,
  0x00, 0x78, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xC0, 0x07, 0x87, 0x80,
  0x1F, 0x0F, 0x00, 0x3E, 0x1E, 0x00, 0xFC, 0x3C, 0x01, 0xF8, 0x78, 0x07,
  0xE0, 0xF8, 0x0F, 0xC1, 0xF0, 0x3F, 0x83, 0xF9, 0xFF, 0x03, 0xFF, 0xBE,
  0x07, 0xFE, 0x78, 0x03, 0xF8, 0xF0, 0x00, 0x83, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x78,
  0xFC, 0x0F, 0x3F, 0x81, 0xEF, 0xF0, 0x3F, 0xF4, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x3F,
  0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0xF8, 0x0C, 0x1E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x10, 0x07, 0xC3, 0xC3, 0xF8,
  0x7F, 0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x80, 0x00, 0x01, 0xE0,
  0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x0F, 0xFF,
  0x7F, 0xFD, 0xFF, 0xF0, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF8, 0x83, 0xFE, 0x07, 0xF8, 0x1F,
  0xE0, 0x04, 0x00, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x78, 0x3C, 0x00, 0xF0,
  0x78, 0x01, 0xE1, 0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x87, 0xC0, 0x1E, 0x0F,
  0x00, 0x3C, 0x1E, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xC1, 0xE0,
  0x07, 0x83, 0xC0, 0x0F, 0x07, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x00,
  0xF0, 0x78, 0x01, 0xE0, 0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x87, 0xC0, 0x1F,
  0x0F, 0x80, 0x7C, 0x1E, 0x00, 0xF8, 0x3C, 0x03, 0xF0, 0x7C, 0x0F, 0xE0,
  0xF8, 0x3F, 0xC1, 0xF9, 0xFF, 0x03, 0xFF, 0xDE, 0x03, 0xFF, 0x3C, 0x03,
  0xF8, 0x78, 0x00, 0x80, 0x00, 0x00, 0xF8, 0x01, 0xFF, 0x80, 0x1E, 0xF8,
  0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x07, 0x8F,
  0x80, 0xF8, 0xF8, 0x0F, 0x07, 0x81, 0xF0, 0x78, 0x1E, 0x07, 0x83, 0xE0,
  0x78, 0x3C, 0x07, 0x87, 0xC0, 0x78, 0x78, 0x07, 0x8F, 0x80, 0x78, 0xF0,
  0x07, 0x8F, 0x00, 0x79, 0xE0, 0x07, 0x9E, 0x00, 0x7B, 0xE0, 0x07, 0xBC,
  0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0xF8,
  0x07, 0xE0, 0x1F, 0xF8, 0x07, 0xE0, 0x1E, 0xF8, 0x0F, 0xE0, 0x3E, 0xF8,
  0x0F, 0xE0, 0x3C, 0xF8, 0x1F, 0xE0, 0x7C, 0xF8, 0x1F, 0xE0, 0x78, 0xF8,
  0x3D, 0xE0, 0x78, 0xF8, 0x3D, 0xE0, 0xF8, 0xF8, 0x39, 0xE0, 0xF0, 0xF8,
  0x79, 0xE1, 0xF0, 0xF8, 0x79, 0xE1, 0xE0, 0xF8, 0xF1, 0xE1, 0xE0, 0xF8,
  0xF1, 0xE3, 0xC0, 0xF8, 0xE1, 0xE3, 0xC0, 0xF1, 0xE1, 0xE7, 0xC0, 0xF1,
  0xE1, 0xE7, 0x80, 0xF3, 0xC1, 0xE7, 0x80, 0xF3, 0xC1, 0xEF, 0x00, 0xF3,
  0x81, 0xEF, 0x00, 0xF7, 0x81, 0xDF, 0x00, 0xF7, 0x81, 0xDE, 0x00, 0xFF,
  0x01, 0xDE, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0xFE,
  0x01, 0xF8, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0xFC,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0xF0, 0x0F, 0x80, 0x7C, 0x0F,
  0x80, 0x3E, 0x07, 0x80, 0x0F, 0x07, 0xC0, 0x07, 0x87, 0xC0, 0x03, 0xC3,
  0xC0, 0x01, 0xF3, 0xE0, 0x00, 0x7B, 0xE0, 0x00, 0x3D, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7B, 0xC0, 0x00, 0x7D, 0xF0, 0x00, 0x7C, 0x78, 0x00, 0x3C, 0x3C, 0x00,
  0x3E, 0x1E, 0x00, 0x3E, 0x0F, 0x80, 0x1E, 0x03, 0xC0, 0x1F, 0x01, 0xE0,
  0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x0F, 0x80, 0x1E, 0x00, 0x00, 0xF8,
  0x00, 0xF8, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x07,
  0xC0, 0x07, 0x80, 0x3C, 0x00, 0x3C, 0x03, 0xE0, 0x01, 0xE0, 0x1E, 0x00,
  0x0F, 0x01, 0xF0, 0x00, 0x78, 0x0F, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0xF0, 0x7C, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x3C, 0x1E,
  0x00, 0x01, 0xE1, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x78, 0xF8, 0x00,
  0x03, 0xC7, 0x80, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x03,
  0x9E, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0x7F, 0xFE, 0x04, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0x78, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00,
  0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x00, 0x07,
  0xF0, 0x01, 0xFF, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0x00,
  0x05, 0xFF, 0x80, 0x3F, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFE,
  0x00, 0xFF, 0xE8, 0x00, 0x7E, 0x00,
};

const GFXglyph NotoSans_Condensed_Italic55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 13, 40, 13, 1, -39 },
  { 66, 15, 14, 19, 6, -39 },
  { 93, 28, 39, 27, 0, -39 },
  { 230, 23, 45, 24, 1, -42 },
  { 360, 32, 41, 37, 3, -40 },
  { 524, 27, 41, 28, 0, -40 },
  { 663, 7, 14, 11, 6, -39 },
  { 676, 17, 48, 15, 1, -39 },
  { 778, 17, 48, 15, -4, -39 },
  { 880, 20, 21, 23, 5, -42 },
  { 933, 22, 26, 26, 3, -32 },
  { 1005, 10, 13, 12, -2, -6 },
  { 1022, 13, 4, 15, 1, -17 },
  { 1029, 6, 7, 12, 1, -6 },
  { 1035, 26, 39, 19, -3, -39 },
  { 1162, 22, 41, 24, 2, -40 },
  { 1275, 15, 39, 24, 6, -39 },
  { 1349, 25, 40, 24, -1, -40 },
  { 1474, 24, 41, 24, 0, -40 },
  { 1597, 25, 39, 24, -1, -39 },
  { 1719, 24, 40, 24, 0, -39 },
  { 1839, 23, 41, 24, 2, -40 },
  { 1957, 23, 39, 24, 3, -39 },
  { 2070, 24, 41, 24, 0, -40 },
  { 2193, 22, 41, 24, 1, -40 },
  { 2306, 11, 31, 12, 0, -30 },
  { 2349, 15, 37, 12, -3, -30 },
  { 2419, 22, 25, 26, 3, -32 },
  { 2488, 22, 15, 26, 3, -27 },
  { 2530, 22, 25, 26, 3, -32 },
  { 2599, 18, 41, 18, 2, -40 },
  { 2692, 34, 44, 37, 2, -39 },
  { 2879, 25, 39, 25, -3, -39 },
  { 3001, 26, 39, 26, 1, -39 },
  { 3128, 25, 41, 25, 3, -40 },
  { 3257, 27, 39, 29, 1, -39 },
  { 3389, 24, 39, 23, 1, -39 },
  { 3506, 24, 39, 21, 1, -39 },
  { 3623, 28, 41, 30, 3, -40 },
  { 3767, 30, 39, 30, 1, -39 },
  { 3914, 21, 39, 15, -2, -39 },
  { 4017, 22, 50, 12, -8, -39 },
  { 4155, 28, 39, 25, 1, -39 },
  { 4292, 16, 39, 21, 1, -39 },
  { 4370, 39, 39, 39, 1, -39 },
  { 4561, 31, 39, 31, 1, -39 },
  { 4713, 27, 41, 31, 3, -40 },
  { 4852, 25, 39, 25, 1, -39 },
  { 4974, 27, 49, 31, 3, -40 },
  { 5140, 25, 39, 26, 1, -39 },
  { 5262, 25, 41, 23, -1, -40 },
  { 5391, 21, 39, 22, 5, -39 },
  { 5494, 28, 40, 29, 3, -39 },
  { 5634, 24, 39, 25, 5, -39 },
  { 5751, 39, 39, 39, 5, -39 },
  { 5942, 30, 39, 23, -3, -39 },
  { 6089, 22, 39, 22, 5, -39 },
  { 6197, 27, 39, 22, -2, -39 },
  { 6329, 21, 48, 16, -1, -39 },
  { 6455, 9, 39, 19, 6, -39 },
  { 6499, 21, 48, 16, -4, -39 },
  { 6625, 23, 22, 25, 1, -39 },
  { 6689, 19, 3, 18, -5, 5 },
  { 6697, 8, 9, 14, 8, -42 },
  { 6706, 23, 31, 26, 2, -30 },
  { 6796, 24, 43, 26, 0, -42 },
  { 6925, 19, 31, 20, 2, -30 },
  { 6999, 26, 43, 26, 2, -42 },
  { 7139, 20, 31, 23, 2, -30 },
  { 7217, 28, 55, 14, -7, -42 },
  { 7410, 25, 43, 26, 0, -30 },
  { 7545, 23, 42, 25, 0, -42 },
  { 7666, 13, 41, 12, 0, -41 },
  { 7733, 20, 54, 12, -7, -41 },
  { 7868, 24, 42, 22, 0, -42 },
  { 7994, 14, 42, 12, 0, -42 },
  { 8068, 36, 30, 38, 0, -30 },
  { 8203, 23, 30, 25, 0, -30 },
  { 8290, 21, 31, 25, 2, -30 },
  { 8372, 26, 43, 26, -2, -30 },
  { 8512, 23, 43, 26, 2, -30 },
  { 8636, 19, 30, 17, 0, -30 },
  { 8708, 19, 31, 19, 0, -30 },
  { 8782, 14, 37, 15, 2, -36 },
  { 8847, 23, 30, 25, 2, -29 },
  { 8934, 20, 29, 21, 3, -29 },
  { 9007, 32, 29, 33, 3, -29 },
  { 9123, 25, 29, 21, -2, -29 },
  { 9214, 29, 42, 21, -5, -29 },
  { 9367, 21, 29, 18, -2, -29 },
  { 9444, 21, 48, 18, 1, -39 },
  { 9570, 4, 55, 23, 10, -42 },
  { 9598, 20, 48, 18, -3, -39 },
  { 9718, 22, 7, 26, 3, -23 },
};

const GFXfont NotoSans_Condensed_Italic55pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Italic55pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Italic55pt7bGlyphs,
  0x20, 0x7E, 75
};

#endif // _NOTOSANS_CONDENSED_ITALIC55PT7B_H_
