#ifndef _NOTOSANS_CONDENSED_ITALIC34PT7B_H_
#define _NOTOSANS_CONDENSED_ITALIC34PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Italic.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Italic34pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x83, 0x81, 0xC0, 0xE0, 0x70, 0x70, 0x38, 0x1C, 0x0E, 0x06,
  0x07, 0x03, 0x81, 0xC0, 0xC0, 0x60, 0x30, 0x38, 0x00, 0x00, 0x00, 0x07,
  0x03, 0x83, 0xC0, 0xE0, 0x39, 0xCC, 0x77, 0x19, 0xC6, 0x73, 0x98, 0xE6,
  0x31, 0x8C, 0xC3, 0x00, 0x00, 0xE3, 0x00, 0x61, 0x80, 0x31, 0xC0, 0x38,
  0xC0, 0x18, 0x60, 0x0C, 0x70, 0x0E, 0x30, 0x3F, 0xFF, 0x1F, 0xFF, 0x83,
  0x8C, 0x01, 0x86, 0x00, 0xC3, 0x00, 0x63, 0x00, 0x61, 0x80, 0x30, 0xC1,
  0xFF, 0xFC, 0xFF, 0xFE, 0x0C, 0x30, 0x06, 0x38, 0x07, 0x18, 0x03, 0x0C,
  0x01, 0x86, 0x00, 0xC6, 0x00, 0xC3, 0x00, 0x00, 0x30, 0x00, 0x40, 0x01,
  0x80, 0x0F, 0xC0, 0x7F, 0xE1, 0xEB, 0x83, 0x91, 0x0E, 0x60, 0x1C, 0xC0,
  0x39, 0x80, 0x72, 0x00, 0x74, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x78, 0x00,
  0xB8, 0x03, 0x38, 0x06, 0x70, 0x0C, 0xE0, 0x11, 0xC8, 0x23, 0x1C, 0xDE,
  0x3F, 0xF8, 0x3F, 0xE0, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x04, 0x00, 0x03, 0xE0, 0x38, 0xEE, 0x06, 0x18, 0xC1, 0x87, 0x18, 0x70,
  0xC3, 0x0C, 0x18, 0x63, 0x87, 0x1C, 0x60, 0xC3, 0x98, 0x18, 0x67, 0x03,
  0x0C, 0xC7, 0x63, 0xBB, 0xFC, 0x66, 0x67, 0xFD, 0x98, 0xDF, 0x73, 0x18,
  0x8C, 0xC3, 0x03, 0x98, 0x60, 0x63, 0x0C, 0x18, 0x61, 0x83, 0x1C, 0x70,
  0xC3, 0x8C, 0x38, 0x71, 0x86, 0x0E, 0x61, 0xC0, 0xFC, 0x70, 0x1F, 0x00,
  0x00, 0x60, 0x01, 0xF8, 0x03, 0xFC, 0x07, 0x1C, 0x07, 0x1C, 0x06, 0x1C,
  0x06, 0x1C, 0x06, 0x18, 0x06, 0x38, 0x07, 0x70, 0x07, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x1F, 0xC0, 0x3D, 0xC7, 0x39, 0xC7, 0x70, 0xE6, 0x60, 0xEE,
  0xE0, 0x7C, 0xE0, 0x7C, 0xE0, 0x38, 0xE0, 0x78, 0x71, 0xFC, 0x7F, 0xDC,
  0x3F, 0x0E, 0x76, 0xEE, 0xEC, 0xCC, 0xC0, 0x01, 0xC0, 0xE0, 0x30, 0x1C,
  0x0E, 0x03, 0x01, 0xC0, 0x60, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0x70, 0x18,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x06, 0x01, 0x80, 0x70, 0x00, 0x01, 0x80, 0x38, 0x03,
  0x00, 0x60, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x30, 0x06, 0x01, 0xC0, 0x38, 0x06, 0x01, 0xC0,
  0x38, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x03, 0x80, 0x60, 0x18, 0x0F, 0x00,
  0x03, 0x80, 0x30, 0x03, 0x06, 0x30, 0x7B, 0x0F, 0xFF, 0x0F, 0xF0, 0xF0,
  0x1F, 0x03, 0x98, 0x71, 0x82, 0x1C, 0x01, 0x00, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x1F, 0xFF, 0xFF, 0xF8, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x38,
  0x71, 0xC3, 0x86, 0x1C, 0x70, 0xFF, 0xFE, 0x77, 0xF7, 0x00, 0x07, 0x00,
  0x06, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03,
  0x80, 0x03, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x0F,
  0xC0, 0x7F, 0x83, 0x8E, 0x0E, 0x1C, 0x70, 0x71, 0x81, 0xCE, 0x07, 0x38,
  0x1D, 0xC0, 0x77, 0x01, 0x9C, 0x06, 0x70, 0x39, 0x80, 0xEE, 0x03, 0xB8,
  0x0E, 0xE0, 0x73, 0x81, 0xCE, 0x07, 0x38, 0x38, 0xE0, 0xE3, 0x87, 0x07,
  0x3C, 0x1F, 0xE0, 0x3E, 0x00, 0x07, 0x87, 0xC7, 0xC7, 0xEF, 0x77, 0x39,
  0x1C, 0x0C, 0x0E, 0x07, 0x03, 0x81, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x18,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0x81, 0xC0, 0xE0, 0x00, 0x30, 0x01, 0xFC,
  0x07, 0xFE, 0x07, 0x0E, 0x02, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x7F, 0xF8, 0x7F, 0xF8, 0xFF, 0xF0, 0x00, 0xE0,
  0x0F, 0xF0, 0x3F, 0xF0, 0x60, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x06, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xE0, 0x3F, 0x00, 0x78, 0x01, 0xFC,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80,
  0x07, 0x10, 0x1E, 0x30, 0x78, 0x7F, 0xE0, 0xFF, 0x80, 0x00, 0x1E, 0x00,
  0x78, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1B, 0x80, 0x66, 0x01, 0xDC,
  0x03, 0x38, 0x0C, 0x70, 0x38, 0xE0, 0xE1, 0x81, 0x87, 0x07, 0x0E, 0x1C,
  0x1C, 0x30, 0x30, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xF0, 0x07, 0x00, 0x0C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x07, 0xFE, 0x0F, 0xFC, 0x1C, 0x00,
  0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x3F,
  0x80, 0x7F, 0xC0, 0xEF, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x88, 0x0F, 0x18, 0x3C, 0x3F,
  0xF0, 0x7F, 0xC0, 0x00, 0x38, 0x03, 0xF0, 0x3F, 0xC1, 0xE0, 0x0E, 0x00,
  0x38, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x3E, 0x1F, 0xFC,
  0x7C, 0x71, 0xE1, 0xC7, 0x03, 0xB8, 0x0E, 0xE0, 0x3B, 0x80, 0xCE, 0x07,
  0x38, 0x1C, 0xE0, 0x71, 0x83, 0x87, 0x1C, 0x1F, 0xF0, 0x3F, 0x00, 0x3F,
  0xFD, 0xFF, 0xF0, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00,
  0x38, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00,
  0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01,
  0xC0, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x60, 0x07, 0xF8, 0x1F, 0xF0, 0x78,
  0x70, 0xE0, 0xE1, 0xC1, 0xC3, 0x03, 0x86, 0x07, 0x0E, 0x1C, 0x1C, 0x38,
  0x1D, 0xE0, 0x3F, 0x00, 0x7C, 0x01, 0xFC, 0x07, 0x1C, 0x1C, 0x38, 0x70,
  0x38, 0xC0, 0x73, 0x80, 0xE7, 0x01, 0xCE, 0x03, 0x9E, 0x0E, 0x1C, 0x3C,
  0x3F, 0xF0, 0x1F, 0xC0, 0x00, 0xE0, 0x07, 0xF0, 0x1F, 0xF0, 0x78, 0xE0,
  0xE1, 0xC3, 0x81, 0x87, 0x03, 0x8C, 0x07, 0x38, 0x0C, 0x70, 0x38, 0xE0,
  0x71, 0xC0, 0xE3, 0x83, 0xC3, 0xDF, 0x87, 0xF7, 0x07, 0xCC, 0x00, 0x38,
  0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x20, 0xF0, 0x7F,
  0xC0, 0xFE, 0x00, 0x0E, 0x3C, 0x78, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x78, 0xF1, 0xC0, 0x03, 0x83, 0xC1, 0xE0, 0x60,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x38, 0x1C, 0x1C, 0x0E, 0x06, 0x07, 0x07, 0x00, 0x00, 0x08, 0x01, 0xC0,
  0x1E, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x1E, 0x00, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x60, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x80, 0x06, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x78, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0x78, 0x03, 0x00, 0x10, 0x00, 0x03, 0x01, 0xFC, 0x3F, 0xE3, 0x0E, 0x00,
  0x70, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xFF,
  0x00, 0xF0, 0x1C, 0x0E, 0x00, 0x60, 0xE0, 0x03, 0x86, 0x00, 0x0C, 0x60,
  0x78, 0x63, 0x0F, 0xE3, 0x30, 0xE7, 0x19, 0x8E, 0x30, 0xD8, 0x61, 0x86,
  0xC7, 0x0C, 0x36, 0x30, 0xE3, 0xB1, 0x86, 0x1B, 0x8C, 0x30, 0xDC, 0xE3,
  0x8E, 0xC7, 0x1C, 0x66, 0x39, 0xE7, 0x30, 0xFB, 0xF1, 0x87, 0x8F, 0x0E,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x0C,
  0x00, 0xFF, 0xE0, 0x01, 0xF8, 0x00, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0,
  0x03, 0xE0, 0x06, 0xE0, 0x1D, 0xC0, 0x33, 0x80, 0xE7, 0x01, 0xCE, 0x07,
  0x1C, 0x0E, 0x38, 0x18, 0x70, 0x70, 0xE0, 0xE1, 0xC3, 0xFF, 0x87, 0xFF,
  0x1C, 0x0E, 0x38, 0x1C, 0xE0, 0x39, 0xC0, 0x77, 0x80, 0xEE, 0x01, 0xDC,
  0x03, 0xF0, 0x07, 0x07, 0xFC, 0x07, 0xFE, 0x07, 0x0F, 0x07, 0x07, 0x06,
  0x07, 0x0E, 0x07, 0x0E, 0x07, 0x0E, 0x07, 0x0E, 0x0E, 0x1C, 0x1E, 0x1F,
  0xF8, 0x1F, 0xF0, 0x1F, 0xF8, 0x18, 0x1C, 0x38, 0x1C, 0x38, 0x0E, 0x38,
  0x0E, 0x38, 0x1C, 0x30, 0x1C, 0x70, 0x1C, 0x70, 0x38, 0x71, 0xF8, 0x7F,
  0xF0, 0xFF, 0xC0, 0x00, 0x30, 0x03, 0xFC, 0x1F, 0xF8, 0x78, 0x21, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x10, 0x3F, 0xE0,
  0x1F, 0xC0, 0x07, 0xFC, 0x03, 0xFF, 0x01, 0xC7, 0xC0, 0xE0, 0xE0, 0x60,
  0x38, 0x70, 0x1C, 0x38, 0x0E, 0x1C, 0x07, 0x0E, 0x03, 0x8E, 0x01, 0xC7,
  0x00, 0xE3, 0x80, 0x71, 0xC0, 0x38, 0xC0, 0x38, 0xE0, 0x1C, 0x70, 0x0E,
  0x38, 0x0E, 0x1C, 0x07, 0x0C, 0x07, 0x0E, 0x07, 0x87, 0x07, 0x83, 0xFF,
  0x81, 0xFF, 0x81, 0xFE, 0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x1C, 0x00, 0x38,
  0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00,
  0x7F, 0xE0, 0xFF, 0x81, 0xFF, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0F, 0xFC, 0x1F, 0xF8,
  0x7F, 0xE0, 0x07, 0xFE, 0x0F, 0xFC, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xFF,
  0xC1, 0xFF, 0x03, 0xFE, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x00,
  0x30, 0x00, 0xFF, 0x81, 0xFF, 0xE1, 0xF0, 0x61, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00,
  0x0E, 0x07, 0xE7, 0x03, 0xF3, 0x83, 0xF9, 0xC0, 0x1C, 0xE0, 0x0C, 0x70,
  0x0E, 0x38, 0x07, 0x1C, 0x03, 0x8E, 0x01, 0xC7, 0x81, 0xC1, 0xE0, 0xE0,
  0x7F, 0xF0, 0x1F, 0xF0, 0x00, 0x07, 0x00, 0xE0, 0xE0, 0x1C, 0x1C, 0x03,
  0x03, 0x80, 0xE0, 0x60, 0x1C, 0x1C, 0x03, 0x83, 0x80, 0x70, 0x70, 0x0C,
  0x0E, 0x03, 0x83, 0x80, 0x70, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF0,
  0x30, 0x0E, 0x0E, 0x01, 0xC1, 0xC0, 0x38, 0x38, 0x06, 0x07, 0x01, 0xC0,
  0xC0, 0x38, 0x38, 0x07, 0x07, 0x00, 0xE0, 0xE0, 0x18, 0x1C, 0x07, 0x07,
  0x00, 0xE0, 0x07, 0xF8, 0x7F, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x1C, 0x0F, 0xE0, 0x7E, 0x00, 0x80, 0x00, 0x07, 0x03, 0xC1, 0xC0,
  0xE0, 0x70, 0x70, 0x1C, 0x38, 0x06, 0x1C, 0x03, 0x8F, 0x00, 0xE3, 0x80,
  0x39, 0xC0, 0x0E, 0xE0, 0x07, 0x78, 0x01, 0xDC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0xB0, 0x03, 0x8E, 0x00, 0xE3, 0x80, 0x38, 0xE0, 0x0E, 0x1C,
  0x03, 0x07, 0x01, 0xC1, 0xC0, 0x70, 0x70, 0x1C, 0x0E, 0x07, 0x03, 0x83,
  0x80, 0xE0, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xFF, 0xDF, 0xFF, 0xFE, 0x07,
  0xC0, 0x0F, 0x83, 0xE0, 0x0F, 0x81, 0xF0, 0x07, 0xC0, 0xF8, 0x07, 0xE0,
  0x7C, 0x03, 0xF0, 0x7E, 0x03, 0xB0, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0xDC,
  0x0C, 0xC0, 0xEE, 0x0E, 0x60, 0x66, 0x07, 0x30, 0x77, 0x03, 0x98, 0x33,
  0x81, 0xCC, 0x39, 0xC0, 0xC6, 0x18, 0xE0, 0xE3, 0x1C, 0x60, 0x71, 0x8C,
  0x70, 0x38, 0xEE, 0x38, 0x18, 0x76, 0x1C, 0x0C, 0x3F, 0x0E, 0x0E, 0x1F,
  0x06, 0x07, 0x0F, 0x87, 0x03, 0x87, 0x83, 0x81, 0x83, 0xC1, 0xC1, 0xC1,
  0xC0, 0xE0, 0x07, 0x80, 0x70, 0x78, 0x07, 0x07, 0x80, 0x60, 0x7C, 0x0E,
  0x07, 0xC0, 0xE0, 0xFC, 0x0E, 0x0E, 0xC0, 0xE0, 0xEE, 0x0C, 0x0C, 0xE1,
  0xC1, 0xCE, 0x1C, 0x1C, 0x61, 0xC1, 0xC6, 0x1C, 0x1C, 0x71, 0x81, 0x87,
  0x38, 0x38, 0x33, 0x83, 0x83, 0x38, 0x38, 0x3B, 0x03, 0x03, 0xB0, 0x30,
  0x3F, 0x07, 0x01, 0xF0, 0x70, 0x1F, 0x07, 0x01, 0xE0, 0x60, 0x1E, 0x0E,
  0x00, 0xE0, 0x00, 0x60, 0x01, 0xFE, 0x01, 0xFF, 0x81, 0xE1, 0xE1, 0xE0,
  0x70, 0xE0, 0x38, 0xE0, 0x1C, 0x70, 0x06, 0x70, 0x03, 0xB8, 0x01, 0x9C,
  0x01, 0xDC, 0x00, 0xEE, 0x00, 0x77, 0x00, 0x3B, 0x80, 0x1D, 0xC0, 0x1C,
  0xE0, 0x0E, 0x70, 0x07, 0x38, 0x07, 0x1C, 0x03, 0x8E, 0x03, 0x87, 0x03,
  0xC1, 0xE3, 0xC0, 0xFF, 0xC0, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x07, 0xFE,
  0x07, 0x1E, 0x07, 0x0F, 0x06, 0x07, 0x0E, 0x07, 0x0E, 0x07, 0x0E, 0x07,
  0x0E, 0x0E, 0x1C, 0x0E, 0x1C, 0x1E, 0x1C, 0x3C, 0x1F, 0xF8, 0x1F, 0xE0,
  0x3E, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x01, 0xFE,
  0x01, 0xFF, 0x81, 0xE1, 0xE1, 0xE0, 0x70, 0xE0, 0x38, 0xE0, 0x1C, 0x70,
  0x06, 0x70, 0x03, 0xB8, 0x01, 0x9C, 0x01, 0xDC, 0x00, 0xEE, 0x00, 0x77,
  0x00, 0x3B, 0x80, 0x1D, 0xC0, 0x1C, 0xE0, 0x0E, 0x70, 0x07, 0x38, 0x07,
  0x1C, 0x03, 0x8E, 0x03, 0x87, 0x03, 0xC1, 0xE3, 0xC0, 0xFF, 0xC0, 0x3F,
  0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00,
  0x03, 0xC0, 0x07, 0xF8, 0x07, 0xFE, 0x07, 0x1E, 0x07, 0x0F, 0x06, 0x07,
  0x0E, 0x07, 0x0E, 0x07, 0x0E, 0x07, 0x0E, 0x0E, 0x1C, 0x0E, 0x1C, 0x1C,
  0x1F, 0xFC, 0x1F, 0xF0, 0x1F, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x38, 0xE0,
  0x38, 0x70, 0x30, 0x70, 0x70, 0x70, 0x70, 0x70, 0x70, 0x38, 0x70, 0x38,
  0xE0, 0x38, 0x00, 0x60, 0x07, 0xFC, 0x1F, 0xF8, 0x78, 0x61, 0xE0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x10, 0x1E, 0x38, 0xF8, 0x7F, 0xE0, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xC1, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30,
  0x03, 0x80, 0x1C, 0x00, 0x1C, 0x03, 0x8E, 0x01, 0xC7, 0x01, 0xC3, 0x00,
  0xE3, 0x80, 0x71, 0xC0, 0x38, 0xE0, 0x18, 0x70, 0x1C, 0x70, 0x0E, 0x38,
  0x07, 0x1C, 0x03, 0x8E, 0x01, 0x86, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0x71,
  0xC0, 0x30, 0xE0, 0x38, 0x60, 0x1C, 0x30, 0x0E, 0x1C, 0x0E, 0x0E, 0x07,
  0x07, 0x8F, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0xE0, 0x0F, 0xC0, 0x3B, 0x80,
  0x77, 0x01, 0xCE, 0x03, 0x9C, 0x06, 0x38, 0x1C, 0x70, 0x38, 0xE0, 0xE1,
  0xC1, 0xC3, 0x87, 0x07, 0x0E, 0x0E, 0x38, 0x1C, 0x70, 0x18, 0xC0, 0x33,
  0x80, 0x66, 0x00, 0xDC, 0x01, 0xB8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00,
  0x1E, 0x00, 0x38, 0x00, 0xE0, 0x38, 0x07, 0xE0, 0x38, 0x0E, 0xE0, 0x38,
  0x0E, 0xE0, 0x78, 0x0C, 0xE0, 0x78, 0x1C, 0xE0, 0xF8, 0x1C, 0xE0, 0xD8,
  0x38, 0xE0, 0xD8, 0x38, 0xE1, 0xD8, 0x30, 0xE1, 0x98, 0x70, 0xE3, 0x98,
  0x70, 0xE3, 0x18, 0xE0, 0xE7, 0x18, 0xE0, 0xE7, 0x18, 0xC0, 0xE6, 0x19,
  0xC0, 0xEE, 0x19, 0xC0, 0xEC, 0x1B, 0x80, 0xFC, 0x1B, 0x80, 0xF8, 0x1B,
  0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x1E, 0x00, 0xF0, 0x1E, 0x00, 0xF0, 0x1E,
  0x00, 0xE0, 0x1C, 0x00, 0x03, 0x81, 0xE0, 0x70, 0x38, 0x0E, 0x0E, 0x01,
  0xC3, 0x80, 0x18, 0x70, 0x03, 0x9C, 0x00, 0x73, 0x00, 0x0E, 0xE0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0xFC, 0x00, 0x3B, 0x80, 0x07, 0x30, 0x01, 0xC7, 0x00, 0x30,
  0xE0, 0x0E, 0x1C, 0x03, 0x83, 0x80, 0x70, 0x70, 0x1C, 0x07, 0x07, 0x00,
  0xE0, 0xE0, 0x3F, 0x80, 0xEE, 0x07, 0x18, 0x18, 0x60, 0xE1, 0xC7, 0x07,
  0x1C, 0x1C, 0xE0, 0x73, 0x81, 0xDC, 0x03, 0x60, 0x0F, 0x80, 0x3C, 0x00,
  0xF0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0x07, 0xFF, 0x07, 0xFF, 0x00,
  0x0F, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0x7F, 0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0xE0,
  0x06, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x03,
  0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xC0,
  0x06, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03,
  0x80, 0x18, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0xE1, 0x86, 0x1C, 0x71, 0xC7,
  0x0C, 0x30, 0xC3, 0x0E, 0x38, 0xE3, 0x86, 0x18, 0x61, 0xC7, 0x1C, 0x71,
  0xC3, 0x03, 0xF8, 0x1F, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x06, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x81, 0xFC, 0x0F, 0xC0,
  0x00, 0x01, 0x80, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x06, 0xE0, 0x39, 0x81,
  0xC6, 0x06, 0x1C, 0x38, 0x30, 0xC0, 0xE7, 0x03, 0x98, 0x06, 0xE0, 0x1C,
  0xFF, 0xFF, 0xFE, 0xE3, 0x9C, 0x63, 0x80, 0x01, 0x00, 0x0F, 0x9C, 0x3F,
  0xB0, 0xE1, 0xE3, 0xC3, 0xC7, 0x03, 0x9C, 0x0E, 0x38, 0x1C, 0x70, 0x38,
  0xC0, 0x73, 0x80, 0xE7, 0x01, 0x8E, 0x07, 0x1C, 0x0E, 0x38, 0x3C, 0x70,
  0x78, 0xF1, 0xE0, 0xFE, 0xC0, 0xF9, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x10, 0x0E, 0xFC,
  0x1B, 0xF8, 0x3C, 0x78, 0xF0, 0x71, 0xE0, 0xE3, 0x81, 0xC7, 0x03, 0x9C,
  0x07, 0x38, 0x0C, 0x70, 0x38, 0xE0, 0x71, 0x80, 0xE7, 0x03, 0x8E, 0x07,
  0x1E, 0x1C, 0x3C, 0x78, 0x6F, 0xE1, 0xCF, 0x80, 0x00, 0xC0, 0x7F, 0x0F,
  0xE1, 0xC2, 0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x87, 0xF8, 0x3F,
  0x80, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00,
  0x0E, 0x00, 0x0E, 0x01, 0x8E, 0x07, 0xCC, 0x0F, 0xEC, 0x1C, 0x3C, 0x38,
  0x3C, 0x38, 0x1C, 0x70, 0x38, 0x70, 0x38, 0x70, 0x38, 0x60, 0x38, 0xE0,
  0x38, 0xE0, 0x70, 0xE0, 0x70, 0xE0, 0x70, 0xE0, 0xF0, 0xE1, 0xE0, 0xF3,
  0xE0, 0x7F, 0x60, 0x3E, 0x60, 0x00, 0x80, 0x7E, 0x0F, 0xF1, 0xC7, 0x38,
  0x33, 0x83, 0x70, 0x77, 0x0F, 0x67, 0xEF, 0xFC, 0xFE, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x47, 0xFC, 0x3F, 0x80, 0x00, 0x0F,
  0x80, 0x0F, 0x80, 0x0E, 0x40, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0x80, 0x01, 0xC0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x38, 0x00, 0x18, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x80, 0x03, 0xF7, 0x07, 0xF6, 0x0E, 0x1E, 0x1C, 0x1E, 0x1C, 0x1E, 0x38,
  0x1C, 0x38, 0x1C, 0x38, 0x1C, 0x30, 0x1C, 0x70, 0x1C, 0x70, 0x38, 0x70,
  0x38, 0x70, 0x38, 0x70, 0x78, 0x70, 0xF8, 0x79, 0xF0, 0x3F, 0xF0, 0x1F,
  0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x81, 0xC0, 0xC3,
  0xC0, 0xFF, 0x80, 0x7E, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x88, 0x0E, 0xFC, 0x37, 0xF0, 0xF1,
  0xC7, 0x83, 0x1C, 0x0C, 0x70, 0x71, 0xC1, 0xCE, 0x07, 0x38, 0x1C, 0xE0,
  0x63, 0x83, 0x8C, 0x0E, 0x70, 0x39, 0xC0, 0xE7, 0x03, 0x1C, 0x1C, 0x60,
  0x73, 0x81, 0xC0, 0x03, 0x07, 0x07, 0x06, 0x00, 0x00, 0x00, 0x0E, 0x0E,
  0x0C, 0x1C, 0x1C, 0x1C, 0x18, 0x38, 0x38, 0x38, 0x38, 0x30, 0x70, 0x70,
  0x70, 0x70, 0x60, 0xE0, 0x00, 0x30, 0x07, 0x00, 0x70, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x18, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x1C, 0x01,
  0xC0, 0xBC, 0x0F, 0x80, 0xF0, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x1E, 0x1C,
  0x38, 0x30, 0xE0, 0xE3, 0x81, 0xCE, 0x03, 0xB8, 0x06, 0xE0, 0x1D, 0xC0,
  0x3F, 0x80, 0x7B, 0x00, 0xE7, 0x01, 0x8E, 0x07, 0x1C, 0x0E, 0x18, 0x1C,
  0x38, 0x38, 0x70, 0x60, 0xE1, 0xC0, 0xE0, 0x03, 0x83, 0x81, 0xC0, 0xE0,
  0x70, 0x30, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x03, 0x81, 0xC0, 0xE0, 0x60,
  0x70, 0x38, 0x1C, 0x0E, 0x06, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x60, 0x70,
  0x00, 0x00, 0x30, 0x20, 0x33, 0xE3, 0xE0, 0xDF, 0xDF, 0xC3, 0xC7, 0xC7,
  0x1E, 0x1E, 0x1C, 0x70, 0x70, 0x71, 0xC1, 0xC1, 0xC7, 0x07, 0x07, 0x38,
  0x18, 0x1C, 0xE0, 0x60, 0x63, 0x83, 0x83, 0x8E, 0x0E, 0x0E, 0x30, 0x38,
  0x39, 0xC0, 0xC0, 0xE7, 0x07, 0x03, 0x1C, 0x1C, 0x1C, 0x70, 0x70, 0x71,
  0x81, 0xC1, 0xCE, 0x06, 0x06, 0x00, 0x00, 0x20, 0x33, 0xF0, 0xDF, 0xC3,
  0xC7, 0x1E, 0x0C, 0x70, 0x31, 0xC1, 0xC7, 0x07, 0x38, 0x1C, 0xE0, 0x73,
  0x81, 0x8E, 0x0E, 0x30, 0x39, 0xC0, 0xE7, 0x03, 0x9C, 0x1C, 0x70, 0x71,
  0x81, 0xCE, 0x07, 0x00, 0x00, 0x80, 0x3F, 0x03, 0xFC, 0x38, 0x73, 0x83,
  0x9C, 0x1D, 0xC0, 0x6E, 0x07, 0x70, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x07, 0x70, 0x3B, 0x81, 0xDC, 0x1C, 0x71, 0xC3, 0xFE, 0x0F, 0xC0, 0x00,
  0x08, 0x06, 0x7E, 0x06, 0xFE, 0x07, 0x8F, 0x0F, 0x07, 0x0F, 0x07, 0x0E,
  0x07, 0x0E, 0x07, 0x0C, 0x07, 0x1C, 0x06, 0x1C, 0x0E, 0x1C, 0x0E, 0x18,
  0x0E, 0x38, 0x1C, 0x38, 0x1C, 0x3C, 0x38, 0x3C, 0x78, 0x37, 0xF0, 0x73,
  0xE0, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x0F, 0xDC, 0x3F, 0xB0, 0xE1,
  0xE3, 0x83, 0xC7, 0x07, 0x9C, 0x0E, 0x38, 0x1C, 0x70, 0x38, 0xC0, 0x73,
  0x80, 0xE7, 0x03, 0x8E, 0x07, 0x1C, 0x0E, 0x38, 0x3C, 0x70, 0xF8, 0xF3,
  0xE0, 0xFF, 0xC0, 0xFB, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x00, 0x20, 0xCF, 0x0D,
  0xF0, 0xF8, 0x1E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x30, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0xE0,
  0x00, 0x01, 0x80, 0xFF, 0x1F, 0xF3, 0xC2, 0x38, 0x03, 0x80, 0x38, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x83, 0x8F, 0xF8, 0xFE, 0x00, 0x06, 0x06, 0x03, 0x03, 0x87, 0xFB,
  0xFC, 0x60, 0x70, 0x38, 0x1C, 0x0C, 0x06, 0x07, 0x03, 0x81, 0xC0, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0F, 0xC3, 0xE0, 0x1C, 0x1C, 0x60, 0x73, 0x81,
  0xCE, 0x07, 0x38, 0x18, 0xE0, 0xE3, 0x03, 0x9C, 0x0E, 0x70, 0x31, 0xC1,
  0xC7, 0x07, 0x18, 0x1C, 0xE0, 0x73, 0x83, 0x8E, 0x1E, 0x38, 0xF8, 0x7F,
  0xE1, 0xF3, 0x80, 0xE0, 0x7E, 0x07, 0xE0, 0xEE, 0x0E, 0xE1, 0xCE, 0x1C,
  0xE1, 0x8E, 0x38, 0xE3, 0x0E, 0x70, 0xE6, 0x0E, 0xE0, 0xEE, 0x07, 0xC0,
  0x7C, 0x07, 0x80, 0x78, 0x07, 0x00, 0xE0, 0xE0, 0x7E, 0x0E, 0x0E, 0xE1,
  0xE0, 0xEE, 0x1E, 0x0C, 0xE3, 0xE1, 0xCE, 0x36, 0x18, 0xE3, 0x63, 0x8E,
  0x66, 0x38, 0xE6, 0x63, 0x0E, 0xE6, 0x70, 0xEC, 0x66, 0x0E, 0xC6, 0xE0,
  0xF8, 0x6E, 0x0D, 0x86, 0xC0, 0xF8, 0x7C, 0x0F, 0x07, 0x80, 0xF0, 0x78,
  0x0E, 0x07, 0x00, 0x0E, 0x0E, 0x1C, 0x38, 0x38, 0xE0, 0x31, 0xC0, 0x77,
  0x00, 0xEC, 0x01, 0xF8, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1F, 0x00,
  0x7E, 0x01, 0xDC, 0x03, 0x18, 0x0E, 0x38, 0x38, 0x70, 0x70, 0xE1, 0xC0,
  0xE0, 0x07, 0x03, 0xC1, 0xC0, 0xE0, 0x70, 0x70, 0x1C, 0x1C, 0x07, 0x06,
  0x01, 0xC3, 0x80, 0x70, 0xC0, 0x1C, 0x70, 0x03, 0x18, 0x00, 0xCE, 0x00,
  0x33, 0x80, 0x0D, 0xC0, 0x03, 0x70, 0x00, 0xD8, 0x00, 0x3E, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x02, 0x70, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0xF8, 0x7F, 0xC0, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x38, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x0E, 0x00, 0xFF, 0xC7, 0xFC, 0x00, 0x00, 0xF0, 0x1F, 0x03, 0xC0, 0x38,
  0x03, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0,
  0x1C, 0x0F, 0x80, 0xE0, 0x0F, 0x80, 0x38, 0x01, 0x80, 0x18, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x30, 0x03, 0x00, 0x70, 0x07, 0x00, 0x78, 0x03, 0xC0,
  0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x03, 0xC0, 0x1F, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0x7C, 0x01, 0xC0, 0x3E, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x01, 0xF8,
  0x0F, 0x00, 0x00, 0x7C, 0x0F, 0xF8, 0xF1, 0xFF, 0x03, 0xE0,
};

const GFXglyph NotoSans_Condensed_Italic34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 9, 24, 8, 0, -24 },
  { 28, 10, 9, 12, 3, -24 },
  { 40, 17, 24, 17, 0, -24 },
  { 91, 15, 28, 15, 0, -26 },
  { 144, 19, 25, 23, 2, -25 },
  { 204, 16, 25, 17, 0, -25 },
  { 254, 4, 9, 7, 4, -24 },
  { 259, 10, 29, 9, 1, -24 },
  { 296, 11, 29, 9, -3, -24 },
  { 336, 12, 13, 14, 3, -26 },
  { 356, 13, 16, 16, 2, -20 },
  { 382, 7, 8, 7, -2, -4 },
  { 389, 8, 2, 9, 1, -10 },
  { 391, 4, 4, 7, 0, -4 },
  { 393, 16, 24, 12, -2, -24 },
  { 441, 14, 25, 15, 1, -25 },
  { 485, 9, 24, 15, 4, -24 },
  { 512, 16, 25, 15, -1, -25 },
  { 562, 15, 25, 15, 0, -25 },
  { 609, 15, 24, 15, 0, -24 },
  { 654, 15, 24, 15, 0, -24 },
  { 699, 14, 25, 15, 1, -25 },
  { 743, 14, 24, 15, 2, -24 },
  { 785, 15, 25, 15, 0, -25 },
  { 832, 15, 25, 15, 0, -25 },
  { 879, 7, 18, 7, 0, -18 },
  { 895, 9, 22, 7, -2, -18 },
  { 920, 13, 16, 16, 2, -20 },
  { 946, 13, 10, 16, 2, -17 },
  { 963, 13, 16, 16, 2, -20 },
  { 989, 12, 25, 11, 1, -25 },
  { 1027, 21, 27, 23, 1, -24 },
  { 1098, 15, 24, 15, -2, -24 },
  { 1143, 16, 24, 16, 0, -24 },
  { 1191, 15, 25, 15, 2, -25 },
  { 1238, 17, 24, 18, 0, -24 },
  { 1289, 15, 24, 14, 0, -24 },
  { 1334, 15, 24, 13, 0, -24 },
  { 1379, 17, 25, 19, 2, -25 },
  { 1433, 19, 24, 18, 0, -24 },
  { 1490, 13, 24, 9, -1, -24 },
  { 1529, 13, 31, 8, -5, -24 },
  { 1580, 18, 24, 15, 0, -24 },
  { 1634, 11, 24, 13, 0, -24 },
  { 1667, 25, 24, 24, 0, -24 },
  { 1742, 20, 24, 19, 0, -24 },
  { 1802, 17, 25, 19, 2, -25 },
  { 1856, 16, 24, 15, 0, -24 },
  { 1904, 17, 31, 19, 2, -25 },
  { 1970, 16, 24, 16, 0, -24 },
  { 2018, 15, 25, 14, 0, -25 },
  { 2065, 13, 24, 13, 3, -24 },
  { 2104, 17, 24, 18, 2, -24 },
  { 2155, 15, 24, 15, 3, -24 },
  { 2200, 24, 24, 24, 3, -24 },
  { 2272, 19, 24, 14, -2, -24 },
  { 2329, 14, 24, 14, 3, -24 },
  { 2371, 16, 24, 13, -1, -24 },
  { 2419, 13, 29, 10, -1, -24 },
  { 2467, 6, 24, 12, 3, -24 },
  { 2485, 13, 29, 10, -2, -24 },
  { 2533, 14, 13, 15, 1, -24 },
  { 2556, 12, 2, 11, -3, 3 },
  { 2559, 5, 5, 9, 5, -26 },
  { 2563, 15, 19, 16, 1, -19 },
  { 2599, 15, 26, 16, 0, -26 },
  { 2648, 12, 19, 12, 1, -19 },
  { 2677, 16, 26, 16, 1, -26 },
  { 2729, 12, 19, 14, 1, -19 },
  { 2758, 17, 34, 9, -4, -26 },
  { 2831, 16, 27, 16, 0, -19 },
  { 2885, 14, 26, 16, 0, -26 },
  { 2931, 8, 25, 7, 0, -25 },
  { 2956, 12, 33, 7, -4, -25 },
  { 3006, 15, 26, 14, 0, -26 },
  { 3055, 9, 26, 7, 0, -26 },
  { 3085, 22, 19, 24, 0, -19 },
  { 3138, 14, 19, 16, 0, -19 },
  { 3172, 13, 19, 15, 1, -19 },
  { 3203, 16, 27, 16, -1, -19 },
  { 3257, 15, 27, 16, 1, -19 },
  { 3308, 12, 19, 11, 0, -19 },
  { 3337, 12, 19, 12, 0, -19 },
  { 3366, 9, 22, 9, 1, -22 },
  { 3391, 14, 18, 16, 1, -18 },
  { 3423, 12, 18, 13, 2, -18 },
  { 3450, 20, 18, 20, 2, -18 },
  { 3495, 15, 18, 13, -1, -18 },
  { 3529, 18, 26, 13, -3, -18 },
  { 3588, 13, 18, 11, -1, -18 },
  { 3618, 12, 29, 11, 1, -24 },
  { 3662, 3, 34, 14, 6, -26 },
  { 3675, 13, 29, 11, -2, -24 },
  { 3723, 13, 4, 16, 2, -14 },
};

const GFXfont NotoSans_Condensed_Italic34pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Italic34pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Italic34pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _NOTOSANS_CONDENSED_ITALIC34PT7B_H_
