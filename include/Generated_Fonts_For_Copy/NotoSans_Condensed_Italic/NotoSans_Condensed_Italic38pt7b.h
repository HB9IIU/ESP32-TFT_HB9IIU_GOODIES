#ifndef _NOTOSANS_CONDENSED_ITALIC38PT7B_H_
#define _NOTOSANS_CONDENSED_ITALIC38PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Italic.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Italic38pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xC0, 0xE0, 0x38, 0x1E, 0x07, 0x81, 0xC0, 0x70, 0x1C, 0x07,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x01, 0xC0, 0x70, 0x1C, 0x06, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x78, 0x3E, 0x07, 0x00, 0x79,
  0xEE, 0x39, 0xC7, 0x38, 0xE6, 0x19, 0xC7, 0x38, 0xE7, 0x1C, 0xC3, 0x18,
  0x60, 0x00, 0x70, 0xC0, 0x0C, 0x38, 0x01, 0x87, 0x00, 0x70, 0xC0, 0x0E,
  0x38, 0x01, 0x87, 0x00, 0x70, 0xC0, 0x0E, 0x18, 0x1F, 0xFF, 0xE3, 0xFF,
  0xFC, 0x0E, 0x18, 0x01, 0x87, 0x00, 0x30, 0xC0, 0x0E, 0x18, 0x01, 0x87,
  0x00, 0x30, 0xE0, 0x7F, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFE, 0x0E, 0x18,
  0x01, 0xC3, 0x00, 0x30, 0xE0, 0x06, 0x18, 0x01, 0xC3, 0x00, 0x30, 0xE0,
  0x06, 0x18, 0x01, 0xC3, 0x00, 0x00, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04,
  0x00, 0x0F, 0x00, 0x1F, 0xF8, 0x3F, 0xF8, 0x3C, 0xCC, 0x1C, 0x40, 0x0E,
  0x60, 0x06, 0x30, 0x03, 0x18, 0x01, 0xCC, 0x00, 0xFC, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0xDE, 0x00, 0x67, 0x00, 0x33,
  0x80, 0x19, 0xC0, 0x08, 0xE0, 0x0C, 0x70, 0x86, 0x70, 0xFF, 0xF8, 0x7F,
  0xF8, 0x0F, 0xF0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00,
  0x02, 0x00, 0x00, 0x3E, 0x01, 0xC1, 0xFC, 0x06, 0x0E, 0x30, 0x38, 0x38,
  0xC0, 0xC0, 0xC3, 0x07, 0x07, 0x0C, 0x38, 0x18, 0x30, 0xC0, 0x61, 0xC7,
  0x03, 0x87, 0x18, 0x0E, 0x1C, 0xE0, 0x38, 0x67, 0x08, 0xE3, 0x98, 0xFB,
  0x8C, 0xE7, 0xFE, 0x73, 0x39, 0xDF, 0x9D, 0xC7, 0x7C, 0xE7, 0x1C, 0x43,
  0x98, 0x70, 0x1C, 0xE1, 0xC0, 0x63, 0x87, 0x03, 0x8E, 0x18, 0x0C, 0x30,
  0x60, 0x70, 0xC3, 0x83, 0x83, 0x0C, 0x0C, 0x0C, 0x70, 0x70, 0x39, 0x81,
  0x80, 0xFE, 0x0E, 0x01, 0xF0, 0x00, 0x10, 0x00, 0x3F, 0x00, 0x1F, 0xE0,
  0x0F, 0x38, 0x03, 0x87, 0x00, 0xC1, 0xC0, 0x70, 0x60, 0x1C, 0x38, 0x07,
  0x0E, 0x01, 0xC7, 0x00, 0x3B, 0x80, 0x0F, 0xE0, 0x03, 0xE0, 0x00, 0xF0,
  0x00, 0xFC, 0x00, 0x7B, 0x87, 0x3C, 0xE1, 0xCE, 0x3C, 0x77, 0x07, 0x39,
  0xC1, 0xFE, 0xF0, 0x3F, 0x38, 0x0F, 0x8E, 0x01, 0xE3, 0x80, 0xF0, 0xF0,
  0x7E, 0x1E, 0x7F, 0x87, 0xFE, 0xF0, 0xFE, 0x1E, 0x7B, 0x9C, 0xE7, 0x33,
  0x9C, 0xE6, 0x00, 0x00, 0xF0, 0x1C, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x70,
  0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x60, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0x60, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01,
  0xC0, 0x1C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x1C,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x1C, 0x00, 0xC0,
  0x86, 0x0E, 0x30, 0x7D, 0x9C, 0xFF, 0xE0, 0xFF, 0x0F, 0x01, 0xFC, 0x1E,
  0x60, 0xE3, 0x82, 0x1E, 0x00, 0x40, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x3C, 0x70, 0xE3, 0x87, 0x1C, 0x38, 0xE0,
  0xFF, 0xFF, 0xBF, 0xC0, 0xFF, 0xFE, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x78, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x20, 0x03, 0xF8, 0x0F,
  0xF0, 0x3C, 0xF0, 0xF0, 0xE1, 0xC1, 0xC7, 0x83, 0x8E, 0x07, 0x1C, 0x0E,
  0x70, 0x1C, 0xE0, 0x39, 0xC0, 0x77, 0x80, 0xEE, 0x01, 0xDC, 0x03, 0xB8,
  0x0F, 0x70, 0x1D, 0xE0, 0x3B, 0x80, 0x77, 0x01, 0xEE, 0x03, 0x9C, 0x07,
  0x38, 0x1C, 0x70, 0x78, 0x70, 0xE0, 0xF7, 0xC1, 0xFF, 0x01, 0xF8, 0x00,
  0x01, 0xC0, 0xF0, 0xFC, 0x7F, 0x3F, 0xFE, 0xE6, 0x39, 0x0E, 0x03, 0x81,
  0xC0, 0x70, 0x1C, 0x07, 0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x81, 0xE0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0x00, 0x10,
  0x00, 0x7F, 0x00, 0xFF, 0xC0, 0xF8, 0xF0, 0x30, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x38, 0x00, 0x3F, 0xFE, 0x3F, 0xFF, 0x1F, 0xFF, 0x80, 0x00, 0x20,
  0x03, 0xFC, 0x0F, 0xFE, 0x07, 0x0F, 0x04, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0xF8,
  0x07, 0xF0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x80, 0x78,
  0xF3, 0xF0, 0xFF, 0xE0, 0xFF, 0x80, 0x00, 0x07, 0x80, 0x07, 0x80, 0x07,
  0xC0, 0x07, 0xE0, 0x03, 0x70, 0x03, 0xF0, 0x03, 0xB8, 0x01, 0x9C, 0x01,
  0xCE, 0x01, 0xCF, 0x00, 0xC7, 0x00, 0xE3, 0x80, 0xE1, 0xC0, 0x60, 0xE0,
  0x70, 0xE0, 0x70, 0x70, 0x70, 0x38, 0x38, 0x1C, 0x3F, 0xFF, 0xDF, 0xFF,
  0xCF, 0xFF, 0xE0, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xC0, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x07, 0x70, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x43, 0xE0, 0x00, 0x70,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01,
  0xC0, 0x01, 0xE0, 0x00, 0xE1, 0x00, 0xF0, 0xF1, 0xF0, 0x7F, 0xF0, 0x1F,
  0xE0, 0x00, 0x00, 0x04, 0x00, 0x7F, 0x00, 0xFF, 0x03, 0xE1, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x39, 0xF0, 0x3B, 0xF8, 0x77, 0xFC, 0x7C, 0x3C, 0x78, 0x1C, 0x70, 0x1C,
  0x70, 0x1C, 0xF0, 0x1C, 0xF0, 0x1C, 0xE0, 0x1C, 0xE0, 0x3C, 0xE0, 0x38,
  0x70, 0x78, 0x70, 0x70, 0x7D, 0xF0, 0x3F, 0xE0, 0x1F, 0x80, 0x3F, 0xFF,
  0x3F, 0xFF, 0x3F, 0xFE, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0,
  0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xF0, 0x00, 0xE0, 0x00, 0x00, 0x10, 0x00, 0xFF, 0x00, 0xFF, 0xC0, 0xF1,
  0xE0, 0x70, 0x78, 0x70, 0x1C, 0x38, 0x0E, 0x1C, 0x07, 0x0E, 0x07, 0x07,
  0x03, 0x81, 0xC3, 0x80, 0xF3, 0x80, 0x3F, 0x80, 0x0F, 0x80, 0x1F, 0xC0,
  0x1E, 0xF0, 0x1C, 0x38, 0x1C, 0x0E, 0x1C, 0x07, 0x0E, 0x03, 0x8F, 0x01,
  0xE7, 0x00, 0xF3, 0x80, 0x71, 0xE0, 0x38, 0x70, 0x3C, 0x3E, 0x3C, 0x0F,
  0xFC, 0x03, 0xFC, 0x00, 0x00, 0x20, 0x01, 0xFC, 0x03, 0xFE, 0x07, 0x8E,
  0x0F, 0x07, 0x0E, 0x07, 0x1E, 0x07, 0x1C, 0x07, 0x1C, 0x07, 0x1C, 0x07,
  0x3C, 0x07, 0x3C, 0x07, 0x3C, 0x0F, 0x1C, 0x1F, 0x1C, 0x1F, 0x1F, 0xFE,
  0x0F, 0xEE, 0x07, 0x8E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x78, 0x00, 0x70, 0x00, 0xE0, 0xC7, 0xC0, 0xFF, 0x80, 0xFF, 0x00,
  0x02, 0x0F, 0x0F, 0x0F, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0xF8, 0xF0, 0xF0, 0x00, 0x80, 0xF0,
  0x3C, 0x0F, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x81, 0xC0, 0x70, 0x38, 0x0E,
  0x03, 0x01, 0xC0, 0x60, 0x38, 0x00, 0x00, 0x06, 0x00, 0x1C, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x00, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07,
  0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80,
  0x01, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1E, 0x00, 0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x3E, 0x00, 0x70, 0x00, 0x80, 0x00, 0x01, 0x00, 0x7F, 0x0F, 0xFC,
  0x38, 0xF1, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80,
  0x38, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x01, 0xC0, 0x1C, 0x00, 0xC0,
  0x0E, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xF8, 0x00,
  0xF0, 0x3C, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x0E, 0x07, 0x00, 0x06, 0x0E,
  0x00, 0x06, 0x1C, 0x0F, 0x87, 0x18, 0x3F, 0xC7, 0x38, 0x79, 0xC7, 0x38,
  0x61, 0x87, 0x30, 0xE1, 0x87, 0x70, 0xC3, 0x86, 0x71, 0xC3, 0x86, 0x61,
  0x83, 0x06, 0x61, 0x83, 0x0E, 0xE3, 0x87, 0x0C, 0xE3, 0x87, 0x0C, 0xE3,
  0x8F, 0x1C, 0xE3, 0x8F, 0x18, 0xE3, 0xFB, 0x70, 0xE1, 0xF3, 0xE0, 0xE0,
  0xE1, 0xC0, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x06, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xB8,
  0x01, 0xDC, 0x01, 0xCE, 0x00, 0xE7, 0x00, 0x73, 0x80, 0x71, 0xC0, 0x38,
  0xE0, 0x38, 0x70, 0x1C, 0x38, 0x1E, 0x1C, 0x0E, 0x0E, 0x0F, 0xFF, 0x07,
  0xFF, 0x87, 0x81, 0xE3, 0x80, 0xF1, 0xC0, 0x79, 0xE0, 0x3C, 0xE0, 0x0E,
  0xF0, 0x07, 0x70, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xE0, 0x03, 0xFE, 0x00,
  0xFF, 0xE0, 0x3F, 0xFC, 0x1E, 0x0F, 0x07, 0x01, 0xC1, 0xC0, 0x70, 0x70,
  0x1C, 0x1C, 0x07, 0x0F, 0x03, 0xC3, 0x80, 0xE0, 0xE0, 0x78, 0x3F, 0xFC,
  0x0F, 0xFC, 0x07, 0xFF, 0x01, 0xC1, 0xE0, 0x70, 0x3C, 0x1C, 0x07, 0x0F,
  0x01, 0xC3, 0x80, 0x70, 0xE0, 0x1C, 0x38, 0x07, 0x0E, 0x03, 0xC7, 0x80,
  0xE1, 0xC0, 0xF8, 0x7F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFE, 0x00, 0x00, 0x08,
  0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0xFC, 0x60, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x3F, 0x78, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x03, 0xC1, 0xE0, 0x70, 0x1E, 0x0E, 0x03,
  0xC1, 0xC0, 0x38, 0x38, 0x07, 0x0F, 0x00, 0xE1, 0xC0, 0x1C, 0x38, 0x03,
  0x87, 0x00, 0x70, 0xE0, 0x0E, 0x38, 0x03, 0xC7, 0x00, 0x78, 0xE0, 0x0E,
  0x1C, 0x01, 0xC7, 0x80, 0x78, 0xE0, 0x0E, 0x1C, 0x03, 0xC3, 0x80, 0x70,
  0x70, 0x1E, 0x1E, 0x07, 0x83, 0x83, 0xE0, 0x7F, 0xF8, 0x0F, 0xFC, 0x03,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0xF0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xE0, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0xF0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x38, 0x00, 0x1C,
  0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01,
  0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0x81, 0xF1, 0xF0, 0x78, 0x04, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x0F, 0xE7, 0x01,
  0xFC, 0xE0, 0x03, 0x9C, 0x00, 0xE3, 0x80, 0x1C, 0x70, 0x03, 0x8E, 0x00,
  0x71, 0xC0, 0x1E, 0x3C, 0x03, 0x87, 0x80, 0x70, 0x78, 0x0E, 0x0F, 0xEF,
  0xC0, 0xFF, 0xF8, 0x07, 0xFC, 0x00, 0x03, 0x80, 0x38, 0x1C, 0x01, 0xC0,
  0xE0, 0x0E, 0x0F, 0x00, 0xE0, 0x70, 0x07, 0x03, 0x80, 0x38, 0x1C, 0x01,
  0xC0, 0xE0, 0x1E, 0x0F, 0x00, 0xE0, 0x70, 0x07, 0x03, 0x80, 0x38, 0x1F,
  0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x70, 0x07, 0x03, 0x80, 0x38,
  0x1C, 0x01, 0xC1, 0xE0, 0x1C, 0x0E, 0x00, 0xE0, 0x70, 0x07, 0x03, 0x80,
  0x38, 0x1C, 0x03, 0xC1, 0xE0, 0x1C, 0x0E, 0x00, 0xE0, 0x70, 0x07, 0x03,
  0x80, 0x38, 0x3C, 0x03, 0xC0, 0x03, 0xFE, 0x07, 0xFC, 0x01, 0xC0, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1E,
  0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x3F, 0x80, 0x7E, 0x01, 0xF8, 0x00,
  0x03, 0x80, 0xF0, 0x38, 0x0E, 0x03, 0x81, 0xC0, 0x78, 0x3C, 0x07, 0x07,
  0x80, 0x70, 0xF0, 0x07, 0x0E, 0x00, 0x71, 0xC0, 0x0F, 0x3C, 0x00, 0xE7,
  0x80, 0x0E, 0xF0, 0x00, 0xEE, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F,
  0xE0, 0x01, 0xE7, 0x00, 0x1C, 0x70, 0x03, 0xC7, 0x00, 0x38, 0x78, 0x03,
  0x83, 0x80, 0x38, 0x38, 0x03, 0x83, 0x80, 0x78, 0x3C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xE0, 0xF0, 0x1E, 0x00, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x78, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x38,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x78, 0x07, 0x00, 0x7F, 0xF7, 0xFF, 0xFF,
  0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x83,
  0xF0, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x07,
  0x70, 0x3F, 0x00, 0xEE, 0x0E, 0xE0, 0x1B, 0xC1, 0xDC, 0x07, 0x70, 0x3B,
  0x80, 0xEE, 0x07, 0x30, 0x39, 0xC0, 0xE6, 0x07, 0x38, 0x38, 0xC1, 0xCF,
  0x07, 0x18, 0x39, 0xC0, 0xE3, 0x8E, 0x38, 0x1C, 0x71, 0xC7, 0x07, 0x0E,
  0x70, 0xE0, 0xE1, 0xCE, 0x3C, 0x1C, 0x3B, 0x87, 0x03, 0x87, 0x70, 0xE0,
  0x70, 0xFC, 0x1C, 0x1C, 0x1F, 0x87, 0x83, 0x83, 0xE0, 0xE0, 0x70, 0x7C,
  0x1C, 0x0E, 0x0F, 0x03, 0x83, 0xC1, 0xE0, 0x70, 0x00, 0x03, 0xC0, 0x1C,
  0x0F, 0x00, 0x70, 0x3C, 0x01, 0xC1, 0xF8, 0x07, 0x07, 0xE0, 0x38, 0x1F,
  0x80, 0xE0, 0x7E, 0x03, 0x81, 0x9C, 0x0E, 0x0E, 0x70, 0x78, 0x39, 0xC1,
  0xC0, 0xE7, 0x07, 0x03, 0x8C, 0x1C, 0x0E, 0x38, 0x70, 0x70, 0xE3, 0x81,
  0xC3, 0x8E, 0x07, 0x0E, 0x38, 0x1C, 0x1C, 0xE0, 0xE0, 0x73, 0x83, 0x81,
  0xDC, 0x0E, 0x07, 0x70, 0x38, 0x0F, 0xC0, 0xE0, 0x3F, 0x07, 0x00, 0xFC,
  0x1C, 0x03, 0xE0, 0x70, 0x07, 0x81, 0xC0, 0x1E, 0x0F, 0x00, 0x78, 0x00,
  0x00, 0x10, 0x00, 0x1F, 0xE0, 0x0F, 0xFE, 0x03, 0xE7, 0xC0, 0xF0, 0x3C,
  0x1C, 0x03, 0x87, 0x80, 0x71, 0xE0, 0x0F, 0x38, 0x01, 0xE7, 0x00, 0x3D,
  0xE0, 0x07, 0xB8, 0x00, 0xF7, 0x00, 0x1D, 0xE0, 0x03, 0xBC, 0x00, 0x77,
  0x00, 0x0E, 0xE0, 0x03, 0xDC, 0x00, 0x73, 0x80, 0x0E, 0x70, 0x03, 0xCE,
  0x00, 0x71, 0xC0, 0x1E, 0x38, 0x03, 0x87, 0x80, 0xF0, 0x70, 0x3C, 0x0F,
  0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xC0,
  0x3F, 0xF8, 0x1E, 0x1E, 0x07, 0x03, 0xC1, 0xC0, 0xF0, 0x70, 0x3C, 0x1C,
  0x0F, 0x0F, 0x03, 0x83, 0x80, 0xE0, 0xE0, 0x38, 0x38, 0x1E, 0x0E, 0x0F,
  0x07, 0x1F, 0x81, 0xFF, 0xC0, 0x7F, 0xC0, 0x1C, 0x00, 0x0F, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x10, 0x00, 0x1F,
  0xE0, 0x0F, 0xFE, 0x03, 0xE7, 0xC0, 0xF0, 0x3C, 0x1C, 0x03, 0x87, 0x80,
  0x71, 0xE0, 0x0F, 0x38, 0x01, 0xE7, 0x00, 0x3D, 0xE0, 0x07, 0xB8, 0x00,
  0xF7, 0x00, 0x1D, 0xE0, 0x03, 0xBC, 0x00, 0x77, 0x00, 0x0E, 0xE0, 0x03,
  0xDC, 0x00, 0x73, 0x80, 0x0E, 0x70, 0x03, 0xCE, 0x00, 0x71, 0xC0, 0x1E,
  0x38, 0x03, 0x87, 0x80, 0xF0, 0x70, 0x3C, 0x0F, 0xFF, 0x00, 0xFF, 0xC0,
  0x0F, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0x70, 0x00, 0x0F, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xF8,
  0x1E, 0x1E, 0x07, 0x03, 0xC1, 0xC0, 0xF0, 0x70, 0x3C, 0x1C, 0x0F, 0x0F,
  0x03, 0xC3, 0x80, 0xE0, 0xE0, 0x78, 0x38, 0x1C, 0x0E, 0x1F, 0x07, 0xFF,
  0x81, 0xFF, 0x80, 0x7F, 0xC0, 0x1C, 0x70, 0x0F, 0x1C, 0x03, 0x87, 0x80,
  0xE0, 0xE0, 0x38, 0x38, 0x0E, 0x0E, 0x07, 0x83, 0xC1, 0xC0, 0x70, 0x70,
  0x1C, 0x1C, 0x07, 0x0F, 0x01, 0xE0, 0x00, 0x10, 0x00, 0xFF, 0x80, 0xFF,
  0xE0, 0xF9, 0xE0, 0xF0, 0x10, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x80, 0xF8, 0x7F,
  0xF8, 0x3F, 0xF8, 0x1F, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1E,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0xE1,
  0xC0, 0x1C, 0x78, 0x07, 0x8E, 0x00, 0xE1, 0xC0, 0x1C, 0x38, 0x03, 0x87,
  0x00, 0x71, 0xE0, 0x1C, 0x38, 0x03, 0x87, 0x00, 0x70, 0xE0, 0x0E, 0x1C,
  0x03, 0xC7, 0x00, 0x70, 0xE0, 0x0E, 0x1C, 0x01, 0xC3, 0x80, 0x38, 0xF0,
  0x0F, 0x1C, 0x01, 0xC3, 0x80, 0x38, 0x70, 0x07, 0x0E, 0x01, 0xE1, 0xC0,
  0x38, 0x38, 0x0F, 0x07, 0x83, 0xC0, 0xFD, 0xF8, 0x0F, 0xFE, 0x00, 0xFF,
  0x00, 0x00, 0xF0, 0x03, 0xF8, 0x03, 0xFC, 0x01, 0xDE, 0x01, 0xE7, 0x00,
  0xE3, 0x80, 0xF1, 0xC0, 0x70, 0xE0, 0x78, 0x70, 0x38, 0x38, 0x1C, 0x1C,
  0x1C, 0x0E, 0x0E, 0x07, 0x0F, 0x03, 0x87, 0x01, 0xC7, 0x80, 0xE3, 0x80,
  0x71, 0xC0, 0x39, 0xC0, 0x1C, 0xE0, 0x0E, 0xE0, 0x07, 0x70, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x00,
  0x70, 0x0E, 0x00, 0xEE, 0x01, 0xC0, 0x3D, 0xC0, 0x78, 0x07, 0x78, 0x0F,
  0x01, 0xEF, 0x03, 0xE0, 0x39, 0xE0, 0x7C, 0x07, 0x3C, 0x0D, 0x81, 0xC7,
  0x83, 0xB0, 0x38, 0xF0, 0x76, 0x0F, 0x1E, 0x1C, 0xC1, 0xC3, 0xC3, 0x98,
  0x38, 0x78, 0x63, 0x0E, 0x0E, 0x1C, 0x61, 0xC1, 0xC3, 0x8C, 0x78, 0x38,
  0xE1, 0x8E, 0x07, 0x1C, 0x31, 0xC0, 0xE7, 0x06, 0x70, 0x1C, 0xE0, 0xCE,
  0x03, 0x98, 0x1B, 0xC0, 0x77, 0x07, 0x70, 0x0E, 0xE0, 0xEE, 0x01, 0xD8,
  0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x07, 0xC0, 0x7C, 0x00, 0xF8, 0x0F, 0x80,
  0x1F, 0x01, 0xF0, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x78, 0x1E,
  0x07, 0x80, 0x70, 0x38, 0x03, 0x83, 0x80, 0x1C, 0x1C, 0x00, 0xE1, 0xC0,
  0x03, 0x9E, 0x00, 0x1C, 0xE0, 0x00, 0xEE, 0x00, 0x07, 0x70, 0x00, 0x3F,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1D, 0xC0, 0x01, 0xC7, 0x00, 0x0E, 0x38,
  0x00, 0xE1, 0xC0, 0x0F, 0x0E, 0x00, 0x70, 0x70, 0x07, 0x03, 0xC0, 0x78,
  0x0E, 0x03, 0x80, 0x70, 0x3C, 0x03, 0x80, 0xF0, 0x0F, 0x70, 0x1E, 0x70,
  0x1C, 0x70, 0x3C, 0x70, 0x38, 0x70, 0x70, 0x70, 0x70, 0x78, 0xE0, 0x39,
  0xE0, 0x39, 0xC0, 0x3B, 0xC0, 0x3B, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x00, 0x1E, 0x00, 0x07,
  0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1C, 0x00,
  0x0F, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F,
  0xFF, 0x80, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x7F, 0x80, 0xFF, 0x00, 0xE3, 0x8E, 0x38, 0x61, 0x87, 0x1C, 0x71, 0xC7,
  0x1C, 0x30, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x18, 0x71, 0xC7, 0x1C, 0x71,
  0xC0, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x3F,
  0x80, 0xFF, 0x00, 0x00, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xF0, 0x03,
  0x70, 0x07, 0x70, 0x06, 0x38, 0x0E, 0x38, 0x1C, 0x38, 0x1C, 0x1C, 0x38,
  0x1C, 0x38, 0x0C, 0x70, 0x0E, 0x70, 0x0E, 0xE0, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xE7, 0x1C, 0xE3, 0x8C, 0x01, 0xC0, 0x07, 0xF3, 0x0F, 0xFF,
  0x0F, 0x1F, 0x1E, 0x0F, 0x3C, 0x0E, 0x38, 0x0E, 0x38, 0x0E, 0x70, 0x0E,
  0x70, 0x0E, 0x70, 0x1C, 0x70, 0x1C, 0xF0, 0x1C, 0xE0, 0x3C, 0xE0, 0x3C,
  0xE0, 0x38, 0xE0, 0x78, 0xF0, 0xF8, 0x79, 0xB8, 0x7F, 0xB0, 0x3E, 0x30,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x1C, 0x07, 0x3F, 0x03, 0xBF, 0xC1,
  0xF0, 0xE0, 0xF0, 0x70, 0x78, 0x3C, 0x78, 0x1E, 0x3C, 0x0F, 0x1C, 0x07,
  0x0E, 0x03, 0x87, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0xF1, 0xC0, 0x70, 0xE0,
  0x38, 0xF0, 0x3C, 0x78, 0x1C, 0x3C, 0x1E, 0x1F, 0x1E, 0x0D, 0xFE, 0x0E,
  0x7E, 0x00, 0x00, 0xF0, 0x1F, 0xC3, 0xFE, 0x1E, 0x11, 0xC0, 0x1E, 0x00,
  0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x30, 0xFF, 0x81, 0xFC,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x01, 0xC7, 0x01, 0xFD, 0xC0,
  0xFF, 0xF0, 0x3C, 0x7C, 0x1C, 0x0F, 0x0F, 0x03, 0x83, 0x80, 0xE0, 0xE0,
  0x38, 0x70, 0x0E, 0x1C, 0x07, 0x87, 0x01, 0xC3, 0xC0, 0x70, 0xF0, 0x1C,
  0x38, 0x0F, 0x0E, 0x03, 0xC3, 0x80, 0xE0, 0xE0, 0x78, 0x3C, 0x3E, 0x07,
  0x9B, 0x81, 0xFE, 0xC0, 0x3E, 0x30, 0x00, 0x00, 0xE0, 0x0F, 0xE0, 0xFF,
  0xC3, 0x87, 0x1C, 0x1C, 0xF0, 0x73, 0x81, 0xDE, 0x0E, 0x70, 0x79, 0xDF,
  0xC7, 0xFE, 0x3F, 0xC0, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xF0,
  0x01, 0xC0, 0x07, 0x86, 0x0F, 0xF8, 0x1F, 0xC0, 0x00, 0x03, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0xE0, 0x01, 0xFC, 0xC1, 0xFF, 0xE0, 0xF1, 0xF0,
  0xF0, 0x78, 0xF0, 0x38, 0x70, 0x1C, 0x38, 0x0E, 0x38, 0x07, 0x1C, 0x07,
  0x8E, 0x03, 0x87, 0x01, 0xC7, 0x80, 0xE3, 0x80, 0xF1, 0xC0, 0x78, 0xE0,
  0x78, 0x70, 0x3C, 0x3C, 0x3E, 0x0F, 0x37, 0x07, 0xFF, 0x01, 0xF3, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x20, 0x38,
  0x1F, 0xFC, 0x0F, 0xFC, 0x03, 0xF8, 0x00, 0x03, 0xC0, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x1C, 0x0E, 0x7E, 0x0E, 0xFF, 0x0F, 0x8F, 0x0F, 0x07, 0x0E, 0x07, 0x1E,
  0x07, 0x1C, 0x07, 0x1C, 0x0F, 0x1C, 0x0E, 0x1C, 0x0E, 0x38, 0x0E, 0x38,
  0x0E, 0x38, 0x1E, 0x38, 0x1C, 0x78, 0x1C, 0x70, 0x1C, 0x70, 0x1C, 0x70,
  0x38, 0x70, 0x38, 0xF0, 0x38, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x0E, 0x07, 0x03, 0x81, 0xC1, 0xE0, 0xE0, 0x70, 0x38, 0x1C, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38,
  0x0F, 0xE0, 0x3F, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x87, 0x83, 0x83, 0x83, 0x81, 0xC3, 0x80, 0xE3, 0xC0, 0x73, 0xC0,
  0x71, 0xC0, 0x39, 0xC0, 0x1D, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF8,
  0x03, 0xCE, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0xF1, 0xE0, 0x70, 0x70, 0x38,
  0x38, 0x1C, 0x1C, 0x0E, 0x0F, 0x0F, 0x03, 0x80, 0x03, 0xC0, 0xE0, 0x38,
  0x0E, 0x03, 0x81, 0xC0, 0x70, 0x1C, 0x07, 0x03, 0xC0, 0xE0, 0x38, 0x0E,
  0x03, 0x81, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x0E, 0x03,
  0x81, 0xE0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x1C, 0x0E,
  0x07, 0x3F, 0x1F, 0x83, 0xBF, 0x9F, 0xE1, 0xF1, 0xF8, 0xF0, 0xF0, 0x78,
  0x38, 0x70, 0x38, 0x1C, 0x78, 0x1C, 0x0E, 0x38, 0x1E, 0x0F, 0x1C, 0x0E,
  0x07, 0x0E, 0x07, 0x03, 0x87, 0x03, 0x81, 0xC7, 0x01, 0xC0, 0xE3, 0x81,
  0xC0, 0xE1, 0xC0, 0xE0, 0x70, 0xE0, 0x70, 0x38, 0xF0, 0x38, 0x1C, 0x70,
  0x3C, 0x0E, 0x38, 0x1C, 0x0E, 0x1C, 0x0E, 0x07, 0x0E, 0x07, 0x03, 0x8F,
  0x03, 0x81, 0xC0, 0x00, 0x18, 0x0E, 0x7E, 0x0E, 0xFF, 0x0F, 0x8F, 0x0F,
  0x07, 0x0E, 0x07, 0x1E, 0x07, 0x1E, 0x07, 0x1C, 0x0F, 0x1C, 0x0E, 0x3C,
  0x0E, 0x38, 0x0E, 0x38, 0x0E, 0x38, 0x1E, 0x38, 0x1C, 0x78, 0x1C, 0x70,
  0x1C, 0x70, 0x1C, 0x70, 0x38, 0x70, 0x38, 0xE0, 0x38, 0x00, 0xE0, 0x07,
  0xF0, 0x3F, 0xF0, 0x70, 0xE1, 0xC1, 0xE7, 0x81, 0xCE, 0x03, 0xBC, 0x07,
  0x70, 0x0E, 0xE0, 0x1D, 0xC0, 0x3F, 0x80, 0xFE, 0x01, 0xDC, 0x03, 0xB8,
  0x0F, 0x70, 0x1C, 0xE0, 0x78, 0xE0, 0xE1, 0xE7, 0x81, 0xFF, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0x00, 0x73, 0xF0, 0x0E, 0xFF, 0x01, 0xF0, 0xE0, 0x3C,
  0x1C, 0x07, 0x83, 0xC1, 0xE0, 0x78, 0x3C, 0x0F, 0x07, 0x01, 0xC0, 0xE0,
  0x38, 0x1C, 0x07, 0x07, 0x00, 0xE0, 0xE0, 0x1C, 0x1C, 0x07, 0x03, 0x80,
  0xE0, 0x70, 0x3C, 0x1E, 0x07, 0x03, 0xC1, 0xE0, 0x7C, 0x78, 0x0F, 0xFE,
  0x03, 0x9F, 0x80, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x07, 0xF3, 0x0F, 0xFF, 0x0F, 0x1F, 0x1C, 0x0F, 0x3C,
  0x0E, 0x38, 0x0E, 0x38, 0x0E, 0x70, 0x0E, 0x70, 0x1E, 0x70, 0x1C, 0x70,
  0x1C, 0xF0, 0x1C, 0xE0, 0x3C, 0xE0, 0x3C, 0xE0, 0x78, 0xE0, 0x78, 0xF0,
  0xF8, 0x79, 0xB8, 0x7F, 0xF0, 0x3E, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01,
  0xC0, 0x00, 0x18, 0x73, 0xC3, 0xBE, 0x1F, 0x90, 0xF0, 0x07, 0x80, 0x78,
  0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x7F, 0xC7, 0xFE, 0x38, 0x33, 0xC0, 0x1C, 0x00, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03,
  0x80, 0x1C, 0x00, 0xE4, 0x0F, 0x39, 0xF1, 0xFF, 0x8F, 0xF0, 0x00, 0x07,
  0x01, 0x80, 0x60, 0x38, 0x0E, 0x1F, 0xF7, 0xFC, 0x70, 0x1C, 0x07, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0xE0, 0x38, 0x0F, 0x21, 0xF8, 0x7E, 0x00, 0x1E, 0x07, 0x1C, 0x07, 0x1C,
  0x0F, 0x1C, 0x0E, 0x3C, 0x0E, 0x38, 0x0E, 0x38, 0x0E, 0x38, 0x1C, 0x38,
  0x1C, 0x78, 0x1C, 0x70, 0x1C, 0x70, 0x3C, 0x70, 0x38, 0x70, 0x38, 0xF0,
  0x78, 0xE0, 0x78, 0xF0, 0xF8, 0xF3, 0xB0, 0x7F, 0x70, 0x3E, 0x70, 0xE0,
  0x1F, 0x80, 0xEE, 0x03, 0xB8, 0x1C, 0xE0, 0x73, 0x83, 0x8E, 0x0E, 0x38,
  0x70, 0x61, 0xC1, 0x8F, 0x06, 0x38, 0x18, 0xE0, 0x67, 0x01, 0x9C, 0x07,
  0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xE0, 0x78,
  0x1F, 0x81, 0xE0, 0xFE, 0x0F, 0x83, 0xB8, 0x36, 0x0E, 0xE0, 0xD8, 0x73,
  0x87, 0xE1, 0xCE, 0x1B, 0x8F, 0x38, 0xEE, 0x38, 0xE3, 0xB8, 0xE3, 0x8C,
  0xE7, 0x0E, 0x73, 0x9C, 0x39, 0x8E, 0x60, 0xEE, 0x3B, 0x83, 0xB0, 0xEE,
  0x0E, 0xC3, 0xF0, 0x3F, 0x0F, 0xC0, 0xF8, 0x3E, 0x03, 0xE0, 0xF8, 0x0F,
  0x03, 0xC0, 0x3C, 0x0F, 0x00, 0x07, 0x03, 0xC1, 0xE1, 0xE0, 0x38, 0x70,
  0x0E, 0x38, 0x03, 0x9E, 0x00, 0x67, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xDC,
  0x00, 0xE7, 0x00, 0x78, 0xE0, 0x1C, 0x38, 0x0E, 0x0E, 0x07, 0x83, 0xC3,
  0xC0, 0x70, 0x03, 0x80, 0x70, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x1C,
  0x01, 0x81, 0xC0, 0x1C, 0x3C, 0x01, 0xC3, 0x80, 0x1C, 0x38, 0x01, 0xC7,
  0x00, 0x1C, 0x70, 0x01, 0xCE, 0x00, 0x1C, 0xE0, 0x01, 0xDC, 0x00, 0x1D,
  0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x70,
  0x03, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xC0,
  0x0E, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xFF, 0x8F, 0xFE,
  0x3F, 0xF0, 0x00, 0x3C, 0x03, 0xF0, 0x1F, 0x80, 0x70, 0x01, 0xC0, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x38, 0x01, 0xE0, 0x3F, 0x00, 0xE0, 0x03, 0xE0, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xE0, 0x0F, 0x80, 0x0E, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x01, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x1F, 0x00, 0x3C, 0x03, 0xE0, 0x1C,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x0F, 0xC0, 0x3E, 0x00, 0xF0,
  0x00, 0x3C, 0x03, 0xFE, 0x07, 0xFF, 0xFE, 0x1F, 0xF8, 0x07, 0x80,
};

const GFXglyph NotoSans_Condensed_Italic38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 10, 27, 9, 0, -27 },
  { 35, 11, 10, 13, 4, -27 },
  { 49, 19, 27, 19, 0, -27 },
  { 114, 17, 31, 17, 0, -29 },
  { 180, 22, 28, 25, 2, -28 },
  { 257, 18, 28, 19, 0, -28 },
  { 320, 5, 10, 7, 4, -27 },
  { 327, 12, 33, 10, 1, -27 },
  { 377, 12, 33, 10, -3, -27 },
  { 427, 13, 14, 16, 4, -29 },
  { 450, 15, 18, 18, 2, -22 },
  { 484, 7, 9, 8, -2, -4 },
  { 492, 9, 3, 10, 1, -12 },
  { 496, 4, 4, 8, 1, -4 },
  { 498, 18, 27, 13, -2, -27 },
  { 559, 15, 28, 17, 1, -28 },
  { 612, 10, 27, 17, 4, -27 },
  { 646, 17, 28, 17, -1, -28 },
  { 706, 16, 28, 17, 0, -28 },
  { 762, 17, 27, 17, 0, -27 },
  { 820, 17, 27, 17, 0, -27 },
  { 878, 16, 28, 17, 1, -28 },
  { 934, 16, 27, 17, 2, -27 },
  { 988, 17, 28, 17, 0, -28 },
  { 1048, 16, 28, 17, 0, -28 },
  { 1104, 8, 21, 8, 0, -21 },
  { 1125, 10, 26, 8, -2, -21 },
  { 1158, 15, 17, 18, 2, -22 },
  { 1190, 15, 11, 18, 2, -19 },
  { 1211, 15, 17, 18, 2, -22 },
  { 1243, 13, 28, 13, 1, -28 },
  { 1289, 24, 30, 25, 1, -27 },
  { 1379, 17, 27, 17, -2, -27 },
  { 1437, 18, 27, 18, 0, -27 },
  { 1498, 17, 28, 17, 2, -28 },
  { 1558, 19, 27, 20, 0, -27 },
  { 1623, 17, 27, 16, 0, -27 },
  { 1681, 17, 27, 15, 0, -27 },
  { 1739, 19, 28, 21, 2, -28 },
  { 1806, 21, 27, 21, 0, -27 },
  { 1877, 15, 27, 11, -2, -27 },
  { 1928, 15, 34, 8, -6, -27 },
  { 1992, 20, 27, 17, 0, -27 },
  { 2060, 12, 27, 14, 0, -27 },
  { 2101, 27, 27, 27, 0, -27 },
  { 2193, 22, 27, 22, 0, -27 },
  { 2268, 19, 28, 21, 2, -28 },
  { 2335, 18, 27, 17, 0, -27 },
  { 2396, 19, 34, 21, 2, -28 },
  { 2477, 18, 27, 18, 0, -27 },
  { 2538, 17, 28, 16, 0, -28 },
  { 2598, 15, 27, 15, 3, -27 },
  { 2649, 19, 27, 20, 2, -27 },
  { 2714, 17, 27, 17, 3, -27 },
  { 2772, 27, 27, 27, 3, -27 },
  { 2864, 21, 27, 16, -2, -27 },
  { 2935, 16, 27, 15, 3, -27 },
  { 2989, 18, 27, 15, -1, -27 },
  { 3050, 15, 33, 11, -1, -27 },
  { 3112, 6, 27, 13, 4, -27 },
  { 3133, 15, 33, 11, -3, -27 },
  { 3195, 16, 15, 17, 1, -27 },
  { 3225, 13, 3, 13, -3, 3 },
  { 3230, 5, 6, 10, 6, -29 },
  { 3234, 16, 21, 18, 1, -21 },
  { 3276, 17, 29, 18, 0, -29 },
  { 3338, 13, 21, 14, 1, -21 },
  { 3373, 18, 29, 18, 1, -29 },
  { 3439, 14, 21, 16, 1, -21 },
  { 3476, 19, 38, 10, -5, -29 },
  { 3567, 17, 30, 18, 0, -21 },
  { 3631, 16, 29, 18, 0, -29 },
  { 3689, 9, 28, 8, 0, -28 },
  { 3721, 14, 37, 8, -5, -28 },
  { 3786, 17, 29, 15, 0, -29 },
  { 3848, 10, 29, 8, 0, -29 },
  { 3885, 25, 21, 26, 0, -21 },
  { 3951, 16, 21, 18, 0, -21 },
  { 3993, 15, 21, 17, 1, -21 },
  { 4033, 19, 30, 18, -2, -21 },
  { 4105, 16, 30, 18, 1, -21 },
  { 4165, 13, 21, 12, 0, -21 },
  { 4200, 13, 21, 13, 0, -21 },
  { 4235, 10, 25, 10, 1, -25 },
  { 4267, 16, 20, 18, 1, -20 },
  { 4307, 14, 20, 14, 2, -20 },
  { 4342, 22, 20, 23, 2, -20 },
  { 4397, 18, 20, 15, -2, -20 },
  { 4442, 20, 29, 14, -4, -20 },
  { 4515, 14, 20, 13, -1, -20 },
  { 4550, 14, 33, 13, 1, -27 },
  { 4608, 3, 38, 16, 7, -29 },
  { 4623, 14, 33, 13, -2, -27 },
  { 4681, 15, 5, 18, 2, -16 },
};

const GFXfont NotoSans_Condensed_Italic38pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Italic38pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Italic38pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _NOTOSANS_CONDENSED_ITALIC38PT7B_H_
