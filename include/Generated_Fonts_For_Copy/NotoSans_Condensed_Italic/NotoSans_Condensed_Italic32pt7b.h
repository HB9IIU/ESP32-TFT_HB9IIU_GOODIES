#ifndef _NOTOSANS_CONDENSED_ITALIC32PT7B_H_
#define _NOTOSANS_CONDENSED_ITALIC32PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Italic.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Italic32pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x07, 0x07, 0x06, 0x0E, 0x0E, 0x0E, 0x0C, 0x0C, 0x1C, 0x1C,
  0x18, 0x18, 0x18, 0x38, 0x30, 0x30, 0x00, 0x00, 0x20, 0x70, 0xF0, 0x60,
  0x73, 0xB9, 0xDC, 0xEC, 0x76, 0x33, 0x19, 0x8D, 0x8C, 0x00, 0xC6, 0x00,
  0xC6, 0x01, 0x86, 0x01, 0x8C, 0x01, 0x8C, 0x03, 0x0C, 0x03, 0x1C, 0x1F,
  0xFF, 0x3F, 0xFF, 0x06, 0x18, 0x06, 0x30, 0x0E, 0x30, 0x0C, 0x30, 0x0C,
  0x60, 0x7F, 0xFC, 0xFF, 0xFC, 0x18, 0xC0, 0x18, 0xC0, 0x30, 0xC0, 0x31,
  0xC0, 0x31, 0x80, 0x71, 0x80, 0x63, 0x80, 0x00, 0x60, 0x01, 0x80, 0x0E,
  0x01, 0xFF, 0x0F, 0xFC, 0x33, 0x21, 0xC8, 0x06, 0x20, 0x19, 0x80, 0x76,
  0x00, 0xF8, 0x03, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0xDC, 0x02,
  0x30, 0x09, 0xC0, 0x67, 0x31, 0xB8, 0xFF, 0xE1, 0xFE, 0x00, 0x40, 0x03,
  0x00, 0x0C, 0x00, 0x20, 0x00, 0x1E, 0x03, 0x8F, 0xC0, 0xC3, 0x30, 0x61,
  0x8C, 0x18, 0x63, 0x0C, 0x18, 0xC7, 0x0C, 0x31, 0x83, 0x0C, 0xC0, 0xC7,
  0x30, 0x31, 0x99, 0xEC, 0x6E, 0xFF, 0x33, 0x33, 0xFD, 0xD8, 0xDE, 0x66,
  0x30, 0x33, 0x0C, 0x0C, 0xC3, 0x06, 0x30, 0xC3, 0x8C, 0x60, 0xC3, 0x18,
  0x60, 0xC6, 0x18, 0x33, 0x0C, 0x0F, 0xC7, 0x01, 0xE0, 0x01, 0xF0, 0x07,
  0xF0, 0x1C, 0xE0, 0x30, 0xC0, 0x61, 0x81, 0xC7, 0x03, 0x8C, 0x03, 0x38,
  0x06, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x01, 0xF8, 0x67, 0x39, 0xDC,
  0x73, 0xB0, 0x66, 0xE0, 0xFD, 0xC0, 0xF3, 0x81, 0xC7, 0x07, 0x8F, 0x1F,
  0x8F, 0xF7, 0x0F, 0xC7, 0x00, 0x37, 0x77, 0x66, 0x6C, 0x01, 0xC0, 0xE0,
  0x70, 0x18, 0x0E, 0x07, 0x01, 0x80, 0xE0, 0x38, 0x0C, 0x07, 0x01, 0x80,
  0x60, 0x38, 0x0E, 0x03, 0x80, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x80, 0xE0, 0x18, 0x06, 0x01, 0xC0, 0x03, 0x00, 0xC0, 0x38,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0xC0, 0x70, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x38, 0x0E, 0x03, 0x00, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0x01,
  0xC0, 0x60, 0x38, 0x0C, 0x06, 0x03, 0x00, 0x07, 0x00, 0xE1, 0x18, 0x3B,
  0x0F, 0xFE, 0x3F, 0xC3, 0x80, 0xD8, 0x73, 0x0E, 0x70, 0x86, 0x00, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x0F, 0xFF, 0xFF,
  0xF0, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x19, 0xCE,
  0xE7, 0x33, 0x98, 0xFF, 0xFF, 0xF8, 0x27, 0xF6, 0x00, 0x06, 0x00, 0x1C,
  0x00, 0x30, 0x00, 0xE0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00,
  0xE0, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0,
  0x03, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x0E,
  0x00, 0x38, 0x00, 0x00, 0x03, 0xE0, 0x3F, 0x83, 0x9C, 0x38, 0x71, 0xC3,
  0x9C, 0x1C, 0xE0, 0xE6, 0x07, 0x70, 0x3B, 0x81, 0xD8, 0x0C, 0xC0, 0x6E,
  0x07, 0x70, 0x3B, 0x81, 0xDC, 0x0C, 0xE0, 0xE7, 0x07, 0x38, 0x71, 0xC3,
  0x8E, 0x38, 0x3F, 0x80, 0xF8, 0x00, 0x07, 0x0F, 0x1F, 0x3E, 0xF6, 0xEE,
  0x4E, 0x0E, 0x0C, 0x0C, 0x1C, 0x1C, 0x1C, 0x18, 0x18, 0x38, 0x38, 0x38,
  0x30, 0x70, 0x70, 0x70, 0x60, 0x01, 0xF8, 0x0F, 0xF8, 0x1C, 0x70, 0x20,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x30,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x0F, 0xFE, 0x3F, 0xFC,
  0x00, 0x03, 0xF0, 0x3F, 0xE0, 0xE3, 0xC2, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x06, 0x00, 0x38, 0x03, 0xC0, 0xFC, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x38,
  0x81, 0xC3, 0xFF, 0x0F, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0xF0, 0x07, 0x80,
  0x1E, 0x00, 0xD8, 0x06, 0xE0, 0x1B, 0x80, 0xCC, 0x06, 0x30, 0x39, 0xC0,
  0xC7, 0x06, 0x1C, 0x38, 0x60, 0xC1, 0x86, 0x0E, 0x38, 0x38, 0xFF, 0xFB,
  0xFF, 0xE0, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0x07,
  0xFC, 0x1F, 0xF0, 0x7F, 0xC3, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x7F, 0x03, 0xFE, 0x04, 0x3C, 0x00, 0x70, 0x01, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x38, 0xC1, 0xE3,
  0xFF, 0x0F, 0xF0, 0x00, 0x00, 0xFC, 0x0F, 0xE0, 0x78, 0x03, 0x80, 0x0C,
  0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xDF, 0x07, 0xFE, 0x1E,
  0x3C, 0x70, 0x73, 0x81, 0xCE, 0x07, 0x38, 0x1C, 0xE0, 0x63, 0x81, 0x8E,
  0x0E, 0x38, 0x30, 0x71, 0xC1, 0xFE, 0x03, 0xF0, 0x00, 0x1F, 0xFC, 0xFF,
  0xF3, 0xFF, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00,
  0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x03,
  0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x0E,
  0x00, 0x00, 0x01, 0xF0, 0x1F, 0xE0, 0xF1, 0xC3, 0x87, 0x0C, 0x0C, 0x70,
  0x31, 0xC1, 0xC3, 0x06, 0x0E, 0x38, 0x1F, 0xC0, 0x7C, 0x01, 0xF0, 0x1F,
  0xE0, 0xE3, 0x87, 0x07, 0x18, 0x1C, 0xE0, 0x33, 0x80, 0xCE, 0x07, 0x38,
  0x1C, 0x70, 0xE1, 0xFF, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x1F, 0xE0, 0xF3,
  0x87, 0x06, 0x1C, 0x1C, 0x60, 0x73, 0x81, 0xCE, 0x07, 0x38, 0x1C, 0xE0,
  0xE3, 0x83, 0x8E, 0x1E, 0x1F, 0xF8, 0x7E, 0xE0, 0x23, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0x80, 0x0E, 0x00, 0x70, 0x03, 0x83, 0xFC, 0x0F, 0xE0, 0x00,
  0x1E, 0x3C, 0x70, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x3C, 0x78, 0xE0, 0x03, 0x83, 0xC1, 0xC0, 0x40, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x70, 0x38, 0x38, 0x18, 0x0C,
  0x0C, 0x0E, 0x00, 0x00, 0x10, 0x03, 0x00, 0xF0, 0x3E, 0x0F, 0x83, 0xE0,
  0xF8, 0x0E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07,
  0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xF0, 0x80, 0x0C, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0x00, 0xF0, 0x3C, 0x0F, 0x07, 0xC0, 0xF0, 0x0C,
  0x00, 0x80, 0x00, 0x1F, 0x87, 0xF8, 0xC7, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x30, 0x0E, 0x03, 0x80, 0xE0, 0x18, 0x06, 0x01, 0xC0, 0x70, 0x0C, 0x01,
  0x80, 0x30, 0x00, 0x00, 0x00, 0x30, 0x0F, 0x01, 0xE0, 0x38, 0x00, 0x00,
  0x3F, 0x00, 0x0F, 0xF8, 0x03, 0x81, 0xC0, 0x70, 0x0E, 0x0E, 0x00, 0x61,
  0xC0, 0x06, 0x18, 0x3C, 0x33, 0x07, 0xE3, 0x30, 0xC6, 0x36, 0x18, 0xC3,
  0x63, 0x0C, 0x36, 0x30, 0xC6, 0x63, 0x0C, 0x6C, 0x61, 0x86, 0xC6, 0x18,
  0x6C, 0x63, 0x8C, 0xC6, 0x38, 0xCC, 0x77, 0xF8, 0xC3, 0xCF, 0x0C, 0x00,
  0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x81, 0x80, 0x1F,
  0xF8, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0,
  0x0F, 0xC0, 0x1B, 0x80, 0x73, 0x00, 0xE6, 0x01, 0x8C, 0x07, 0x18, 0x0C,
  0x30, 0x38, 0x60, 0x60, 0xC1, 0xFF, 0x83, 0xFF, 0x0F, 0xFE, 0x1C, 0x0C,
  0x70, 0x18, 0xE0, 0x31, 0x80, 0x67, 0x00, 0xCE, 0x01, 0xB8, 0x03, 0x80,
  0x07, 0xF0, 0x0F, 0xF8, 0x18, 0xF8, 0x30, 0x70, 0xE0, 0x61, 0xC0, 0xC3,
  0x83, 0x86, 0x07, 0x1C, 0x0C, 0x38, 0x78, 0x7F, 0xC0, 0xFF, 0x81, 0x87,
  0x87, 0x07, 0x0E, 0x07, 0x1C, 0x0E, 0x30, 0x1C, 0x60, 0x39, 0xC0, 0xE3,
  0x83, 0xC7, 0x0F, 0x0F, 0xFC, 0x3F, 0xE0, 0x00, 0x00, 0xFE, 0x07, 0xFC,
  0x1E, 0x10, 0x78, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x70, 0x00, 0x60, 0x00, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x82, 0x07,
  0xFC, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x07, 0xFC, 0x07, 0xFE, 0x06, 0x0E,
  0x0E, 0x07, 0x0E, 0x07, 0x0E, 0x07, 0x0C, 0x07, 0x1C, 0x07, 0x1C, 0x07,
  0x1C, 0x07, 0x18, 0x07, 0x18, 0x07, 0x38, 0x0E, 0x38, 0x0E, 0x38, 0x0E,
  0x30, 0x1C, 0x30, 0x1C, 0x70, 0x38, 0x70, 0x70, 0x73, 0xE0, 0x7F, 0xC0,
  0xFF, 0x00, 0x07, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0x30, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x7F, 0xC0, 0xFF,
  0x81, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0F, 0xF8, 0x3F, 0xF0, 0x00, 0x07, 0xFE,
  0x0F, 0xF8, 0x1F, 0xF0, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x06,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xFF, 0x81, 0xFF, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0C, 0x00, 0x38, 0x00, 0x00, 0x00, 0xFE, 0x01, 0xFF, 0xC1, 0xF1,
  0xC1, 0xE0, 0x20, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x0F, 0xC6, 0x07, 0xE3, 0x00, 0x71,
  0x80, 0x31, 0xC0, 0x18, 0x60, 0x1C, 0x30, 0x0E, 0x1C, 0x07, 0x0E, 0x03,
  0x03, 0xC1, 0x81, 0xFF, 0xC0, 0x3F, 0xC0, 0x07, 0x01, 0xC1, 0xC0, 0x70,
  0x60, 0x18, 0x18, 0x06, 0x0E, 0x03, 0x83, 0x80, 0xE0, 0xE0, 0x38, 0x30,
  0x0C, 0x1C, 0x07, 0x07, 0x01, 0xC1, 0xFF, 0xF0, 0x7F, 0xF8, 0x18, 0x06,
  0x0E, 0x03, 0x83, 0x80, 0xE0, 0xE0, 0x38, 0x30, 0x0C, 0x0C, 0x03, 0x07,
  0x01, 0xC1, 0xC0, 0x70, 0x70, 0x1C, 0x18, 0x06, 0x0E, 0x03, 0x80, 0x0F,
  0xF0, 0xFF, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x0C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x0F, 0xF0, 0xFE, 0x00, 0x00, 0x38,
  0x01, 0xC0, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00,
  0xE0, 0x07, 0x00, 0x70, 0x27, 0x81, 0xF8, 0x0F, 0x80, 0x00, 0x07, 0x03,
  0x83, 0x83, 0x81, 0x83, 0x80, 0xC1, 0xC0, 0xE1, 0xC0, 0x71, 0xC0, 0x39,
  0xC0, 0x19, 0xC0, 0x1C, 0xE0, 0x0E, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xFC, 0x01, 0xEE, 0x00, 0xE7, 0x00, 0x71, 0xC0, 0x30, 0xE0, 0x18, 0x70,
  0x1C, 0x18, 0x0E, 0x0E, 0x07, 0x07, 0x03, 0x03, 0x83, 0x80, 0xE0, 0x07,
  0x01, 0xC0, 0x60, 0x18, 0x0E, 0x03, 0x80, 0xE0, 0x30, 0x1C, 0x07, 0x01,
  0xC0, 0x60, 0x18, 0x0E, 0x03, 0x80, 0xE0, 0x30, 0x0C, 0x07, 0x01, 0xC0,
  0x70, 0x1F, 0xFF, 0xFC, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0x7C, 0x1E, 0x00,
  0xF8, 0x3C, 0x03, 0xE0, 0xF8, 0x06, 0xC1, 0xF0, 0x0F, 0x83, 0x60, 0x3F,
  0x06, 0xC0, 0x6E, 0x1D, 0x81, 0xD8, 0x3B, 0x83, 0x70, 0x77, 0x0E, 0xE0,
  0xCE, 0x19, 0xC1, 0x9C, 0x73, 0x07, 0x38, 0xC6, 0x0E, 0x73, 0x9C, 0x18,
  0x66, 0x38, 0x30, 0xDC, 0x70, 0x61, 0xB0, 0xC1, 0xC3, 0xE1, 0x83, 0x87,
  0x87, 0x06, 0x0F, 0x0E, 0x0C, 0x1C, 0x1C, 0x38, 0x38, 0x30, 0x00, 0x07,
  0x00, 0xE0, 0xF0, 0x1C, 0x1E, 0x03, 0x03, 0xC0, 0x60, 0xF8, 0x1C, 0x1B,
  0x03, 0x83, 0x70, 0x70, 0x6E, 0x0C, 0x1C, 0xC3, 0x83, 0x98, 0x70, 0x73,
  0x8E, 0x0C, 0x71, 0x81, 0x86, 0x30, 0x70, 0xCE, 0x0E, 0x1D, 0xC1, 0xC3,
  0xB8, 0x30, 0x36, 0x06, 0x06, 0xC1, 0xC0, 0xD8, 0x38, 0x1F, 0x06, 0x03,
  0xE0, 0xC0, 0x38, 0x38, 0x07, 0x00, 0x00, 0xF8, 0x03, 0xFE, 0x07, 0x8E,
  0x0E, 0x07, 0x1C, 0x07, 0x1C, 0x03, 0x38, 0x03, 0x38, 0x03, 0x38, 0x03,
  0x70, 0x07, 0x70, 0x07, 0x70, 0x07, 0x70, 0x07, 0x60, 0x07, 0xE0, 0x0E,
  0xE0, 0x0E, 0xE0, 0x0E, 0x60, 0x1C, 0x70, 0x1C, 0x70, 0x38, 0x78, 0xF0,
  0x3F, 0xE0, 0x1F, 0xC0, 0x07, 0xF0, 0x0F, 0xF0, 0x19, 0xF0, 0x30, 0xF0,
  0xE0, 0xE1, 0xC1, 0xC3, 0x83, 0x86, 0x07, 0x1C, 0x0C, 0x38, 0x38, 0x70,
  0xF0, 0xC7, 0xC1, 0xFF, 0x07, 0xF8, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00,
  0x60, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xF8, 0x03, 0xFE, 0x07, 0x8E, 0x0E, 0x07, 0x1C, 0x07, 0x1C, 0x03,
  0x38, 0x03, 0x38, 0x03, 0x38, 0x03, 0x70, 0x07, 0x70, 0x07, 0x70, 0x07,
  0x70, 0x07, 0x60, 0x07, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0x60, 0x1C,
  0x70, 0x1C, 0x70, 0x38, 0x78, 0xF0, 0x3F, 0xE0, 0x1F, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x07, 0xF0, 0x0F, 0xF0,
  0x19, 0xF0, 0x30, 0x70, 0xE0, 0xE1, 0xC1, 0xC3, 0x83, 0x86, 0x07, 0x1C,
  0x0C, 0x38, 0x38, 0x70, 0xE0, 0xFF, 0xC1, 0xFE, 0x07, 0x38, 0x0E, 0x30,
  0x1C, 0x70, 0x30, 0xE0, 0x61, 0xC1, 0xC1, 0x83, 0x83, 0x87, 0x07, 0x0C,
  0x0E, 0x38, 0x1E, 0x00, 0x03, 0xF8, 0x1F, 0xF0, 0xF1, 0xC7, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x60, 0x01, 0x80,
  0x0E, 0x00, 0x38, 0xC3, 0xC3, 0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xE0, 0x0E, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x80,
  0x18, 0x03, 0x80, 0x38, 0x03, 0x80, 0x30, 0x03, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x0E, 0x03, 0x86, 0x01,
  0x83, 0x00, 0xC3, 0x80, 0xE1, 0xC0, 0x70, 0xE0, 0x38, 0x60, 0x18, 0x70,
  0x0C, 0x38, 0x0E, 0x1C, 0x07, 0x0E, 0x03, 0x86, 0x01, 0x87, 0x01, 0xC3,
  0x80, 0xE1, 0xC0, 0x70, 0xC0, 0x30, 0x60, 0x18, 0x70, 0x1C, 0x38, 0x0E,
  0x0C, 0x0E, 0x07, 0x0F, 0x03, 0xFF, 0x00, 0x7E, 0x00, 0xE0, 0x1F, 0x80,
  0x6E, 0x03, 0xB8, 0x0E, 0xE0, 0x73, 0x81, 0xCE, 0x0E, 0x38, 0x38, 0xE1,
  0xC3, 0x87, 0x0E, 0x18, 0x38, 0xE0, 0xE3, 0x03, 0x9C, 0x0E, 0x70, 0x3B,
  0x80, 0xEE, 0x03, 0xB0, 0x0F, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x07,
  0x00, 0x00, 0xE0, 0x30, 0x0F, 0x81, 0xC0, 0x7E, 0x07, 0x01, 0xB8, 0x1C,
  0x0E, 0xE0, 0xF0, 0x3B, 0x83, 0xC0, 0xCE, 0x1F, 0x07, 0x38, 0x6C, 0x18,
  0xC3, 0xB0, 0xE3, 0x0C, 0xC3, 0x8C, 0x33, 0x0C, 0x31, 0xCC, 0x70, 0xC6,
  0x31, 0x83, 0x38, 0xCE, 0x0C, 0xC3, 0x38, 0x33, 0x0C, 0xC0, 0xDC, 0x37,
  0x03, 0x60, 0xD8, 0x0F, 0x83, 0xE0, 0x3C, 0x0F, 0x00, 0xF0, 0x3C, 0x03,
  0x80, 0xF0, 0x0E, 0x03, 0x80, 0x00, 0x07, 0x01, 0xC0, 0xC0, 0xE0, 0x38,
  0x70, 0x0E, 0x1C, 0x03, 0x8E, 0x00, 0x63, 0x00, 0x19, 0xC0, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0xF8, 0x00, 0x36, 0x00, 0x1D, 0xC0, 0x0E, 0x70, 0x03, 0x1C, 0x01, 0xC3,
  0x00, 0xE0, 0xC0, 0x38, 0x38, 0x1C, 0x0E, 0x0E, 0x03, 0x80, 0xE0, 0x3F,
  0x03, 0xB8, 0x39, 0xC1, 0xCE, 0x1C, 0x30, 0xE1, 0x8E, 0x0C, 0x60, 0x77,
  0x03, 0xB0, 0x1F, 0x80, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x06, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x00,
  0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x03,
  0x80, 0x07, 0x00, 0x1F, 0xFC, 0x3F, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x03,
  0x00, 0x30, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0C,
  0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x38,
  0x03, 0x80, 0x30, 0x03, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0x7E,
  0x0F, 0xE0, 0xE3, 0x86, 0x18, 0x61, 0x86, 0x1C, 0x70, 0xC3, 0x0C, 0x30,
  0xC3, 0x8E, 0x38, 0x61, 0x86, 0x18, 0x61, 0xC0, 0x03, 0xF0, 0x7F, 0x00,
  0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x1C, 0x01,
  0xC0, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80, 0x38, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0xFC,
  0x0F, 0xC0, 0x01, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x80, 0xEC, 0x06, 0x60,
  0x73, 0x83, 0x0C, 0x38, 0x61, 0x83, 0x98, 0x0D, 0xC0, 0x6C, 0x03, 0x80,
  0xFF, 0xFF, 0xFC, 0xE6, 0x73, 0x10, 0x07, 0xDC, 0x7F, 0x61, 0xC7, 0x8E,
  0x0E, 0x30, 0x39, 0xC0, 0xE7, 0x03, 0x18, 0x0C, 0xE0, 0x73, 0x81, 0xCE,
  0x06, 0x38, 0x38, 0xE0, 0xE3, 0x87, 0x8E, 0x3E, 0x1F, 0xB0, 0x7C, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x3E, 0x0D, 0xF8, 0x7C, 0x71, 0xE1, 0xC7, 0x07, 0x1C, 0x1C, 0xE0,
  0x73, 0x81, 0xCE, 0x07, 0x30, 0x18, 0xC0, 0xE7, 0x03, 0x9C, 0x1C, 0x70,
  0x71, 0xE3, 0x86, 0xFC, 0x33, 0xE0, 0x07, 0xE3, 0xFC, 0x70, 0x1C, 0x03,
  0x00, 0xE0, 0x18, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x3C, 0x43, 0xF8, 0x3F, 0x00, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x07, 0xEE, 0x1F, 0xD8, 0x38,
  0xF0, 0xE0, 0xE1, 0x81, 0xC7, 0x03, 0x0E, 0x06, 0x18, 0x1C, 0x70, 0x38,
  0xE0, 0x71, 0xC0, 0xC3, 0x83, 0x87, 0x07, 0x0E, 0x1E, 0x1C, 0x7C, 0x1F,
  0xB0, 0x3E, 0x60, 0x07, 0xE1, 0xFE, 0x1C, 0x73, 0x87, 0x70, 0x77, 0x06,
  0x61, 0xEF, 0xFC, 0xFF, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xF0, 0x87, 0xF8, 0x3F, 0x80, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE4, 0x03, 0xF8, 0x03, 0xF8, 0x00,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C,
  0x00, 0x1C, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x60, 0x00, 0x03, 0xEE, 0x1F,
  0xD8, 0x38, 0xF0, 0xE0, 0xE1, 0x81, 0xC7, 0x03, 0x8E, 0x06, 0x18, 0x1C,
  0x70, 0x38, 0xE0, 0x71, 0xC0, 0xC3, 0x83, 0x87, 0x07, 0x0E, 0x1E, 0x1C,
  0x7C, 0x1F, 0xB0, 0x3E, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C,
  0x10, 0x38, 0x3F, 0xE0, 0x7F, 0x80, 0x3C, 0x00, 0x07, 0x00, 0x1C, 0x00,
  0x60, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x7E, 0x0F, 0xF8,
  0x78, 0x71, 0xE1, 0xC7, 0x06, 0x18, 0x18, 0xE0, 0x63, 0x83, 0x8E, 0x0E,
  0x30, 0x30, 0xC0, 0xC7, 0x07, 0x1C, 0x1C, 0x70, 0x71, 0x81, 0x86, 0x06,
  0x38, 0x38, 0x02, 0x07, 0x07, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x0C, 0x1C,
  0x1C, 0x18, 0x18, 0x38, 0x38, 0x38, 0x30, 0x30, 0x70, 0x70, 0x70, 0x60,
  0x60, 0xE0, 0x00, 0x20, 0x07, 0x00, 0x70, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x38, 0x03,
  0x80, 0x38, 0x03, 0x00, 0x30, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x06,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x1C, 0x0F, 0x80, 0xF8,
  0x0E, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x07, 0x0C, 0x38, 0x71, 0xC1, 0xCE, 0x06, 0x70, 0x19,
  0x80, 0xEE, 0x03, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0xE6, 0x07, 0x18, 0x1C,
  0x70, 0x71, 0xC1, 0x83, 0x06, 0x0E, 0x38, 0x38, 0x07, 0x07, 0x06, 0x06,
  0x0E, 0x0E, 0x0E, 0x0C, 0x0C, 0x1C, 0x1C, 0x18, 0x18, 0x38, 0x38, 0x38,
  0x30, 0x30, 0x70, 0x70, 0x70, 0x60, 0x60, 0xE0, 0x0D, 0xF1, 0xF0, 0x7F,
  0xDF, 0xC7, 0x8F, 0x8E, 0x38, 0x38, 0x71, 0xC1, 0xC3, 0x8C, 0x1C, 0x1C,
  0xE0, 0xE0, 0xC7, 0x07, 0x06, 0x38, 0x30, 0x71, 0x81, 0x83, 0x8C, 0x1C,
  0x1C, 0xE0, 0xE0, 0xC7, 0x07, 0x06, 0x38, 0x30, 0x71, 0x81, 0x83, 0x8C,
  0x1C, 0x1C, 0xE0, 0xE0, 0xC0, 0x00, 0x20, 0x37, 0xE1, 0xFF, 0x87, 0xC7,
  0x1E, 0x1C, 0x70, 0x71, 0xC1, 0x8E, 0x0E, 0x38, 0x38, 0xE0, 0xE3, 0x03,
  0x8C, 0x0C, 0x70, 0x71, 0xC1, 0xC7, 0x07, 0x18, 0x18, 0xE0, 0x63, 0x83,
  0x80, 0x07, 0xE0, 0xFF, 0x87, 0x1C, 0x70, 0x63, 0x03, 0x38, 0x1D, 0x80,
  0xCC, 0x06, 0xE0, 0x37, 0x03, 0xB8, 0x1D, 0xC0, 0xCE, 0x0E, 0x70, 0x63,
  0xC7, 0x0F, 0xF0, 0x3F, 0x00, 0x06, 0x7C, 0x0D, 0xF8, 0x3E, 0x38, 0x78,
  0x70, 0xE0, 0xE1, 0xC1, 0xC7, 0x03, 0x8E, 0x07, 0x1C, 0x0E, 0x30, 0x18,
  0x60, 0x71, 0xC0, 0xE3, 0x83, 0x87, 0x07, 0x0F, 0x1C, 0x1B, 0xF0, 0x77,
  0xC0, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x60, 0x00, 0xC0, 0x00, 0x07, 0xDC, 0x7F, 0x61, 0xC7, 0x8E, 0x0E, 0x30,
  0x39, 0xC0, 0xE7, 0x03, 0x18, 0x1C, 0xE0, 0x73, 0x81, 0xCE, 0x06, 0x38,
  0x38, 0xE0, 0xE3, 0x87, 0x8E, 0x3E, 0x1F, 0xB0, 0x7C, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00,
  0x0D, 0xE1, 0xFC, 0x7C, 0x0F, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x38,
  0x06, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x03, 0x00, 0xE0, 0x00,
  0x0F, 0xE3, 0xFC, 0xE0, 0x9C, 0x03, 0x80, 0x70, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0E, 0x01, 0xC0, 0x18, 0x07, 0x20, 0xE7, 0xF8, 0xFE, 0x00,
  0x0C, 0x06, 0x03, 0x03, 0x97, 0xF3, 0xF8, 0xE0, 0x70, 0x38, 0x18, 0x0C,
  0x0E, 0x07, 0x03, 0x01, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1F, 0x87, 0xC0,
  0x18, 0x19, 0xC0, 0xCE, 0x0E, 0x70, 0x73, 0x03, 0x18, 0x19, 0xC1, 0xCE,
  0x0E, 0x70, 0x73, 0x03, 0x18, 0x39, 0xC1, 0xCE, 0x0E, 0x70, 0xF3, 0x8F,
  0x1F, 0xD8, 0x7C, 0xC0, 0xC0, 0x7C, 0x0E, 0xC0, 0xCC, 0x1C, 0xC1, 0x8E,
  0x38, 0xE3, 0x0E, 0x70, 0xE7, 0x0E, 0x60, 0xEE, 0x0E, 0xC0, 0xFC, 0x0F,
  0x80, 0xF8, 0x07, 0x00, 0x70, 0x00, 0xC1, 0xE0, 0xF8, 0x3C, 0x3B, 0x07,
  0x86, 0x61, 0xB1, 0xCC, 0x36, 0x39, 0x8F, 0xC6, 0x31, 0xB9, 0xC6, 0x37,
  0x30, 0xCC, 0xEE, 0x19, 0x9D, 0xC3, 0x73, 0xB0, 0x6C, 0x7E, 0x0D, 0x8D,
  0x81, 0xE1, 0xB0, 0x3C, 0x3C, 0x07, 0x87, 0x80, 0xE0, 0xF0, 0x00, 0x1C,
  0x1C, 0x38, 0xE0, 0xE3, 0x83, 0x9C, 0x06, 0x60, 0x1B, 0x80, 0x7C, 0x00,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x07, 0x70, 0x19, 0xC0, 0xE3, 0x07,
  0x0C, 0x18, 0x38, 0xE0, 0xE0, 0x07, 0x03, 0x83, 0x83, 0x81, 0xC1, 0x80,
  0xE1, 0xC0, 0x70, 0xE0, 0x38, 0xE0, 0x1C, 0x70, 0x0E, 0x30, 0x07, 0x38,
  0x03, 0x98, 0x00, 0xDC, 0x00, 0x6C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00,
  0xE0, 0x00, 0x60, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0xFF, 0x00, 0x60, 0x0E, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x70, 0x07,
  0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x00, 0x70, 0x0F, 0xF8, 0xFF,
  0x80, 0x00, 0x70, 0x1E, 0x03, 0xC0, 0x30, 0x07, 0x00, 0x70, 0x06, 0x00,
  0x60, 0x0E, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x3C, 0x0F, 0x00, 0xF0, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x30, 0x03, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x3C, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x03, 0x00, 0x3C, 0x03, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x01, 0xC0, 0x0F,
  0x00, 0xF0, 0x3C, 0x03, 0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0xE0,
  0x0E, 0x00, 0xC0, 0x0C, 0x03, 0xC0, 0xF8, 0x0F, 0x00, 0xFC, 0x1F, 0xFF,
  0x87, 0xF8, 0x1E,
};

const GFXglyph NotoSans_Condensed_Italic32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 8, 23, 8, 0, -23 },
  { 24, 9, 8, 11, 3, -23 },
  { 33, 16, 23, 16, 0, -23 },
  { 79, 14, 26, 14, 0, -24 },
  { 125, 18, 23, 21, 2, -23 },
  { 177, 15, 23, 16, 0, -23 },
  { 221, 4, 8, 6, 3, -23 },
  { 225, 10, 28, 9, 1, -23 },
  { 260, 10, 28, 9, -2, -23 },
  { 295, 11, 11, 13, 3, -24 },
  { 311, 12, 15, 15, 2, -19 },
  { 334, 5, 8, 7, -1, -4 },
  { 339, 7, 3, 9, 1, -10 },
  { 342, 4, 4, 7, 0, -4 },
  { 344, 15, 23, 11, -2, -23 },
  { 388, 13, 23, 14, 1, -23 },
  { 426, 8, 23, 14, 4, -23 },
  { 449, 15, 23, 14, -1, -23 },
  { 493, 14, 23, 14, 0, -23 },
  { 534, 14, 23, 14, 0, -23 },
  { 575, 14, 23, 14, 0, -23 },
  { 616, 14, 23, 14, 1, -23 },
  { 657, 14, 23, 14, 1, -23 },
  { 698, 14, 23, 14, 0, -23 },
  { 739, 14, 23, 14, 0, -23 },
  { 780, 7, 17, 7, 0, -17 },
  { 795, 9, 21, 7, -2, -17 },
  { 819, 12, 15, 15, 2, -19 },
  { 842, 12, 9, 15, 2, -16 },
  { 856, 12, 15, 15, 2, -19 },
  { 879, 11, 23, 11, 1, -23 },
  { 911, 20, 26, 21, 1, -23 },
  { 976, 15, 23, 14, -2, -23 },
  { 1020, 15, 23, 15, 0, -23 },
  { 1064, 15, 23, 14, 1, -23 },
  { 1108, 16, 23, 17, 0, -23 },
  { 1154, 15, 23, 13, 0, -23 },
  { 1198, 15, 23, 12, 0, -23 },
  { 1242, 17, 23, 18, 1, -23 },
  { 1291, 18, 23, 17, 0, -23 },
  { 1343, 12, 23, 9, -1, -23 },
  { 1378, 13, 29, 7, -5, -23 },
  { 1426, 17, 23, 14, 0, -23 },
  { 1475, 10, 23, 12, 0, -23 },
  { 1504, 23, 23, 23, 0, -23 },
  { 1571, 19, 23, 18, 0, -23 },
  { 1626, 16, 23, 18, 1, -23 },
  { 1672, 15, 23, 15, 0, -23 },
  { 1716, 16, 28, 18, 1, -23 },
  { 1772, 15, 23, 15, 0, -23 },
  { 1816, 14, 23, 13, 0, -23 },
  { 1857, 12, 23, 13, 3, -23 },
  { 1892, 17, 23, 17, 1, -23 },
  { 1941, 14, 23, 14, 3, -23 },
  { 1982, 22, 23, 23, 3, -23 },
  { 2046, 18, 23, 13, -2, -23 },
  { 2098, 13, 23, 13, 3, -23 },
  { 2136, 15, 23, 13, -1, -23 },
  { 2180, 12, 28, 9, -1, -23 },
  { 2222, 6, 23, 11, 3, -23 },
  { 2240, 12, 28, 9, -2, -23 },
  { 2282, 13, 13, 14, 1, -23 },
  { 2304, 11, 2, 11, -3, 3 },
  { 2307, 4, 5, 8, 5, -24 },
  { 2310, 14, 17, 15, 1, -17 },
  { 2340, 14, 24, 15, 0, -24 },
  { 2382, 11, 17, 11, 1, -17 },
  { 2406, 15, 24, 15, 1, -24 },
  { 2451, 12, 17, 13, 1, -17 },
  { 2477, 16, 32, 8, -4, -24 },
  { 2541, 15, 25, 15, 0, -17 },
  { 2588, 14, 24, 15, 0, -24 },
  { 2630, 8, 24, 7, 0, -24 },
  { 2654, 12, 32, 7, -4, -24 },
  { 2702, 14, 24, 13, 0, -24 },
  { 2744, 8, 24, 7, 0, -24 },
  { 2768, 21, 17, 22, 0, -17 },
  { 2813, 14, 18, 15, 0, -18 },
  { 2845, 13, 17, 15, 1, -17 },
  { 2873, 15, 25, 15, -1, -17 },
  { 2920, 14, 25, 15, 1, -17 },
  { 2964, 11, 17, 10, 0, -17 },
  { 2988, 11, 17, 11, 0, -17 },
  { 3012, 9, 21, 9, 1, -21 },
  { 3036, 13, 17, 15, 1, -17 },
  { 3064, 12, 17, 12, 2, -17 },
  { 3090, 19, 17, 19, 2, -17 },
  { 3131, 14, 17, 12, -1, -17 },
  { 3161, 17, 25, 12, -3, -17 },
  { 3215, 12, 17, 11, -1, -17 },
  { 3241, 12, 28, 11, 1, -23 },
  { 3283, 2, 32, 13, 6, -24 },
  { 3291, 12, 28, 11, -2, -23 },
  { 3333, 12, 4, 15, 2, -13 },
};

const GFXfont NotoSans_Condensed_Italic32pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Italic32pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Italic32pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _NOTOSANS_CONDENSED_ITALIC32PT7B_H_
