#ifndef _NOTOSANS_CONDENSED_ITALIC67PT7B_H_
#define _NOTOSANS_CONDENSED_ITALIC67PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Italic.ttf
// Size: 67pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Italic67pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07,
  0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC,
  0x00, 0x30, 0x00, 0x3F, 0x07, 0xE7, 0xE0, 0xFC, 0xFC, 0x1F, 0x1F, 0x87,
  0xE3, 0xE0, 0xFC, 0x7C, 0x1F, 0x9F, 0x83, 0xE3, 0xE0, 0x7C, 0x7C, 0x0F,
  0x8F, 0x81, 0xE1, 0xF0, 0x7C, 0x3C, 0x0F, 0x87, 0x81, 0xF1, 0xF0, 0x3C,
  0x3E, 0x07, 0x87, 0x80, 0xF0, 0xF0, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x1E,
  0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x3C, 0x07,
  0x80, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x00, 0xF0,
  0x1F, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0x01, 0xF0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x03,
  0xC0, 0x3C, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00,
  0xF8, 0x0F, 0x00, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x3C, 0x07, 0x80, 0x00,
  0x3E, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xF8, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0xF0, 0x1E, 0x00,
  0x00, 0x78, 0x0F, 0x00, 0x00, 0x7C, 0x07, 0x80, 0x00, 0x3C, 0x07, 0xC0,
  0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x0F, 0x01, 0xF0,
  0x00, 0x07, 0x80, 0xF0, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x03, 0xC0, 0x7C,
  0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0xF8, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0x80, 0x3F, 0xFD, 0xFC, 0x03, 0xF1, 0xC1, 0xC0, 0x3F, 0x0E,
  0x02, 0x01, 0xF0, 0x70, 0x00, 0x0F, 0x83, 0x80, 0x00, 0xF8, 0x3C, 0x00,
  0x07, 0xC1, 0xC0, 0x00, 0x3E, 0x0E, 0x00, 0x01, 0xF0, 0x70, 0x00, 0x0F,
  0xC7, 0x80, 0x00, 0x3E, 0x3C, 0x00, 0x01, 0xF9, 0xC0, 0x00, 0x0F, 0xEE,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3B, 0xF8, 0x00, 0x01, 0xCF, 0xC0, 0x00, 0x0E,
  0x3F, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x07, 0x07, 0xC0, 0x00, 0x38, 0x3E,
  0x00, 0x01, 0xC1, 0xF0, 0x00, 0x0E, 0x0F, 0x80, 0x00, 0xF0, 0x7C, 0x00,
  0x07, 0x07, 0xC0, 0x80, 0x38, 0x3E, 0x07, 0x01, 0xC7, 0xF0, 0x3E, 0x0E,
  0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0x80, 0x1F, 0xF0, 0x00, 0x3C,
  0x00, 0xFF, 0xE0, 0x01, 0xF0, 0x07, 0xFF, 0x80, 0x07, 0x80, 0x3E, 0x1E,
  0x00, 0x3E, 0x00, 0xF0, 0x7C, 0x00, 0xF0, 0x07, 0xC1, 0xF0, 0x07, 0x80,
  0x1E, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x1F, 0x00, 0xF0, 0x03, 0xC0, 0x7C,
  0x07, 0xC0, 0x0F, 0x01, 0xE0, 0x1E, 0x00, 0x7C, 0x07, 0x80, 0xF8, 0x01,
  0xE0, 0x1E, 0x07, 0xC0, 0x07, 0x80, 0x78, 0x1E, 0x00, 0x1E, 0x03, 0xE0,
  0xF8, 0x00, 0xF8, 0x0F, 0x83, 0xC0, 0x03, 0xE0, 0x3C, 0x1F, 0x00, 0x0F,
  0x00, 0xF0, 0xF8, 0x00, 0x3C, 0x07, 0xC3, 0xC0, 0x00, 0xF0, 0x1F, 0x1F,
  0x07, 0xE3, 0xC0, 0x78, 0x78, 0x7F, 0xCF, 0x03, 0xE3, 0xE3, 0xFF, 0xBC,
  0x0F, 0x0F, 0x1F, 0xFF, 0xF0, 0x7C, 0x7C, 0x78, 0x7F, 0xE1, 0xE3, 0xE3,
  0xE0, 0xFF, 0xFF, 0x8F, 0x0F, 0x03, 0xDF, 0xFC, 0x7C, 0x7C, 0x0F, 0x3F,
  0xE1, 0xE1, 0xE0, 0x3C, 0x7F, 0x0F, 0x8F, 0x80, 0xF0, 0x60, 0x7C, 0x3C,
  0x03, 0xC0, 0x01, 0xE0, 0xF0, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x7C, 0x00,
  0x3C, 0x1F, 0x01, 0xF0, 0x01, 0xF0, 0x78, 0x07, 0x80, 0x0F, 0x81, 0xE0,
  0x1E, 0x00, 0x3E, 0x07, 0x80, 0xF8, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x07,
  0x80, 0xF8, 0x0F, 0x00, 0x3E, 0x03, 0xE0, 0x3C, 0x00, 0xF0, 0x0F, 0x81,
  0xF0, 0x07, 0xC0, 0x3E, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0xF0,
  0x03, 0xE0, 0xF0, 0x07, 0xC0, 0x07, 0x87, 0xC0, 0x1E, 0x00, 0x1F, 0xFE,
  0x00, 0xF8, 0x00, 0x7F, 0xF0, 0x07, 0xC0, 0x00, 0xFF, 0xC0, 0x1E, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x1F, 0x03, 0xE0,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x3E, 0x03, 0xF0,
  0x00, 0x7E, 0x03, 0xE0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x7C, 0x03, 0xE0,
  0x00, 0x7C, 0x07, 0xE0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x7E, 0x0F, 0xC0,
  0x00, 0x7E, 0x1F, 0x80, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0x3E, 0x3E, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x1F, 0x07, 0xF3, 0xE0, 0x1F,
  0x0F, 0xE3, 0xF0, 0x3F, 0x0F, 0xC3, 0xF0, 0x3E, 0x1F, 0x81, 0xF8, 0x3E,
  0x3F, 0x01, 0xF8, 0x7C, 0x3E, 0x00, 0xFC, 0x7C, 0x7E, 0x00, 0xFC, 0xFC,
  0x7E, 0x00, 0x7C, 0xF8, 0x7C, 0x00, 0x7F, 0xF0, 0x7C, 0x00, 0x7F, 0xF0,
  0xFC, 0x00, 0x3F, 0xE0, 0xFC, 0x00, 0x3F, 0xE0, 0xFC, 0x00, 0x1F, 0xC0,
  0xFC, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x3F, 0xC0, 0x7E, 0x00, 0x7F, 0xC0,
  0x7E, 0x01, 0xFF, 0xE0, 0x7F, 0x87, 0xFF, 0xE0, 0x3F, 0xFF, 0xF3, 0xF0,
  0x3F, 0xFF, 0xC3, 0xF0, 0x1F, 0xFF, 0x83, 0xF8, 0x07, 0xFE, 0x01, 0xF8,
  0x00, 0xE0, 0x00, 0x00, 0x1F, 0x9F, 0x8F, 0xC7, 0xE3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0x83, 0xC3, 0xE1, 0xE0, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x08, 0x07, 0xC0, 0x1C, 0x0F, 0x00, 0x3E,
  0x1E, 0x00, 0xFF, 0x3C, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7F, 0x00, 0x01, 0xFF,
  0x00, 0x07, 0xDE, 0x00, 0x3F, 0x1E, 0x00, 0xFC, 0x3C, 0x03, 0xF8, 0x7C,
  0x03, 0xE0, 0x7C, 0x03, 0x80, 0xF8, 0x02, 0x01, 0xF8, 0x00, 0x03, 0xC0,
  0x00, 0x02, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0x7C,
  0x0F, 0xC0, 0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x07, 0xC0,
  0x7C, 0x07, 0x80, 0xF0, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFE, 0x7F,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x1C, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x30, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8,
  0x00, 0xFF, 0x7F, 0x80, 0x3F, 0x83, 0xF0, 0x07, 0xE0, 0x3E, 0x01, 0xF8,
  0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0x83, 0xF0, 0x01, 0xF0,
  0x7E, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC3, 0xF0, 0x00, 0xF8, 0x7E, 0x00,
  0x1F, 0x0F, 0x80, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x8F,
  0x80, 0x03, 0xF3, 0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x0F, 0x8F, 0xC0, 0x01,
  0xF1, 0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xF9, 0xF8,
  0x00, 0x3F, 0x3E, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x3F,
  0x1F, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0xF8, 0xFC, 0x00, 0x3F, 0x1F, 0x80,
  0x07, 0xE3, 0xF0, 0x00, 0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE1,
  0xF8, 0x00, 0xF8, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xC0, 0xFC, 0x01,
  0xF8, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x07,
  0xF9, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xF0,
  0x7F, 0x7C, 0x3F, 0xBF, 0x1F, 0xCF, 0xCF, 0xE3, 0xE1, 0xF0, 0xF8, 0x70,
  0x7E, 0x08, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xF0, 0x01, 0xFE, 0x3F, 0xE0, 0x07, 0xE0, 0x1F, 0x80, 0x0E,
  0x00, 0x7F, 0x00, 0x10, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0x8F, 0xF8, 0x01, 0xE0,
  0x0F, 0xE0, 0x0C, 0x00, 0x3F, 0x00, 0x40, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xF0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x20, 0x00, 0x3F, 0x81,
  0x80, 0x03, 0xF8, 0x0F, 0x80, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xBE, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xF7, 0xC0, 0x00, 0x07, 0x9F, 0x00, 0x00, 0x3E, 0x7C, 0x00,
  0x01, 0xF3, 0xF0, 0x00, 0x07, 0x8F, 0x80, 0x00, 0x3E, 0x3E, 0x00, 0x01,
  0xF0, 0xF8, 0x00, 0x07, 0x87, 0xE0, 0x00, 0x3E, 0x1F, 0x80, 0x01, 0xF0,
  0x7C, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF0, 0x3F,
  0x00, 0x0F, 0x80, 0xF8, 0x00, 0x3E, 0x03, 0xE0, 0x01, 0xF0, 0x0F, 0x80,
  0x0F, 0x80, 0x7E, 0x00, 0x3E, 0x01, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3C, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xF0, 0x0F, 0x80,
  0x0F, 0xC0, 0x7C, 0x00, 0x3E, 0x01, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xF8, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x02,
  0x00, 0x03, 0xF8, 0x0E, 0x00, 0x1F, 0xC0, 0x3E, 0x03, 0xFE, 0x00, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xF0,
  0x01, 0xFF, 0x06, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF8, 0x7F, 0x00, 0x1F, 0x1F, 0xFC, 0x01, 0xF3, 0xFF, 0xE0, 0x3F,
  0x7F, 0xFE, 0x03, 0xEF, 0xFF, 0xF0, 0x3F, 0xE0, 0x7F, 0x03, 0xFC, 0x03,
  0xF0, 0x7F, 0x80, 0x1F, 0x87, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x87,
  0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x87, 0xC0, 0x01, 0xF8, 0x7C, 0x00,
  0x1F, 0x8F, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0x0F, 0xC0, 0x01, 0xF0,
  0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3E, 0x07, 0xC0,
  0x07, 0xE0, 0x7C, 0x00, 0x7E, 0x07, 0xC0, 0x0F, 0xC0, 0x7E, 0x01, 0xFC,
  0x07, 0xF0, 0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF,
  0xFE, 0x00, 0x7F, 0x87, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x3F,
  0x01, 0xF8, 0x01, 0xF8, 0x0F, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0x7E, 0x07,
  0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0xF8, 0x0F, 0xC0,
  0x07, 0xC0, 0x7E, 0x00, 0x7E, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F,
  0x00, 0x7E, 0x03, 0xF0, 0x01, 0xF8, 0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xE3, 0xF8,
  0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x00, 0xFC, 0x0F,
  0xC0, 0x07, 0xE0, 0x7E, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0xF8, 0x3F, 0x00,
  0x07, 0xE1, 0xF0, 0x00, 0x3F, 0x0F, 0x80, 0x01, 0xF8, 0x7C, 0x00, 0x0F,
  0xC3, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x3F, 0x07,
  0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0x81, 0xFC, 0x01, 0xFC, 0x07, 0xF8,
  0x3F, 0xC0, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xC0, 0x0F, 0xF1, 0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x1F, 0x80,
  0x7E, 0x03, 0xF0, 0x03, 0xE0, 0x3E, 0x00, 0x3E, 0x07, 0xE0, 0x03, 0xE0,
  0x7C, 0x00, 0x3F, 0x07, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0x80,
  0x03, 0xF0, 0xF8, 0x00, 0x3F, 0x0F, 0x80, 0x03, 0xF1, 0xF8, 0x00, 0x3E,
  0x1F, 0x80, 0x03, 0xE1, 0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x07, 0xE1, 0xF8,
  0x00, 0xFE, 0x1F, 0x80, 0x0F, 0xE0, 0xF8, 0x01, 0xFE, 0x0F, 0xC0, 0x3F,
  0xC0, 0xFE, 0x07, 0xFC, 0x0F, 0xFB, 0xF7, 0xC0, 0x7F, 0xFF, 0x7C, 0x03,
  0xFF, 0xEF, 0xC0, 0x1F, 0xF8, 0xF8, 0x00, 0xFF, 0x0F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0xE0, 0x7F, 0x80, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x03,
  0xFC, 0x0F, 0xE0, 0x1F, 0x80, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x03, 0xFC, 0x07, 0xE0, 0x1F, 0x00, 0x30, 0x00, 0x00, 0x1F, 0x00,
  0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03,
  0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00,
  0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x7F,
  0xFF, 0xC0, 0xFF, 0xFF, 0xC1, 0xFC, 0x7F, 0x81, 0xC0, 0x3F, 0x02, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00,
  0x00, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x3E,
  0x00, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x3F,
  0xC0, 0x3C, 0x1F, 0x00, 0x7F, 0xFC, 0x1E, 0x0F, 0x00, 0x7F, 0xFC, 0x0F,
  0x0F, 0x80, 0x7F, 0xFE, 0x07, 0x87, 0x80, 0x7C, 0x1F, 0x03, 0xC3, 0xC0,
  0x7C, 0x0F, 0x81, 0xE3, 0xE0, 0x3C, 0x07, 0x80, 0xF1, 0xE0, 0x3E, 0x03,
  0xC0, 0x79, 0xF0, 0x3E, 0x03, 0xE0, 0x3C, 0xF0, 0x1E, 0x01, 0xF0, 0x1E,
  0x78, 0x0F, 0x00, 0xF0, 0x0F, 0x3C, 0x0F, 0x80, 0x78, 0x0F, 0xBE, 0x07,
  0x80, 0x7C, 0x07, 0x9E, 0x03, 0xC0, 0x3E, 0x03, 0xCF, 0x03, 0xE0, 0x1E,
  0x01, 0xE7, 0x81, 0xE0, 0x1F, 0x01, 0xF3, 0xC0, 0xF0, 0x0F, 0x80, 0xF1,
  0xE0, 0x78, 0x07, 0xC0, 0x79, 0xF0, 0x3C, 0x07, 0xC0, 0x78, 0xF8, 0x1E,
  0x03, 0xE0, 0x3C, 0x78, 0x0F, 0x03, 0xF0, 0x3C, 0x3C, 0x07, 0x81, 0xF8,
  0x1E, 0x1E, 0x03, 0xE1, 0xDC, 0x1E, 0x0F, 0x01, 0xF9, 0xEF, 0x3F, 0x07,
  0x80, 0xFF, 0xE7, 0xFF, 0x03, 0xE0, 0x3F, 0xE1, 0xFF, 0x01, 0xF0, 0x0F,
  0xE0, 0xFE, 0x00, 0x78, 0x00, 0x80, 0x08, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xE0,
  0x00, 0x03, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x3E,
  0xF8, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x3E, 0x3E,
  0x00, 0x00, 0xF8, 0xF8, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x1F, 0x0F, 0x80,
  0x00, 0x7C, 0x3E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00,
  0x7E, 0x0F, 0x80, 0x01, 0xF0, 0x3E, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x3E,
  0x03, 0xE0, 0x01, 0xF8, 0x0F, 0x80, 0x07, 0xC0, 0x3E, 0x00, 0x3F, 0x00,
  0xF8, 0x00, 0xFC, 0x03, 0xE0, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x80, 0x3E,
  0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x3F,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0xFC, 0x1F, 0x80,
  0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3F, 0x1F, 0x80, 0x00,
  0xFC, 0x7E, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x3F,
  0x7E, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x1F, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F,
  0x80, 0x7F, 0x80, 0x1F, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x3F, 0x00, 0xFC,
  0x00, 0x7E, 0x01, 0xF8, 0x00, 0xFC, 0x03, 0xE0, 0x01, 0xF8, 0x07, 0xC0,
  0x03, 0xF0, 0x1F, 0x80, 0x07, 0xE0, 0x3F, 0x00, 0x0F, 0xC0, 0x7C, 0x00,
  0x1F, 0x80, 0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x03,
  0xF0, 0x0F, 0xC0, 0x0F, 0xE0, 0x1F, 0x00, 0x3F, 0x80, 0x3E, 0x07, 0xFE,
  0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x0F, 0x81, 0xFF, 0x00, 0x3F, 0x00, 0x7F, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x7C, 0x07,
  0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x3E,
  0x00, 0x07, 0xE0, 0x7C, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x1F, 0x03, 0xF0,
  0x00, 0x7E, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0x80, 0x03, 0xF8, 0x1F, 0x00,
  0x07, 0xE0, 0x7E, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x7F, 0x01, 0xF8, 0x03,
  0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xBF, 0x80, 0x1F, 0xF0, 0x06,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x60, 0x01,
  0xFF, 0x0F, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xE0, 0x3F, 0xE0,
  0x01, 0xF0, 0x07, 0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7F,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x03,
  0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0xFC, 0x07, 0xC0, 0x00,
  0x7E, 0x03, 0xE0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x0F, 0xC0, 0xFC, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x03, 0xF0, 0x3E, 0x00,
  0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x0F, 0xC0,
  0x00, 0x7E, 0x07, 0xC0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x07, 0xE0, 0x7C,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x1F,
  0x80, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x7F, 0x00,
  0xF8, 0x00, 0x3F, 0x80, 0x7C, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x7F, 0x80,
  0x3F, 0x00, 0x7F, 0x80, 0x1F, 0x81, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0xF8, 0x01,
  0xFC, 0x00, 0x04, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x3F, 0xFE, 0x1F, 0x80, 0x0F, 0xFF, 0x87, 0xC0, 0x03, 0xFF, 0xC3,
  0xF0, 0x00, 0xFF, 0xF0, 0xFC, 0x00, 0x7F, 0xFC, 0x3F, 0x00, 0x00, 0x3F,
  0x0F, 0xC0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x00,
  0xF8, 0x3F, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x00, 0x7C, 0x07, 0xE0,
  0x00, 0x3F, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x03, 0xE0, 0x1F,
  0xC0, 0x00, 0xF8, 0x03, 0xF8, 0x00, 0x3E, 0x00, 0xFF, 0x00, 0x1F, 0x80,
  0x1F, 0xF8, 0x3F, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x7C, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x1F, 0x80, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x1F, 0x00,
  0x00, 0xF8, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x01, 0xF8, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x01, 0xF0, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x7C,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0xFC, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x1F, 0x80, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x1F,
  0x00, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x01, 0xF8,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x7E,
  0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x07, 0xE0,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x02, 0x1F, 0xE0, 0x00, 0x7F,
  0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0xE0, 0x07, 0xC0, 0x01,
  0xF8, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x07, 0xE0, 0x00, 0xF8, 0x01, 0xFC, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x0F, 0xC0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0xFE, 0x00,
  0x03, 0xE0, 0x3F, 0x80, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0x03, 0xF0, 0x7F, 0x00, 0x00, 0x7C, 0x1F, 0xC0, 0x00, 0x0F, 0x83,
  0xF0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x0F,
  0xCF, 0xE0, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00,
  0x0F, 0xDF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xEF,
  0x80, 0x00, 0x07, 0xF9, 0xF8, 0x00, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0x1F,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00,
  0x1F, 0x81, 0xF8, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x7C, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x7E, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x1F, 0x80, 0x01, 0xF0, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x1F, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00,
  0x00, 0xFB, 0xE0, 0x07, 0xFE, 0x00, 0x03, 0xF7, 0xC0, 0x1F, 0x3C, 0x00,
  0x07, 0xDF, 0x80, 0x3E, 0x7C, 0x00, 0x0F, 0xBF, 0x00, 0x7C, 0xF8, 0x00,
  0x3E, 0x7C, 0x00, 0xF9, 0xF0, 0x00, 0x7C, 0xF8, 0x03, 0xF3, 0xE0, 0x01,
  0xF3, 0xF0, 0x07, 0xE7, 0xC0, 0x03, 0xE7, 0xE0, 0x0F, 0x8F, 0x80, 0x0F,
  0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x7C,
  0x3E, 0x00, 0xFC, 0x7C, 0x00, 0xF8, 0xFC, 0x01, 0xF0, 0xF8, 0x03, 0xE1,
  0xF8, 0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xE0, 0x07, 0xC3, 0xE0, 0x1F, 0x07,
  0xC0, 0x0F, 0x87, 0xC0, 0x3E, 0x1F, 0x80, 0x3F, 0x0F, 0x80, 0xF8, 0x3F,
  0x00, 0x7C, 0x1F, 0x01, 0xF0, 0x7E, 0x00, 0xF8, 0x1E, 0x07, 0xC0, 0xF8,
  0x01, 0xF0, 0x3C, 0x0F, 0x81, 0xF0, 0x07, 0xE0, 0x7C, 0x3F, 0x07, 0xE0,
  0x0F, 0xC0, 0xF8, 0x7C, 0x0F, 0xC0, 0x1F, 0x01, 0xF1, 0xF8, 0x1F, 0x80,
  0x3E, 0x03, 0xE3, 0xE0, 0x3E, 0x00, 0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0x01,
  0xF8, 0x0F, 0x9F, 0x01, 0xF8, 0x03, 0xF0, 0x1F, 0x3E, 0x03, 0xF0, 0x07,
  0xC0, 0x3E, 0xF8, 0x07, 0xC0, 0x0F, 0x80, 0x7D, 0xF0, 0x0F, 0x80, 0x1F,
  0x00, 0xFF, 0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xFF, 0x80, 0x7E, 0x00, 0xF8,
  0x03, 0xFE, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xFC, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0xFE, 0x00,
  0x01, 0xF0, 0x07, 0xF8, 0x00, 0x07, 0xC0, 0x1F, 0xE0, 0x00, 0x3F, 0x00,
  0x7F, 0x80, 0x00, 0xFC, 0x01, 0xFE, 0x00, 0x03, 0xE0, 0x07, 0xFC, 0x00,
  0x0F, 0x80, 0x3F, 0xF0, 0x00, 0x3E, 0x00, 0xFF, 0xC0, 0x01, 0xF8, 0x03,
  0xFF, 0x00, 0x07, 0xC0, 0x0F, 0xFE, 0x00, 0x1F, 0x00, 0x3E, 0xF8, 0x00,
  0x7C, 0x01, 0xF3, 0xE0, 0x03, 0xF0, 0x07, 0xCF, 0x80, 0x0F, 0xC0, 0x1F,
  0x3F, 0x00, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0x03, 0xF1, 0xF0, 0x03,
  0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x80, 0x3E, 0x1F, 0x00, 0x7E, 0x00, 0xF8,
  0x3E, 0x01, 0xF0, 0x03, 0xE0, 0xF8, 0x07, 0xC0, 0x1F, 0x83, 0xE0, 0x1F,
  0x00, 0x7C, 0x0F, 0x80, 0xFC, 0x01, 0xF0, 0x3F, 0x03, 0xF0, 0x07, 0xC0,
  0x7C, 0x0F, 0x80, 0x1F, 0x01, 0xF0, 0x3E, 0x00, 0xFC, 0x07, 0xC0, 0xF8,
  0x03, 0xE0, 0x1F, 0x87, 0xE0, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x3E, 0x00,
  0xF8, 0x7C, 0x01, 0xF8, 0x03, 0xE1, 0xF0, 0x07, 0xE0, 0x0F, 0x8F, 0xC0,
  0x1F, 0x00, 0x1F, 0x3F, 0x00, 0x7C, 0x00, 0x7C, 0xF8, 0x01, 0xF0, 0x01,
  0xF3, 0xE0, 0x0F, 0xC0, 0x07, 0xCF, 0x80, 0x3F, 0x00, 0x1F, 0xBE, 0x00,
  0xF8, 0x00, 0x3F, 0xF8, 0x03, 0xE0, 0x00, 0xFF, 0xC0, 0x0F, 0x80, 0x03,
  0xFF, 0x00, 0x7E, 0x00, 0x0F, 0xFC, 0x01, 0xF0, 0x00, 0x1F, 0xF0, 0x07,
  0xC0, 0x00, 0x7F, 0x80, 0x1F, 0x00, 0x01, 0xFE, 0x00, 0x7C, 0x00, 0x07,
  0xF8, 0x03, 0xF0, 0x00, 0x1F, 0xE0, 0x0F, 0x80, 0x00, 0x3F, 0x80, 0x3E,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xBF, 0xF0, 0x01, 0xFE, 0x03, 0xFC, 0x01, 0xFC, 0x00,
  0xFE, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0xFC, 0x00,
  0x07, 0xE0, 0x7E, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x7F, 0x00,
  0x00, 0x7C, 0x3F, 0x00, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x1F, 0x1F, 0x80,
  0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x03, 0xE7, 0xE0,
  0x00, 0x03, 0xF3, 0xF0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0xFD, 0xF8,
  0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x1F, 0xBF,
  0x00, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x01, 0xF9,
  0xF8, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E,
  0x3F, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0x1F,
  0x87, 0xE0, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x0F,
  0xE0, 0x7E, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x07, 0xE0, 0x1F, 0xC0, 0x0F,
  0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xF0, 0x01, 0xF0, 0x1F, 0xE0, 0x07, 0xC0, 0x3F, 0x80, 0x3F, 0x00,
  0x7F, 0x00, 0xFC, 0x00, 0xFC, 0x03, 0xF0, 0x03, 0xF0, 0x0F, 0x80, 0x0F,
  0xC0, 0x3E, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0xFC, 0x07, 0xE0, 0x03, 0xF0,
  0x1F, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0xFC, 0x0F,
  0xC0, 0x07, 0xE0, 0x3F, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x7E, 0x03, 0xE0,
  0x03, 0xF0, 0x1F, 0x80, 0x1F, 0xC0, 0x7E, 0x00, 0xFE, 0x01, 0xF8, 0x0F,
  0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xBF, 0xF0, 0x01, 0xFE, 0x03, 0xFC,
  0x01, 0xFC, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0xFC, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01,
  0xF8, 0x7F, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0x3E, 0x1F, 0x80, 0x00,
  0x1F, 0x1F, 0x80, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x07, 0xC7, 0xE0, 0x00,
  0x03, 0xE7, 0xE0, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x01, 0xF9, 0xF8, 0x00,
  0x00, 0xFD, 0xF8, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x3F, 0x7E, 0x00,
  0x00, 0x1F, 0xBF, 0x00, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x0F, 0xCF, 0x80,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x01, 0xFB, 0xF0,
  0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x7E, 0x7E,
  0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3F, 0x8F,
  0xC0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x0F, 0xC0,
  0xFC, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x07, 0xE0,
  0x1F, 0xC0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x03, 0xFF, 0x3F, 0xF0,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xF0,
  0x1F, 0xE0, 0x07, 0xC0, 0x3F, 0xC0, 0x3F, 0x00, 0x7F, 0x00, 0xFC, 0x00,
  0xFC, 0x03, 0xF0, 0x03, 0xF0, 0x0F, 0x80, 0x0F, 0xC0, 0x3E, 0x00, 0x3F,
  0x01, 0xF8, 0x00, 0xFC, 0x07, 0xE0, 0x03, 0xF0, 0x1F, 0x00, 0x0F, 0xC0,
  0x7C, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0x3F,
  0x00, 0x1F, 0x80, 0xF8, 0x00, 0xFC, 0x03, 0xE0, 0x07, 0xF0, 0x1F, 0x80,
  0x3F, 0x80, 0x7E, 0x01, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00,
  0x0F, 0xC1, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x07,
  0xE0, 0x7E, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x7C, 0x03, 0xE0, 0x01, 0xF0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x3F, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0xFC, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x80, 0x7E, 0x00, 0x7E,
  0x01, 0xF8, 0x00, 0xFC, 0x07, 0xE0, 0x03, 0xF0, 0x1F, 0x00, 0x0F, 0xC0,
  0x7C, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xF8, 0x3E,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0x80, 0x1F, 0xE0, 0x1E, 0x00, 0x7F, 0x00, 0x0C, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x01, 0x00, 0x03,
  0xF8, 0x03, 0x80, 0x0F, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFD, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0xFC,
  0x07, 0xC0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x07,
  0xE0, 0x3F, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x7E, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x03, 0xF0, 0x1F, 0x80,
  0x00, 0xFC, 0x07, 0xC0, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x7C,
  0x00, 0x03, 0xE0, 0x3F, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x7E, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x03, 0xF0,
  0x1F, 0x80, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x7C, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00,
  0x7E, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x07, 0xC0, 0x3E, 0x00,
  0x01, 0xF0, 0x1F, 0x80, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x3F, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x7C, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x01, 0xF8, 0x0F,
  0xC0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x07, 0xC0,
  0x3F, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x0F,
  0xE0, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x03, 0xF3, 0xF0,
  0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x7E, 0x3F, 0x00, 0x03, 0xF0, 0xFC, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0x3E, 0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xE0,
  0x3F, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xF0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0x7C, 0x01, 0xF0, 0x01, 0xF0,
  0x0F, 0xC0, 0x07, 0xC0, 0x3F, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x7C, 0x07,
  0xE0, 0x01, 0xF0, 0x1F, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x1F, 0x03, 0xE0,
  0x00, 0x7C, 0x1F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xC3, 0xF0, 0x00,
  0x1F, 0x0F, 0x80, 0x00, 0x7C, 0x7E, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x07,
  0xC7, 0xC0, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x01, 0xF7,
  0xE0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF7, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xEF, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0x9F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x1F,
  0xE0, 0x00, 0xF8, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0xFF,
  0x80, 0x07, 0xC3, 0xF0, 0x01, 0xEF, 0x00, 0x1F, 0x87, 0xE0, 0x07, 0xDE,
  0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xBC, 0x00, 0x7C, 0x1F, 0x80, 0x1E, 0x78,
  0x01, 0xF8, 0x3F, 0x00, 0x7C, 0xF0, 0x03, 0xE0, 0x7E, 0x00, 0xF9, 0xE0,
  0x0F, 0xC0, 0xF8, 0x03, 0xE3, 0xC0, 0x1F, 0x81, 0xF0, 0x07, 0xC7, 0x80,
  0x3E, 0x03, 0xE0, 0x0F, 0x1F, 0x00, 0xFC, 0x07, 0xC0, 0x3E, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x7C, 0x07, 0xE0, 0x1F, 0x01, 0xF0, 0xF8, 0x0F,
  0x80, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x00, 0x7C, 0x0F, 0x83, 0xE0, 0x7E,
  0x00, 0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x3E, 0x0F, 0x83, 0xF0,
  0x03, 0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0x07, 0xC1, 0xF0, 0x3E, 0x0F, 0x80,
  0x0F, 0x87, 0xC0, 0x7C, 0x3F, 0x00, 0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x00,
  0x3E, 0x1E, 0x01, 0xF1, 0xF8, 0x00, 0x7C, 0x7C, 0x03, 0xE3, 0xE0, 0x00,
  0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x01, 0xF3, 0xE0, 0x0F, 0x9F, 0x80, 0x03,
  0xE7, 0xC0, 0x1F, 0x3E, 0x00, 0x07, 0xCF, 0x00, 0x3E, 0xFC, 0x00, 0x0F,
  0xBE, 0x00, 0x7D, 0xF0, 0x00, 0x1F, 0x7C, 0x00, 0xFB, 0xE0, 0x00, 0x3E,
  0xF0, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x07, 0xE0, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00,
  0x07, 0xE0, 0x3F, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x1F,
  0x00, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x01,
  0xF8, 0xFC, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x00, 0x3E, 0x7C, 0x00,
  0x00, 0x01, 0xF7, 0xE0, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xDF, 0x80, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00, 0x03, 0xE3,
  0xE0, 0x00, 0x00, 0x3F, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x00,
  0x1F, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0xF8,
  0x00, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x7C,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFB, 0xF0,
  0x00, 0x3E, 0x7E, 0x00, 0x0F, 0xCF, 0xC0, 0x03, 0xF0, 0xF8, 0x00, 0x7E,
  0x1F, 0x00, 0x1F, 0x83, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0,
  0x1F, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x3F, 0x00,
  0x7C, 0x07, 0xC0, 0x0F, 0x81, 0xF8, 0x01, 0xF0, 0x7E, 0x00, 0x3F, 0x0F,
  0x80, 0x07, 0xE3, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x9F, 0x80, 0x01,
  0xF3, 0xE0, 0x00, 0x3E, 0xFC, 0x00, 0x07, 0xDF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xFF,
  0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x80, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x01, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x80, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x01, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x00, 0x07, 0xFF,
  0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F,
  0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1E, 0x7C, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3C, 0x3C, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0x81, 0xF0, 0x01, 0xF0,
  0x1F, 0x00, 0x1F, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x07, 0xC0, 0x0F, 0x80, 0xFC, 0x00, 0x7C, 0x0F, 0x80, 0x07, 0xC1, 0xF0,
  0x00, 0x7C, 0x1F, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x3E, 0x3E, 0x00, 0x03,
  0xE7, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xF0, 0x7F, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFC, 0x7E, 0x1F, 0x8F,
  0xC3, 0xE0, 0xF8, 0x7C, 0x1E, 0x07, 0x83, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xFF, 0x07, 0xC0, 0x1F, 0xFE, 0x3E, 0x01, 0xFF, 0xF3, 0xE0, 0x1F,
  0xFF, 0xDF, 0x01, 0xFE, 0x1E, 0xF8, 0x0F, 0xE0, 0x7F, 0xC0, 0xFE, 0x01,
  0xFC, 0x07, 0xE0, 0x0F, 0xE0, 0x7E, 0x00, 0x3F, 0x03, 0xF0, 0x01, 0xF8,
  0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7C, 0x1F, 0x80, 0x03, 0xE0, 0xFC,
  0x00, 0x3F, 0x07, 0xC0, 0x01, 0xF8, 0x3E, 0x00, 0x0F, 0xC3, 0xF0, 0x00,
  0x7C, 0x1F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x3F, 0x07, 0xC0, 0x01, 0xF8,
  0x3E, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x7C, 0x1F, 0x80, 0x07, 0xE0, 0xFC,
  0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0xFC, 0x0F, 0xC0, 0x0F, 0xE0, 0x7E, 0x00, 0xFF, 0x03, 0xF0, 0x07, 0xF8,
  0x0F, 0xC0, 0x7F, 0x80, 0x7F, 0x0F, 0x7C, 0x03, 0xFF, 0xFB, 0xE0, 0x0F,
  0xFF, 0x9F, 0x00, 0x3F, 0xF8, 0xF8, 0x00, 0xFF, 0x07, 0x80, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x18, 0x00, 0x1F, 0x0F, 0xF0, 0x01, 0xF1,
  0xFF, 0xC0, 0x1F, 0x3F, 0xFC, 0x03, 0xF7, 0xFF, 0xE0, 0x3E, 0xF8, 0xFE,
  0x03, 0xFE, 0x03, 0xF0, 0x3F, 0xC0, 0x3F, 0x03, 0xF8, 0x03, 0xF0, 0x7F,
  0x00, 0x1F, 0x07, 0xF0, 0x01, 0xF0, 0x7E, 0x00, 0x1F, 0x07, 0xE0, 0x01,
  0xF0, 0x7C, 0x00, 0x1F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F,
  0x80, 0x03, 0xF0, 0xF8, 0x00, 0x3F, 0x1F, 0x80, 0x03, 0xE1, 0xF8, 0x00,
  0x3E, 0x1F, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x7E, 0x1F, 0x00, 0x07, 0xE3,
  0xF0, 0x00, 0x7C, 0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x3F, 0x00,
  0x1F, 0x83, 0xF0, 0x01, 0xF8, 0x7F, 0x00, 0x3F, 0x07, 0xF0, 0x03, 0xF0,
  0x7F, 0x00, 0x7E, 0x07, 0xF8, 0x0F, 0xE0, 0xFB, 0xC1, 0xFC, 0x0F, 0xBF,
  0xFF, 0x80, 0xF9, 0xFF, 0xF0, 0x0F, 0x0F, 0xFE, 0x00, 0xF0, 0x7F, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x3F,
  0xFF, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xFC, 0x01, 0xFE, 0x1C, 0x03, 0xF8,
  0x04, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x40, 0x7F, 0x83, 0xC0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x01, 0x81, 0xF8, 0x00, 0x1F,
  0xE1, 0xF8, 0x00, 0x7F, 0xF9, 0xF0, 0x00, 0xFF, 0xF9, 0xF0, 0x01, 0xFF,
  0xFD, 0xF0, 0x03, 0xFC, 0x3D, 0xF0, 0x03, 0xF8, 0x1F, 0xF0, 0x07, 0xF0,
  0x0F, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x07, 0xE0, 0x0F, 0x80,
  0x07, 0xE0, 0x1F, 0x80, 0x07, 0xE0, 0x1F, 0x80, 0x07, 0xC0, 0x3F, 0x00,
  0x07, 0xC0, 0x3F, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x0F, 0xC0, 0x7E, 0x00,
  0x0F, 0x80, 0x7E, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x0F, 0x80, 0x7C, 0x00,
  0x1F, 0x80, 0x7C, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x1F, 0x00, 0xFC, 0x00,
  0x1F, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0xFC, 0x00,
  0x7F, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFC, 0x00,
  0xFE, 0x00, 0xFC, 0x01, 0xFE, 0x00, 0xFC, 0x03, 0xFC, 0x00, 0x7E, 0x07,
  0xFC, 0x00, 0x7F, 0x0F, 0x7C, 0x00, 0x7F, 0xFF, 0x7C, 0x00, 0x3F, 0xFE,
  0x7C, 0x00, 0x1F, 0xFC, 0x78, 0x00, 0x0F, 0xF0, 0x78, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFF, 0x00,
  0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x1F, 0xE1, 0xF8, 0x0F, 0xC0, 0x7C,
  0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0x87, 0xE0, 0x07,
  0xC3, 0xF0, 0x03, 0xE3, 0xF0, 0x03, 0xF1, 0xF8, 0x03, 0xF0, 0xF8, 0x03,
  0xF8, 0xFC, 0x07, 0xF8, 0x7E, 0x1F, 0xF8, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x60, 0x7F, 0x80, 0xF0, 0x1F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x70, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0xFE, 0x1F, 0x00, 0x0F,
  0xFF, 0x1E, 0x00, 0x1F, 0xFF, 0x1E, 0x00, 0x3F, 0xFF, 0xBE, 0x00, 0x3F,
  0x87, 0xBE, 0x00, 0x7F, 0x03, 0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0xFC,
  0x01, 0xFC, 0x01, 0xF8, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0xFC, 0x03, 0xF0,
  0x00, 0xFC, 0x03, 0xF0, 0x00, 0xF8, 0x07, 0xE0, 0x01, 0xF8, 0x07, 0xE0,
  0x01, 0xF8, 0x07, 0xC0, 0x01, 0xF8, 0x0F, 0xC0, 0x01, 0xF8, 0x0F, 0xC0,
  0x01, 0xF0, 0x0F, 0xC0, 0x01, 0xF0, 0x0F, 0x80, 0x03, 0xF0, 0x0F, 0x80,
  0x03, 0xF0, 0x1F, 0x80, 0x03, 0xE0, 0x1F, 0x80, 0x07, 0xE0, 0x1F, 0x80,
  0x07, 0xE0, 0x1F, 0x80, 0x07, 0xE0, 0x1F, 0x80, 0x0F, 0xE0, 0x1F, 0x80,
  0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0x80,
  0x3F, 0xC0, 0x1F, 0x80, 0x7F, 0xC0, 0x0F, 0xC0, 0xFF, 0x80, 0x0F, 0xE1,
  0xEF, 0x80, 0x0F, 0xFF, 0xEF, 0x80, 0x07, 0xFF, 0xDF, 0x80, 0x03, 0xFF,
  0x9F, 0x80, 0x01, 0xFE, 0x1F, 0x00, 0x00, 0x70, 0x1F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0xC0, 0x01, 0xF8, 0x00, 0xF0, 0x07,
  0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x02,
  0x00, 0x0F, 0x87, 0xFC, 0x01, 0xF1, 0xFF, 0xC0, 0x3E, 0xFF, 0xF8, 0x0F,
  0xDF, 0xFF, 0x81, 0xF7, 0xC7, 0xF0, 0x3F, 0xE0, 0x7E, 0x07, 0xF8, 0x07,
  0xC0, 0xFE, 0x00, 0xF8, 0x3F, 0x80, 0x1F, 0x07, 0xF0, 0x03, 0xE0, 0xFC,
  0x00, 0x7C, 0x1F, 0x80, 0x0F, 0x83, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7E,
  0x1F, 0x80, 0x0F, 0x83, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x7E, 0x1F, 0x80,
  0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC1,
  0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xC1, 0xF0, 0x00,
  0xF8, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3F,
  0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x3F, 0x00, 0x1F,
  0x87, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x83, 0xE0,
  0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0x80, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x7F, 0x01, 0xF0, 0x07,
  0xE0, 0x0F, 0x80, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x3F, 0x00,
  0x3E, 0x03, 0xF0, 0x01, 0xF0, 0x3F, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0xFC,
  0x1F, 0x80, 0x07, 0xE1, 0xF8, 0x00, 0x3E, 0x1F, 0x80, 0x01, 0xF1, 0xF8,
  0x00, 0x0F, 0x9F, 0x80, 0x00, 0xFC, 0xFC, 0x00, 0x07, 0xCF, 0xC0, 0x00,
  0x3E, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF,
  0xFC, 0x00, 0x07, 0xFB, 0xF0, 0x00, 0x3F, 0x9F, 0x80, 0x01, 0xF8, 0xFC,
  0x00, 0x1F, 0x83, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xC0, 0xFC, 0x00,
  0x3E, 0x07, 0xE0, 0x01, 0xF0, 0x1F, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0xFC,
  0x07, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xF8, 0x00, 0xF8, 0x07, 0xC0, 0x07, 0xE0,
  0x3E, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x3E, 0x1F, 0xE0, 0x1F, 0xE0, 0x07, 0x8F, 0xFE,
  0x0F, 0xFE, 0x00, 0xF3, 0xFF, 0xE3, 0xFF, 0xE0, 0x3E, 0xFF, 0xFC, 0xFF,
  0xFC, 0x07, 0xDE, 0x1F, 0xFE, 0x1F, 0xC0, 0xFF, 0x81, 0xFF, 0x81, 0xF8,
  0x1F, 0xE0, 0x3F, 0xC0, 0x3F, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0xE0, 0xFE,
  0x00, 0xFE, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0x83, 0xF0, 0x03,
  0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x83, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x7E, 0x00, 0x7E, 0x00, 0x7E,
  0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0xC1, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x7E,
  0x00, 0x3E, 0x00, 0x3E, 0x0F, 0xC0, 0x07, 0xC0, 0x0F, 0xC1, 0xF0, 0x01,
  0xF8, 0x01, 0xF8, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC1, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x07, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x1F, 0x00, 0x1F, 0x80, 0x1F, 0x83, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x1F, 0x80, 0x0F, 0x80, 0x0F,
  0x83, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x7C, 0x00, 0x7E, 0x00, 0x7E, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x07, 0xC3, 0xFE,
  0x00, 0x3C, 0x7F, 0xF8, 0x01, 0xE7, 0xFF, 0xE0, 0x1F, 0x7F, 0xFF, 0x00,
  0xFB, 0xE3, 0xF8, 0x07, 0xFC, 0x0F, 0xC0, 0x3F, 0xC0, 0x3F, 0x03, 0xFC,
  0x01, 0xF8, 0x1F, 0xC0, 0x0F, 0x80, 0xFE, 0x00, 0x7C, 0x07, 0xE0, 0x03,
  0xE0, 0x3F, 0x00, 0x3F, 0x03, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xC0,
  0xFC, 0x00, 0x7C, 0x07, 0xC0, 0x03, 0xE0, 0x3E, 0x00, 0x3F, 0x03, 0xF0,
  0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0x7C, 0x07, 0xC0, 0x03,
  0xE0, 0x7E, 0x00, 0x3F, 0x03, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0x80,
  0xF8, 0x00, 0x7C, 0x07, 0xC0, 0x03, 0xE0, 0x7E, 0x00, 0x3F, 0x03, 0xF0,
  0x01, 0xF8, 0x1F, 0x80, 0x0F, 0x80, 0xF8, 0x00, 0x7C, 0x07, 0xC0, 0x07,
  0xE0, 0x7E, 0x00, 0x3F, 0x03, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0x80,
  0xF8, 0x00, 0x7C, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x00, 0xFF, 0x0F, 0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x0F, 0xC0,
  0x0F, 0xC3, 0xF0, 0x01, 0xF1, 0xF8, 0x00, 0x7C, 0x7E, 0x00, 0x1F, 0x1F,
  0x00, 0x07, 0xCF, 0xC0, 0x01, 0xF3, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x1F,
  0x7E, 0x00, 0x0F, 0xDF, 0x80, 0x03, 0xF7, 0xC0, 0x00, 0xFD, 0xF0, 0x00,
  0x3F, 0x7C, 0x00, 0x0F, 0xBF, 0x00, 0x07, 0xEF, 0xC0, 0x01, 0xFB, 0xF0,
  0x00, 0x7E, 0xFC, 0x00, 0x1F, 0x3F, 0x00, 0x0F, 0xCF, 0xC0, 0x03, 0xF3,
  0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x07, 0xC0, 0x1F,
  0xC1, 0xF8, 0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x1F, 0x0F, 0xF0, 0x00, 0x1E, 0x1F, 0xFC,
  0x00, 0x1E, 0x3F, 0xFC, 0x00, 0x3E, 0x7F, 0xFE, 0x00, 0x3E, 0xF8, 0x7E,
  0x00, 0x3F, 0xE0, 0x3F, 0x00, 0x3F, 0xC0, 0x3F, 0x00, 0x3F, 0x80, 0x3F,
  0x00, 0x7F, 0x80, 0x1F, 0x00, 0x7F, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x1F,
  0x00, 0x7E, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x1F,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x3F,
  0x01, 0xF8, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x7E,
  0x01, 0xF0, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x7C,
  0x03, 0xF0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0xFC, 0x03, 0xF0, 0x01, 0xF8,
  0x03, 0xF0, 0x01, 0xF8, 0x07, 0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x03, 0xF0,
  0x07, 0xF0, 0x07, 0xE0, 0x07, 0xF8, 0x0F, 0xE0, 0x07, 0xFC, 0x1F, 0xC0,
  0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0x9F, 0xFF, 0x00, 0x0F, 0x8F, 0xFE, 0x00,
  0x0F, 0x87, 0xF8, 0x00, 0x1F, 0x81, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xFF, 0x87, 0xC0, 0x1F, 0xFE, 0x3C, 0x01, 0xFF, 0xF3, 0xE0, 0x1F,
  0xFF, 0xDF, 0x00, 0xFE, 0x1E, 0xF8, 0x0F, 0xE0, 0x7F, 0xC0, 0xFE, 0x01,
  0xFC, 0x07, 0xE0, 0x0F, 0xE0, 0x7E, 0x00, 0x3F, 0x03, 0xE0, 0x01, 0xF8,
  0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7C, 0x1F, 0x80, 0x07, 0xE0, 0xFC,
  0x00, 0x3F, 0x07, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x0F, 0x83, 0xF0, 0x00,
  0x7C, 0x1F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x3F, 0x07, 0xC0, 0x01, 0xF8,
  0x7E, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x7C, 0x1F, 0x80, 0x07, 0xE0, 0xFC,
  0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF8, 0x3F, 0x00, 0x1F, 0x81, 0xF8, 0x01,
  0xFC, 0x0F, 0xC0, 0x0F, 0xE0, 0x7E, 0x00, 0xFF, 0x03, 0xF0, 0x0F, 0xF8,
  0x0F, 0xC0, 0xFF, 0x80, 0x7F, 0x0F, 0x7C, 0x03, 0xFF, 0xFB, 0xE0, 0x0F,
  0xFF, 0xBF, 0x00, 0x3F, 0xF9, 0xF0, 0x00, 0xFF, 0x0F, 0x80, 0x01, 0xC0,
  0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x03, 0xC1, 0xFC, 0x07, 0x8F, 0xF0, 0x0F, 0x3F, 0xE0, 0x3E, 0x7F, 0xC0,
  0x7D, 0xFF, 0x00, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07,
  0xF0, 0x3C, 0x07, 0xE0, 0x0C, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xE0, 0x80, 0x07, 0xE0, 0x80, 0x0F, 0xE0, 0xF0, 0x3F, 0xC0, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x07, 0xFF, 0xCF, 0xFF,
  0xF3, 0xFF, 0xF8, 0xFF, 0xFE, 0x7F, 0xFF, 0x81, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x40, 0x7F, 0xF0, 0x1F, 0xFC,
  0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x01, 0xF0,
  0x3E, 0x00, 0x1F, 0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xC0,
  0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x7E,
  0x0F, 0xC0, 0x07, 0xC0, 0xF8, 0x00, 0x7C, 0x0F, 0x80, 0x07, 0xC0, 0xF8,
  0x00, 0xFC, 0x1F, 0x80, 0x0F, 0xC1, 0xF8, 0x00, 0xF8, 0x1F, 0x00, 0x0F,
  0x81, 0xF0, 0x00, 0xF8, 0x3F, 0x00, 0x1F, 0x83, 0xF0, 0x01, 0xF8, 0x3E,
  0x00, 0x1F, 0x03, 0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x3F, 0x07, 0xE0, 0x03,
  0xF0, 0x7E, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0xE0, 0x7C, 0x00, 0x7E, 0x07,
  0xC0, 0x07, 0xE0, 0xFC, 0x00, 0xFE, 0x0F, 0xC0, 0x0F, 0xC0, 0xFC, 0x01,
  0xFC, 0x0F, 0xC0, 0x3F, 0xC0, 0xFC, 0x07, 0xFC, 0x07, 0xE1, 0xF7, 0xC0,
  0x7F, 0xFE, 0x78, 0x07, 0xFF, 0xCF, 0x80, 0x3F, 0xF8, 0xF8, 0x01, 0xFF,
  0x0F, 0x80, 0x03, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0xFC,
  0xF8, 0x00, 0xF8, 0xF8, 0x01, 0xF8, 0xF8, 0x01, 0xF8, 0xF8, 0x01, 0xF0,
  0xF8, 0x03, 0xF0, 0xF8, 0x03, 0xE0, 0xF8, 0x07, 0xE0, 0xF8, 0x07, 0xC0,
  0xF8, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0xFC, 0x1F, 0x80, 0x7C, 0x1F, 0x00,
  0x7C, 0x3F, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x7C, 0x00,
  0x7C, 0x7C, 0x00, 0x7C, 0xFC, 0x00, 0x7C, 0xF8, 0x00, 0x7D, 0xF8, 0x00,
  0x7D, 0xF0, 0x00, 0x7D, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0xF0,
  0x01, 0xF8, 0x00, 0xFB, 0xE0, 0x07, 0xF0, 0x03, 0xF7, 0xC0, 0x0F, 0xE0,
  0x07, 0xEF, 0x80, 0x1F, 0xC0, 0x0F, 0x9F, 0x00, 0x7F, 0x80, 0x3F, 0x3E,
  0x00, 0xFF, 0x00, 0x7C, 0x7C, 0x03, 0xFE, 0x01, 0xF8, 0xF8, 0x07, 0xBC,
  0x03, 0xE1, 0xF0, 0x0F, 0x78, 0x07, 0xC3, 0xE0, 0x3E, 0xF0, 0x1F, 0x87,
  0xC0, 0x79, 0xE0, 0x3E, 0x0F, 0x81, 0xF3, 0xC0, 0xFC, 0x1F, 0x03, 0xC7,
  0x81, 0xF0, 0x3E, 0x0F, 0x8F, 0x03, 0xE0, 0x7C, 0x1F, 0x1E, 0x0F, 0xC0,
  0xF8, 0x3C, 0x3C, 0x1F, 0x01, 0xF0, 0xF8, 0x78, 0x7E, 0x03, 0xE1, 0xE0,
  0xF0, 0xF8, 0x07, 0xC7, 0xC1, 0xE1, 0xF0, 0x0F, 0x8F, 0x83, 0xC7, 0xC0,
  0x1F, 0x1E, 0x07, 0x8F, 0x80, 0x3E, 0x7C, 0x0F, 0x1F, 0x00, 0x7C, 0xF0,
  0x1E, 0x7C, 0x00, 0xFB, 0xE0, 0x3C, 0xF8, 0x01, 0xF7, 0xC0, 0x7B, 0xE0,
  0x03, 0xEF, 0x00, 0xF7, 0xC0, 0x07, 0xFE, 0x01, 0xEF, 0x80, 0x0F, 0xF8,
  0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x7E, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x07, 0xE0, 0x3F, 0x00, 0x07, 0xC0,
  0x7C, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x3F, 0x0F,
  0x80, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x00, 0xF9, 0xF0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00,
  0xFC, 0xF8, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1F,
  0x87, 0xE0, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0xF8, 0x0F, 0x80, 0x03, 0xF0,
  0x1F, 0x80, 0x0F, 0xC0, 0x3F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7E, 0x00,
  0x7C, 0x01, 0xF8, 0x00, 0xFC, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x07, 0xE0, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3E,
  0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x01, 0xF8, 0x01, 0xF0, 0x00, 0x3F, 0x00,
  0x7E, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x0F,
  0x80, 0x7C, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0x3E, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x7C, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0x1F, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0xFC, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x0F, 0x87,
  0xE0, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0x07,
  0xC7, 0xC0, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00, 0x0F, 0x3E, 0x00, 0x00,
  0x01, 0xE7, 0xC0, 0x00, 0x00, 0x3D, 0xF0, 0x00, 0x00, 0x07, 0xBE, 0x00,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x27, 0xFF, 0x00, 0x05, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xF4, 0x00,
  0x0F, 0xF8, 0x80, 0x00, 0x0C, 0x00,
};

const GFXglyph NotoSans_Condensed_Italic67pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 16, 49, 16, 1, -48 },
  { 99, 19, 17, 24, 7, -48 },
  { 140, 33, 48, 33, 1, -48 },
  { 338, 29, 55, 29, 1, -51 },
  { 538, 38, 50, 45, 4, -49 },
  { 776, 32, 50, 34, 0, -49 },
  { 976, 9, 17, 13, 7, -48 },
  { 996, 20, 59, 18, 2, -48 },
  { 1144, 21, 59, 18, -5, -48 },
  { 1299, 23, 25, 28, 7, -51 },
  { 1371, 27, 32, 32, 3, -40 },
  { 1479, 12, 17, 15, -3, -8 },
  { 1505, 16, 6, 18, 1, -21 },
  { 1517, 7, 9, 15, 1, -8 },
  { 1525, 31, 48, 23, -3, -48 },
  { 1711, 27, 50, 29, 2, -49 },
  { 1880, 18, 48, 29, 8, -48 },
  { 1988, 30, 49, 29, -1, -49 },
  { 2172, 29, 50, 29, 0, -49 },
  { 2354, 30, 48, 29, -1, -48 },
  { 2534, 30, 49, 29, 0, -48 },
  { 2718, 28, 50, 29, 2, -49 },
  { 2893, 29, 48, 29, 3, -48 },
  { 3067, 29, 50, 29, 1, -49 },
  { 3249, 28, 50, 29, 1, -49 },
  { 3424, 14, 37, 15, 0, -36 },
  { 3489, 17, 45, 15, -3, -36 },
  { 3585, 27, 30, 32, 3, -39 },
  { 3687, 27, 19, 32, 3, -33 },
  { 3752, 27, 30, 32, 3, -39 },
  { 3854, 23, 50, 22, 2, -49 },
  { 3998, 41, 54, 45, 2, -48 },
  { 4275, 30, 48, 30, -4, -48 },
  { 4455, 31, 48, 32, 1, -48 },
  { 4641, 31, 50, 30, 3, -49 },
  { 4835, 33, 48, 35, 1, -48 },
  { 5033, 29, 48, 27, 1, -48 },
  { 5207, 29, 48, 26, 1, -48 },
  { 5381, 34, 50, 37, 3, -49 },
  { 5594, 36, 48, 36, 1, -48 },
  { 5810, 26, 48, 19, -3, -48 },
  { 5966, 27, 61, 15, -10, -48 },
  { 6172, 35, 48, 30, 1, -48 },
  { 6382, 20, 48, 25, 1, -48 },
  { 6502, 47, 48, 47, 1, -48 },
  { 6784, 38, 48, 38, 1, -48 },
  { 7012, 33, 50, 38, 3, -49 },
  { 7219, 30, 48, 30, 1, -48 },
  { 7399, 33, 60, 38, 3, -49 },
  { 7647, 30, 48, 31, 1, -48 },
  { 7827, 31, 50, 28, -1, -49 },
  { 8021, 27, 48, 26, 5, -48 },
  { 8183, 34, 49, 36, 3, -48 },
  { 8392, 30, 48, 30, 6, -48 },
  { 8572, 47, 48, 48, 6, -48 },
  { 8854, 37, 48, 28, -4, -48 },
  { 9076, 27, 48, 27, 6, -48 },
  { 9238, 32, 48, 26, -2, -48 },
  { 9430, 25, 59, 19, -1, -48 },
  { 9615, 11, 48, 23, 7, -48 },
  { 9681, 26, 59, 19, -5, -48 },
  { 9873, 28, 27, 30, 1, -48 },
  { 9968, 23, 4, 22, -6, 6 },
  { 9980, 9, 10, 17, 10, -51 },
  { 9992, 29, 38, 31, 2, -37 },
  { 10130, 28, 52, 31, 1, -51 },
  { 10312, 24, 38, 24, 2, -37 },
  { 10426, 32, 52, 31, 2, -51 },
  { 10634, 25, 38, 28, 2, -37 },
  { 10753, 33, 67, 17, -8, -51 },
  { 11030, 32, 53, 31, -1, -37 },
  { 11242, 27, 51, 31, 1, -51 },
  { 11415, 15, 49, 14, 1, -49 },
  { 11507, 25, 65, 14, -9, -49 },
  { 11711, 29, 51, 27, 1, -51 },
  { 11896, 16, 51, 14, 1, -51 },
  { 11998, 43, 37, 46, 1, -37 },
  { 12197, 29, 37, 31, 0, -37 },
  { 12332, 26, 38, 30, 2, -37 },
  { 12456, 32, 53, 31, -3, -37 },
  { 12668, 29, 53, 31, 2, -37 },
  { 12861, 23, 37, 21, 1, -37 },
  { 12968, 24, 38, 24, 0, -37 },
  { 13082, 18, 45, 18, 2, -44 },
  { 13184, 28, 37, 31, 2, -36 },
  { 13314, 24, 36, 25, 4, -36 },
  { 13422, 39, 36, 40, 4, -36 },
  { 13598, 31, 36, 26, -3, -36 },
  { 13738, 35, 52, 25, -6, -36 },
  { 13966, 26, 36, 22, -2, -36 },
  { 14083, 25, 59, 22, 1, -48 },
  { 14268, 5, 67, 28, 12, -51 },
  { 14310, 25, 59, 22, -4, -48 },
  { 14495, 27, 9, 32, 3, -28 },
};

const GFXfont NotoSans_Condensed_Italic67pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Italic67pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Italic67pt7bGlyphs,
  0x20, 0x7E, 91
};

#endif // _NOTOSANS_CONDENSED_ITALIC67PT7B_H_
