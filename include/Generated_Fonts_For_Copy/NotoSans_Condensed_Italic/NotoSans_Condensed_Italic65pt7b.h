#ifndef _NOTOSANS_CONDENSED_ITALIC65PT7B_H_
#define _NOTOSANS_CONDENSED_ITALIC65PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Italic.ttf
// Size: 65pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Italic65pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x01,
  0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x20, 0x00, 0x3F,
  0x0F, 0xCF, 0x83, 0xF3, 0xE0, 0xF8, 0xF8, 0x3E, 0x7E, 0x0F, 0x9F, 0x03,
  0xE7, 0xC1, 0xF1, 0xF0, 0x7C, 0x7C, 0x1F, 0x1E, 0x07, 0xCF, 0x81, 0xE3,
  0xE0, 0x78, 0xF0, 0x3E, 0x3C, 0x0F, 0x0F, 0x03, 0xC3, 0xC0, 0xF0, 0x00,
  0x01, 0xE0, 0x3C, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x03, 0xC0, 0x78, 0x00,
  0x03, 0xC0, 0x78, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x07, 0xC0, 0xF8, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0x1E, 0x03, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x07, 0x80, 0x00,
  0x7C, 0x0F, 0x80, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00,
  0xF8, 0x0F, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00,
  0xF0, 0x1E, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x01,
  0xE0, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0x80, 0xF0, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3C,
  0x07, 0x80, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0x78,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFE, 0x01, 0xF8, 0xE1, 0xC0, 0x3F, 0x1E, 0x04, 0x03, 0xE1, 0xC0,
  0x00, 0x3C, 0x1C, 0x00, 0x07, 0xC1, 0xC0, 0x00, 0x7C, 0x1C, 0x00, 0x07,
  0xC3, 0xC0, 0x00, 0x7C, 0x38, 0x00, 0x07, 0xC3, 0x80, 0x00, 0x7E, 0x38,
  0x00, 0x03, 0xF3, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xEF, 0xC0,
  0x00, 0x1E, 0x7E, 0x00, 0x01, 0xC3, 0xE0, 0x00, 0x1C, 0x3E, 0x00, 0x01,
  0xC3, 0xE0, 0x00, 0x1C, 0x3E, 0x00, 0x03, 0x83, 0xE0, 0x00, 0x38, 0x3E,
  0x00, 0x03, 0x83, 0xE0, 0x80, 0x38, 0x7C, 0x0C, 0x03, 0x8F, 0xC0, 0xF0,
  0x71, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x3E, 0x00, 0xFF, 0xC0, 0x01, 0xE0, 0x0F,
  0xFE, 0x00, 0x1E, 0x00, 0xF8, 0xF8, 0x01, 0xF0, 0x0F, 0x83, 0xC0, 0x0F,
  0x00, 0x78, 0x1E, 0x00, 0xF8, 0x07, 0xC0, 0xF0, 0x07, 0x80, 0x3C, 0x07,
  0x80, 0x78, 0x01, 0xE0, 0x3C, 0x07, 0xC0, 0x1F, 0x01, 0xE0, 0x3C, 0x00,
  0xF0, 0x0F, 0x03, 0xE0, 0x07, 0x80, 0xF8, 0x1E, 0x00, 0x3C, 0x07, 0x81,
  0xE0, 0x03, 0xE0, 0x3C, 0x1F, 0x00, 0x1F, 0x01, 0xE0, 0xF0, 0x00, 0xF0,
  0x0F, 0x0F, 0x80, 0x07, 0x80, 0xF8, 0x78, 0x00, 0x3C, 0x07, 0x87, 0xC0,
  0x01, 0xE0, 0x3C, 0x3C, 0x3F, 0x8F, 0x03, 0xE3, 0xC3, 0xFE, 0x78, 0x1E,
  0x3E, 0x3F, 0xFB, 0xC1, 0xF1, 0xE3, 0xF7, 0xDE, 0x0F, 0x1F, 0x1E, 0x1F,
  0xF8, 0xF8, 0xF1, 0xE0, 0xFF, 0xFF, 0x8F, 0x0F, 0x03, 0xDF, 0xF8, 0xF8,
  0xF0, 0x1E, 0x7F, 0x87, 0x87, 0x80, 0xF1, 0xF8, 0x7C, 0x7C, 0x07, 0x80,
  0x03, 0xC3, 0xC0, 0x7C, 0x00, 0x3E, 0x1E, 0x03, 0xE0, 0x03, 0xE0, 0xF0,
  0x1E, 0x00, 0x1E, 0x0F, 0x80, 0xF0, 0x01, 0xF0, 0x78, 0x07, 0x80, 0x0F,
  0x03, 0xC0, 0x7C, 0x00, 0xF8, 0x1E, 0x03, 0xE0, 0x07, 0x80, 0xF0, 0x1E,
  0x00, 0x78, 0x07, 0x80, 0xF0, 0x07, 0xC0, 0x3C, 0x0F, 0x80, 0x3C, 0x01,
  0xE0, 0x78, 0x03, 0xE0, 0x0F, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x3C, 0x01,
  0xF0, 0x03, 0xC3, 0xE0, 0x1F, 0x00, 0x1F, 0x3E, 0x00, 0xF0, 0x00, 0xFF,
  0xE0, 0x0F, 0x80, 0x03, 0xFF, 0x00, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x7C,
  0x03, 0xE0, 0x00, 0xF8, 0x07, 0xC0, 0x01, 0xF0, 0x1F, 0x00, 0x03, 0xE0,
  0x3E, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x1F, 0x03,
  0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7E, 0x3E, 0x00, 0x00, 0x7C, 0xFC,
  0x00, 0x00, 0xFB, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x07, 0xEF, 0x80, 0x7C, 0x1F, 0x9F, 0x80, 0xF8,
  0x7E, 0x1F, 0x03, 0xF1, 0xF8, 0x3F, 0x07, 0xC3, 0xE0, 0x3E, 0x0F, 0x8F,
  0xC0, 0x7E, 0x3E, 0x1F, 0x00, 0xFC, 0x7C, 0x7E, 0x00, 0xFD, 0xF0, 0xF8,
  0x01, 0xFF, 0xE1, 0xF0, 0x01, 0xFF, 0x87, 0xE0, 0x03, 0xFF, 0x0F, 0xC0,
  0x03, 0xFC, 0x1F, 0x80, 0x07, 0xF0, 0x3F, 0x00, 0x0F, 0xE0, 0x7E, 0x00,
  0x3F, 0xC0, 0x7C, 0x00, 0xFF, 0x80, 0xFC, 0x03, 0xFF, 0x81, 0xFC, 0x1F,
  0xFF, 0x01, 0xFF, 0xFF, 0x3F, 0x03, 0xFF, 0xFC, 0x7E, 0x03, 0xFF, 0xF0,
  0x7E, 0x01, 0xFF, 0x80, 0xFC, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0x3F, 0x3E,
  0x3E, 0x3E, 0x7E, 0x7C, 0x7C, 0x7C, 0x78, 0x78, 0x78, 0xF8, 0xF0, 0xF0,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03,
  0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x0C, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0x7F, 0x1C,
  0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xC0, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xCF, 0x00,
  0x1F, 0x9E, 0x00, 0x7E, 0x3E, 0x01, 0xF8, 0x3C, 0x03, 0xE0, 0x7C, 0x03,
  0xC0, 0xF8, 0x01, 0x00, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0x02, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xF0, 0x3E, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0xFC, 0x0F, 0x81,
  0xF8, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0x80, 0x78, 0x0F,
  0x00, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x08,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x30, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x01,
  0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0x87, 0xE0,
  0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x07, 0xC0, 0xF8, 0x01,
  0xF0, 0x7E, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x0F, 0xC0, 0x07, 0xC3, 0xF0,
  0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x7E, 0x00, 0x1F, 0x1F, 0x80, 0x07, 0xC7,
  0xC0, 0x01, 0xF3, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x3F, 0x3E, 0x00, 0x0F,
  0xCF, 0x80, 0x03, 0xE3, 0xE0, 0x00, 0xF9, 0xF8, 0x00, 0x3E, 0x7E, 0x00,
  0x1F, 0x9F, 0x00, 0x07, 0xE7, 0xC0, 0x01, 0xF1, 0xF0, 0x00, 0x7C, 0x7C,
  0x00, 0x1F, 0x3F, 0x00, 0x0F, 0xCF, 0xC0, 0x03, 0xE3, 0xE0, 0x00, 0xF8,
  0xF8, 0x00, 0x7E, 0x3E, 0x00, 0x1F, 0x8F, 0x80, 0x07, 0xC3, 0xE0, 0x03,
  0xF0, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x7E, 0x0F, 0x80, 0x1F, 0x03, 0xF0,
  0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x1F, 0x83, 0xF8, 0x07, 0xF1, 0xFC, 0x00,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0xC0, 0x3F,
  0xE0, 0x3F, 0xF0, 0x3F, 0xF8, 0x7F, 0xF8, 0x7F, 0x7C, 0x7F, 0x3E, 0x7F,
  0x3F, 0x3E, 0x1F, 0x0E, 0x0F, 0x82, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x00, 0x3F, 0x01, 0xF8, 0x00, 0xE0, 0x07, 0xE0, 0x06, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xE0, 0x0F, 0x80, 0x7F, 0x00, 0x60, 0x03, 0xF0, 0x04, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x80, 0x00, 0xFC, 0x0C, 0x00, 0x3F, 0xC0,
  0xF8, 0x0F, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3D, 0xF0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x3E,
  0xF8, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x1F, 0x3E, 0x00, 0x01, 0xF3, 0xF0,
  0x00, 0x0F, 0x1F, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x00,
  0xF8, 0x3E, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x07, 0xC0,
  0xF8, 0x00, 0x3C, 0x07, 0xC0, 0x03, 0xE0, 0x7E, 0x00, 0x3E, 0x03, 0xE0,
  0x01, 0xE0, 0x1F, 0x00, 0x1F, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F,
  0x00, 0x7E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0xF8, 0x00,
  0xF8, 0x07, 0xC0, 0x07, 0xC0, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xE0, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x0E, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x10, 0x00, 0x1F,
  0x80, 0xC0, 0x03, 0xFC, 0x07, 0xC0, 0x7F, 0xC0, 0x3F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x0F, 0xF0, 0x01, 0xF3, 0xFF,
  0x80, 0x3F, 0x7F, 0xFC, 0x03, 0xEF, 0xFF, 0xE0, 0x3F, 0xF1, 0xFE, 0x03,
  0xFC, 0x07, 0xE0, 0x7F, 0x80, 0x3F, 0x07, 0xF0, 0x03, 0xF0, 0x7F, 0x00,
  0x3F, 0x07, 0xE0, 0x01, 0xF0, 0x7E, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0,
  0x7C, 0x00, 0x1F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0,
  0x03, 0xE0, 0xFC, 0x00, 0x3E, 0x0F, 0xC0, 0x03, 0xE0, 0xFC, 0x00, 0x7E,
  0x0F, 0xC0, 0x07, 0xC0, 0x7C, 0x00, 0xFC, 0x07, 0xC0, 0x0F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0x3F, 0x07, 0xF0, 0x03, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x10, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0xFF,
  0xBF, 0xE0, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x1F, 0x00, 0x3F,
  0x03, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x03, 0xE0, 0x01, 0xF0, 0x3E,
  0x00, 0x1F, 0x03, 0xE0, 0x03, 0xF0, 0x3E, 0x00, 0x3E, 0x03, 0xE0, 0x07,
  0xE0, 0x3F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x00,
  0xF8, 0x3F, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x7F, 0xBF, 0x80, 0x0F, 0xE1, 0xF8, 0x01, 0xFC, 0x0F, 0xC0, 0x3F, 0x80,
  0x7E, 0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xF0,
  0xFC, 0x00, 0x3F, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80,
  0x01, 0xF0, 0xF8, 0x00, 0x3F, 0x0F, 0x80, 0x03, 0xF0, 0xF8, 0x00, 0x3E,
  0x0F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x0F, 0xE0, 0x0F, 0xC0, 0x7F,
  0x03, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF8, 0x03, 0xF8, 0x3F, 0x80, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0x3E, 0x03,
  0xE0, 0x07, 0xC0, 0xFC, 0x00, 0xFC, 0x1F, 0x00, 0x1F, 0x87, 0xE0, 0x01,
  0xF0, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0xC3, 0xE0, 0x01, 0xF8, 0xFC,
  0x00, 0x3F, 0x1F, 0x80, 0x07, 0xE3, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x1F,
  0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x87, 0xE0,
  0x0F, 0xF0, 0x7E, 0x01, 0xFE, 0x0F, 0xE0, 0xFF, 0x81, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xBE, 0x01, 0xFF, 0xE7, 0xC0, 0x1F, 0xF1, 0xF0, 0x00, 0xF8,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF8, 0x03, 0x01, 0xFE, 0x00, 0x7F, 0xFF, 0x80,
  0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xC0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x03,
  0xE0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0xFE, 0x03, 0xF0, 0x1F, 0x00, 0x60,
  0x00, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF0,
  0x03, 0xF8, 0x00, 0xF8, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07,
  0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0x80, 0xFF, 0xFF, 0x03, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF8, 0x1C, 0x07, 0xF0, 0x40, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x03,
  0xFC, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00,
  0x7C, 0x00, 0x3F, 0x00, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0xF8, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x07, 0xF0, 0x0F,
  0x07, 0xC0, 0x1F, 0xFE, 0x0F, 0x07, 0x80, 0x7F, 0xFC, 0x0F, 0x0F, 0x80,
  0xFF, 0xFC, 0x0F, 0x0F, 0x01, 0xF0, 0x7C, 0x0F, 0x1F, 0x01, 0xE0, 0x7C,
  0x0F, 0x1E, 0x03, 0xE0, 0x78, 0x0F, 0x1E, 0x07, 0xC0, 0x78, 0x0F, 0x3C,
  0x07, 0x80, 0xF8, 0x0F, 0x3C, 0x0F, 0x80, 0xF8, 0x0F, 0x3C, 0x0F, 0x00,
  0xF0, 0x1F, 0x7C, 0x0F, 0x00, 0xF0, 0x1E, 0x78, 0x1F, 0x01, 0xF0, 0x1E,
  0x78, 0x1E, 0x01, 0xF0, 0x1E, 0x78, 0x1E, 0x01, 0xE0, 0x3E, 0x78, 0x1E,
  0x01, 0xE0, 0x3C, 0xF8, 0x3E, 0x03, 0xE0, 0x3C, 0xF0, 0x3E, 0x03, 0xE0,
  0x78, 0xF0, 0x3E, 0x07, 0xC0, 0x78, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0xF0,
  0x3E, 0x0F, 0xC0, 0xF0, 0xF0, 0x3E, 0x0F, 0xC1, 0xE0, 0xF0, 0x1F, 0x1D,
  0xE3, 0xE0, 0xF0, 0x1F, 0xFD, 0xFF, 0xC0, 0xF0, 0x1F, 0xF8, 0xFF, 0x80,
  0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xF8, 0x03, 0xC0, 0x18, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0xC0, 0x00, 0x07, 0xF8, 0x0F, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7D, 0xF0,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0x1E, 0x7C, 0x00, 0x01, 0xF3, 0xE0, 0x00,
  0x0F, 0x9F, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x7C,
  0x3E, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF0, 0x7C,
  0x00, 0x1F, 0x83, 0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x07, 0xC0, 0xF8, 0x00,
  0x7C, 0x07, 0xC0, 0x03, 0xE0, 0x3E, 0x00, 0x3F, 0x01, 0xF8, 0x01, 0xF0,
  0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x03,
  0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0xF8, 0x00, 0x3E, 0x0F, 0xC0,
  0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x7C, 0x3F, 0x00, 0x03,
  0xE3, 0xF0, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0xF9, 0xF8, 0x00, 0x07, 0xCF,
  0xC0, 0x00, 0x3E, 0xFC, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x0F, 0xBE, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7C, 0x0F,
  0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x0F, 0xC0, 0x0F, 0xC0, 0x3E, 0x00, 0x3F,
  0x00, 0xF8, 0x00, 0x7C, 0x07, 0xE0, 0x01, 0xF0, 0x1F, 0x80, 0x07, 0xC0,
  0x7C, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0xFC, 0x07, 0xC0, 0x03, 0xF0, 0x3F,
  0x00, 0x0F, 0x80, 0xFC, 0x00, 0x7E, 0x03, 0xE0, 0x03, 0xF0, 0x0F, 0x80,
  0x1F, 0xC0, 0x3E, 0x00, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0,
  0x0F, 0xC0, 0x3F, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0xF8, 0x00, 0xFC, 0x03,
  0xE0, 0x01, 0xF0, 0x1F, 0x80, 0x07, 0xE0, 0x7E, 0x00, 0x1F, 0x81, 0xF0,
  0x00, 0x7E, 0x07, 0xC0, 0x01, 0xF8, 0x1F, 0x00, 0x07, 0xE0, 0xFC, 0x00,
  0x1F, 0x83, 0xF0, 0x00, 0x7E, 0x0F, 0x80, 0x03, 0xF0, 0x3E, 0x00, 0x0F,
  0xC0, 0xF8, 0x00, 0x7F, 0x07, 0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0xC0,
  0x7C, 0x00, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0x01, 0xC0, 0x0F, 0xF0,
  0x01, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x20,
  0x03, 0xFE, 0x0F, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x7C, 0x1F, 0xF8, 0x00, 0xFC, 0x03, 0xFC, 0x00,
  0xFC, 0x01, 0xFC, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0xF8, 0x00, 0x7E, 0x01,
  0xF8, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3F, 0x01,
  0xF0, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x3F, 0x03,
  0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x07,
  0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x7E, 0x0F,
  0xC0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0xFC, 0x0F,
  0x80, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x1F,
  0x00, 0x01, 0xF8, 0x1F, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x03, 0xF0, 0x3F,
  0x00, 0x07, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x0F, 0xE0, 0x3E,
  0x00, 0x1F, 0xC0, 0x3E, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x7F, 0x00, 0x7E,
  0x00, 0xFF, 0x00, 0x7C, 0x07, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xE0, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x07,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0xF8, 0x01, 0xFC, 0x00, 0x18,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0xFF, 0xF0, 0xF8, 0x00, 0x7F, 0xF8, 0x7C, 0x00,
  0x7F, 0xFC, 0x7E, 0x00, 0x3F, 0xFC, 0x3F, 0x00, 0x1F, 0xFE, 0x1F, 0x80,
  0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x07, 0xC1, 0xF8, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x01, 0xF0, 0x7E,
  0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0x7C, 0x0F,
  0xC0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0x0F, 0x80, 0x3F, 0x00, 0x07, 0xC0, 0x1F, 0xC0, 0x03, 0xE0,
  0x07, 0xFC, 0x0F, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x0F, 0xC0, 0x00, 0x7C, 0x01, 0xF0,
  0x00, 0x1F, 0x80, 0x3E, 0x00, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0x7C, 0x01,
  0xF8, 0x00, 0x0F, 0x80, 0x3F, 0x00, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0x7E,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x01, 0xF0, 0x07, 0xE0, 0x00,
  0x3E, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x01, 0xF8, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x1F, 0x80, 0x00, 0xF8, 0x03,
  0xE0, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x0F, 0x80, 0x00, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xC0,
  0x00, 0x7C, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x03, 0xF0, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x3F, 0x00, 0x01, 0xF0,
  0x07, 0xC0, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x01,
  0xF0, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x1F, 0x00,
  0x01, 0xF8, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x1F,
  0x80, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x07, 0xE0,
  0x0F, 0x80, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x03,
  0xE0, 0x0F, 0x80, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xFF,
  0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x1D, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x1F,
  0xC0, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xF0, 0x01, 0xF0, 0x01,
  0xF8, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x3F, 0x00, 0x03, 0xE0, 0x0F, 0xC0, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0x7E,
  0x03, 0xF0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x07, 0xC0, 0xFE, 0x00, 0x01,
  0xF0, 0x3F, 0x00, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x3F, 0x0F, 0xC0, 0x00,
  0x0F, 0xC7, 0xE0, 0x00, 0x03, 0xE3, 0xF8, 0x00, 0x00, 0xF8, 0xFC, 0x00,
  0x00, 0x3E, 0x7E, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0x01, 0xF7, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFD, 0xF8, 0x00, 0x00, 0xFE,
  0x3E, 0x00, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x7C, 0x07, 0xE0, 0x00,
  0x1F, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x03, 0xF0, 0x0F, 0x80,
  0x00, 0xF8, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x3F,
  0x00, 0x07, 0xE0, 0x07, 0xC0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x7C, 0x00,
  0x7E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C,
  0x00, 0x0F, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x07, 0xDF, 0x00, 0x01, 0xF7, 0xC0,
  0x1F, 0x7C, 0x00, 0x07, 0xFF, 0x00, 0x7D, 0xF0, 0x00, 0x3E, 0xF8, 0x01,
  0xF7, 0xC0, 0x00, 0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x07, 0xCF, 0x80, 0x3F,
  0x7C, 0x00, 0x1F, 0x7E, 0x00, 0xF9, 0xF0, 0x00, 0xF9, 0xF8, 0x03, 0xE7,
  0xC0, 0x03, 0xE7, 0xC0, 0x0F, 0x9F, 0x00, 0x1F, 0x1F, 0x00, 0x3E, 0x3C,
  0x00, 0x7C, 0x7C, 0x01, 0xF8, 0xF0, 0x03, 0xE3, 0xF0, 0x07, 0xC3, 0xC0,
  0x0F, 0x8F, 0x80, 0x1F, 0x0F, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x01,
  0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x0F, 0x87, 0xE0, 0x0F, 0x83, 0xE0, 0x3E,
  0x1F, 0x80, 0x3E, 0x0F, 0x81, 0xF0, 0x7C, 0x00, 0xF8, 0x3E, 0x07, 0xC1,
  0xF0, 0x03, 0xE0, 0xF8, 0x3E, 0x07, 0xC0, 0x1F, 0x83, 0xE0, 0xF8, 0x3F,
  0x00, 0x7C, 0x0F, 0x87, 0xC0, 0xFC, 0x01, 0xF0, 0x3E, 0x1F, 0x03, 0xE0,
  0x07, 0xC0, 0xF8, 0xF8, 0x0F, 0x80, 0x1F, 0x03, 0xE3, 0xE0, 0x3E, 0x00,
  0xFC, 0x07, 0x8F, 0x01, 0xF8, 0x03, 0xE0, 0x1E, 0x7C, 0x07, 0xE0, 0x0F,
  0x80, 0x79, 0xE0, 0x1F, 0x00, 0x3E, 0x01, 0xEF, 0x80, 0x7C, 0x00, 0xF8,
  0x07, 0xBE, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0xF0, 0x0F, 0xC0, 0x1F, 0x00,
  0x7F, 0xC0, 0x3E, 0x00, 0x7C, 0x01, 0xFE, 0x00, 0xF8, 0x01, 0xF0, 0x07,
  0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7F,
  0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xE0,
  0x07, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xF8, 0x03, 0xF8, 0x00, 0x07,
  0xC0, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0xFF, 0x00, 0x03, 0xE0, 0x07, 0xF8,
  0x00, 0x1F, 0x00, 0x7F, 0xC0, 0x00, 0xF8, 0x03, 0xFE, 0x00, 0x07, 0xC0,
  0x1F, 0xF8, 0x00, 0x7E, 0x00, 0xF7, 0xC0, 0x03, 0xE0, 0x0F, 0xBE, 0x00,
  0x1F, 0x00, 0x7D, 0xF0, 0x00, 0xF8, 0x03, 0xEF, 0x80, 0x07, 0xC0, 0x1F,
  0x3E, 0x00, 0x7E, 0x00, 0xF9, 0xF0, 0x03, 0xE0, 0x0F, 0x8F, 0x80, 0x1F,
  0x00, 0x7C, 0x7C, 0x00, 0xF8, 0x03, 0xE1, 0xF0, 0x0F, 0xC0, 0x1F, 0x0F,
  0x80, 0x7C, 0x00, 0xF8, 0x7C, 0x03, 0xE0, 0x0F, 0x83, 0xE0, 0x1F, 0x00,
  0x7C, 0x0F, 0x80, 0xF8, 0x03, 0xE0, 0x7C, 0x0F, 0xC0, 0x1F, 0x03, 0xE0,
  0x7C, 0x00, 0xF8, 0x1F, 0x03, 0xE0, 0x0F, 0x80, 0xF8, 0x1F, 0x00, 0x7C,
  0x03, 0xE0, 0xF8, 0x03, 0xE0, 0x1F, 0x0F, 0xC0, 0x1F, 0x00, 0xF8, 0x7C,
  0x01, 0xF8, 0x07, 0xC3, 0xE0, 0x0F, 0x80, 0x1F, 0x1F, 0x00, 0x7C, 0x00,
  0xF8, 0xF8, 0x03, 0xE0, 0x07, 0xCF, 0xC0, 0x1F, 0x00, 0x3E, 0x7C, 0x01,
  0xF8, 0x00, 0xF3, 0xE0, 0x0F, 0x80, 0x07, 0xDF, 0x00, 0x7C, 0x00, 0x3E,
  0xF8, 0x03, 0xE0, 0x01, 0xF7, 0x80, 0x1F, 0x00, 0x0F, 0xFC, 0x01, 0xF8,
  0x00, 0x3F, 0xE0, 0x0F, 0x80, 0x01, 0xFF, 0x00, 0x7C, 0x00, 0x0F, 0xF8,
  0x03, 0xE0, 0x00, 0x7F, 0x80, 0x1F, 0x00, 0x01, 0xFC, 0x01, 0xF0, 0x00,
  0x0F, 0xE0, 0x0F, 0x80, 0x00, 0x7F, 0x00, 0x7C, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0x81, 0xFC,
  0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1F,
  0x0F, 0xC0, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x1F,
  0x1F, 0x80, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0x1F,
  0x3F, 0x00, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F,
  0x7E, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F,
  0x7C, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E,
  0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x00, 0xFC,
  0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x01, 0xF8,
  0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF0,
  0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xC0,
  0x7E, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x00,
  0x3F, 0xE1, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xC0, 0x07, 0xC3, 0xFF, 0x00, 0x7E, 0x03, 0xF8, 0x03, 0xF0,
  0x0F, 0xE0, 0x1F, 0x00, 0x3F, 0x00, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x07,
  0xC0, 0x7E, 0x00, 0x3E, 0x03, 0xE0, 0x01, 0xF0, 0x1F, 0x00, 0x0F, 0x80,
  0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0x7E, 0x00, 0x3F, 0x03, 0xE0,
  0x01, 0xF0, 0x1F, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x0F,
  0xC0, 0x7E, 0x00, 0xFE, 0x03, 0xE0, 0x0F, 0xE0, 0x1F, 0x01, 0xFE, 0x00,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0x81, 0xFC, 0x00,
  0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1F, 0x0F,
  0xC0, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x1F, 0x1F,
  0x80, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0x1F, 0x3F,
  0x00, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0x7E,
  0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0x7C,
  0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC,
  0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x00, 0xFC, 0xFC,
  0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x01, 0xF8, 0xFC,
  0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0x7E,
  0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0x3F,
  0xE1, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xC3, 0xFF, 0x00, 0x7E, 0x03,
  0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x00, 0x3F, 0x00, 0xF8, 0x01, 0xF8,
  0x0F, 0xC0, 0x07, 0xC0, 0x7E, 0x00, 0x3E, 0x03, 0xF0, 0x01, 0xF0, 0x1F,
  0x00, 0x0F, 0x80, 0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0x7E, 0x00,
  0x3F, 0x03, 0xE0, 0x01, 0xF0, 0x1F, 0x00, 0x1F, 0x80, 0xF8, 0x01, 0xFC,
  0x0F, 0xC0, 0x0F, 0xC0, 0x7E, 0x01, 0xFC, 0x03, 0xE0, 0x3F, 0xE0, 0x1F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0x07, 0xE0, 0x01, 0xF8, 0x1F, 0x00,
  0x0F, 0xC0, 0xF8, 0x00, 0x7C, 0x07, 0xC0, 0x03, 0xE0, 0x3F, 0x00, 0x1F,
  0x01, 0xF8, 0x01, 0xF8, 0x07, 0xC0, 0x0F, 0xC0, 0x3E, 0x00, 0x7C, 0x01,
  0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x01, 0xF8, 0x01, 0xF0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x7C, 0x00, 0x7E, 0x03, 0xE0, 0x03, 0xF0, 0x1F,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0x7C, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFE, 0x03,
  0xC0, 0x0F, 0xE0, 0x03, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x40, 0x00, 0xFE, 0x01,
  0xC0, 0x07, 0xF0, 0x07, 0xF0, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFE, 0x80, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0xF8, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x03,
  0xE0, 0x3F, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00,
  0xFC, 0x07, 0xC0, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x3E, 0x03, 0xF0, 0x00,
  0x1F, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x0F, 0xC0, 0xFC, 0x00,
  0x07, 0xC0, 0x7E, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x03, 0xF0, 0x1F, 0x00,
  0x01, 0xF8, 0x0F, 0x80, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x7C, 0x07, 0xE0,
  0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0xF8,
  0x00, 0x0F, 0x80, 0xFC, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x03, 0xE0, 0x3E,
  0x00, 0x03, 0xF0, 0x1F, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0xF8, 0x0F,
  0xC0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x3F, 0x01,
  0xF0, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x07, 0xC0,
  0x7E, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x01, 0xF0,
  0x0F, 0x80, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0xFC,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x3F, 0xE1, 0xFE,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x0F,
  0xCF, 0x80, 0x00, 0x7C, 0x7C, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x3F, 0x1F,
  0x00, 0x03, 0xF0, 0xF8, 0x00, 0x1F, 0x87, 0xC0, 0x01, 0xF8, 0x3E, 0x00,
  0x0F, 0xC1, 0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x07, 0xE0, 0x7C, 0x00, 0x3E,
  0x03, 0xF0, 0x03, 0xF0, 0x1F, 0x80, 0x1F, 0x00, 0xFC, 0x01, 0xF8, 0x07,
  0xE0, 0x0F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0,
  0x3E, 0x00, 0x3E, 0x03, 0xF0, 0x01, 0xF0, 0x1F, 0x00, 0x0F, 0x81, 0xF8,
  0x00, 0x7C, 0x0F, 0x80, 0x03, 0xE0, 0xFC, 0x00, 0x1F, 0x07, 0xC0, 0x00,
  0xF8, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF1,
  0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x7C, 0xFC, 0x00, 0x03, 0xE7, 0xC0,
  0x00, 0x1F, 0x3E, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x07, 0xDF, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xEF, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF3, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0xF8, 0x00,
  0x7E, 0x3E, 0x00, 0x1F, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x7F, 0x80, 0x0F,
  0xC3, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0x0F, 0x80, 0x0F, 0x78, 0x00, 0xF8,
  0x3E, 0x00, 0x7D, 0xE0, 0x07, 0xE0, 0xF8, 0x01, 0xF7, 0x80, 0x1F, 0x03,
  0xE0, 0x07, 0x9E, 0x00, 0xFC, 0x0F, 0x80, 0x3E, 0x78, 0x03, 0xF0, 0x3E,
  0x00, 0xF1, 0xE0, 0x0F, 0x80, 0xF8, 0x07, 0xC7, 0x80, 0x7E, 0x03, 0xE0,
  0x1F, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x78, 0x0F, 0xC0, 0x3E, 0x03,
  0xE1, 0xE0, 0x3E, 0x00, 0xF8, 0x0F, 0x07, 0x80, 0xF8, 0x03, 0xE0, 0x7C,
  0x1E, 0x07, 0xE0, 0x0F, 0x81, 0xF0, 0x78, 0x1F, 0x00, 0x3E, 0x0F, 0x81,
  0xE0, 0xFC, 0x00, 0xF8, 0x3E, 0x07, 0x83, 0xE0, 0x03, 0xE0, 0xF0, 0x1E,
  0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x78, 0x7E, 0x00, 0x3E, 0x1F, 0x01, 0xE1,
  0xF0, 0x00, 0xF8, 0xF8, 0x07, 0x8F, 0xC0, 0x03, 0xE3, 0xE0, 0x1E, 0x3E,
  0x00, 0x0F, 0x8F, 0x00, 0x78, 0xF8, 0x00, 0x3E, 0x7C, 0x01, 0xE7, 0xE0,
  0x00, 0xF9, 0xE0, 0x07, 0x9F, 0x00, 0x03, 0xEF, 0x80, 0x1E, 0x7C, 0x00,
  0x0F, 0xBE, 0x00, 0xFB, 0xE0, 0x00, 0x3E, 0xF0, 0x03, 0xEF, 0x80, 0x00,
  0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x0F, 0xC0,
  0x00, 0xF8, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0xFC, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x07,
  0xC0, 0x7C, 0x00, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0xF8, 0x00,
  0x00, 0x3E, 0x1F, 0x80, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x00, 0x3E, 0x3E,
  0x00, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0xFB, 0xE0, 0x00, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0x01, 0xF3, 0xE0,
  0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x00, 0x7C,
  0x1F, 0x00, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00,
  0x1F, 0x81, 0xF8, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0xF8,
  0x00, 0x07, 0xE0, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xEF, 0xC0, 0x03, 0xF3, 0xF0,
  0x00, 0xFC, 0xFC, 0x00, 0x7E, 0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x0F, 0xC1,
  0xF0, 0x03, 0xE0, 0x7C, 0x01, 0xF8, 0x1F, 0x00, 0x7C, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x1F, 0x80, 0x3E, 0x07, 0xC0, 0x0F, 0x83, 0xF0, 0x03, 0xE0,
  0xF8, 0x00, 0xF8, 0x7E, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x8F, 0xC0, 0x01,
  0xF3, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x1F, 0x7C, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF,
  0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x03, 0xC0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x0F, 0x01, 0xE0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x07, 0x80, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x1E, 0x03, 0xC0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x0F, 0x01, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x07,
  0x80, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF,
  0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3E, 0x78, 0x00,
  0x0F, 0x8F, 0x80, 0x01, 0xE1, 0xF0, 0x00, 0x7C, 0x1E, 0x00, 0x0F, 0x03,
  0xE0, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x07, 0x80, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x1F, 0x00, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x3E, 0x07, 0xC0, 0x07,
  0xC1, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0xF3, 0xE0,
  0x00, 0x1F, 0x7C, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3C, 0x7F, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xE0, 0xFC, 0x1F, 0x87,
  0xE0, 0xF8, 0x3F, 0x07, 0xC0, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x3C, 0x00,
  0x1F, 0xE1, 0xF0, 0x07, 0xFF, 0x1F, 0x00, 0xFF, 0xF9, 0xE0, 0x1F, 0xFF,
  0xBE, 0x03, 0xFC, 0x7F, 0xE0, 0x7F, 0x01, 0xFE, 0x07, 0xE0, 0x1F, 0xE0,
  0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x00, 0xFC, 0x1F, 0x80,
  0x0F, 0xC1, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0xF8,
  0x3E, 0x00, 0x0F, 0x87, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x07, 0xC0,
  0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F,
  0x0F, 0xC0, 0x03, 0xE0, 0xFC, 0x00, 0x3E, 0x0F, 0xC0, 0x07, 0xE0, 0xF8,
  0x00, 0x7E, 0x0F, 0x80, 0x0F, 0xE0, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x1F,
  0xC0, 0xFC, 0x03, 0xFC, 0x07, 0xC0, 0x7F, 0xC0, 0x7E, 0x0F, 0x78, 0x07,
  0xFF, 0xE7, 0x80, 0x3F, 0xFC, 0xF8, 0x01, 0xFF, 0x8F, 0x80, 0x0F, 0xF0,
  0xF8, 0x00, 0x18, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x3F, 0xC0, 0x0F, 0x9F, 0xFC, 0x03,
  0xF7, 0xFF, 0xC0, 0x7D, 0xFF, 0xF8, 0x0F, 0xFC, 0x3F, 0x81, 0xFE, 0x03,
  0xF0, 0x3F, 0x80, 0x7E, 0x0F, 0xF0, 0x07, 0xC1, 0xFC, 0x00, 0xF8, 0x3F,
  0x00, 0x1F, 0x07, 0xE0, 0x03, 0xE1, 0xF8, 0x00, 0x7C, 0x3F, 0x00, 0x0F,
  0x87, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0xC7, 0xE0,
  0x01, 0xF8, 0xF8, 0x00, 0x3F, 0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0xF8,
  0x7C, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xE3, 0xE0, 0x00, 0xF8, 0x7C, 0x00,
  0x3F, 0x0F, 0x80, 0x07, 0xE1, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x0F,
  0xE0, 0x0F, 0xC1, 0xFC, 0x01, 0xF8, 0x3F, 0x80, 0x7E, 0x0F, 0xB8, 0x3F,
  0x81, 0xF7, 0xFF, 0xE0, 0x3E, 0x7F, 0xFC, 0x07, 0x8F, 0xFE, 0x00, 0xF0,
  0xFF, 0x80, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xFC,
  0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x3F, 0xC1, 0x80, 0xFE, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x10, 0x1F, 0xC0, 0xE0, 0x1F,
  0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x07, 0xF8, 0x7C,
  0x00, 0x3F, 0xF9, 0xF8, 0x00, 0xFF, 0xFB, 0xE0, 0x03, 0xFF, 0xF7, 0xC0,
  0x0F, 0xF0, 0xFF, 0x80, 0x3F, 0x80, 0xFF, 0x00, 0x7E, 0x01, 0xFC, 0x01,
  0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x0F, 0xC0, 0x07, 0xE0, 0x1F,
  0x80, 0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x3E, 0x01, 0xF0,
  0x00, 0x7C, 0x07, 0xE0, 0x00, 0xF8, 0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0x80,
  0x07, 0xC0, 0x3E, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x1F, 0x01, 0xF8, 0x00,
  0x7E, 0x03, 0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x01, 0xF0, 0x0F, 0xC0, 0x07,
  0xE0, 0x1F, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x7E,
  0x00, 0xF8, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x0F, 0xF0,
  0x07, 0xE0, 0x3F, 0xE0, 0x07, 0xE0, 0xF7, 0x80, 0x0F, 0xFF, 0xDF, 0x00,
  0x0F, 0xFF, 0x3E, 0x00, 0x1F, 0xFC, 0x7C, 0x00, 0x0F, 0xF0, 0xF8, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0xFF,
  0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xF8, 0x3E, 0x07, 0xF0, 0x3F, 0x07, 0xE0,
  0x1F, 0x0F, 0xC0, 0x1F, 0x0F, 0x80, 0x1F, 0x1F, 0x80, 0x3E, 0x1F, 0x00,
  0x3E, 0x3F, 0x00, 0x7E, 0x3E, 0x00, 0x7C, 0x3E, 0x01, 0xFC, 0x7E, 0x07,
  0xF8, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xFC,
  0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x20, 0x7F, 0x00,
  0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF,
  0x80, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x3E, 0x00, 0x1F, 0xFC, 0x7C,
  0x00, 0x7F, 0xFC, 0xF0, 0x01, 0xFF, 0xFB, 0xE0, 0x07, 0xF8, 0x7F, 0xC0,
  0x0F, 0xC0, 0x7F, 0x80, 0x3F, 0x00, 0xFF, 0x00, 0xFC, 0x00, 0xFC, 0x01,
  0xF8, 0x01, 0xF8, 0x07, 0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x07, 0xE0, 0x1F,
  0x00, 0x0F, 0x80, 0x7E, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x3E, 0x01, 0xF0,
  0x00, 0xFC, 0x07, 0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xE0, 0x1F, 0x00,
  0x07, 0xC0, 0x3E, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x3F, 0x01, 0xF8, 0x00,
  0x7E, 0x03, 0xF0, 0x00, 0xF8, 0x07, 0xE0, 0x03, 0xF0, 0x0F, 0x80, 0x07,
  0xE0, 0x1F, 0x00, 0x1F, 0xC0, 0x3E, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0xFE,
  0x00, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x07, 0xF8, 0x03, 0xF0, 0x1F, 0xF0,
  0x03, 0xF0, 0x7F, 0xC0, 0x07, 0xFF, 0xEF, 0x80, 0x07, 0xFF, 0x9F, 0x00,
  0x0F, 0xFE, 0x3E, 0x00, 0x0F, 0xF8, 0xFC, 0x00, 0x03, 0x81, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x0C, 0x00, 0x3F, 0x00, 0x1F, 0x01,
  0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x3F,
  0xC0, 0x0F, 0x9F, 0xFC, 0x03, 0xE7, 0xFF, 0xC0, 0x7D, 0xFF, 0xF8, 0x0F,
  0xFC, 0x3F, 0x01, 0xFE, 0x03, 0xF0, 0x3F, 0x80, 0x7E, 0x0F, 0xE0, 0x0F,
  0xC1, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x3E, 0x07, 0xE0, 0x07, 0xC1, 0xF8,
  0x00, 0xF8, 0x3F, 0x00, 0x1F, 0x07, 0xC0, 0x07, 0xE0, 0xF8, 0x00, 0xF8,
  0x1F, 0x00, 0x1F, 0x07, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x1F, 0x00,
  0x1F, 0x83, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x1F, 0x80, 0x0F, 0x83,
  0xE0, 0x03, 0xF0, 0x7C, 0x00, 0x7E, 0x0F, 0x80, 0x0F, 0x81, 0xF0, 0x01,
  0xF0, 0x7E, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0xC1, 0xF0, 0x01, 0xF0, 0x3E,
  0x00, 0x3E, 0x0F, 0xC0, 0x07, 0xC1, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x3F,
  0x07, 0xC0, 0x07, 0xC0, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x1C, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x7C,
  0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x87, 0xE0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x03, 0xF0, 0x1F, 0x00, 0x7E, 0x03, 0xF0,
  0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x03, 0xE0, 0x3F, 0x00, 0x3E, 0x07, 0xE0,
  0x03, 0xE0, 0x7C, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xC1, 0xF8, 0x00, 0x7C,
  0x3F, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x8F, 0xC0,
  0x00, 0xF9, 0xF8, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F,
  0x7F, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFC, 0xF8,
  0x00, 0x1F, 0x8F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x3E, 0x0F, 0xC0, 0x03,
  0xE0, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0x7E, 0x00, 0x7E, 0x07,
  0xE0, 0x07, 0xC0, 0x3E, 0x00, 0x7C, 0x03, 0xF0, 0x07, 0xC0, 0x3F, 0x00,
  0xFC, 0x01, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0xF8, 0x01, 0xF8, 0x0F, 0x80,
  0x1F, 0x80, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01,
  0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x00, 0x01, 0xE1, 0xFE, 0x01, 0xFE, 0x00, 0x78, 0xFF, 0xC1, 0xFF,
  0xC0, 0x3E, 0x7F, 0xF8, 0xFF, 0xF8, 0x0F, 0xBF, 0xFE, 0x7F, 0xFE, 0x03,
  0xFF, 0x1F, 0xFE, 0x1F, 0x80, 0xFF, 0x03, 0xFF, 0x03, 0xF0, 0x3F, 0x80,
  0x7F, 0x00, 0xFC, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0x07, 0xF0, 0x07, 0xE0,
  0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x03, 0xE0, 0x7E, 0x00, 0xFC, 0x00, 0xF8,
  0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x83, 0xE0,
  0x03, 0xE0, 0x07, 0xE0, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x7E,
  0x00, 0x7C, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x07, 0xE0, 0x07, 0xC0, 0x07,
  0xC1, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x1F,
  0x00, 0x3F, 0x00, 0x3E, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x03,
  0xE0, 0x07, 0xE0, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x3E, 0x00,
  0x7C, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC1,
  0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x1F, 0x00,
  0x3F, 0x00, 0x3E, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x83, 0xF0, 0x03, 0xE0,
  0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x3E, 0x00, 0x3E, 0x00, 0x7C,
  0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x00, 0x00, 0x08, 0x00, 0x0F, 0x07,
  0xF8, 0x00, 0xF1, 0xFF, 0xC0, 0x1F, 0x3F, 0xFE, 0x01, 0xF7, 0xFF, 0xE0,
  0x1F, 0xFC, 0xFE, 0x01, 0xFE, 0x03, 0xF0, 0x3F, 0xC0, 0x3F, 0x03, 0xF8,
  0x03, 0xF0, 0x3F, 0x80, 0x3F, 0x03, 0xF0, 0x03, 0xE0, 0x3F, 0x00, 0x3E,
  0x07, 0xE0, 0x03, 0xE0, 0x7E, 0x00, 0x3E, 0x07, 0xE0, 0x07, 0xE0, 0x7C,
  0x00, 0x7E, 0x07, 0xC0, 0x07, 0xC0, 0xFC, 0x00, 0x7C, 0x0F, 0xC0, 0x0F,
  0xC0, 0xF8, 0x00, 0xFC, 0x0F, 0x80, 0x0F, 0x81, 0xF8, 0x00, 0xF8, 0x1F,
  0x80, 0x0F, 0x81, 0xF0, 0x01, 0xF8, 0x1F, 0x00, 0x1F, 0x81, 0xF0, 0x01,
  0xF0, 0x3F, 0x00, 0x1F, 0x03, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x3F, 0x03,
  0xE0, 0x03, 0xF0, 0x3E, 0x00, 0x3E, 0x07, 0xE0, 0x03, 0xE0, 0x7E, 0x00,
  0x7E, 0x07, 0xC0, 0x07, 0xE0, 0x7C, 0x00, 0x7C, 0x0F, 0xC0, 0x07, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF,
  0xE0, 0x3F, 0x87, 0xF0, 0x3F, 0x80, 0xFC, 0x1F, 0x80, 0x7E, 0x1F, 0x80,
  0x1F, 0x0F, 0x80, 0x0F, 0x8F, 0xC0, 0x07, 0xC7, 0xC0, 0x03, 0xE7, 0xE0,
  0x01, 0xF3, 0xE0, 0x00, 0xF9, 0xF0, 0x00, 0x7D, 0xF8, 0x00, 0x3E, 0xFC,
  0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xBE, 0x00, 0x0F, 0xDF, 0x00, 0x07, 0xFF,
  0x80, 0x03, 0xEF, 0xC0, 0x01, 0xF7, 0xC0, 0x01, 0xFB, 0xE0, 0x00, 0xFD,
  0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x7E, 0x7C, 0x00, 0x3F, 0x3F, 0x00, 0x3F,
  0x1F, 0x80, 0x1F, 0x87, 0xC0, 0x1F, 0x83, 0xF0, 0x1F, 0x81, 0xFC, 0x1F,
  0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x00, 0x1E, 0x0F, 0xF0, 0x00, 0x3C, 0x7F,
  0xF0, 0x00, 0xF9, 0xFF, 0xF0, 0x01, 0xF7, 0xFF, 0xE0, 0x03, 0xEF, 0x0F,
  0xE0, 0x07, 0xFC, 0x0F, 0xC0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0xC0, 0x1F,
  0x00, 0x7F, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0xF8,
  0x03, 0xE0, 0x01, 0xF0, 0x0F, 0xC0, 0x03, 0xE0, 0x1F, 0x80, 0x07, 0xC0,
  0x3E, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x7E, 0x03,
  0xE0, 0x00, 0xFC, 0x07, 0xC0, 0x01, 0xF0, 0x0F, 0x80, 0x03, 0xE0, 0x1F,
  0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x3E, 0x01, 0xF0,
  0x00, 0xFC, 0x03, 0xE0, 0x01, 0xF8, 0x07, 0xC0, 0x07, 0xE0, 0x1F, 0x80,
  0x0F, 0xC0, 0x3F, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0xFE, 0x01,
  0xF8, 0x01, 0xFE, 0x0F, 0xE0, 0x07, 0xDF, 0xFF, 0xC0, 0x0F, 0x9F, 0xFF,
  0x00, 0x1F, 0x3F, 0xF8, 0x00, 0x3E, 0x1F, 0xE0, 0x00, 0x7C, 0x0E, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE1, 0xF0, 0x07,
  0xFF, 0x1F, 0x00, 0xFF, 0xF9, 0xE0, 0x1F, 0xFF, 0xBE, 0x03, 0xF8, 0x7F,
  0xE0, 0x3F, 0x01, 0xFE, 0x07, 0xE0, 0x1F, 0xC0, 0xFC, 0x00, 0xFC, 0x0F,
  0xC0, 0x0F, 0xC1, 0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0xC1, 0xF0, 0x00,
  0xF8, 0x3F, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0x87,
  0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00,
  0x1F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xE0,
  0xFC, 0x00, 0x7E, 0x0F, 0x80, 0x07, 0xE0, 0xF8, 0x00, 0xFE, 0x0F, 0x80,
  0x0F, 0xC0, 0xF8, 0x01, 0xFC, 0x0F, 0xC0, 0x1F, 0xC0, 0xFC, 0x03, 0xFC,
  0x0F, 0xC0, 0x7F, 0xC0, 0x7E, 0x0F, 0xF8, 0x07, 0xFF, 0xEF, 0x80, 0x3F,
  0xFC, 0xF8, 0x03, 0xFF, 0x8F, 0x80, 0x1F, 0xF1, 0xF8, 0x00, 0x38, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE1, 0xFC, 0x07, 0x8F, 0xF0,
  0x3E, 0x7F, 0x80, 0xFB, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0x78, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0x03, 0xC0, 0xF8, 0x01,
  0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x10, 0x01, 0xF8, 0x38, 0x0F, 0xF0,
  0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xFF, 0x9F, 0xFF,
  0xCF, 0xFF, 0xEF, 0xFF, 0xF0, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F,
  0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x03,
  0xF0, 0x41, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x0F, 0xF8, 0x01, 0xE0,
  0x00, 0x03, 0xE0, 0x03, 0xE0, 0xFC, 0x00, 0x7C, 0x1F, 0x80, 0x0F, 0x83,
  0xE0, 0x03, 0xF0, 0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x83, 0xF0, 0x01,
  0xF0, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0xC1, 0xF0, 0x01, 0xF0, 0x3E,
  0x00, 0x3E, 0x0F, 0xC0, 0x07, 0xC1, 0xF0, 0x01, 0xF8, 0x3E, 0x00, 0x3E,
  0x07, 0xC0, 0x07, 0xC1, 0xF8, 0x00, 0xF8, 0x3F, 0x00, 0x1F, 0x07, 0xC0,
  0x07, 0xE0, 0xF8, 0x00, 0xF8, 0x1F, 0x00, 0x1F, 0x07, 0xE0, 0x03, 0xE0,
  0xF8, 0x00, 0xFC, 0x1F, 0x00, 0x1F, 0x83, 0xE0, 0x03, 0xE0, 0x7C, 0x00,
  0xFC, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x07, 0xF0, 0x7E, 0x00, 0xFE, 0x0F,
  0xC0, 0x3F, 0x81, 0xF8, 0x0F, 0xF0, 0x3F, 0x87, 0xFE, 0x03, 0xFF, 0xF7,
  0xC0, 0x7F, 0xFC, 0xF0, 0x07, 0xFF, 0x1E, 0x00, 0x7F, 0x83, 0xC0, 0x01,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x7E,
  0xF8, 0x00, 0x7C, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0xF8, 0xF8, 0x01, 0xF8,
  0xF8, 0x01, 0xF0, 0xF8, 0x03, 0xF0, 0xF8, 0x03, 0xE0, 0xF8, 0x07, 0xE0,
  0xF8, 0x07, 0xC0, 0xF8, 0x07, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x1F, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x3F, 0x00, 0xF8, 0x3E, 0x00,
  0x78, 0x7E, 0x00, 0x78, 0x7C, 0x00, 0x78, 0x7C, 0x00, 0x78, 0xF8, 0x00,
  0x78, 0xF8, 0x00, 0x79, 0xF0, 0x00, 0x79, 0xF0, 0x00, 0x7B, 0xE0, 0x00,
  0x7B, 0xE0, 0x00, 0x7B, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0xF8, 0x00, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xF0, 0x03, 0xEF, 0x80, 0x1F,
  0xC0, 0x1F, 0xBE, 0x00, 0xFF, 0x00, 0x7C, 0xF8, 0x03, 0xFC, 0x01, 0xF3,
  0xE0, 0x0F, 0xF0, 0x0F, 0xCF, 0x80, 0x7F, 0xC0, 0x3E, 0x3E, 0x01, 0xFF,
  0x01, 0xF8, 0xF8, 0x0F, 0xFC, 0x07, 0xC3, 0xE0, 0x3D, 0xF0, 0x1F, 0x0F,
  0x80, 0xF7, 0xC0, 0xF8, 0x3E, 0x07, 0xDF, 0x03, 0xE0, 0xF8, 0x1E, 0x7C,
  0x1F, 0x83, 0xE0, 0xF9, 0xF0, 0x7C, 0x0F, 0x83, 0xC7, 0xC1, 0xF0, 0x3E,
  0x1F, 0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x7C, 0x3E, 0x03, 0xE1, 0xE1, 0xF1,
  0xF0, 0x0F, 0x8F, 0x87, 0xC7, 0xC0, 0x3E, 0x3C, 0x1F, 0x1F, 0x00, 0xF9,
  0xF0, 0x7C, 0xF8, 0x03, 0xE7, 0x81, 0xE3, 0xE0, 0x0F, 0x9E, 0x07, 0x9F,
  0x00, 0x3E, 0xF8, 0x1E, 0x7C, 0x00, 0xFB, 0xC0, 0x79, 0xF0, 0x03, 0xFF,
  0x01, 0xEF, 0x80, 0x0F, 0xF8, 0x07, 0xBE, 0x00, 0x3D, 0xE0, 0x1E, 0xF0,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x07, 0xF8, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0xFC, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x1F,
  0x00, 0xFC, 0x00, 0x7C, 0x03, 0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xE0,
  0xFC, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x7C, 0xFC,
  0x00, 0x01, 0xF3, 0xE0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x1F, 0x7C, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xDF,
  0x00, 0x00, 0x3E, 0x7C, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x07, 0xC3, 0xE0,
  0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF8, 0x3E, 0x00, 0x07, 0xC0, 0xFC, 0x00,
  0x3F, 0x01, 0xF0, 0x01, 0xF8, 0x07, 0xC0, 0x07, 0xC0, 0x1F, 0x00, 0x3F,
  0x00, 0x7E, 0x01, 0xF8, 0x00, 0xF8, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x0F, 0xC0, 0x0F, 0x80, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF8,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x0F,
  0x80, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x3F, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x7C,
  0x07, 0xE0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x01,
  0xF0, 0x3E, 0x00, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x1F, 0x07, 0xC0, 0x00,
  0x07, 0xC1, 0xF0, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x00, 0x7C, 0x3E, 0x00,
  0x00, 0x1F, 0x1F, 0x00, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x01, 0xF3, 0xE0,
  0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0x1F, 0x3C, 0x00, 0x00, 0x07, 0xDF,
  0x00, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x20, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x4F, 0xFE, 0x00, 0x17, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x9F,
  0xFD, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFA, 0x00, 0x07,
  0xF8,
};

const GFXglyph NotoSans_Condensed_Italic65pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 16, 47, 16, 1, -46 },
  { 95, 18, 16, 23, 7, -46 },
  { 131, 32, 46, 32, 1, -46 },
  { 315, 28, 53, 29, 1, -49 },
  { 501, 37, 48, 43, 4, -47 },
  { 723, 31, 48, 33, 0, -47 },
  { 909, 8, 16, 13, 7, -46 },
  { 925, 20, 57, 17, 2, -47 },
  { 1068, 20, 57, 17, -5, -47 },
  { 1211, 23, 25, 27, 6, -50 },
  { 1283, 26, 30, 31, 3, -38 },
  { 1381, 12, 16, 14, -3, -7 },
  { 1405, 15, 5, 18, 1, -20 },
  { 1415, 7, 9, 14, 1, -8 },
  { 1423, 30, 47, 22, -3, -47 },
  { 1600, 26, 48, 29, 2, -47 },
  { 1756, 17, 46, 29, 8, -46 },
  { 1854, 29, 47, 29, -1, -47 },
  { 2025, 28, 48, 29, 0, -47 },
  { 2193, 29, 47, 29, -1, -47 },
  { 2364, 29, 47, 29, 0, -46 },
  { 2535, 28, 48, 29, 2, -47 },
  { 2703, 28, 46, 29, 3, -46 },
  { 2864, 28, 48, 29, 1, -47 },
  { 3032, 27, 48, 29, 1, -47 },
  { 3194, 13, 36, 14, 0, -35 },
  { 3253, 17, 44, 14, -3, -35 },
  { 3347, 26, 30, 31, 3, -38 },
  { 3445, 26, 18, 31, 3, -32 },
  { 3504, 26, 30, 31, 3, -38 },
  { 3602, 22, 48, 22, 2, -47 },
  { 3734, 40, 53, 43, 2, -47 },
  { 3999, 29, 47, 29, -4, -47 },
  { 4170, 30, 46, 31, 1, -46 },
  { 4343, 30, 48, 29, 3, -47 },
  { 4523, 32, 46, 34, 1, -46 },
  { 4707, 28, 46, 27, 1, -46 },
  { 4868, 29, 46, 25, 1, -46 },
  { 5035, 33, 48, 36, 3, -47 },
  { 5233, 35, 46, 35, 1, -46 },
  { 5435, 25, 46, 18, -3, -46 },
  { 5579, 26, 58, 15, -10, -46 },
  { 5768, 34, 46, 29, 1, -46 },
  { 5964, 19, 46, 25, 1, -46 },
  { 6074, 46, 46, 46, 1, -46 },
  { 6339, 37, 46, 37, 1, -46 },
  { 6552, 32, 48, 37, 3, -47 },
  { 6744, 29, 46, 29, 1, -46 },
  { 6911, 32, 58, 37, 3, -47 },
  { 7143, 29, 46, 30, 1, -46 },
  { 7310, 30, 48, 27, -1, -47 },
  { 7490, 26, 46, 25, 5, -46 },
  { 7640, 33, 47, 35, 3, -46 },
  { 7834, 29, 46, 29, 6, -46 },
  { 8001, 46, 46, 46, 6, -46 },
  { 8266, 36, 46, 27, -4, -46 },
  { 8473, 26, 46, 26, 6, -46 },
  { 8623, 31, 46, 26, -2, -46 },
  { 8802, 24, 57, 18, -1, -47 },
  { 8973, 11, 47, 22, 7, -47 },
  { 9038, 24, 57, 18, -4, -47 },
  { 9209, 27, 26, 29, 1, -46 },
  { 9297, 23, 4, 22, -6, 6 },
  { 9309, 10, 11, 17, 9, -50 },
  { 9323, 28, 36, 30, 2, -35 },
  { 9449, 27, 50, 30, 1, -49 },
  { 9618, 23, 36, 23, 2, -35 },
  { 9722, 31, 50, 30, 2, -49 },
  { 9916, 24, 36, 27, 2, -35 },
  { 10024, 32, 66, 17, -8, -50 },
  { 10288, 31, 51, 31, -1, -35 },
  { 10486, 27, 49, 30, 1, -49 },
  { 10652, 15, 48, 14, 1, -48 },
  { 10742, 24, 64, 14, -8, -48 },
  { 10934, 28, 49, 26, 1, -49 },
  { 11106, 15, 49, 14, 1, -49 },
  { 11198, 42, 35, 45, 1, -35 },
  { 11382, 28, 36, 30, 0, -36 },
  { 11508, 25, 36, 30, 2, -35 },
  { 11621, 31, 50, 30, -3, -35 },
  { 11815, 28, 51, 30, 2, -35 },
  { 11994, 22, 35, 20, 1, -35 },
  { 12091, 23, 36, 23, 0, -35 },
  { 12195, 17, 44, 17, 2, -43 },
  { 12289, 27, 36, 30, 2, -35 },
  { 12411, 24, 35, 24, 4, -35 },
  { 12516, 38, 35, 39, 4, -35 },
  { 12683, 30, 35, 25, -3, -35 },
  { 12815, 34, 51, 25, -6, -35 },
  { 13032, 25, 35, 22, -2, -35 },
  { 13142, 25, 56, 22, 1, -46 },
  { 13317, 4, 65, 27, 12, -50 },
  { 13350, 23, 56, 22, -3, -46 },
  { 13511, 26, 8, 31, 3, -27 },
};

const GFXfont NotoSans_Condensed_Italic65pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Italic65pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Italic65pt7bGlyphs,
  0x20, 0x7E, 89
};

#endif // _NOTOSANS_CONDENSED_ITALIC65PT7B_H_
