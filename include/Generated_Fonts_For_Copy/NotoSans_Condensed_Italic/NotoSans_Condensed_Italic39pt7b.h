#ifndef _NOTOSANS_CONDENSED_ITALIC39PT7B_H_
#define _NOTOSANS_CONDENSED_ITALIC39PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Italic.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Italic39pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xC0, 0xF0, 0x38, 0x0E, 0x07, 0x81, 0xE0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0xF0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x60, 0x00, 0x00, 0x00, 0x00, 0x40, 0x78, 0x1E, 0x0F, 0x81, 0xC0,
  0x78, 0xEF, 0x3D, 0xC7, 0x38, 0xE7, 0x1C, 0xE3, 0x98, 0x67, 0x1C, 0xE3,
  0x98, 0x70, 0x00, 0x30, 0xE0, 0x07, 0x0C, 0x00, 0x70, 0xC0, 0x06, 0x1C,
  0x00, 0xE1, 0x80, 0x0E, 0x18, 0x00, 0xC3, 0x80, 0x0C, 0x38, 0x1F, 0xFF,
  0xF1, 0xFF, 0xFF, 0x1F, 0xFF, 0xE0, 0x38, 0x60, 0x03, 0x06, 0x00, 0x30,
  0xE0, 0x07, 0x0C, 0x00, 0x70, 0xC0, 0x06, 0x1C, 0x07, 0xFF, 0xF8, 0xFF,
  0xFF, 0x8F, 0xFF, 0xF8, 0x0C, 0x38, 0x01, 0xC3, 0x00, 0x18, 0x70, 0x01,
  0x87, 0x00, 0x38, 0x60, 0x03, 0x06, 0x00, 0x30, 0xE0, 0x07, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x1F, 0xF0, 0x1F,
  0xFC, 0x1E, 0xDE, 0x1E, 0x62, 0x0E, 0x30, 0x07, 0x30, 0x03, 0x98, 0x01,
  0xCC, 0x00, 0xE6, 0x00, 0x7F, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8,
  0x00, 0x7E, 0x00, 0x2F, 0x00, 0x33, 0x80, 0x18, 0xE0, 0x0C, 0x70, 0x06,
  0x70, 0x06, 0x38, 0x43, 0x3C, 0x7F, 0xFC, 0x3F, 0xFC, 0x07, 0xF8, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0x80, 0x38, 0x1F,
  0x80, 0xE0, 0x73, 0x01, 0x81, 0xC7, 0x07, 0x03, 0x0E, 0x0C, 0x0E, 0x1C,
  0x38, 0x1C, 0x30, 0xE0, 0x30, 0x61, 0xC0, 0x60, 0xC7, 0x01, 0xC3, 0x8C,
  0x03, 0x87, 0x38, 0x07, 0x0C, 0x63, 0xCE, 0x39, 0xCF, 0xDC, 0x77, 0x3B,
  0xB9, 0xCC, 0xE3, 0x3F, 0x39, 0x87, 0x3C, 0x67, 0x0E, 0x01, 0xCE, 0x18,
  0x07, 0x18, 0x30, 0x0E, 0x30, 0xE0, 0x38, 0xE1, 0xC0, 0x61, 0xC3, 0x81,
  0xC3, 0x86, 0x07, 0x07, 0x1C, 0x0E, 0x0E, 0x38, 0x38, 0x1C, 0xE0, 0x60,
  0x1F, 0x81, 0xC0, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x3F, 0xC0, 0x07, 0x3C,
  0x01, 0xC3, 0x80, 0x38, 0x70, 0x07, 0x0E, 0x01, 0xC1, 0xC0, 0x38, 0x70,
  0x07, 0x0E, 0x00, 0x73, 0x80, 0x0E, 0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xF8, 0x00, 0xF7, 0x07, 0x3C, 0xF1, 0xC7, 0x0E, 0x39,
  0xC1, 0xEE, 0x38, 0x1D, 0xCF, 0x03, 0xF1, 0xC0, 0x7E, 0x38, 0x07, 0x87,
  0x81, 0xF0, 0xF0, 0x7E, 0x0F, 0xBF, 0xE1, 0xFF, 0x9C, 0x1F, 0xC3, 0xC0,
  0x3B, 0xDC, 0xE7, 0x39, 0x9C, 0xE7, 0x00, 0x00, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x03,
  0x80, 0x38, 0x07, 0x80, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x06, 0x00, 0x70, 0x07, 0x00, 0x70, 0x03, 0x80, 0x01, 0xC0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0x80,
  0x38, 0x07, 0x00, 0x70, 0x0E, 0x01, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0F,
  0x00, 0x03, 0x00, 0x1C, 0x00, 0xE1, 0x07, 0x0E, 0x30, 0x7D, 0x81, 0xFF,
  0xE1, 0xFF, 0x0F, 0x00, 0xFC, 0x0E, 0x60, 0xF3, 0x87, 0x1C, 0x10, 0x70,
  0x02, 0x00, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x3C, 0x70, 0xE3, 0x87, 0x1C, 0x38, 0xE0, 0xFF, 0xFF, 0xBF, 0xC0,
  0x2F, 0xFF, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF8, 0x03, 0xFE, 0x03, 0xFE,
  0x07, 0x8E, 0x0F, 0x0F, 0x0E, 0x07, 0x1E, 0x07, 0x1C, 0x07, 0x3C, 0x07,
  0x38, 0x07, 0x38, 0x07, 0x38, 0x0F, 0x78, 0x0E, 0x70, 0x0E, 0x70, 0x0E,
  0x70, 0x0E, 0x70, 0x1E, 0xF0, 0x1C, 0xF0, 0x1C, 0xE0, 0x1C, 0xE0, 0x38,
  0xE0, 0x38, 0xE0, 0x78, 0xF0, 0x70, 0x70, 0xF0, 0x7F, 0xE0, 0x3F, 0xC0,
  0x3F, 0x80, 0x01, 0xC1, 0xF0, 0xF8, 0x7E, 0x3F, 0xBE, 0xEE, 0x7B, 0x1C,
  0x07, 0x01, 0xC0, 0xF0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x78, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x78, 0x1C, 0x07, 0x01,
  0xC0, 0x00, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0xF8, 0x0E, 0x0F, 0x02, 0x03,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1F, 0xFF, 0x0F,
  0xFF, 0xC3, 0xFF, 0xF0, 0x01, 0xFC, 0x03, 0xFF, 0x83, 0xFF, 0xC0, 0xC0,
  0xF0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x1F, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x80, 0x78, 0x79, 0xF8, 0x3F,
  0xF8, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03,
  0xE0, 0x03, 0xF0, 0x01, 0xB8, 0x01, 0xDC, 0x01, 0xDC, 0x00, 0xCE, 0x00,
  0xE7, 0x00, 0xE3, 0x80, 0xE3, 0xC0, 0x71, 0xC0, 0x70, 0xE0, 0x70, 0x70,
  0x38, 0x38, 0x38, 0x3C, 0x38, 0x1C, 0x18, 0x0E, 0x1F, 0xFF, 0xEF, 0xFF,
  0xF7, 0xFF, 0xF8, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x70,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x80, 0x78, 0x78, 0xF8, 0x3F,
  0xF8, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x7F, 0xC0, 0x78,
  0x00, 0x78, 0x00, 0x38, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x0E, 0x18, 0x07, 0x7F, 0x03, 0xFF, 0xC3, 0xF1, 0xE1, 0xF0, 0x70,
  0xF0, 0x3C, 0x70, 0x1E, 0x38, 0x0F, 0x3C, 0x07, 0x9E, 0x03, 0x8F, 0x01,
  0xC7, 0x80, 0xE3, 0xC0, 0xF0, 0xE0, 0x70, 0x70, 0x78, 0x3E, 0xF8, 0x0F,
  0xF8, 0x03, 0xF8, 0x00, 0x3F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x00, 0x0F,
  0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80,
  0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0xE0, 0xF0, 0x70, 0x70, 0x38, 0x70,
  0x1C, 0x38, 0x0E, 0x1C, 0x07, 0x0E, 0x07, 0x83, 0x83, 0x81, 0xC3, 0x80,
  0x77, 0x80, 0x3F, 0x80, 0x1F, 0x00, 0x1F, 0xE0, 0x3E, 0xF0, 0x3C, 0x3C,
  0x1C, 0x0E, 0x1C, 0x07, 0x8E, 0x01, 0xCF, 0x00, 0xE7, 0x80, 0x73, 0xC0,
  0x79, 0xE0, 0x38, 0x70, 0x3C, 0x3E, 0x3C, 0x0F, 0xFC, 0x03, 0xFC, 0x00,
  0x00, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0xC0, 0xE0, 0xE0, 0xF0, 0x70, 0x70,
  0x3C, 0x78, 0x0E, 0x38, 0x0F, 0x1C, 0x07, 0x8E, 0x03, 0xC7, 0x01, 0xC3,
  0x80, 0xE1, 0xC0, 0xF0, 0xE0, 0x78, 0x78, 0xFC, 0x3F, 0xEE, 0x0F, 0xEE,
  0x01, 0xC7, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x73, 0xF0, 0x3F, 0xF0, 0x1F, 0xE0, 0x00,
  0x07, 0x0F, 0x0F, 0x0F, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x20, 0x78, 0xF8, 0xF0, 0xF0, 0x01, 0xC0, 0xF0,
  0x3C, 0x0F, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x70, 0x3C, 0x0E,
  0x03, 0x81, 0xC0, 0x60, 0x38, 0x00, 0x00, 0x01, 0x00, 0x07, 0x00, 0x1F,
  0x00, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x00, 0xF8, 0x00,
  0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFE,
  0x00, 0x3F, 0x00, 0x0F, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x80, 0x00, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x00, 0xF8, 0x00, 0xE0,
  0x00, 0x80, 0x00, 0x0F, 0xE1, 0xFF, 0x87, 0xFE, 0x20, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x38, 0x03, 0x80, 0x3C,
  0x03, 0xC0, 0x3C, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x70, 0x07, 0xC0, 0x3C, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0xF8, 0x7C, 0x01, 0xE0,
  0x1E, 0x03, 0x80, 0x0E, 0x07, 0x00, 0x07, 0x06, 0x00, 0x07, 0x0E, 0x00,
  0x03, 0x1C, 0x1F, 0xE3, 0x18, 0x3F, 0xC3, 0x38, 0x71, 0xC3, 0x38, 0x61,
  0xC3, 0x30, 0xE1, 0xC3, 0x70, 0xC1, 0x87, 0x71, 0xC3, 0x87, 0x61, 0x83,
  0x87, 0x61, 0x83, 0x86, 0xE3, 0x83, 0x0E, 0xE3, 0x87, 0x0E, 0xE3, 0x87,
  0x0C, 0xE3, 0x8F, 0x18, 0xE1, 0xFB, 0xF8, 0xE1, 0xF1, 0xF0, 0xE0, 0x60,
  0xC0, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1E, 0x03, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0x60, 0x03, 0xF0, 0x01, 0xF8, 0x01,
  0xCC, 0x00, 0xE6, 0x00, 0xE3, 0x00, 0x71, 0xC0, 0x78, 0xE0, 0x38, 0x70,
  0x1C, 0x38, 0x1C, 0x1C, 0x0E, 0x0E, 0x0F, 0x07, 0x07, 0xFF, 0x87, 0xFF,
  0xC3, 0xFF, 0xE3, 0xC0, 0x71, 0xC0, 0x39, 0xE0, 0x1C, 0xF0, 0x0E, 0x70,
  0x07, 0x78, 0x03, 0xB8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x70, 0x03, 0xFE,
  0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x01, 0xC1, 0xE0, 0x78, 0x1E, 0x0E, 0x03,
  0xC1, 0xC0, 0x78, 0x38, 0x0F, 0x07, 0x01, 0xC1, 0xE0, 0x38, 0x38, 0x0F,
  0x07, 0x03, 0xC0, 0xFF, 0xF0, 0x1F, 0xF0, 0x07, 0xFF, 0x80, 0xE0, 0x78,
  0x1C, 0x07, 0x03, 0x80, 0xF0, 0xF0, 0x1E, 0x1E, 0x03, 0xC3, 0x80, 0x78,
  0x70, 0x0E, 0x0E, 0x03, 0xC3, 0xC0, 0x78, 0x70, 0x3E, 0x0F, 0xFF, 0x81,
  0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0xF0, 0x3F, 0xF8,
  0x1F, 0x02, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x08, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F,
  0xF8, 0x03, 0xFF, 0xC0, 0x38, 0x7C, 0x07, 0x81, 0xE0, 0x78, 0x0E, 0x07,
  0x00, 0xE0, 0x70, 0x0F, 0x07, 0x00, 0xF0, 0xF0, 0x0F, 0x0E, 0x00, 0xF0,
  0xE0, 0x0F, 0x0E, 0x00, 0xF0, 0xE0, 0x0E, 0x1E, 0x00, 0xE1, 0xC0, 0x1E,
  0x1C, 0x01, 0xE1, 0xC0, 0x1C, 0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x38, 0x07,
  0x83, 0x80, 0x78, 0x38, 0x0F, 0x07, 0x81, 0xE0, 0x70, 0x7C, 0x07, 0xFF,
  0x80, 0x7F, 0xF0, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F,
  0xF8, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0xFE, 0x03,
  0xFF, 0x01, 0xFF, 0xC0, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00,
  0x70, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0,
  0xFF, 0xE0, 0x3F, 0xF8, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1C, 0x00, 0x07,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x7F, 0xC0, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7C, 0x06, 0x0F, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x01, 0xFC, 0xF0,
  0x3F, 0xCE, 0x03, 0xF8, 0xE0, 0x03, 0x8E, 0x00, 0x38, 0xE0, 0x07, 0x8E,
  0x00, 0x70, 0xE0, 0x07, 0x0F, 0x00, 0x70, 0xF0, 0x07, 0x0F, 0x00, 0xF0,
  0x78, 0x0E, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0xC0, 0x03, 0xC0,
  0x3C, 0x0E, 0x00, 0xF0, 0x38, 0x03, 0x80, 0xE0, 0x0E, 0x07, 0x80, 0x38,
  0x1C, 0x01, 0xE0, 0x70, 0x07, 0x01, 0xC0, 0x1C, 0x07, 0x00, 0x70, 0x3C,
  0x01, 0xC0, 0xE0, 0x0F, 0x03, 0x80, 0x38, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF,
  0x81, 0xFF, 0xFE, 0x07, 0x00, 0x78, 0x1C, 0x01, 0xC0, 0x70, 0x07, 0x03,
  0xC0, 0x1C, 0x0F, 0x00, 0xF0, 0x38, 0x03, 0x80, 0xE0, 0x0E, 0x03, 0x80,
  0x38, 0x1E, 0x00, 0xE0, 0x70, 0x07, 0x81, 0xC0, 0x1C, 0x07, 0x00, 0x70,
  0x3C, 0x01, 0xC0, 0x03, 0xFF, 0x03, 0xFE, 0x00, 0xF8, 0x00, 0x70, 0x00,
  0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x00,
  0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03,
  0x80, 0x07, 0x80, 0x5F, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x03, 0xC0, 0x78,
  0x1C, 0x07, 0x80, 0xE0, 0x78, 0x07, 0x03, 0x80, 0x78, 0x3C, 0x03, 0x83,
  0xC0, 0x1C, 0x3C, 0x00, 0xE3, 0xC0, 0x07, 0x1C, 0x00, 0x79, 0xE0, 0x03,
  0x9E, 0x00, 0x1D, 0xE0, 0x00, 0xEE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xC0,
  0x03, 0xEE, 0x00, 0x1E, 0x70, 0x00, 0xE3, 0x80, 0x0F, 0x1E, 0x00, 0x78,
  0x70, 0x03, 0x83, 0x80, 0x1C, 0x1E, 0x00, 0xE0, 0xF0, 0x0F, 0x03, 0x80,
  0x70, 0x1C, 0x03, 0x80, 0xF0, 0x1C, 0x07, 0x81, 0xE0, 0x1C, 0x00, 0x03,
  0xC0, 0x38, 0x03, 0x80, 0x38, 0x07, 0x80, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x07, 0x80, 0x70,
  0x07, 0xFF, 0x7F, 0xFF, 0xFF, 0x03, 0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x1F,
  0x03, 0xE0, 0x03, 0xF0, 0x3E, 0x00, 0x3E, 0x07, 0xE0, 0x07, 0xE0, 0x7E,
  0x00, 0x7E, 0x07, 0xE0, 0x0E, 0xE0, 0x7E, 0x00, 0xFE, 0x07, 0x60, 0x1D,
  0xC0, 0xE6, 0x01, 0xDC, 0x0E, 0x70, 0x39, 0xC0, 0xE7, 0x03, 0x9C, 0x0E,
  0x70, 0x73, 0xC0, 0xE7, 0x07, 0x38, 0x1C, 0x70, 0xE3, 0x81, 0xC7, 0x0E,
  0x38, 0x1C, 0x71, 0xC7, 0x81, 0xC7, 0x1C, 0x70, 0x3C, 0x73, 0x87, 0x03,
  0x87, 0x38, 0x70, 0x38, 0x73, 0x07, 0x03, 0x87, 0x70, 0xF0, 0x38, 0x77,
  0x0E, 0x07, 0x07, 0xE0, 0xE0, 0x70, 0x3E, 0x0E, 0x07, 0x03, 0xC0, 0xE0,
  0x70, 0x3C, 0x1E, 0x0F, 0x03, 0x81, 0xC0, 0x03, 0xC0, 0x0E, 0x07, 0x80,
  0x1C, 0x0F, 0x80, 0x70, 0x1F, 0x00, 0xE0, 0x7E, 0x01, 0xC0, 0xFC, 0x03,
  0x81, 0xDC, 0x0F, 0x03, 0xB8, 0x1C, 0x07, 0x70, 0x38, 0x1C, 0xE0, 0x70,
  0x39, 0xC0, 0xE0, 0x71, 0xC3, 0xC0, 0xE3, 0x87, 0x01, 0xC7, 0x0E, 0x07,
  0x0E, 0x1C, 0x0E, 0x0E, 0x38, 0x1C, 0x1C, 0xF0, 0x38, 0x39, 0xC0, 0xF0,
  0x73, 0x81, 0xC0, 0xE7, 0x03, 0x80, 0xEE, 0x07, 0x01, 0xF8, 0x0E, 0x03,
  0xF0, 0x3C, 0x07, 0xE0, 0x70, 0x07, 0xC0, 0xE0, 0x0F, 0x81, 0xC0, 0x1E,
  0x07, 0x80, 0x3C, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x03,
  0xC1, 0xE0, 0xF0, 0x1E, 0x3C, 0x03, 0xC7, 0x00, 0x39, 0xE0, 0x07, 0x38,
  0x00, 0xEF, 0x00, 0x1D, 0xE0, 0x03, 0xB8, 0x00, 0x77, 0x00, 0x0F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0E, 0xE0, 0x01, 0xDC, 0x00, 0x7B, 0x80,
  0x0F, 0x70, 0x01, 0xCE, 0x00, 0x79, 0xC0, 0x0E, 0x3C, 0x03, 0xC7, 0x80,
  0xF0, 0x78, 0x3C, 0x0F, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x0E, 0x1F, 0x07, 0x83, 0xC1, 0xC0,
  0x70, 0x70, 0x1C, 0x1C, 0x07, 0x07, 0x01, 0xC3, 0xC0, 0xF0, 0xE0, 0x3C,
  0x38, 0x0E, 0x0E, 0x07, 0x83, 0x87, 0xC1, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F,
  0xF0, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x03, 0xC1, 0xE0,
  0xF0, 0x1E, 0x3C, 0x03, 0xC7, 0x00, 0x39, 0xE0, 0x07, 0x38, 0x00, 0xEF,
  0x00, 0x1D, 0xE0, 0x03, 0xB8, 0x00, 0x77, 0x00, 0x0F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x00, 0x0E, 0xE0, 0x01, 0xDC, 0x00, 0x7B, 0x80, 0x0F, 0x70,
  0x01, 0xCE, 0x00, 0x79, 0xC0, 0x0E, 0x3C, 0x03, 0xC7, 0x80, 0xF0, 0x78,
  0x3C, 0x0F, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0x1E, 0x00, 0x01,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x0E, 0x1F, 0x07,
  0x83, 0xC1, 0xC0, 0x70, 0x70, 0x1C, 0x1C, 0x07, 0x07, 0x01, 0xC3, 0xC0,
  0xF0, 0xE0, 0x3C, 0x38, 0x1E, 0x0E, 0x0F, 0x83, 0x8F, 0xC1, 0xFF, 0xE0,
  0x7F, 0xE0, 0x1C, 0x70, 0x07, 0x1E, 0x03, 0xC3, 0x80, 0xF0, 0xE0, 0x38,
  0x38, 0x0E, 0x0F, 0x03, 0x83, 0xC1, 0xE0, 0x70, 0x70, 0x1C, 0x1C, 0x07,
  0x87, 0x01, 0xE3, 0xC0, 0x38, 0x00, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xE1,
  0xF0, 0x20, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x80, 0x78, 0x7F, 0xF8,
  0x3F, 0xF8, 0x1F, 0xF8, 0x00, 0x7F, 0xFE, 0xFF, 0xFF, 0xFF, 0xF8, 0x1C,
  0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0xF0, 0xE0, 0x0E, 0x0E, 0x00, 0xE1, 0xE0, 0x0E, 0x1C, 0x01, 0xE1, 0xC0,
  0x1E, 0x1C, 0x01, 0xC1, 0xC0, 0x1C, 0x3C, 0x01, 0xC3, 0x80, 0x3C, 0x38,
  0x03, 0x83, 0x80, 0x38, 0x38, 0x03, 0x87, 0x80, 0x38, 0x70, 0x07, 0x87,
  0x00, 0x70, 0x70, 0x07, 0x0F, 0x00, 0x70, 0xE0, 0x0F, 0x0E, 0x00, 0xE0,
  0xE0, 0x0E, 0x0E, 0x00, 0xE0, 0xE0, 0x1E, 0x0E, 0x01, 0xC0, 0xF0, 0x3C,
  0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x01, 0xFE, 0x00, 0xF0, 0x03, 0xFC, 0x00,
  0xE7, 0x00, 0x79, 0xC0, 0x1C, 0x70, 0x0F, 0x1C, 0x03, 0x87, 0x01, 0xE1,
  0xC0, 0x70, 0x70, 0x1C, 0x1C, 0x0F, 0x07, 0x03, 0x81, 0xC1, 0xE0, 0x70,
  0x70, 0x1C, 0x3C, 0x07, 0x0E, 0x01, 0xC3, 0x80, 0x71, 0xC0, 0x1C, 0x70,
  0x07, 0x38, 0x01, 0xCE, 0x00, 0x77, 0x80, 0x1D, 0xC0, 0x07, 0x70, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xE0,
  0x0E, 0x00, 0xFC, 0x03, 0xC0, 0x3B, 0x80, 0x78, 0x07, 0x70, 0x1F, 0x01,
  0xEE, 0x03, 0xE0, 0x39, 0xC0, 0x7C, 0x0F, 0x38, 0x1F, 0x81, 0xC7, 0x03,
  0xF0, 0x38, 0xE0, 0xEE, 0x0F, 0x1C, 0x1D, 0xC1, 0xC3, 0x83, 0x38, 0x78,
  0x70, 0xE7, 0x0E, 0x0E, 0x1C, 0xE1, 0xC1, 0xC7, 0x1C, 0x78, 0x38, 0xE3,
  0x8E, 0x07, 0x38, 0x73, 0xC0, 0xE7, 0x0E, 0x70, 0x1C, 0xC1, 0xCE, 0x03,
  0xB8, 0x3B, 0x80, 0x77, 0x07, 0x70, 0x0F, 0xC0, 0xEE, 0x01, 0xB8, 0x1F,
  0x80, 0x36, 0x03, 0xF0, 0x07, 0xC0, 0x7C, 0x00, 0xF8, 0x0F, 0x80, 0x1E,
  0x01, 0xF0, 0x03, 0xC0, 0x3C, 0x00, 0x70, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x78, 0x0E, 0x03, 0x80, 0x70, 0x3C, 0x03, 0x81, 0xC0, 0x1C, 0x1C, 0x00,
  0xF0, 0xE0, 0x03, 0x8E, 0x00, 0x1C, 0xF0, 0x00, 0xE7, 0x00, 0x07, 0x70,
  0x00, 0x3F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xE7, 0x00,
  0x0E, 0x38, 0x00, 0xF1, 0xC0, 0x07, 0x0E, 0x00, 0x78, 0x78, 0x03, 0x83,
  0xC0, 0x38, 0x0E, 0x03, 0xC0, 0x70, 0x1C, 0x03, 0x81, 0xE0, 0x1E, 0x00,
  0xF0, 0x0F, 0x70, 0x0E, 0x70, 0x1E, 0x70, 0x1C, 0x70, 0x3C, 0x70, 0x38,
  0x78, 0x70, 0x38, 0x70, 0x38, 0xE0, 0x39, 0xE0, 0x39, 0xC0, 0x3B, 0xC0,
  0x3B, 0x80, 0x3F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x03, 0xFF, 0xE0, 0x7F,
  0xF8, 0x1F, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0x80,
  0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x38, 0x00,
  0x0F, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1F, 0xFF, 0x83, 0xFF, 0xE0,
  0x7F, 0xFC, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x0E, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0xE1, 0xC3, 0x87, 0x06, 0x0E,
  0x1C, 0x38, 0x70, 0xE1, 0xC1, 0x83, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE0,
  0xC1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0x70, 0x00, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x7F, 0x01, 0xFE, 0x00,
  0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x03, 0xF0, 0x07, 0x30,
  0x07, 0x38, 0x0E, 0x38, 0x0E, 0x18, 0x1C, 0x1C, 0x1C, 0x1C, 0x38, 0x0E,
  0x38, 0x0E, 0x70, 0x0E, 0xE0, 0x07, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xE7, 0x9C, 0xE3, 0x8C, 0x03, 0xF3, 0x83, 0xFD, 0xC3, 0xEF, 0xC3,
  0xC1, 0xE1, 0xC0, 0xF1, 0xE0, 0x78, 0xE0, 0x3C, 0xF0, 0x1C, 0x78, 0x0E,
  0x38, 0x07, 0x1C, 0x03, 0x8E, 0x03, 0xCF, 0x01, 0xC7, 0x80, 0xE3, 0xC0,
  0xF1, 0xC0, 0x78, 0xF0, 0x78, 0x78, 0x7C, 0x1E, 0x7E, 0x0F, 0xF7, 0x03,
  0xF3, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x9F, 0x03,
  0xDF, 0xC1, 0xDD, 0xE0, 0xF8, 0x78, 0x78, 0x1C, 0x3C, 0x0E, 0x3C, 0x07,
  0x1E, 0x03, 0x8E, 0x01, 0xC7, 0x01, 0xE3, 0x80, 0xF3, 0x80, 0x71, 0xC0,
  0x38, 0xE0, 0x3C, 0x70, 0x1C, 0x78, 0x0E, 0x3C, 0x0F, 0x1E, 0x0F, 0x0F,
  0xCF, 0x06, 0x7F, 0x07, 0x3F, 0x00, 0x01, 0xFC, 0x1F, 0xE0, 0xFF, 0x87,
  0x80, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x01,
  0xC0, 0x07, 0xCC, 0x0F, 0xF0, 0x1F, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x7E, 0x70, 0x1F, 0xEE, 0x07, 0xDF, 0x81,
  0xE0, 0xF0, 0x38, 0x1E, 0x0F, 0x03, 0xC1, 0xC0, 0x78, 0x78, 0x0E, 0x0F,
  0x01, 0xC1, 0xC0, 0x38, 0x38, 0x07, 0x0F, 0x01, 0xC1, 0xE0, 0x38, 0x3C,
  0x07, 0x07, 0x01, 0xE0, 0xE0, 0x3C, 0x1E, 0x0F, 0x03, 0xC3, 0xE0, 0x3C,
  0xFC, 0x07, 0xFB, 0x80, 0x7E, 0x70, 0x00, 0x01, 0xF8, 0x1F, 0xF0, 0xF3,
  0xC7, 0x87, 0x1C, 0x1C, 0xE0, 0x73, 0x81, 0xDE, 0x0F, 0x70, 0x79, 0xFF,
  0xC7, 0xFC, 0x3F, 0x80, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xF0,
  0x01, 0xC0, 0x47, 0x87, 0x0F, 0xFC, 0x1F, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0xF8, 0x01, 0xFF, 0x00,
  0x1F, 0xF0, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x9E, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF9,
  0xC0, 0xFF, 0x70, 0x7D, 0xD8, 0x3C, 0x1E, 0x0E, 0x07, 0x87, 0x81, 0xE1,
  0xC0, 0x78, 0x70, 0x1C, 0x3C, 0x07, 0x0E, 0x01, 0xC3, 0x80, 0x70, 0xE0,
  0x3C, 0x78, 0x0E, 0x1E, 0x03, 0x87, 0x01, 0xE1, 0xC0, 0x78, 0x78, 0x3C,
  0x1E, 0x1F, 0x03, 0xCF, 0xC0, 0xFF, 0x70, 0x1F, 0xBC, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x08, 0x0F, 0x03, 0x8F,
  0x80, 0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x9F, 0x03, 0xBF, 0xC1, 0xDF, 0xE0, 0xF8, 0x78, 0x78, 0x3C,
  0x38, 0x1C, 0x3C, 0x0E, 0x1C, 0x07, 0x0E, 0x03, 0x87, 0x01, 0xC3, 0x81,
  0xE3, 0x80, 0xE1, 0xC0, 0x70, 0xE0, 0x38, 0x70, 0x3C, 0x78, 0x1C, 0x38,
  0x0E, 0x1C, 0x07, 0x0E, 0x03, 0x87, 0x03, 0xC7, 0x81, 0xC0, 0x01, 0x81,
  0xC0, 0xE0, 0x70, 0x10, 0x00, 0x00, 0x00, 0x07, 0x07, 0x83, 0x81, 0xC0,
  0xE0, 0x70, 0x78, 0x38, 0x1C, 0x0E, 0x07, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0xF0, 0x70, 0x38, 0x1C, 0x0E, 0x0F, 0x00, 0x00, 0x0C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x01,
  0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0xF0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x2F, 0x80, 0xFC, 0x03,
  0xE0, 0x00, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x83, 0xC3,
  0xC1, 0xC1, 0xC1, 0xC0, 0xE1, 0xC0, 0x71, 0xE0, 0x39, 0xE0, 0x3D, 0xE0,
  0x1C, 0xE0, 0x0E, 0xE0, 0x07, 0xF0, 0x03, 0xFC, 0x03, 0xEE, 0x01, 0xE7,
  0x00, 0xE3, 0x80, 0x71, 0xE0, 0x78, 0x70, 0x38, 0x38, 0x1C, 0x1C, 0x0E,
  0x0F, 0x07, 0x03, 0x87, 0x81, 0xC0, 0x01, 0xC0, 0xF0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0xF0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x78, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x78, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x3C, 0x00, 0x06, 0x3E, 0x1F, 0x03,
  0xBF, 0xDF, 0xE0, 0xFF, 0xF7, 0x78, 0x3E, 0x1F, 0x0F, 0x0F, 0x07, 0x83,
  0xC3, 0x81, 0xE0, 0xE1, 0xE0, 0x70, 0x38, 0x70, 0x1C, 0x0E, 0x1C, 0x0F,
  0x03, 0x87, 0x03, 0x80, 0xE1, 0xC0, 0xE0, 0x70, 0xE0, 0x38, 0x1C, 0x38,
  0x0E, 0x07, 0x0E, 0x07, 0x81, 0xC3, 0x81, 0xC0, 0xF1, 0xE0, 0x70, 0x38,
  0x70, 0x1C, 0x0E, 0x1C, 0x07, 0x03, 0x87, 0x03, 0x80, 0xE1, 0xC0, 0xE0,
  0x78, 0xF0, 0x38, 0x1C, 0x00, 0x06, 0x3E, 0x07, 0x7F, 0x83, 0xFF, 0xC1,
  0xF0, 0xF0, 0xF0, 0x78, 0x70, 0x38, 0x78, 0x1C, 0x3C, 0x0E, 0x1C, 0x07,
  0x0E, 0x07, 0x8F, 0x03, 0xC7, 0x81, 0xC3, 0x80, 0xE1, 0xC0, 0x70, 0xE0,
  0x78, 0xF0, 0x38, 0x70, 0x1C, 0x38, 0x0E, 0x1C, 0x07, 0x0E, 0x07, 0x8F,
  0x03, 0x80, 0x03, 0xF8, 0x0F, 0xF8, 0x3E, 0xF8, 0xF0, 0x71, 0xC0, 0xE7,
  0x81, 0xCE, 0x03, 0xBC, 0x07, 0x70, 0x0E, 0xE0, 0x1D, 0xC0, 0x3F, 0x80,
  0x7F, 0x01, 0xFC, 0x03, 0xB8, 0x07, 0x70, 0x1E, 0xF0, 0x38, 0xE0, 0xF1,
  0xF7, 0xC1, 0xFF, 0x01, 0xF8, 0x00, 0x01, 0x8F, 0x80, 0x73, 0xF8, 0x0E,
  0xEF, 0x01, 0xF0, 0xF0, 0x3C, 0x0E, 0x07, 0x81, 0xC1, 0xE0, 0x38, 0x3C,
  0x07, 0x07, 0x00, 0xE0, 0xE0, 0x3C, 0x1C, 0x07, 0x87, 0x00, 0xE0, 0xE0,
  0x1C, 0x1C, 0x07, 0x83, 0x80, 0xE0, 0x70, 0x1C, 0x1E, 0x07, 0x03, 0xE1,
  0xE0, 0x7E, 0x78, 0x0E, 0xFE, 0x03, 0xDF, 0x80, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xF3, 0x83, 0xFD, 0xC3, 0xEF,
  0xC3, 0xC1, 0xE1, 0xC0, 0xF1, 0xE0, 0x78, 0xE0, 0x3C, 0xF0, 0x1C, 0x70,
  0x0E, 0x38, 0x07, 0x1C, 0x03, 0x9E, 0x03, 0x8F, 0x01, 0xC7, 0x80, 0xE3,
  0xC0, 0xF1, 0xC0, 0x78, 0xF0, 0x78, 0x78, 0x7C, 0x1E, 0x7E, 0x0F, 0xF7,
  0x03, 0xF7, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x06, 0x7C,
  0x3B, 0xE0, 0xEF, 0x83, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x07,
  0xF8, 0x3F, 0xF1, 0xF7, 0x87, 0x02, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x07,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE2, 0x07, 0x8E, 0x7C, 0x3F, 0xF0, 0xFF, 0x00,
  0x03, 0x00, 0xE0, 0x18, 0x03, 0x00, 0xE0, 0x3F, 0xDF, 0xF3, 0xFE, 0x1C,
  0x03, 0x80, 0x70, 0x1E, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x78, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x07, 0x90, 0x7E, 0x0F, 0xC0,
  0x0E, 0x07, 0x8F, 0x03, 0x87, 0x01, 0xC3, 0x80, 0xE1, 0xC0, 0x71, 0xE0,
  0x70, 0xE0, 0x38, 0x70, 0x1C, 0x38, 0x0E, 0x1C, 0x0F, 0x1E, 0x07, 0x0E,
  0x03, 0x87, 0x01, 0xC3, 0x81, 0xE1, 0xC0, 0xF1, 0xE0, 0x70, 0xF0, 0x78,
  0x78, 0x7C, 0x3E, 0xEE, 0x0F, 0xF6, 0x03, 0xE3, 0x00, 0xE0, 0x1F, 0xC0,
  0x3B, 0x80, 0xE7, 0x01, 0xCE, 0x07, 0x9C, 0x0E, 0x38, 0x3C, 0x38, 0x70,
  0x71, 0xE0, 0xE3, 0x81, 0xC7, 0x03, 0x9C, 0x07, 0x38, 0x0E, 0xE0, 0x1D,
  0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80,
  0x00, 0xE0, 0x38, 0x0F, 0xC0, 0xF0, 0x3B, 0x81, 0xE0, 0x77, 0x07, 0xC1,
  0xEE, 0x0F, 0x83, 0x9C, 0x1B, 0x07, 0x38, 0x76, 0x1C, 0x70, 0xCC, 0x38,
  0xE3, 0x98, 0xF1, 0xC7, 0x31, 0xC3, 0x8C, 0x63, 0x87, 0x38, 0xCE, 0x0E,
  0x61, 0x9C, 0x1D, 0xC3, 0x70, 0x3B, 0x86, 0xE0, 0x76, 0x0D, 0xC0, 0xFC,
  0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x78, 0x07, 0xC0, 0xF0, 0x0F, 0x01,
  0xC0, 0x00, 0x07, 0x01, 0xC1, 0xE0, 0xE0, 0x38, 0x78, 0x0E, 0x1C, 0x03,
  0x8E, 0x00, 0xF7, 0x80, 0x1D, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x77, 0x00,
  0x38, 0xE0, 0x1E, 0x38, 0x07, 0x0E, 0x03, 0x83, 0xC1, 0xE0, 0x70, 0xF0,
  0x1C, 0x00, 0x03, 0x80, 0x78, 0x1E, 0x03, 0x80, 0xF0, 0x3C, 0x03, 0x81,
  0xC0, 0x1C, 0x1E, 0x00, 0xE0, 0xE0, 0x07, 0x07, 0x00, 0x38, 0x70, 0x01,
  0xC3, 0x80, 0x0E, 0x38, 0x00, 0x71, 0xC0, 0x03, 0x9C, 0x00, 0x1C, 0xE0,
  0x00, 0xEE, 0x00, 0x07, 0x70, 0x00, 0x3B, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0,
  0x00, 0xBE, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xFE, 0x1F,
  0xF8, 0x3F, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x07,
  0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xFF, 0x87, 0xFF, 0x0F, 0xFE,
  0x00, 0x00, 0x1C, 0x01, 0xF0, 0x0F, 0xC0, 0x78, 0x01, 0xC0, 0x07, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0xE0, 0x0F, 0x80, 0xF8, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x80, 0x3F, 0x00, 0x3C,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0x80, 0x07, 0x80, 0x3F, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x7C, 0x01, 0xF0,
  0x0F, 0xC0, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x3F, 0x00,
  0xFC, 0x03, 0xC0, 0x00, 0x7E, 0x01, 0xFF, 0x87, 0xFF, 0xFF, 0x81, 0xFE,
  0x80, 0x38,
};

const GFXglyph NotoSans_Condensed_Italic39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 10, 28, 9, 0, -28 },
  { 36, 11, 10, 14, 4, -28 },
  { 50, 20, 28, 19, 0, -28 },
  { 120, 17, 32, 17, 0, -30 },
  { 188, 23, 28, 26, 2, -28 },
  { 269, 19, 28, 20, 0, -28 },
  { 336, 5, 10, 8, 4, -28 },
  { 343, 12, 34, 10, 1, -28 },
  { 394, 12, 34, 10, -3, -28 },
  { 445, 13, 15, 16, 4, -30 },
  { 470, 15, 18, 18, 2, -23 },
  { 504, 7, 9, 9, -2, -4 },
  { 512, 9, 3, 11, 1, -12 },
  { 516, 4, 5, 9, 1, -5 },
  { 519, 18, 28, 13, -2, -28 },
  { 582, 16, 28, 17, 1, -28 },
  { 638, 10, 28, 17, 5, -28 },
  { 673, 18, 28, 17, -1, -28 },
  { 736, 17, 28, 17, 0, -28 },
  { 796, 17, 28, 17, 0, -28 },
  { 856, 17, 28, 17, 0, -28 },
  { 916, 17, 28, 17, 1, -28 },
  { 976, 16, 28, 17, 2, -28 },
  { 1032, 17, 28, 17, 0, -28 },
  { 1092, 17, 28, 17, 0, -28 },
  { 1152, 8, 21, 9, 0, -21 },
  { 1173, 10, 26, 9, -2, -21 },
  { 1206, 16, 18, 18, 2, -23 },
  { 1242, 15, 11, 18, 2, -19 },
  { 1263, 16, 18, 18, 2, -23 },
  { 1299, 13, 28, 13, 1, -28 },
  { 1345, 24, 31, 26, 1, -28 },
  { 1438, 17, 28, 18, -2, -28 },
  { 1498, 19, 28, 19, 0, -28 },
  { 1565, 18, 28, 17, 2, -28 },
  { 1628, 20, 28, 21, 0, -28 },
  { 1698, 18, 28, 16, 0, -28 },
  { 1761, 18, 28, 15, 0, -28 },
  { 1824, 20, 28, 21, 2, -28 },
  { 1894, 22, 28, 21, 0, -28 },
  { 1971, 16, 28, 11, -2, -28 },
  { 2027, 16, 35, 9, -6, -28 },
  { 2097, 21, 28, 18, 0, -28 },
  { 2171, 12, 28, 15, 0, -28 },
  { 2213, 28, 28, 28, 0, -28 },
  { 2311, 23, 28, 22, 0, -28 },
  { 2392, 19, 28, 22, 2, -28 },
  { 2459, 18, 28, 18, 0, -28 },
  { 2522, 19, 35, 22, 2, -28 },
  { 2606, 18, 28, 18, 0, -28 },
  { 2669, 17, 28, 16, 0, -28 },
  { 2729, 15, 28, 15, 3, -28 },
  { 2782, 20, 28, 21, 2, -28 },
  { 2852, 18, 28, 17, 3, -28 },
  { 2915, 27, 28, 28, 4, -28 },
  { 3010, 21, 28, 16, -2, -28 },
  { 3084, 16, 28, 16, 3, -28 },
  { 3140, 19, 28, 15, -1, -28 },
  { 3207, 15, 34, 11, -1, -28 },
  { 3271, 7, 28, 13, 4, -28 },
  { 3296, 15, 34, 11, -3, -28 },
  { 3360, 16, 16, 18, 1, -28 },
  { 3392, 13, 3, 13, -3, 3 },
  { 3397, 5, 6, 10, 6, -30 },
  { 3401, 17, 21, 18, 1, -21 },
  { 3446, 17, 30, 18, 0, -30 },
  { 3510, 14, 21, 14, 1, -21 },
  { 3547, 19, 30, 18, 1, -30 },
  { 3619, 14, 21, 16, 1, -21 },
  { 3656, 20, 39, 10, -5, -30 },
  { 3754, 18, 30, 18, 0, -21 },
  { 3822, 17, 30, 18, 0, -30 },
  { 3886, 9, 29, 8, 0, -29 },
  { 3919, 14, 38, 8, -5, -29 },
  { 3986, 17, 30, 16, 0, -30 },
  { 4050, 10, 30, 8, 0, -30 },
  { 4088, 26, 21, 27, 0, -21 },
  { 4157, 17, 21, 18, 0, -21 },
  { 4202, 15, 21, 18, 1, -21 },
  { 4242, 19, 30, 18, -2, -21 },
  { 4314, 17, 30, 18, 1, -21 },
  { 4378, 14, 21, 12, 0, -21 },
  { 4415, 14, 21, 14, 0, -21 },
  { 4452, 11, 26, 10, 1, -26 },
  { 4488, 17, 21, 18, 1, -21 },
  { 4533, 15, 21, 15, 2, -21 },
  { 4573, 23, 21, 23, 2, -21 },
  { 4634, 18, 21, 15, -2, -21 },
  { 4682, 21, 30, 15, -4, -21 },
  { 4761, 15, 21, 13, -1, -21 },
  { 4801, 14, 34, 13, 1, -28 },
  { 4861, 3, 39, 16, 7, -30 },
  { 4876, 14, 34, 13, -2, -28 },
  { 4936, 16, 5, 18, 2, -16 },
};

const GFXfont NotoSans_Condensed_Italic39pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Italic39pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Italic39pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _NOTOSANS_CONDENSED_ITALIC39PT7B_H_
