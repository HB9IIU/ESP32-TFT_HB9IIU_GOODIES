#ifndef _NOTOSANS_CONDENSED_ITALIC48PT7B_H_
#define _NOTOSANS_CONDENSED_ITALIC48PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Italic.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Italic48pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x0E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x00, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1E, 0x00,
  0x3C, 0x7D, 0xF1, 0xE7, 0x87, 0x9E, 0x1E, 0x78, 0x71, 0xE3, 0xC7, 0x0F,
  0x1C, 0x3C, 0xF0, 0xE3, 0x83, 0x8E, 0x0E, 0x38, 0x70, 0x00, 0x0E, 0x0E,
  0x00, 0x1E, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x1C,
  0x00, 0x38, 0x38, 0x00, 0x38, 0x38, 0x00, 0x38, 0x38, 0x00, 0x70, 0x70,
  0x00, 0x70, 0x70, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0x00, 0xE0, 0xE0, 0x01, 0xE0, 0xE0, 0x01, 0xC1, 0xC0, 0x01, 0xC1, 0xC0,
  0x01, 0xC1, 0xC0, 0x03, 0x83, 0x80, 0x03, 0x83, 0x80, 0x03, 0x83, 0x80,
  0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x0E, 0x07, 0x00,
  0x0E, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x1E, 0x0E, 0x00, 0x1C, 0x1C, 0x00,
  0x1C, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x38, 0x38, 0x00,
  0x38, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0xE0, 0x7D, 0xC6,
  0x07, 0x8C, 0x10, 0x3C, 0x60, 0x01, 0xC3, 0x00, 0x0E, 0x38, 0x00, 0x71,
  0xC0, 0x03, 0x8C, 0x00, 0x1E, 0x60, 0x00, 0xFB, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x3B,
  0xC0, 0x01, 0x9F, 0x00, 0x0C, 0x78, 0x00, 0x63, 0xC0, 0x07, 0x1E, 0x00,
  0x38, 0xF0, 0x01, 0x87, 0x84, 0x0C, 0x78, 0x30, 0x67, 0xC1, 0xFF, 0xFC,
  0x1F, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0x60, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0xF0, 0x3F, 0xC0, 0x1C, 0x0F, 0x38, 0x07, 0x03,
  0xC7, 0x00, 0xE0, 0x70, 0xE0, 0x38, 0x1E, 0x1E, 0x0F, 0x03, 0x83, 0x81,
  0xC0, 0x70, 0x70, 0x78, 0x0E, 0x0E, 0x0E, 0x03, 0xC1, 0xC3, 0x80, 0x70,
  0x38, 0x70, 0x0E, 0x0F, 0x1C, 0x01, 0xC1, 0xC7, 0x80, 0x38, 0x38, 0xE3,
  0xE7, 0x07, 0x38, 0xFE, 0xE1, 0xC7, 0x3F, 0xFC, 0x39, 0xCF, 0x1F, 0xCE,
  0x79, 0xC3, 0xFF, 0xCE, 0x78, 0x77, 0xF3, 0xCE, 0x0E, 0x38, 0x71, 0xC1,
  0xC0, 0x1C, 0x78, 0x38, 0x07, 0x8E, 0x07, 0x00, 0xE1, 0xC1, 0xE0, 0x3C,
  0x38, 0x38, 0x07, 0x07, 0x07, 0x01, 0xC1, 0xE0, 0xE0, 0x38, 0x3C, 0x3C,
  0x0E, 0x07, 0x87, 0x03, 0xC0, 0xF0, 0xE0, 0x70, 0x0E, 0x38, 0x1C, 0x01,
  0xFF, 0x03, 0x80, 0x3F, 0xC0, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x7F, 0x80, 0x01, 0xFF, 0x80, 0x07, 0xCF, 0x00, 0x0F, 0x0F, 0x00,
  0x3C, 0x1E, 0x00, 0x78, 0x3C, 0x00, 0xE0, 0x78, 0x01, 0xC0, 0xE0, 0x03,
  0x83, 0xC0, 0x07, 0x07, 0x80, 0x0F, 0x1E, 0x00, 0x1E, 0x78, 0x00, 0x3D,
  0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x7D, 0xE0, 0xF1, 0xE3, 0xC1, 0xE7, 0xC3, 0xC7,
  0x8F, 0x07, 0x8F, 0x3C, 0x0F, 0x9C, 0x78, 0x0F, 0x78, 0xE0, 0x1F, 0xE3,
  0xC0, 0x1F, 0xC7, 0x80, 0x3F, 0x0F, 0x00, 0x3C, 0x1E, 0x00, 0xF8, 0x3E,
  0x03, 0xF8, 0x3E, 0x1F, 0xF0, 0x7F, 0xFD, 0xF0, 0x7F, 0xF1, 0xE0, 0x7F,
  0x83, 0xE0, 0x3C, 0xF7, 0x9E, 0x79, 0xE7, 0x1C, 0x73, 0xCE, 0x38, 0x00,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0xF0,
  0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F,
  0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x00, 0x00, 0x80, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x04, 0x1C, 0x03,
  0x0E, 0x03, 0xE7, 0x01, 0xFF, 0x9E, 0x3F, 0xFF, 0x01, 0xFF, 0x81, 0xF0,
  0x21, 0xFC, 0x01, 0xEE, 0x01, 0xE7, 0x81, 0xE1, 0xC0, 0x70, 0xF0, 0x10,
  0x78, 0x00, 0x18, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x0F,
  0x87, 0x87, 0xC3, 0xC1, 0xE1, 0xE0, 0xF0, 0xF0, 0x78, 0x38, 0x38, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x33, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x1F,
  0xE0, 0x07, 0xFE, 0x01, 0xFF, 0xE0, 0x7C, 0x3C, 0x0F, 0x07, 0x83, 0xC0,
  0x78, 0x78, 0x0F, 0x1E, 0x01, 0xE3, 0xC0, 0x3C, 0xF0, 0x07, 0x9E, 0x00,
  0xF3, 0xC0, 0x1E, 0xF0, 0x03, 0xDE, 0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x03,
  0xDF, 0x00, 0x7B, 0xC0, 0x0F, 0x78, 0x01, 0xEF, 0x00, 0x79, 0xE0, 0x0F,
  0x3C, 0x01, 0xE7, 0x80, 0x3C, 0xE0, 0x0F, 0x1C, 0x01, 0xE3, 0x80, 0x7C,
  0x70, 0x0F, 0x0E, 0x01, 0xE1, 0xE0, 0x78, 0x3C, 0x1E, 0x07, 0xC7, 0xC0,
  0x7F, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xF0, 0x1F, 0x07,
  0xF0, 0xFF, 0x1F, 0xE3, 0xFE, 0xF9, 0xEF, 0x1E, 0x63, 0xC4, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0x00,
  0x0F, 0x80, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x7F, 0xFE, 0x01, 0xE0,
  0xF8, 0x02, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x38,
  0x1F, 0x00, 0x80, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC2, 0x00, 0x7C, 0x1C, 0x07, 0xC0,
  0xFF, 0xFE, 0x07, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x77, 0x00, 0x03, 0x9C, 0x00, 0x1E, 0xF0, 0x00, 0x73, 0xC0,
  0x03, 0x8F, 0x00, 0x1E, 0x38, 0x00, 0x71, 0xE0, 0x03, 0x87, 0x80, 0x1E,
  0x1E, 0x00, 0xF0, 0x78, 0x03, 0x81, 0xC0, 0x1E, 0x0F, 0x00, 0xF0, 0x3C,
  0x03, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x03, 0x80, 0x78, 0x1F,
  0xFF, 0xFE, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xC8, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0,
  0x7F, 0xFE, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF0,
  0x06, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x40, 0x0F,
  0x83, 0x80, 0xFC, 0x1F, 0xFF, 0xC0, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC1, 0x00, 0x39,
  0xFE, 0x07, 0xBF, 0xF0, 0x7F, 0xFF, 0x07, 0xE0, 0xF8, 0x7C, 0x07, 0x8F,
  0x80, 0x78, 0xF8, 0x07, 0x8F, 0x00, 0x78, 0xF0, 0x07, 0x8F, 0x00, 0x78,
  0xF0, 0x07, 0x8F, 0x00, 0x78, 0xF0, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x0F,
  0x0F, 0x01, 0xE0, 0xF0, 0x3E, 0x07, 0x87, 0xC0, 0x7F, 0xF8, 0x03, 0xFF,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0x87, 0xFF, 0xFC,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x03, 0xFF, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xF0, 0x3E, 0x0F, 0x81,
  0xE0, 0x3C, 0x0E, 0x01, 0xE0, 0xF0, 0x0F, 0x07, 0x80, 0x78, 0x3C, 0x03,
  0xC1, 0xE0, 0x1E, 0x0F, 0x01, 0xE0, 0x3C, 0x1F, 0x01, 0xE1, 0xF0, 0x07,
  0x9F, 0x00, 0x3F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xC0,
  0x1F, 0xBE, 0x01, 0xF0, 0xF8, 0x1F, 0x03, 0xE0, 0xF0, 0x0F, 0x0F, 0x00,
  0x78, 0x78, 0x03, 0xC3, 0xC0, 0x1E, 0x3C, 0x00, 0xF1, 0xE0, 0x07, 0x8F,
  0x00, 0x3C, 0x3C, 0x01, 0xE1, 0xE0, 0x1E, 0x0F, 0x81, 0xF0, 0x3F, 0xFF,
  0x00, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0xF8, 0x01,
  0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xC3, 0xE0, 0xF8, 0x1E, 0x0F, 0x01, 0xE1,
  0xE0, 0x0E, 0x1E, 0x00, 0xE1, 0xE0, 0x0F, 0x1C, 0x00, 0xE3, 0xC0, 0x1E,
  0x3C, 0x01, 0xE3, 0xC0, 0x1E, 0x3C, 0x01, 0xE3, 0xC0, 0x3E, 0x3C, 0x03,
  0xE3, 0xE0, 0x7E, 0x1F, 0x1F, 0xC1, 0xFF, 0xFC, 0x0F, 0xFB, 0xC0, 0x7E,
  0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x08,
  0x1F, 0x00, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x03, 0x81,
  0xF0, 0x7C, 0x1F, 0x07, 0x81, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10,
  0x1E, 0x07, 0xC3, 0xF0, 0xF8, 0x1E, 0x00, 0x00, 0xE0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x03,
  0x80, 0x78, 0x07, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x0F,
  0x00, 0x03, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x0F,
  0x80, 0x00, 0xE0, 0x00, 0x08, 0x00, 0x00, 0x01, 0xE0, 0x0F, 0xF8, 0x3F,
  0xFC, 0x1F, 0xFE, 0x18, 0x1E, 0x10, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x0F, 0xE3, 0xF0, 0x01, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0x38, 0x0E, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x07, 0x0F, 0x00,
  0x00, 0x38, 0x70, 0x1F, 0xC1, 0xC7, 0x01, 0xFF, 0x0E, 0x38, 0x1F, 0xF8,
  0x73, 0x81, 0xC3, 0x83, 0x9C, 0x1C, 0x1C, 0x1D, 0xC1, 0xE0, 0xE0, 0xEE,
  0x0E, 0x0F, 0x07, 0x70, 0xF0, 0x70, 0x3F, 0x87, 0x03, 0x83, 0xB8, 0x38,
  0x1C, 0x1D, 0xC1, 0xC1, 0xE0, 0xEE, 0x1C, 0x0E, 0x07, 0x70, 0xE0, 0x70,
  0x73, 0x87, 0x07, 0x83, 0x9C, 0x38, 0x3C, 0x38, 0xE1, 0xC3, 0xE1, 0xC7,
  0x0F, 0x3F, 0x1C, 0x38, 0x3F, 0x9F, 0xC1, 0xC1, 0xF8, 0xFC, 0x0E, 0x03,
  0x81, 0x80, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x18, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x1D, 0xE0, 0x00, 0xF7, 0x80, 0x03, 0xDE, 0x00, 0x0E, 0x78,
  0x00, 0x79, 0xE0, 0x01, 0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x3C, 0x78, 0x01,
  0xE1, 0xE0, 0x07, 0x87, 0x80, 0x3C, 0x1E, 0x00, 0xF0, 0x78, 0x07, 0x81,
  0xE0, 0x1E, 0x07, 0x80, 0x78, 0x1E, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0,
  0x7F, 0xFF, 0x81, 0xE0, 0x1E, 0x0F, 0x80, 0x78, 0x3C, 0x01, 0xE1, 0xF0,
  0x07, 0x87, 0x80, 0x0F, 0x3E, 0x00, 0x3C, 0xF0, 0x00, 0xF3, 0xC0, 0x03,
  0xDE, 0x00, 0x0F, 0x78, 0x00, 0x3F, 0xE0, 0x00, 0xF0, 0x01, 0xFF, 0xC0,
  0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0xF0, 0x7F, 0x03, 0xC0, 0x7C, 0x0F,
  0x00, 0xF0, 0x78, 0x03, 0xC1, 0xE0, 0x0F, 0x07, 0x80, 0x3C, 0x1E, 0x00,
  0xF0, 0x78, 0x07, 0xC3, 0xC0, 0x1E, 0x0F, 0x00, 0xF8, 0x3C, 0x07, 0xC0,
  0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0x78, 0x3C, 0x01, 0xE0, 0xF0, 0x07, 0xC3, 0xC0, 0x1F,
  0x0F, 0x00, 0x7C, 0x3C, 0x01, 0xE1, 0xE0, 0x07, 0x87, 0x80, 0x1E, 0x1E,
  0x00, 0xF8, 0x78, 0x07, 0xC1, 0xE0, 0x3F, 0x0F, 0x07, 0xF8, 0x3F, 0xFF,
  0xC0, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x3F,
  0xF8, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0x81, 0x80, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x83, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1E, 0x1F, 0xC0,
  0x3C, 0x07, 0xC0, 0x78, 0x07, 0x81, 0xE0, 0x0F, 0x83, 0xC0, 0x0F, 0x07,
  0x80, 0x1E, 0x0F, 0x00, 0x3C, 0x1E, 0x00, 0x78, 0x78, 0x00, 0xF0, 0xF0,
  0x01, 0xE1, 0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x8F, 0x00, 0x0F, 0x1E, 0x00,
  0x1E, 0x3C, 0x00, 0x7C, 0x78, 0x00, 0xF0, 0xF0, 0x01, 0xE3, 0xC0, 0x03,
  0xC7, 0x80, 0x0F, 0x8F, 0x00, 0x1E, 0x1E, 0x00, 0x7C, 0x3C, 0x00, 0xF0,
  0xF0, 0x03, 0xE1, 0xE0, 0x0F, 0x83, 0xC0, 0x3F, 0x07, 0x80, 0xFC, 0x0F,
  0x03, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0xFF, 0xF8, 0x01, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF,
  0xF8, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xFF, 0xF0, 0x1F,
  0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x1F,
  0xFF, 0x80, 0xFF, 0xFC, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0xFF, 0x80, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xE0, 0x1F, 0x80, 0xF0, 0x1F, 0x80, 0x10, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x03, 0xFE, 0x1E, 0x01,
  0xFF, 0x1F, 0x00, 0xFF, 0x8F, 0x80, 0x03, 0xC7, 0x80, 0x03, 0xC3, 0xC0,
  0x01, 0xE1, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x3C, 0x3E,
  0x00, 0x3C, 0x0F, 0x00, 0x1E, 0x07, 0x80, 0x0F, 0x03, 0xE0, 0x07, 0x81,
  0xF8, 0x03, 0x80, 0x7E, 0x07, 0xC0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0,
  0x01, 0xFF, 0xE0, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0xF0, 0x01, 0xE0, 0x3C,
  0x00, 0x78, 0x0F, 0x00, 0x1E, 0x03, 0xC0, 0x07, 0x80, 0xF0, 0x01, 0xE0,
  0x78, 0x00, 0xF0, 0x1E, 0x00, 0x3C, 0x07, 0x80, 0x0F, 0x01, 0xE0, 0x03,
  0xC0, 0x78, 0x00, 0xF0, 0x3C, 0x00, 0x78, 0x0F, 0x00, 0x1E, 0x03, 0xC0,
  0x07, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x01, 0xE0, 0x03, 0xC0, 0x78, 0x00, 0xF0, 0x3C, 0x00, 0x78,
  0x0F, 0x00, 0x1E, 0x03, 0xC0, 0x07, 0x80, 0xF0, 0x01, 0xE0, 0x3C, 0x00,
  0x78, 0x1E, 0x00, 0x3C, 0x07, 0x80, 0x0F, 0x01, 0xE0, 0x03, 0xC0, 0x78,
  0x00, 0xF0, 0x1E, 0x00, 0x3C, 0x0F, 0x00, 0x1E, 0x03, 0xC0, 0x07, 0x80,
  0xF0, 0x01, 0xE0, 0x3C, 0x00, 0x78, 0x00, 0x01, 0xFF, 0xE0, 0x3F, 0xF8,
  0x01, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xFF, 0x00, 0xFF,
  0xF0, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0,
  0x06, 0x7E, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xE0, 0x0F, 0x81, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x0F, 0x80,
  0x3C, 0x0F, 0x80, 0x1E, 0x07, 0x80, 0x1E, 0x07, 0x80, 0x0F, 0x07, 0xC0,
  0x07, 0x87, 0xC0, 0x03, 0xC3, 0xC0, 0x01, 0xE3, 0xC0, 0x01, 0xE3, 0xE0,
  0x00, 0xF3, 0xE0, 0x00, 0x7B, 0xE0, 0x00, 0x3D, 0xE0, 0x00, 0x3D, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xE7,
  0x80, 0x03, 0xE3, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x78,
  0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x0F, 0x80, 0x1E, 0x03, 0xC0, 0x0F,
  0x01, 0xE0, 0x07, 0x80, 0xF0, 0x03, 0xC0, 0x7C, 0x03, 0xC0, 0x1E, 0x01,
  0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xE0, 0x00, 0x01, 0xE0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF0,
  0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x03, 0xF8, 0x0F,
  0xE0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x1F, 0xC0,
  0x7F, 0x80, 0x0F, 0xF0, 0x1F, 0xE0, 0x03, 0xFC, 0x07, 0xF8, 0x01, 0xEF,
  0x01, 0xDE, 0x00, 0x7B, 0xC0, 0x73, 0x80, 0x3D, 0xE0, 0x3C, 0xE0, 0x0F,
  0x78, 0x0F, 0x38, 0x07, 0x9E, 0x03, 0xCE, 0x01, 0xE7, 0x80, 0xE3, 0x80,
  0x71, 0xE0, 0x78, 0xE0, 0x3C, 0xF0, 0x1E, 0x38, 0x0E, 0x3C, 0x07, 0x8E,
  0x07, 0x8F, 0x01, 0xE3, 0xC1, 0xC3, 0xC0, 0x70, 0xF0, 0xF1, 0xE0, 0x3C,
  0x3C, 0x38, 0x78, 0x0F, 0x0F, 0x1E, 0x1E, 0x03, 0xC3, 0xC7, 0x07, 0x80,
  0xF0, 0xF3, 0xC1, 0xE0, 0x38, 0x3C, 0xE0, 0xF0, 0x1E, 0x0F, 0x78, 0x3C,
  0x07, 0x81, 0xDC, 0x0F, 0x01, 0xE0, 0x7F, 0x03, 0xC0, 0x70, 0x1F, 0x80,
  0xF0, 0x1C, 0x07, 0xE0, 0x78, 0x0F, 0x01, 0xF8, 0x1E, 0x03, 0xC0, 0x7C,
  0x07, 0x80, 0xF0, 0x1F, 0x01, 0xE0, 0x38, 0x07, 0x80, 0xF8, 0x00, 0x01,
  0xF0, 0x01, 0xE0, 0x7E, 0x00, 0x3C, 0x0F, 0xC0, 0x07, 0x81, 0xF8, 0x00,
  0xE0, 0x3F, 0x00, 0x3C, 0x07, 0xF0, 0x07, 0x81, 0xFE, 0x00, 0xF0, 0x3F,
  0xC0, 0x1E, 0x07, 0xB8, 0x03, 0x80, 0xE7, 0x80, 0xF0, 0x1C, 0xF0, 0x1E,
  0x07, 0x9E, 0x03, 0xC0, 0xF1, 0xC0, 0x78, 0x1E, 0x3C, 0x0E, 0x03, 0x87,
  0x83, 0xC0, 0xF0, 0xF0, 0x78, 0x1E, 0x0E, 0x0F, 0x03, 0xC1, 0xC1, 0xE0,
  0x78, 0x3C, 0x78, 0x0E, 0x07, 0x8F, 0x03, 0xC0, 0xF1, 0xE0, 0x78, 0x0E,
  0x3C, 0x0F, 0x01, 0xE7, 0x01, 0xE0, 0x3D, 0xE0, 0x38, 0x07, 0xBC, 0x0F,
  0x00, 0x77, 0x81, 0xE0, 0x0E, 0xF0, 0x3C, 0x01, 0xFC, 0x07, 0x80, 0x3F,
  0x80, 0xE0, 0x07, 0xF0, 0x3C, 0x00, 0x7E, 0x07, 0x80, 0x0F, 0xC0, 0xF0,
  0x01, 0xF0, 0x1E, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFC, 0x01, 0xF0, 0x7E, 0x03, 0xE0, 0x1E,
  0x07, 0xC0, 0x1F, 0x0F, 0x80, 0x0F, 0x0F, 0x00, 0x0F, 0x1F, 0x00, 0x0F,
  0x1E, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x3E, 0x00, 0x0F, 0x3C, 0x00, 0x0F,
  0x3C, 0x00, 0x0F, 0x7C, 0x00, 0x0F, 0x78, 0x00, 0x1F, 0x78, 0x00, 0x1F,
  0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x3E,
  0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x78,
  0xF0, 0x00, 0xF8, 0xF8, 0x00, 0xF0, 0x78, 0x01, 0xF0, 0x78, 0x03, 0xE0,
  0x7C, 0x07, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x07,
  0x87, 0xE0, 0x3C, 0x0F, 0x81, 0xE0, 0x3C, 0x1E, 0x01, 0xE0, 0xF0, 0x0F,
  0x07, 0x80, 0x78, 0x3C, 0x03, 0xC1, 0xE0, 0x1E, 0x1E, 0x00, 0xF0, 0xF0,
  0x0F, 0x87, 0x80, 0x78, 0x3C, 0x07, 0xC3, 0xC0, 0x7C, 0x1E, 0x0F, 0xE0,
  0xFF, 0xFE, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFC, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFC, 0x01, 0xF0, 0x7E,
  0x03, 0xE0, 0x1E, 0x07, 0xC0, 0x1F, 0x0F, 0x80, 0x0F, 0x0F, 0x00, 0x0F,
  0x1F, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x3E, 0x00, 0x0F,
  0x3C, 0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x7C, 0x00, 0x0F, 0x78, 0x00, 0x0F,
  0x78, 0x00, 0x1F, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0xF8, 0x00, 0x1E,
  0xF8, 0x00, 0x3E, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x7C,
  0xF0, 0x00, 0x78, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0xF0, 0x78, 0x01, 0xF0,
  0x78, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0xFF, 0x80,
  0x1F, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0x00,
  0xFF, 0xFC, 0x07, 0x87, 0xF0, 0x3C, 0x0F, 0x81, 0xE0, 0x3C, 0x1E, 0x01,
  0xE0, 0xF0, 0x0F, 0x07, 0x80, 0x78, 0x3C, 0x03, 0xC1, 0xE0, 0x1E, 0x1E,
  0x00, 0xF0, 0xF0, 0x0F, 0x87, 0x80, 0x78, 0x3C, 0x07, 0xC3, 0xC0, 0xFC,
  0x1F, 0xFF, 0xC0, 0xFF, 0xFC, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xC3,
  0xC0, 0x1E, 0x0F, 0x00, 0xF0, 0x78, 0x07, 0x83, 0xC0, 0x3C, 0x1E, 0x03,
  0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x3C, 0x07,
  0xC3, 0xC0, 0x1E, 0x1E, 0x00, 0xF0, 0xF0, 0x07, 0x87, 0x80, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x03, 0xFF, 0x80, 0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0x3E,
  0x07, 0x03, 0xE0, 0x08, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x82, 0x00, 0x7C, 0x1E, 0x1F, 0xC0,
  0xFF, 0xFE, 0x07, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x0F, 0x83, 0xC0, 0x07, 0x81,
  0xE0, 0x03, 0xC0, 0xF0, 0x01, 0xE0, 0x78, 0x00, 0xF0, 0x78, 0x00, 0xF0,
  0x3C, 0x00, 0x78, 0x1E, 0x00, 0x3C, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x0F,
  0x07, 0x80, 0x0F, 0x03, 0xC0, 0x07, 0x81, 0xE0, 0x03, 0xC0, 0xF0, 0x01,
  0xE0, 0xF0, 0x01, 0xE0, 0x78, 0x00, 0xF0, 0x3C, 0x00, 0x78, 0x1E, 0x00,
  0x3C, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x07, 0x80, 0x0F, 0x03, 0xC0,
  0x07, 0x81, 0xE0, 0x03, 0xC0, 0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0x78,
  0x00, 0xF0, 0x3C, 0x00, 0x78, 0x1E, 0x00, 0x78, 0x0F, 0x80, 0x3C, 0x03,
  0xC0, 0x3C, 0x01, 0xF8, 0x7E, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xEF, 0x00, 0x0F,
  0x3C, 0x00, 0x3C, 0xF0, 0x01, 0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x3E, 0x1C,
  0x00, 0xF0, 0x70, 0x07, 0xC1, 0xC0, 0x1E, 0x07, 0x00, 0x78, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x78, 0x07, 0x81, 0xE0, 0x1E, 0x0F, 0x00,
  0x78, 0x3C, 0x01, 0xE1, 0xE0, 0x07, 0x87, 0x80, 0x1E, 0x1E, 0x00, 0x78,
  0xF0, 0x01, 0xE3, 0xC0, 0x07, 0x9E, 0x00, 0x1E, 0x78, 0x00, 0x7B, 0xC0,
  0x01, 0xEF, 0x00, 0x07, 0xB8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xFC, 0x00, 0x78, 0x01, 0xEF, 0x00,
  0x3E, 0x00, 0x7B, 0xC0, 0x0F, 0x80, 0x3E, 0xF0, 0x07, 0xE0, 0x0F, 0x3C,
  0x01, 0xF8, 0x03, 0xCF, 0x00, 0x7E, 0x01, 0xE3, 0xC0, 0x3F, 0x80, 0x78,
  0xF0, 0x0E, 0xE0, 0x3E, 0x3C, 0x07, 0xB8, 0x0F, 0x0F, 0x01, 0xCE, 0x03,
  0xC3, 0xC0, 0x73, 0x81, 0xE0, 0xF0, 0x3C, 0xE0, 0x78, 0x3C, 0x0E, 0x38,
  0x3C, 0x0F, 0x07, 0x8E, 0x0F, 0x03, 0xC1, 0xC3, 0x83, 0xC0, 0xF0, 0xF0,
  0xE1, 0xE0, 0x3C, 0x3C, 0x38, 0x78, 0x0F, 0x0E, 0x0E, 0x3C, 0x03, 0xC7,
  0x83, 0x8F, 0x00, 0xF1, 0xC0, 0xE3, 0xC0, 0x3C, 0xF0, 0x39, 0xE0, 0x0F,
  0x3C, 0x0E, 0x78, 0x03, 0xCE, 0x03, 0x9C, 0x00, 0xF7, 0x80, 0xEF, 0x00,
  0x3D, 0xC0, 0x3B, 0xC0, 0x0F, 0xF0, 0x0F, 0xE0, 0x03, 0xF8, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x0F, 0xC0, 0x0F,
  0x80, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0x00, 0xF8, 0x01, 0xE0,
  0x1E, 0x00, 0x3C, 0x07, 0x80, 0x07, 0x81, 0xF0, 0x00, 0xF0, 0x3C, 0x00,
  0x0F, 0x0F, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x3C, 0x78, 0x00, 0x07, 0x9F,
  0x00, 0x00, 0x73, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x0F, 0x1E, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x78, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0xC1,
  0xE0, 0x00, 0xF0, 0x1E, 0x00, 0x3C, 0x03, 0xC0, 0x0F, 0x80, 0x78, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x1F, 0x00, 0x3E, 0x00, 0xF0, 0x01,
  0xFF, 0x00, 0x3E, 0x78, 0x03, 0xC7, 0x80, 0x78, 0x78, 0x07, 0x87, 0x80,
  0xF0, 0x78, 0x1F, 0x07, 0x81, 0xE0, 0x38, 0x3E, 0x03, 0x83, 0xC0, 0x3C,
  0x78, 0x03, 0xC7, 0x80, 0x3C, 0xF0, 0x03, 0xCF, 0x00, 0x3D, 0xE0, 0x01,
  0xDC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x7F,
  0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xFF, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x00, 0xF0, 0xF0, 0xF0, 0xF0, 0x70, 0x70, 0x70, 0x78,
  0x78, 0x78, 0x78, 0x78, 0x38, 0x38, 0x38, 0x3C, 0x3C, 0x3C, 0x3C, 0x1C,
  0x1C, 0x1C, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x0E, 0x0E, 0x0E, 0x0F, 0x0F,
  0x0F, 0x0F, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00,
  0xFE, 0x00, 0x1E, 0xE0, 0x01, 0xCF, 0x00, 0x3C, 0xF0, 0x03, 0x87, 0x00,
  0x78, 0x78, 0x07, 0x07, 0x80, 0xF0, 0x38, 0x0E, 0x03, 0xC1, 0xE0, 0x1C,
  0x3C, 0x01, 0xC3, 0xC0, 0x1E, 0x78, 0x00, 0xE7, 0x00, 0x0E, 0xF0, 0x00,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xF1, 0xE3, 0xC3, 0xC3,
  0x87, 0x87, 0x00, 0xF8, 0x70, 0x3F, 0xCF, 0x07, 0xFE, 0xF0, 0xFC, 0xEE,
  0x1F, 0x03, 0xE1, 0xE0, 0x3E, 0x3E, 0x03, 0xE3, 0xC0, 0x3E, 0x7C, 0x03,
  0xC7, 0x80, 0x3C, 0x78, 0x03, 0xCF, 0x80, 0x3C, 0xF0, 0x03, 0x8F, 0x00,
  0x78, 0xF0, 0x07, 0x8F, 0x00, 0x78, 0xF0, 0x07, 0x8F, 0x00, 0xF0, 0xF0,
  0x0F, 0x0F, 0x01, 0xF0, 0xF0, 0x1F, 0x0F, 0x03, 0xF0, 0xF8, 0x6E, 0x0F,
  0xFE, 0xE0, 0x7F, 0xCE, 0x03, 0xF1, 0xE0, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF1, 0xF0,
  0x07, 0x3F, 0xC0, 0x7B, 0xFF, 0x03, 0xFC, 0xF8, 0x1F, 0x83, 0xE0, 0xF8,
  0x0F, 0x07, 0xC0, 0x78, 0x7C, 0x03, 0xC3, 0xC0, 0x1E, 0x1E, 0x00, 0xF0,
  0xF0, 0x07, 0x8F, 0x00, 0x3C, 0x78, 0x03, 0xC3, 0xC0, 0x1E, 0x1E, 0x00,
  0xF0, 0xE0, 0x07, 0x8F, 0x00, 0x78, 0x78, 0x03, 0xC3, 0xC0, 0x1E, 0x1E,
  0x01, 0xE0, 0xF0, 0x1F, 0x0F, 0xC0, 0xF0, 0x7E, 0x0F, 0x83, 0xBF, 0xF8,
  0x1C, 0xFF, 0x81, 0xE3, 0xF0, 0x00, 0x00, 0xFE, 0x03, 0xFF, 0x07, 0xFF,
  0x0F, 0xC6, 0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF8, 0x30, 0x7F, 0xF0, 0x3F, 0xF0, 0x1F, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xF0, 0x03, 0xF1, 0xE0, 0x0F, 0xF3, 0xC0, 0x3F, 0xF7, 0x80,
  0xF8, 0x6E, 0x03, 0xE0, 0x7C, 0x07, 0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x3C,
  0x03, 0xC0, 0xF8, 0x07, 0x81, 0xE0, 0x0F, 0x03, 0xC0, 0x1E, 0x0F, 0x80,
  0x3C, 0x1E, 0x00, 0x70, 0x3C, 0x01, 0xE0, 0x78, 0x03, 0xC0, 0xF0, 0x07,
  0x81, 0xE0, 0x1F, 0x07, 0xC0, 0x3C, 0x0F, 0x00, 0x78, 0x1E, 0x01, 0xF0,
  0x1E, 0x07, 0xE0, 0x3C, 0x0F, 0xC0, 0x7C, 0x77, 0x00, 0xFF, 0xEE, 0x00,
  0xFF, 0x9C, 0x00, 0xFC, 0x78, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0xE0, 0x3F,
  0xF8, 0x1F, 0x1F, 0x0F, 0x83, 0xC3, 0xC0, 0xF1, 0xE0, 0x3C, 0x78, 0x0F,
  0x3C, 0x07, 0x8F, 0x01, 0xE3, 0x81, 0xF1, 0xFF, 0xF8, 0x7F, 0xFC, 0x1F,
  0xFC, 0x07, 0xE0, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x40, 0xFF, 0xF0,
  0x1F, 0xFC, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00,
  0x8E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x7E, 0x1C, 0x03,
  0xFC, 0xF0, 0x1F, 0xFB, 0xC0, 0xF8, 0xEE, 0x07, 0xC0, 0xF8, 0x1E, 0x03,
  0xE0, 0xF8, 0x0F, 0x83, 0xC0, 0x3E, 0x1F, 0x00, 0xF0, 0x78, 0x03, 0xC1,
  0xE0, 0x0F, 0x0F, 0x80, 0x3C, 0x3C, 0x00, 0xE0, 0xF0, 0x07, 0x83, 0xC0,
  0x1E, 0x0F, 0x00, 0x78, 0x3C, 0x03, 0xE1, 0xF0, 0x0F, 0x07, 0x80, 0x7C,
  0x1E, 0x01, 0xF0, 0x3C, 0x0F, 0xC0, 0xF0, 0x7F, 0x03, 0xE3, 0xB8, 0x0F,
  0xFF, 0xE0, 0x1F, 0xF7, 0x80, 0x3F, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x80, 0x3E, 0x03, 0x01, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x7F,
  0xE0, 0x00, 0x10, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xCF, 0xC0, 0x39, 0xFE, 0x07,
  0xBF, 0xF0, 0x7F, 0x9F, 0x07, 0xE0, 0xF0, 0x7C, 0x0F, 0x07, 0x80, 0xF0,
  0xF8, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0xF1, 0xE0, 0x1E,
  0x1E, 0x01, 0xE1, 0xE0, 0x1E, 0x1E, 0x01, 0xE1, 0xC0, 0x1E, 0x3C, 0x03,
  0xC3, 0xC0, 0x3C, 0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x38, 0x03, 0xC7, 0x80,
  0x78, 0x78, 0x07, 0x87, 0x80, 0x78, 0x78, 0x07, 0x8F, 0x00, 0xF0, 0x00,
  0xE0, 0x1F, 0x01, 0xF0, 0x1E, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x70, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x80, 0x78,
  0x07, 0x80, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1E, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x02,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x1E, 0x07, 0x01, 0xE0, 0x78, 0x1E,
  0x03, 0xC1, 0xF0, 0x1E, 0x1F, 0x00, 0xF0, 0xF0, 0x07, 0x0F, 0x00, 0x78,
  0xF0, 0x03, 0xCF, 0x00, 0x1E, 0xF8, 0x00, 0xE7, 0x80, 0x0F, 0x7C, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xF9, 0xE0, 0x0F, 0x8F,
  0x00, 0x78, 0x78, 0x03, 0xC3, 0xC0, 0x1E, 0x0F, 0x00, 0xE0, 0x78, 0x0F,
  0x03, 0xC0, 0x78, 0x1F, 0x03, 0xC0, 0x78, 0x1E, 0x03, 0xC1, 0xE0, 0x1E,
  0x00, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x78, 0x07, 0x80,
  0x78, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x07,
  0x80, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x00, 0x03, 0x8F, 0xC0, 0xF8, 0x07,
  0x3F, 0xC7, 0xF8, 0x1E, 0xFF, 0x9F, 0xF8, 0x3F, 0x8F, 0xF9, 0xF0, 0x7E,
  0x0F, 0xC1, 0xE0, 0xF8, 0x1F, 0x03, 0xC1, 0xE0, 0x3E, 0x07, 0x87, 0xC0,
  0x78, 0x0F, 0x0F, 0x00, 0xF0, 0x1E, 0x1E, 0x01, 0xC0, 0x3C, 0x3C, 0x07,
  0x80, 0x78, 0xF0, 0x0F, 0x00, 0xE1, 0xE0, 0x1E, 0x03, 0xC3, 0xC0, 0x3C,
  0x07, 0x87, 0x80, 0xF0, 0x0F, 0x0F, 0x01, 0xE0, 0x1E, 0x3C, 0x03, 0xC0,
  0x38, 0x78, 0x07, 0x80, 0xF0, 0xF0, 0x0E, 0x01, 0xE1, 0xE0, 0x3C, 0x03,
  0xC3, 0x80, 0x78, 0x07, 0x8F, 0x00, 0xF0, 0x1E, 0x1E, 0x01, 0xE0, 0x3C,
  0x3C, 0x03, 0x80, 0x78, 0x78, 0x0F, 0x00, 0xF1, 0xE0, 0x1E, 0x01, 0xC0,
  0x03, 0x8F, 0xC0, 0x39, 0xFE, 0x07, 0xBF, 0xF0, 0x7F, 0x9F, 0x07, 0xE0,
  0xF0, 0x7C, 0x0F, 0x0F, 0x80, 0xF0, 0xF8, 0x0F, 0x0F, 0x00, 0xF0, 0xF0,
  0x0F, 0x0F, 0x00, 0xF1, 0xE0, 0x1E, 0x1E, 0x01, 0xE1, 0xE0, 0x1E, 0x1E,
  0x01, 0xE1, 0xE0, 0x1E, 0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x3C, 0x03, 0xC3,
  0xC0, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x78, 0x78, 0x07, 0x87, 0x80, 0x78,
  0x78, 0x07, 0x8F, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xF8,
  0x3E, 0x3E, 0x1F, 0x07, 0xC7, 0x80, 0xF3, 0xC0, 0x3C, 0xF0, 0x0F, 0x78,
  0x03, 0xDE, 0x00, 0xF7, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x7F, 0xC0, 0x1E, 0xE0, 0x07, 0xB8, 0x01, 0xEE, 0x00, 0xF3,
  0xC0, 0x3C, 0xF0, 0x1E, 0x3C, 0x0F, 0x8F, 0x87, 0xC1, 0xFF, 0xE0, 0x3F,
  0xF0, 0x07, 0xF8, 0x00, 0x00, 0xE1, 0xF0, 0x01, 0xCF, 0xF0, 0x07, 0xBF,
  0xF0, 0x0F, 0xE1, 0xE0, 0x1F, 0x83, 0xE0, 0x3E, 0x03, 0xC0, 0x7C, 0x07,
  0x81, 0xF0, 0x0F, 0x03, 0xE0, 0x1E, 0x07, 0x80, 0x3C, 0x0F, 0x00, 0x78,
  0x3C, 0x00, 0xF0, 0x78, 0x03, 0xC0, 0xF0, 0x07, 0x81, 0xE0, 0x0F, 0x03,
  0x80, 0x1E, 0x0F, 0x00, 0x78, 0x1E, 0x00, 0xF0, 0x3C, 0x01, 0xE0, 0x78,
  0x07, 0x80, 0xF0, 0x1F, 0x03, 0xF0, 0x3C, 0x07, 0xE0, 0xF8, 0x0F, 0xFF,
  0xE0, 0x1E, 0xFF, 0x80, 0x38, 0xFE, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x38, 0x0F, 0xF3, 0xC0, 0xFF, 0xDE, 0x0F,
  0x8E, 0xE0, 0xF8, 0x1F, 0x07, 0x80, 0xF8, 0x78, 0x07, 0xC3, 0xC0, 0x3E,
  0x3E, 0x01, 0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0x78, 0xF8, 0x03, 0xC7, 0x80,
  0x1C, 0x3C, 0x01, 0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0x78, 0x78, 0x07, 0xC7,
  0x80, 0x3C, 0x3C, 0x01, 0xE1, 0xE0, 0x1F, 0x07, 0x81, 0xF8, 0x3C, 0x0F,
  0xC1, 0xF1, 0xDC, 0x0F, 0xFF, 0xE0, 0x3F, 0xEF, 0x00, 0xFC, 0x78, 0x00,
  0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x03, 0x8F, 0x81, 0xCF, 0xC1, 0xEF, 0xC0,
  0xFF, 0xE0, 0x76, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xFE, 0x03, 0xFF, 0xC3, 0xFF, 0xE1, 0xF0, 0xE1, 0xE0, 0x10,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC4, 0x03, 0xC3,
  0x03, 0xE1, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0xE0, 0x00, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x70, 0x07, 0x00, 0xF0, 0x1F, 0xF7, 0xFF, 0x7F, 0xF9, 0xE0,
  0x1E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x80,
  0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0E, 0x00, 0xF0, 0x0F, 0xF0, 0xFF, 0x07, 0xF0, 0x0F, 0x00, 0xF1,
  0xE0, 0x0E, 0x1E, 0x01, 0xE1, 0xE0, 0x1E, 0x1E, 0x01, 0xE1, 0xC0, 0x1E,
  0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x38, 0x03,
  0x87, 0x80, 0x78, 0x78, 0x07, 0x87, 0x80, 0x78, 0x78, 0x07, 0x8F, 0x00,
  0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x1F, 0x0F, 0x01, 0xF0, 0xF0,
  0x3E, 0x0F, 0x07, 0xE0, 0xF0, 0xFE, 0x0F, 0xFD, 0xE0, 0xFF, 0x9E, 0x07,
  0xF1, 0xC0, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x03, 0xDE, 0x01, 0xEF, 0x01,
  0xE7, 0x80, 0xF3, 0xC0, 0x79, 0xE0, 0x78, 0xF0, 0x3C, 0x78, 0x3C, 0x3C,
  0x1E, 0x1E, 0x1E, 0x0F, 0x0F, 0x07, 0x8F, 0x03, 0xC7, 0x81, 0xE7, 0x80,
  0xF3, 0xC0, 0x79, 0xC0, 0x1D, 0xE0, 0x0E, 0xE0, 0x07, 0xF0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x0F,
  0x00, 0xFF, 0x01, 0xF0, 0x1E, 0xF0, 0x1F, 0x01, 0xEF, 0x03, 0xF0, 0x1C,
  0xF0, 0x3F, 0x03, 0xCF, 0x07, 0xF0, 0x3C, 0xF0, 0x77, 0x07, 0x8F, 0x07,
  0x70, 0x78, 0xF0, 0xE7, 0x07, 0x0F, 0x0E, 0x70, 0xF0, 0xF1, 0xE7, 0x0F,
  0x0F, 0x1C, 0x71, 0xE0, 0xF1, 0xC7, 0x1E, 0x0F, 0x38, 0x71, 0xC0, 0xF3,
  0x87, 0x3C, 0x0F, 0x78, 0x73, 0x80, 0xE7, 0x07, 0x78, 0x0E, 0x70, 0x77,
  0x80, 0xEE, 0x07, 0x70, 0x0E, 0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xE0, 0x0F,
  0xC0, 0x7E, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0x80, 0xFC, 0x00, 0xF8, 0x0F,
  0xC0, 0x0F, 0x80, 0xF8, 0x00, 0x03, 0xC0, 0x3C, 0x0F, 0x01, 0xE0, 0x3C,
  0x0F, 0x80, 0x70, 0x3C, 0x01, 0xE1, 0xE0, 0x07, 0x8F, 0x80, 0x1E, 0x3C,
  0x00, 0x39, 0xE0, 0x00, 0xF7, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F,
  0x00, 0x03, 0xDC, 0x00, 0x0F, 0x78, 0x00, 0x79, 0xE0, 0x03, 0xC7, 0x80,
  0x0F, 0x0F, 0x00, 0x78, 0x3C, 0x03, 0xC0, 0xF0, 0x0F, 0x03, 0xC0, 0x78,
  0x07, 0x83, 0xE0, 0x1E, 0x00, 0x00, 0xF0, 0x07, 0xC0, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3C, 0x00, 0xF0, 0x0F, 0x00, 0x3C, 0x07,
  0x80, 0x0F, 0x01, 0xE0, 0x03, 0xC0, 0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x3C,
  0x1E, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xC3, 0xC0, 0x00, 0x70, 0xF0, 0x00,
  0x1C, 0x38, 0x00, 0x07, 0x1E, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x73, 0xC0,
  0x00, 0x1C, 0xE0, 0x00, 0x07, 0x78, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x24, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC1,
  0xFF, 0xF0, 0x7F, 0xF8, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x03, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x07,
  0xE0, 0x03, 0xF8, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0,
  0x01, 0xF8, 0x03, 0xF8, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x0F, 0xC0, 0x00, 0x20, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x78, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7F, 0x00, 0x07,
  0xC0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFC, 0x00, 0x30, 0x00, 0x00,
  0x1F, 0x00, 0x17, 0xFE, 0x03, 0xFF, 0xF8, 0xFF, 0x3F, 0xFF, 0xC0, 0x7F,
  0xE8, 0x01, 0xF8,
};

const GFXglyph NotoSans_Condensed_Italic48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 11, 34, 12, 1, -34 },
  { 48, 14, 12, 17, 5, -34 },
  { 69, 24, 34, 24, 0, -34 },
  { 171, 21, 39, 21, 0, -36 },
  { 274, 27, 35, 32, 3, -35 },
  { 393, 23, 35, 24, 0, -35 },
  { 494, 6, 12, 9, 5, -34 },
  { 503, 15, 42, 13, 1, -34 },
  { 582, 15, 42, 13, -4, -34 },
  { 661, 17, 18, 20, 5, -37 },
  { 700, 20, 22, 23, 2, -28 },
  { 755, 9, 11, 10, -2, -5 },
  { 768, 11, 4, 13, 1, -15 },
  { 774, 5, 6, 10, 1, -6 },
  { 778, 22, 34, 16, -2, -34 },
  { 872, 19, 35, 21, 2, -35 },
  { 956, 12, 34, 21, 6, -34 },
  { 1007, 22, 35, 21, -1, -35 },
  { 1104, 21, 35, 21, 0, -35 },
  { 1196, 22, 34, 21, -1, -34 },
  { 1290, 21, 34, 21, 0, -34 },
  { 1380, 20, 35, 21, 2, -35 },
  { 1468, 21, 34, 21, 2, -34 },
  { 1558, 21, 35, 21, 0, -35 },
  { 1650, 20, 35, 21, 1, -35 },
  { 1738, 10, 26, 11, 0, -26 },
  { 1771, 12, 32, 11, -2, -26 },
  { 1819, 20, 22, 23, 2, -28 },
  { 1874, 19, 14, 23, 2, -24 },
  { 1908, 20, 22, 23, 2, -28 },
  { 1963, 16, 35, 16, 2, -35 },
  { 2033, 29, 38, 32, 2, -34 },
  { 2171, 22, 34, 22, -3, -34 },
  { 2265, 22, 34, 23, 1, -34 },
  { 2359, 23, 35, 21, 2, -35 },
  { 2460, 23, 34, 25, 1, -34 },
  { 2558, 21, 34, 20, 1, -34 },
  { 2648, 21, 34, 18, 1, -34 },
  { 2738, 25, 35, 26, 2, -35 },
  { 2848, 26, 34, 26, 1, -34 },
  { 2959, 19, 34, 13, -2, -34 },
  { 3040, 19, 43, 11, -7, -34 },
  { 3143, 25, 34, 22, 1, -34 },
  { 3250, 14, 34, 18, 1, -34 },
  { 3310, 34, 34, 34, 1, -34 },
  { 3455, 27, 34, 27, 1, -34 },
  { 3570, 24, 35, 27, 2, -35 },
  { 3675, 21, 34, 22, 1, -34 },
  { 3765, 24, 43, 27, 2, -35 },
  { 3894, 21, 34, 22, 1, -34 },
  { 3984, 21, 35, 20, 0, -35 },
  { 4076, 19, 34, 19, 4, -34 },
  { 4157, 25, 34, 26, 2, -34 },
  { 4264, 22, 34, 22, 4, -34 },
  { 4358, 34, 34, 34, 4, -34 },
  { 4503, 27, 34, 20, -3, -34 },
  { 4618, 20, 34, 19, 4, -34 },
  { 4703, 24, 34, 19, -2, -34 },
  { 4805, 18, 42, 14, -1, -34 },
  { 4900, 8, 34, 17, 5, -34 },
  { 4934, 18, 42, 14, -3, -34 },
  { 5029, 20, 19, 22, 1, -34 },
  { 5077, 16, 3, 16, -4, 4 },
  { 5083, 7, 8, 12, 7, -37 },
  { 5090, 20, 26, 22, 2, -26 },
  { 5155, 21, 36, 22, 0, -36 },
  { 5250, 16, 26, 17, 2, -26 },
  { 5302, 23, 36, 23, 1, -36 },
  { 5406, 18, 26, 20, 1, -26 },
  { 5465, 24, 49, 12, -6, -37 },
  { 5612, 22, 38, 23, 0, -26 },
  { 5717, 20, 36, 22, 0, -36 },
  { 5807, 12, 35, 10, 0, -35 },
  { 5860, 18, 47, 10, -6, -35 },
  { 5966, 21, 36, 19, 0, -36 },
  { 6061, 12, 36, 10, 0, -36 },
  { 6115, 31, 26, 33, 0, -26 },
  { 6216, 20, 26, 22, 0, -26 },
  { 6281, 18, 26, 22, 2, -26 },
  { 6340, 23, 37, 22, -2, -26 },
  { 6447, 21, 37, 23, 1, -26 },
  { 6545, 17, 26, 15, 0, -26 },
  { 6601, 17, 26, 17, 0, -26 },
  { 6657, 12, 32, 13, 2, -32 },
  { 6705, 20, 26, 22, 2, -26 },
  { 6770, 17, 26, 18, 3, -26 },
  { 6826, 28, 26, 29, 3, -26 },
  { 6917, 22, 26, 19, -2, -26 },
  { 6989, 26, 38, 18, -5, -26 },
  { 7113, 18, 26, 16, -1, -26 },
  { 7172, 18, 42, 16, 1, -34 },
  { 7267, 3, 48, 20, 9, -37 },
  { 7285, 18, 42, 16, -3, -34 },
  { 7380, 20, 6, 23, 2, -20 },
};

const GFXfont NotoSans_Condensed_Italic48pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Italic48pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Italic48pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _NOTOSANS_CONDENSED_ITALIC48PT7B_H_
