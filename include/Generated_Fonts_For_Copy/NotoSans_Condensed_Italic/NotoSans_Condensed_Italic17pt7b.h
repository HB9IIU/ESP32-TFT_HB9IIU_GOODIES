#ifndef _NOTOSANS_CONDENSED_ITALIC17PT7B_H_
#define _NOTOSANS_CONDENSED_ITALIC17PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Italic.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Italic17pt7bBitmaps[] PROGMEM = {
  0x00, 0x13, 0x32, 0x22, 0x26, 0x40, 0xCC, 0xDC, 0xA5, 0x60, 0x09, 0x04,
  0x86, 0x8F, 0xF1, 0x20, 0xA0, 0x91, 0xFE, 0x2C, 0x24, 0x12, 0x0B, 0x00,
  0x04, 0x04, 0x3F, 0x28, 0x28, 0x28, 0x38, 0x1C, 0x14, 0x14, 0x94, 0xF8,
  0x20, 0x20, 0x71, 0x94, 0x4D, 0x22, 0x48, 0x94, 0x27, 0xFE, 0xA4, 0x49,
  0x14, 0x89, 0x22, 0x49, 0x1C, 0x1E, 0x12, 0x32, 0x34, 0x1C, 0x18, 0x79,
  0x4B, 0xCE, 0x86, 0xCE, 0x7A, 0xFA, 0x0C, 0x43, 0x08, 0x21, 0x04, 0x10,
  0x43, 0x0C, 0x10, 0x41, 0x06, 0x00, 0x10, 0xC2, 0x10, 0x84, 0x23, 0x10,
  0x8C, 0x46, 0x22, 0x00, 0x32, 0x8E, 0xCF, 0x52, 0x60, 0x10, 0x20, 0x47,
  0xFF, 0xE2, 0x04, 0x08, 0x2D, 0x60, 0xF0, 0xF0, 0x03, 0x02, 0x06, 0x04,
  0x0C, 0x08, 0x18, 0x10, 0x20, 0x20, 0x40, 0xC0, 0x3D, 0x94, 0x71, 0xC6,
  0x18, 0x63, 0x8A, 0x29, 0x3C, 0x37, 0xD3, 0x22, 0x26, 0x64, 0x4C, 0x3E,
  0x44, 0x08, 0x10, 0x60, 0x82, 0x0C, 0x30, 0xC3, 0x07, 0xE0, 0x3E, 0x44,
  0x08, 0x10, 0x67, 0x03, 0x02, 0x04, 0x0A, 0x37, 0xC0, 0x06, 0x0C, 0x28,
  0xF1, 0x44, 0x91, 0x26, 0xFE, 0x10, 0x20, 0xC0, 0x1F, 0x30, 0x20, 0x20,
  0x20, 0x7C, 0x04, 0x06, 0x04, 0x04, 0x8C, 0xF8, 0x1E, 0x61, 0x82, 0x0D,
  0x97, 0xB3, 0x46, 0x8D, 0x12, 0x67, 0x80, 0x7E, 0x0C, 0x10, 0x60, 0x83,
  0x04, 0x18, 0x20, 0xC1, 0x06, 0x00, 0x1E, 0x33, 0x23, 0x22, 0x36, 0x18,
  0x2C, 0x44, 0xC6, 0xC4, 0xCC, 0x78, 0x1E, 0x45, 0x8B, 0x14, 0x2C, 0xDF,
  0x8B, 0x04, 0x18, 0x67, 0x80, 0x32, 0x00, 0x00, 0x0C, 0xC0, 0x18, 0x80,
  0x00, 0x00, 0x04, 0x62, 0x30, 0x02, 0x18, 0xC6, 0x0C, 0x07, 0x03, 0x81,
  0xFE, 0x00, 0x07, 0xF0, 0x81, 0xC0, 0xE0, 0x70, 0xC6, 0x30, 0x40, 0xFC,
  0x42, 0x11, 0x11, 0x08, 0xC0, 0x21, 0x00, 0x0F, 0x8C, 0x22, 0x05, 0x3D,
  0xDA, 0x64, 0x9B, 0x26, 0x9A, 0xA4, 0xA6, 0xC8, 0x02, 0x00, 0x7C, 0x00,
  0x06, 0x06, 0x0E, 0x0A, 0x1A, 0x12, 0x32, 0x3E, 0x23, 0x63, 0x43, 0xC3,
  0x1E, 0x33, 0x31, 0x21, 0x23, 0x3C, 0x66, 0x62, 0x42, 0x46, 0x46, 0xF8,
  0x1F, 0x30, 0x60, 0x40, 0xC0, 0xC0, 0x80, 0x80, 0x80, 0x80, 0xC4, 0x78,
  0x1E, 0x19, 0x8C, 0x44, 0x32, 0x19, 0x09, 0x84, 0xC6, 0x43, 0x23, 0x13,
  0x1F, 0x00, 0x1F, 0x30, 0x30, 0x20, 0x20, 0x3C, 0x60, 0x60, 0x40, 0x40,
  0x40, 0xF8, 0x1F, 0x30, 0x30, 0x20, 0x20, 0x20, 0x7C, 0x60, 0x40, 0x40,
  0x40, 0xC0, 0x1F, 0x98, 0x98, 0x08, 0x0C, 0x06, 0x0A, 0x39, 0x04, 0x82,
  0x43, 0x31, 0x8F, 0x80, 0x10, 0xCC, 0x23, 0x08, 0x86, 0x21, 0x8F, 0xC6,
  0x11, 0x8C, 0x43, 0x10, 0x84, 0x23, 0x08, 0x1E, 0x10, 0x20, 0xC1, 0x82,
  0x04, 0x08, 0x30, 0x60, 0x87, 0x80, 0x02, 0x0C, 0x18, 0x20, 0x40, 0x83,
  0x06, 0x08, 0x10, 0x20, 0xC1, 0x82, 0x3C, 0x00, 0x11, 0x99, 0x8D, 0x84,
  0x82, 0xC1, 0xC1, 0xE0, 0xD0, 0x4C, 0x26, 0x11, 0x18, 0xC0, 0x11, 0x8C,
  0x42, 0x11, 0x8C, 0x42, 0x11, 0xF0, 0x18, 0x33, 0x87, 0x28, 0x72, 0x8E,
  0x28, 0xA2, 0x9A, 0x69, 0x64, 0xB6, 0x4A, 0x44, 0xA4, 0x4C, 0x4C, 0xCC,
  0x18, 0x4E, 0x32, 0x88, 0xA2, 0x28, 0x8B, 0x66, 0x59, 0x94, 0x45, 0x11,
  0xC4, 0x33, 0x0C, 0x1E, 0x33, 0x61, 0x41, 0xC1, 0xC1, 0x83, 0x83, 0x82,
  0x86, 0xCC, 0x78, 0x1E, 0x33, 0x33, 0x23, 0x23, 0x26, 0x7C, 0x60, 0x40,
  0x40, 0x40, 0xC0, 0x1E, 0x33, 0x61, 0x41, 0xC1, 0xC1, 0x83, 0x83, 0x82,
  0x86, 0xCC, 0x78, 0x18, 0x08, 0x0C, 0x1E, 0x33, 0x33, 0x23, 0x23, 0x26,
  0x7C, 0x68, 0x4C, 0x44, 0x44, 0xC6, 0x1F, 0x32, 0x60, 0x60, 0x20, 0x38,
  0x1C, 0x0C, 0x04, 0x0C, 0x8C, 0xF8, 0xFE, 0x20, 0x41, 0x83, 0x04, 0x08,
  0x10, 0x60, 0x81, 0x02, 0x00, 0x21, 0x61, 0x63, 0x43, 0x42, 0xC2, 0xC2,
  0x86, 0x86, 0x84, 0xCC, 0x78, 0xC3, 0x42, 0x46, 0x44, 0x4C, 0x48, 0x48,
  0x58, 0x50, 0x70, 0x60, 0x60, 0x84, 0x38, 0xC6, 0x8C, 0x49, 0xC4, 0x94,
  0xC9, 0x48, 0xA5, 0x8A, 0x50, 0xE5, 0x0C, 0x70, 0xC6, 0x08, 0x60, 0x11,
  0x8C, 0x86, 0xC1, 0x40, 0xC0, 0x60, 0x30, 0x28, 0x34, 0x12, 0x11, 0x98,
  0xC0, 0xC6, 0x89, 0x32, 0x47, 0x8E, 0x1C, 0x10, 0x60, 0xC1, 0x02, 0x00,
  0x1F, 0x80, 0x80, 0x80, 0xC0, 0x40, 0x60, 0x60, 0x20, 0x30, 0x10, 0x10,
  0x1F, 0x80, 0x1C, 0xC3, 0x08, 0x20, 0x86, 0x10, 0x41, 0x04, 0x30, 0x82,
  0x0E, 0x00, 0x92, 0x4D, 0x92, 0x49, 0x30, 0x1C, 0x10, 0xC2, 0x08, 0x20,
  0x86, 0x10, 0x41, 0x0C, 0x30, 0x8E, 0x00, 0x08, 0x38, 0x51, 0x22, 0x68,
  0x70, 0x80, 0x7F, 0xF0, 0xCC, 0x80, 0x3E, 0x8B, 0x14, 0x28, 0xD1, 0xA2,
  0x4C, 0xE8, 0x10, 0x20, 0xC1, 0x82, 0xE6, 0x48, 0xB1, 0x42, 0x85, 0x1E,
  0x6B, 0x80, 0x3A, 0x31, 0x08, 0x42, 0x12, 0xF0, 0x03, 0x02, 0x02, 0x02,
  0x3E, 0x44, 0xC4, 0x84, 0x8C, 0x8C, 0x88, 0x98, 0xE8, 0x39, 0x3C, 0xE6,
  0xF2, 0x08, 0x22, 0xF0, 0x03, 0x04, 0x04, 0x0C, 0x1E, 0x08, 0x08, 0x18,
  0x18, 0x10, 0x10, 0x10, 0x30, 0x30, 0x20, 0x20, 0xC0, 0x1F, 0x22, 0x62,
  0x42, 0x46, 0x46, 0x44, 0x4C, 0x74, 0x0C, 0x08, 0x98, 0xF0, 0x10, 0x20,
  0xC1, 0x82, 0xE6, 0x48, 0xB1, 0x46, 0x8D, 0x16, 0x2C, 0xC0, 0x13, 0x00,
  0x22, 0x26, 0x44, 0x4C, 0xC0, 0x04, 0x30, 0x00, 0x08, 0x20, 0x86, 0x10,
  0x41, 0x0C, 0x30, 0x82, 0x18, 0xC0, 0x10, 0x10, 0x30, 0x31, 0x26, 0x24,
  0x28, 0x78, 0x78, 0x58, 0x48, 0xC8, 0xCC, 0x11, 0x33, 0x22, 0x26, 0x44,
  0x4C, 0xC0, 0x2E, 0xE6, 0x64, 0x88, 0xB3, 0x34, 0x66, 0x88, 0x91, 0x16,
  0x22, 0xCC, 0xC0, 0x2E, 0x64, 0x8B, 0x14, 0x68, 0xD1, 0x62, 0xCC, 0x39,
  0x1C, 0x61, 0x86, 0x38, 0xA6, 0xF0, 0x17, 0x19, 0x11, 0x31, 0x21, 0x21,
  0x23, 0x66, 0x7C, 0x40, 0x40, 0x40, 0xC0, 0x3E, 0x8B, 0x14, 0x28, 0xD1,
  0xA2, 0x4C, 0xE8, 0x30, 0x60, 0x81, 0x00, 0x2C, 0xC2, 0x18, 0x41, 0x04,
  0x30, 0xC0, 0x3D, 0x84, 0x18, 0x30, 0x61, 0xA6, 0xF0, 0x26, 0xF4, 0x4C,
  0x88, 0x88, 0xC0, 0x46, 0x8B, 0x16, 0x28, 0xD1, 0x22, 0x4C, 0xE8, 0x86,
  0x28, 0xA6, 0x92, 0xCA, 0x38, 0xC0, 0x8C, 0xE3, 0x29, 0x5A, 0x54, 0xA5,
  0x29, 0xCE, 0x63, 0x38, 0xCC, 0x00, 0x33, 0x12, 0x14, 0x1C, 0x18, 0x18,
  0x2C, 0x64, 0xC4, 0x10, 0x88, 0xC4, 0x43, 0x61, 0xA0, 0xF0, 0x70, 0x38,
  0x08, 0x0C, 0x04, 0x06, 0x0E, 0x00, 0x3E, 0x08, 0x30, 0x41, 0x06, 0x08,
  0x30, 0xF8, 0x0E, 0x10, 0x60, 0x81, 0x02, 0x08, 0x60, 0x20, 0x40, 0x83,
  0x06, 0x0C, 0x0C, 0x00, 0xFF, 0xFF, 0x80, 0x18, 0x30, 0x82, 0x08, 0x20,
  0x83, 0x10, 0x43, 0x0C, 0x21, 0x8C, 0x00, 0xF3, 0x38,
};

const GFXglyph NotoSans_Condensed_Italic17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 4, 12, 4, 0, -12 },
  { 7, 5, 4, 6, 2, -12 },
  { 10, 9, 12, 8, 0, -12 },
  { 24, 8, 14, 7, 0, -13 },
  { 38, 10, 12, 11, 1, -12 },
  { 53, 8, 12, 9, 0, -12 },
  { 65, 2, 4, 3, 2, -12 },
  { 66, 6, 15, 5, 0, -12 },
  { 78, 5, 15, 5, -1, -12 },
  { 88, 6, 6, 7, 2, -13 },
  { 93, 7, 8, 8, 1, -10 },
  { 100, 3, 4, 4, -1, -2 },
  { 102, 4, 1, 5, 0, -5 },
  { 103, 2, 2, 4, 0, -2 },
  { 104, 8, 12, 6, -1, -12 },
  { 116, 6, 12, 7, 1, -12 },
  { 125, 4, 12, 7, 2, -12 },
  { 131, 7, 12, 7, 0, -12 },
  { 142, 7, 12, 7, 0, -12 },
  { 153, 7, 12, 7, 0, -12 },
  { 164, 8, 12, 7, 0, -12 },
  { 176, 7, 12, 7, 1, -12 },
  { 187, 7, 12, 7, 1, -12 },
  { 198, 8, 12, 7, 0, -12 },
  { 210, 7, 12, 7, 0, -12 },
  { 221, 4, 9, 4, 0, -9 },
  { 226, 5, 11, 4, -1, -9 },
  { 233, 7, 8, 8, 1, -10 },
  { 240, 7, 4, 8, 1, -8 },
  { 244, 7, 8, 8, 1, -10 },
  { 251, 5, 12, 6, 1, -12 },
  { 259, 10, 13, 11, 1, -12 },
  { 276, 8, 12, 8, -1, -12 },
  { 288, 8, 12, 8, 0, -12 },
  { 300, 8, 12, 8, 1, -12 },
  { 312, 9, 12, 9, 0, -12 },
  { 326, 8, 12, 7, 0, -12 },
  { 338, 8, 12, 7, 0, -12 },
  { 350, 9, 12, 9, 1, -12 },
  { 364, 10, 12, 9, 0, -12 },
  { 379, 7, 12, 5, -1, -12 },
  { 390, 7, 15, 4, -3, -12 },
  { 404, 9, 12, 8, 0, -12 },
  { 418, 5, 12, 6, 0, -12 },
  { 426, 12, 12, 12, 0, -12 },
  { 444, 10, 12, 10, 0, -12 },
  { 459, 8, 12, 10, 1, -12 },
  { 471, 8, 12, 8, 0, -12 },
  { 483, 8, 15, 10, 1, -12 },
  { 498, 8, 12, 8, 0, -12 },
  { 510, 8, 12, 7, 0, -12 },
  { 522, 7, 12, 7, 1, -12 },
  { 533, 8, 12, 9, 1, -12 },
  { 545, 8, 12, 8, 1, -12 },
  { 557, 12, 12, 12, 2, -12 },
  { 575, 9, 12, 7, -1, -12 },
  { 589, 7, 12, 7, 1, -12 },
  { 600, 9, 12, 7, -1, -12 },
  { 614, 6, 15, 5, 0, -12 },
  { 626, 3, 12, 6, 2, -12 },
  { 631, 6, 15, 5, -1, -12 },
  { 643, 7, 7, 8, 0, -12 },
  { 650, 6, 2, 6, -2, 1 },
  { 652, 3, 3, 4, 2, -13 },
  { 654, 7, 9, 8, 1, -9 },
  { 662, 7, 13, 8, 0, -13 },
  { 674, 5, 9, 6, 1, -9 },
  { 680, 8, 13, 8, 1, -13 },
  { 693, 6, 9, 7, 1, -9 },
  { 700, 8, 17, 4, -2, -13 },
  { 717, 8, 13, 8, 0, -9 },
  { 730, 7, 13, 8, 0, -13 },
  { 742, 4, 13, 4, 0, -13 },
  { 749, 6, 17, 4, -2, -13 },
  { 762, 8, 13, 7, 0, -13 },
  { 775, 4, 13, 4, 0, -13 },
  { 782, 11, 9, 12, 0, -9 },
  { 795, 7, 9, 8, 0, -9 },
  { 803, 6, 9, 8, 1, -9 },
  { 810, 8, 13, 8, -1, -9 },
  { 823, 7, 13, 8, 1, -9 },
  { 835, 6, 9, 5, 0, -9 },
  { 842, 6, 9, 6, 0, -9 },
  { 849, 4, 11, 5, 1, -11 },
  { 855, 7, 9, 8, 1, -9 },
  { 863, 6, 9, 6, 1, -9 },
  { 870, 10, 9, 10, 1, -9 },
  { 882, 8, 9, 7, -1, -9 },
  { 891, 9, 13, 6, -2, -9 },
  { 906, 7, 9, 6, -1, -9 },
  { 914, 7, 15, 6, 0, -12 },
  { 928, 1, 17, 7, 3, -13 },
  { 931, 6, 15, 6, -1, -12 },
  { 943, 7, 2, 8, 1, -7 },
};

const GFXfont NotoSans_Condensed_Italic17pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Italic17pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Italic17pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _NOTOSANS_CONDENSED_ITALIC17PT7B_H_
