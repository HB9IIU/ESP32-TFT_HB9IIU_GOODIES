#ifndef _NOTOSANS_CONDENSED_ITALIC9PT7B_H_
#define _NOTOSANS_CONDENSED_ITALIC9PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Italic.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Italic9pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x20, 0xF0, 0x33, 0xD5, 0xE6, 0x50, 0x27, 0x64, 0x66, 0xC4,
  0x46, 0xB9, 0xFE, 0xB6, 0xC0, 0x25, 0x56, 0xBB, 0xF0, 0xC0, 0x6A, 0x49,
  0x20, 0x24, 0x92, 0xB0, 0x5F, 0x00, 0x2F, 0x22, 0xC0, 0xC0, 0x80, 0x32,
  0x44, 0x88, 0x25, 0x59, 0x9A, 0xE0, 0xD5, 0x60, 0x25, 0x12, 0x24, 0xE0,
  0x25, 0x16, 0x22, 0xE0, 0x33, 0x6A, 0xF2, 0x74, 0x61, 0x2E, 0x16, 0x46,
  0x99, 0x60, 0x71, 0x22, 0x4C, 0x25, 0x56, 0xA9, 0xE0, 0x25, 0x59, 0x72,
  0xC0, 0x40, 0x80, 0x40, 0xA0, 0x3C, 0x61, 0xFF, 0xC3, 0x68, 0x64, 0xA4,
  0x20, 0x3D, 0x7B, 0x6D, 0xBA, 0x07, 0x00, 0x11, 0x8A, 0x64, 0xE4, 0x75,
  0x65, 0x9E, 0x1B, 0x11, 0x08, 0x41, 0x80, 0x72, 0x52, 0xA9, 0x70, 0x74,
  0x64, 0x8E, 0x74, 0x64, 0x88, 0x13, 0x51, 0x28, 0xC9, 0xC0, 0x4A, 0x5C,
  0xA9, 0x48, 0x69, 0x29, 0x80, 0x24, 0x94, 0x94, 0x5B, 0x18, 0xCA, 0x58,
  0x49, 0x29, 0xC0, 0x65, 0xB6, 0xED, 0xB6, 0xA0, 0x6B, 0x5B, 0x59, 0x48,
  0x13, 0x53, 0x18, 0xC9, 0xC0, 0x75, 0x56, 0x88, 0x13, 0x53, 0x18, 0xC9,
  0xC4, 0x10, 0x75, 0x56, 0xAB, 0x25, 0x44, 0x22, 0xE0, 0xEA, 0x49, 0x00,
  0x4A, 0x55, 0x29, 0x30, 0xBA, 0xAC, 0xC8, 0xA6, 0xAD, 0xBA, 0x92, 0x40,
  0x29, 0x84, 0x65, 0x68, 0xBB, 0x49, 0x00, 0x72, 0x24, 0x8E, 0x69, 0x49,
  0x30, 0xFC, 0x31, 0x22, 0x22, 0xC0, 0x25, 0x90, 0xE0, 0x90, 0x75, 0x99,
  0xE0, 0x44, 0x75, 0x99, 0xE0, 0x6A, 0x46, 0x08, 0x9C, 0xA9, 0x53, 0x80,
  0x65, 0xE8, 0x60, 0x12, 0x72, 0x24, 0x44, 0x80, 0x75, 0x9A, 0xE2, 0xE0,
  0x44, 0x75, 0x99, 0xA0, 0x45, 0xA8, 0x20, 0x94, 0x92, 0x80, 0x44, 0x56,
  0x4A, 0xA0, 0x55, 0xA8, 0x7D, 0x59, 0x69, 0xA8, 0x75, 0x99, 0xA0, 0x65,
  0x99, 0x60, 0x75, 0x99, 0xE8, 0x80, 0x75, 0x9A, 0xE2, 0x20, 0x6A, 0x48,
  0x71, 0x1C, 0x5D, 0x49, 0x80, 0x55, 0x9A, 0xE0, 0x9A, 0xAC, 0x40, 0xAF,
  0xAD, 0x4A, 0x00, 0x56, 0x44, 0xA0, 0x4A, 0x8C, 0x42, 0x23, 0x00, 0x65,
  0x4C, 0x34, 0x48, 0x44, 0xC0, 0xFF, 0x80, 0x69, 0x14, 0xA0, 0xF0,
};

const GFXglyph NotoSans_Condensed_Italic9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 6, 2, 0, -6 },
  { 3, 2, 2, 3, 1, -6 },
  { 4, 5, 6, 4, 0, -6 },
  { 8, 4, 8, 4, 0, -7 },
  { 12, 5, 7, 6, 1, -7 },
  { 17, 4, 7, 5, 0, -7 },
  { 21, 1, 2, 2, 1, -6 },
  { 22, 3, 7, 2, 0, -6 },
  { 25, 3, 7, 2, -1, -6 },
  { 28, 3, 3, 4, 1, -7 },
  { 30, 4, 4, 4, 0, -5 },
  { 32, 1, 2, 2, 0, -1 },
  { 33, 2, 1, 2, 0, -3 },
  { 34, 1, 1, 2, 0, -1 },
  { 35, 4, 6, 3, 0, -6 },
  { 38, 4, 7, 4, 0, -7 },
  { 42, 2, 6, 4, 1, -6 },
  { 44, 4, 7, 4, 0, -7 },
  { 48, 4, 7, 4, 0, -7 },
  { 52, 4, 6, 4, 0, -6 },
  { 55, 4, 6, 4, 0, -6 },
  { 58, 4, 7, 4, 0, -7 },
  { 62, 4, 6, 4, 0, -6 },
  { 65, 4, 7, 4, 0, -7 },
  { 69, 4, 7, 4, 0, -7 },
  { 73, 2, 5, 2, 0, -5 },
  { 75, 2, 6, 2, 0, -5 },
  { 77, 4, 4, 4, 0, -5 },
  { 79, 4, 2, 4, 0, -4 },
  { 80, 4, 4, 4, 0, -5 },
  { 82, 3, 7, 3, 0, -7 },
  { 85, 6, 7, 6, 0, -6 },
  { 91, 5, 6, 4, -1, -6 },
  { 95, 4, 6, 4, 0, -6 },
  { 98, 5, 7, 4, 0, -7 },
  { 103, 5, 6, 5, 0, -6 },
  { 107, 4, 6, 4, 0, -6 },
  { 110, 4, 6, 3, 0, -6 },
  { 113, 5, 7, 5, 0, -7 },
  { 118, 5, 6, 5, 0, -6 },
  { 122, 3, 6, 3, 0, -6 },
  { 125, 3, 8, 2, -1, -6 },
  { 128, 5, 6, 4, 0, -6 },
  { 132, 3, 6, 3, 0, -6 },
  { 135, 6, 6, 6, 0, -6 },
  { 140, 5, 6, 5, 0, -6 },
  { 144, 5, 7, 5, 0, -7 },
  { 149, 4, 6, 4, 0, -6 },
  { 152, 5, 9, 5, 0, -7 },
  { 158, 4, 6, 4, 0, -6 },
  { 161, 4, 7, 4, 0, -7 },
  { 165, 3, 6, 4, 1, -6 },
  { 168, 5, 6, 5, 0, -6 },
  { 172, 4, 6, 4, 1, -6 },
  { 175, 6, 6, 6, 1, -6 },
  { 180, 5, 6, 4, -1, -6 },
  { 184, 3, 6, 4, 1, -6 },
  { 187, 4, 6, 4, 0, -6 },
  { 190, 3, 7, 3, 0, -6 },
  { 193, 1, 6, 3, 1, -6 },
  { 194, 4, 7, 3, -1, -6 },
  { 198, 4, 3, 4, 0, -6 },
  { 200, 3, 1, 3, -1, 1 },
  { 201, 2, 2, 2, 1, -7 },
  { 202, 4, 5, 4, 0, -5 },
  { 205, 4, 7, 4, 0, -7 },
  { 209, 3, 5, 3, 0, -5 },
  { 211, 5, 7, 4, 0, -7 },
  { 216, 4, 5, 4, 0, -5 },
  { 219, 4, 9, 2, -1, -7 },
  { 224, 4, 7, 4, 0, -5 },
  { 228, 4, 7, 4, 0, -7 },
  { 232, 2, 7, 2, 0, -7 },
  { 234, 3, 9, 2, -1, -7 },
  { 238, 4, 7, 4, 0, -7 },
  { 242, 2, 7, 2, 0, -7 },
  { 244, 6, 5, 6, 0, -5 },
  { 248, 4, 5, 4, 0, -5 },
  { 251, 4, 5, 4, 0, -5 },
  { 254, 4, 7, 4, 0, -5 },
  { 258, 4, 7, 4, 0, -5 },
  { 262, 3, 5, 3, 0, -5 },
  { 264, 3, 5, 3, 0, -5 },
  { 266, 3, 6, 2, 0, -6 },
  { 269, 4, 5, 4, 0, -5 },
  { 272, 4, 5, 3, 0, -5 },
  { 275, 5, 5, 5, 1, -5 },
  { 279, 4, 5, 3, 0, -5 },
  { 282, 5, 7, 3, -1, -5 },
  { 287, 3, 5, 3, 0, -5 },
  { 289, 4, 7, 3, 0, -6 },
  { 293, 1, 9, 4, 1, -7 },
  { 295, 3, 7, 3, 0, -6 },
  { 298, 4, 1, 4, 0, -4 },
};

const GFXfont NotoSans_Condensed_Italic9pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Italic9pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Italic9pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _NOTOSANS_CONDENSED_ITALIC9PT7B_H_
