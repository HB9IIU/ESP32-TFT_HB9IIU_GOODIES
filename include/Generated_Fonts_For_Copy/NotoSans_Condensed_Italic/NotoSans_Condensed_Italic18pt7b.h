#ifndef _NOTOSANS_CONDENSED_ITALIC18PT7B_H_
#define _NOTOSANS_CONDENSED_ITALIC18PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Italic.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Italic18pt7bBitmaps[] PROGMEM = {
  0x00, 0x18, 0x8C, 0x63, 0x10, 0x84, 0x60, 0x01, 0x8C, 0x00, 0xDE, 0xE5,
  0x29, 0x00, 0x0D, 0x84, 0x82, 0x43, 0x27, 0xF8, 0x90, 0x48, 0x48, 0xFF,
  0x12, 0x13, 0x09, 0x04, 0x80, 0x04, 0x04, 0x1F, 0x35, 0x28, 0x28, 0x38,
  0x1C, 0x14, 0x16, 0x16, 0x94, 0xF8, 0x20, 0x20, 0x30, 0xD2, 0x24, 0x93,
  0x2C, 0x9A, 0x25, 0x79, 0x57, 0xA9, 0x1A, 0x44, 0x92, 0x24, 0x8A, 0x43,
  0x80, 0x0E, 0x09, 0x04, 0x86, 0x41, 0x60, 0xE0, 0xE0, 0xD3, 0x4D, 0x63,
  0xB1, 0x99, 0xC7, 0xB0, 0x7E, 0x80, 0x0C, 0x21, 0x0C, 0x21, 0x86, 0x10,
  0x41, 0x0C, 0x30, 0x41, 0x04, 0x18, 0x10, 0xC2, 0x10, 0x84, 0x21, 0x18,
  0xC4, 0x62, 0x31, 0x10, 0x10, 0x4D, 0x1F, 0x73, 0x45, 0x80, 0x10, 0x20,
  0x40, 0x8F, 0xE2, 0x04, 0x08, 0x10, 0x2D, 0x60, 0x7F, 0x80, 0xF0, 0x01,
  0x81, 0x80, 0x80, 0xC0, 0x40, 0x60, 0x20, 0x30, 0x10, 0x10, 0x08, 0x08,
  0x0C, 0x00, 0x1C, 0x6D, 0x9A, 0x3C, 0x78, 0xE1, 0x42, 0x85, 0x1A, 0x24,
  0xCF, 0x00, 0x19, 0xDD, 0x23, 0x18, 0xC4, 0x23, 0x18, 0x84, 0x00, 0x1E,
  0x33, 0x03, 0x03, 0x02, 0x06, 0x04, 0x08, 0x18, 0x30, 0x60, 0xC0, 0xFC,
  0x1E, 0x33, 0x03, 0x03, 0x02, 0x06, 0x38, 0x04, 0x06, 0x06, 0x04, 0x8C,
  0xF8, 0x03, 0x07, 0x06, 0x0A, 0x16, 0x36, 0x24, 0x44, 0xC4, 0xFE, 0x0C,
  0x08, 0x08, 0x1F, 0x1F, 0x30, 0x20, 0x20, 0x7C, 0x2E, 0x06, 0x06, 0x06,
  0x06, 0x8C, 0xF8, 0x0E, 0x60, 0x83, 0x04, 0x1F, 0x33, 0x62, 0x85, 0x0A,
  0x36, 0xC7, 0x00, 0x7F, 0x02, 0x06, 0x04, 0x0C, 0x08, 0x18, 0x10, 0x30,
  0x20, 0x60, 0x40, 0xC0, 0x1E, 0x33, 0x21, 0x23, 0x32, 0x16, 0x1C, 0x64,
  0x46, 0xC6, 0xC6, 0xC4, 0x78, 0x1E, 0x32, 0x23, 0x63, 0x63, 0x63, 0x66,
  0x3A, 0x06, 0x04, 0x0C, 0x18, 0xF0, 0x33, 0x20, 0x00, 0x00, 0xCC, 0x18,
  0xC4, 0x00, 0x00, 0x00, 0x23, 0x11, 0x80, 0x02, 0x0C, 0x73, 0x8C, 0x0C,
  0x06, 0x03, 0x02, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x81, 0x81, 0xC0, 0xE0,
  0x61, 0x8C, 0x60, 0x80, 0x79, 0x30, 0xC2, 0x18, 0x42, 0x10, 0x42, 0x00,
  0x30, 0x80, 0x07, 0x83, 0x18, 0x81, 0x30, 0x34, 0xF3, 0x36, 0x64, 0x94,
  0x92, 0xB2, 0x56, 0xD2, 0x6E, 0x40, 0x0C, 0x00, 0xFC, 0x06, 0x00, 0x03,
  0x07, 0x07, 0x0F, 0x0B, 0x1B, 0x13, 0x33, 0x3F, 0x63, 0x63, 0x43, 0xC1,
  0x1E, 0x09, 0x8C, 0x66, 0x33, 0x11, 0x18, 0xF8, 0xC4, 0x63, 0x21, 0x90,
  0x88, 0xCF, 0xC0, 0x0F, 0x39, 0x20, 0x60, 0x40, 0xC0, 0xC0, 0x80, 0x80,
  0x80, 0xC0, 0xC4, 0x7C, 0x1E, 0x0B, 0x8C, 0x66, 0x33, 0x09, 0x0C, 0x86,
  0xC3, 0x61, 0x21, 0x91, 0x89, 0xCF, 0x80, 0x1F, 0x10, 0x30, 0x30, 0x30,
  0x20, 0x3E, 0x60, 0x60, 0x40, 0x40, 0x40, 0xFC, 0x1F, 0x10, 0x30, 0x30,
  0x30, 0x20, 0x3E, 0x60, 0x60, 0x40, 0x40, 0x40, 0xC0, 0x0F, 0x9C, 0xC8,
  0x0C, 0x04, 0x06, 0x03, 0x1D, 0x0E, 0x83, 0x41, 0x30, 0x98, 0x47, 0xE0,
  0x10, 0xC4, 0x33, 0x0C, 0xC2, 0x30, 0x88, 0x63, 0xF9, 0x84, 0x61, 0x10,
  0x44, 0x31, 0x0C, 0xC2, 0x00, 0x1E, 0x18, 0x20, 0x41, 0x83, 0x04, 0x08,
  0x10, 0x60, 0xC1, 0x0F, 0x80, 0x02, 0x04, 0x18, 0x30, 0x60, 0x81, 0x06,
  0x0C, 0x10, 0x20, 0x41, 0x83, 0x04, 0x78, 0x10, 0xC4, 0x63, 0x30, 0xD8,
  0x34, 0x0A, 0x03, 0x81, 0xB0, 0x6C, 0x11, 0x04, 0x41, 0x18, 0xC6, 0x00,
  0x10, 0x43, 0x0C, 0x30, 0x82, 0x18, 0x61, 0x04, 0x10, 0xFC, 0x18, 0x18,
  0xC1, 0xCE, 0x0C, 0x70, 0xE2, 0x85, 0x14, 0x78, 0xA2, 0xCD, 0x34, 0x6D,
  0x22, 0x79, 0x13, 0x98, 0x9C, 0xCC, 0xC4, 0x00, 0x18, 0x63, 0x08, 0xE1,
  0x1C, 0x62, 0xCC, 0x59, 0x09, 0x23, 0x24, 0x67, 0x88, 0xF1, 0x0C, 0x21,
  0x8C, 0x30, 0x1E, 0x19, 0x88, 0x6C, 0x34, 0x1E, 0x0F, 0x07, 0x02, 0x83,
  0x41, 0xB1, 0x99, 0xC7, 0x80, 0x1E, 0x17, 0x31, 0x31, 0x31, 0x23, 0x26,
  0x7C, 0x60, 0x40, 0x40, 0x40, 0xC0, 0x1E, 0x19, 0x88, 0x6C, 0x34, 0x1E,
  0x0F, 0x07, 0x02, 0x83, 0x41, 0xB1, 0x99, 0xC7, 0x80, 0xC0, 0x30, 0x18,
  0x1E, 0x17, 0x31, 0x31, 0x31, 0x23, 0x3E, 0x7C, 0x6C, 0x44, 0x44, 0x46,
  0xC6, 0x1F, 0x33, 0x20, 0x20, 0x20, 0x30, 0x18, 0x0C, 0x04, 0x04, 0x04,
  0x8C, 0xF8, 0x7F, 0xFC, 0x40, 0x83, 0x06, 0x0C, 0x10, 0x20, 0xC1, 0x82,
  0x04, 0x00, 0x21, 0x90, 0xD8, 0x4C, 0x24, 0x12, 0x1B, 0x0D, 0x84, 0xC2,
  0x43, 0x21, 0x99, 0x87, 0x80, 0x83, 0x86, 0x86, 0x8C, 0x8C, 0x88, 0x98,
  0x90, 0xB0, 0xA0, 0xE0, 0xC0, 0xC0, 0x86, 0x18, 0x63, 0x8E, 0x28, 0xE6,
  0x9E, 0x69, 0x64, 0x96, 0xCB, 0x68, 0xA7, 0x8E, 0x70, 0xC7, 0x0C, 0x70,
  0xC6, 0x00, 0x18, 0xC6, 0x61, 0x90, 0x2C, 0x0A, 0x03, 0x80, 0xC0, 0x70,
  0x14, 0x0D, 0x82, 0x61, 0x18, 0xC2, 0x00, 0x87, 0x1A, 0x26, 0xCD, 0x1E,
  0x18, 0x30, 0x41, 0x83, 0x06, 0x08, 0x00, 0x1F, 0x80, 0xC0, 0xC0, 0x40,
  0x60, 0x20, 0x30, 0x30, 0x10, 0x18, 0x08, 0x0C, 0x0F, 0xE0, 0x1C, 0x43,
  0x0C, 0x20, 0x82, 0x18, 0x61, 0x04, 0x10, 0xC2, 0x08, 0x38, 0x93, 0x6C,
  0x92, 0x49, 0xB6, 0x1E, 0x08, 0x10, 0x60, 0xC1, 0x02, 0x04, 0x18, 0x30,
  0x40, 0x81, 0x06, 0x08, 0x70, 0x08, 0x0C, 0x14, 0x16, 0x22, 0x62, 0xC3,
  0xFE, 0xB4, 0x3A, 0xDD, 0x1E, 0x38, 0x50, 0xA3, 0x46, 0x9D, 0xD0, 0x10,
  0x10, 0x10, 0x30, 0x36, 0x2B, 0x33, 0x23, 0x63, 0x63, 0x42, 0x46, 0xE4,
  0xB8, 0x1D, 0xD4, 0x30, 0x82, 0x08, 0x20, 0x8B, 0xC0, 0x01, 0x03, 0x03,
  0x02, 0x3A, 0x6E, 0x46, 0xC6, 0x84, 0x84, 0x8C, 0x8C, 0x9C, 0xE8, 0x19,
  0xB4, 0x73, 0xBB, 0x88, 0x20, 0x8B, 0xE0, 0x03, 0x83, 0x81, 0x00, 0x80,
  0xE0, 0xF0, 0x20, 0x10, 0x18, 0x0C, 0x06, 0x02, 0x01, 0x01, 0x80, 0xC0,
  0x40, 0x20, 0x70, 0x00, 0x1D, 0x37, 0x23, 0x63, 0x42, 0x42, 0x46, 0x46,
  0x4E, 0x74, 0x04, 0x0C, 0x88, 0xF8, 0x18, 0x10, 0x10, 0x30, 0x36, 0x3B,
  0x33, 0x22, 0x62, 0x62, 0x46, 0x46, 0xC4, 0xC4, 0x11, 0x03, 0x22, 0x26,
  0x64, 0x4C, 0xC0, 0x04, 0x10, 0x03, 0x08, 0x20, 0x86, 0x18, 0x41, 0x0C,
  0x30, 0x82, 0x18, 0xC0, 0x18, 0x10, 0x10, 0x30, 0x33, 0x26, 0x24, 0x28,
  0x78, 0x78, 0x48, 0x48, 0xCC, 0xCC, 0x18, 0x84, 0x63, 0x10, 0x84, 0x63,
  0x10, 0x8C, 0x60, 0x2E, 0x63, 0xEB, 0x33, 0x32, 0x23, 0x62, 0x26, 0x62,
  0x46, 0x24, 0x46, 0xC4, 0x6C, 0x44, 0x2E, 0x3F, 0x33, 0x63, 0x62, 0x62,
  0x46, 0x46, 0xC4, 0xC4, 0x18, 0xD9, 0x1E, 0x38, 0x70, 0xA1, 0x46, 0x99,
  0xE0, 0x13, 0x0A, 0xC6, 0x62, 0x33, 0x19, 0x8C, 0x84, 0x46, 0x72, 0x3E,
  0x18, 0x08, 0x04, 0x06, 0x00, 0x3A, 0xDD, 0x1E, 0x38, 0x50, 0xA3, 0x46,
  0x9D, 0xD0, 0x20, 0xC1, 0x82, 0x00, 0x2C, 0xB3, 0x08, 0x61, 0x84, 0x10,
  0xC3, 0x00, 0x3D, 0x96, 0x18, 0x30, 0x61, 0x82, 0x9B, 0xC0, 0x22, 0x7F,
  0x44, 0xCC, 0x88, 0x8E, 0x62, 0x8D, 0x1E, 0x2C, 0x50, 0xA3, 0x46, 0x99,
  0xD0, 0x87, 0x0B, 0x36, 0x4D, 0x9A, 0x3C, 0x70, 0xE1, 0x80, 0xCC, 0x71,
  0x8A, 0x33, 0x4A, 0x49, 0x59, 0x6A, 0x29, 0x45, 0x38, 0xC6, 0x18, 0xC0,
  0x31, 0x89, 0x84, 0x83, 0x80, 0xC0, 0xC0, 0x70, 0x48, 0x64, 0x63, 0x00,
  0x18, 0xC6, 0x21, 0x98, 0x64, 0x1B, 0x06, 0x81, 0xE0, 0x30, 0x0C, 0x02,
  0x01, 0x80, 0x40, 0x30, 0x38, 0x00, 0x1E, 0x7C, 0x10, 0x60, 0x82, 0x0C,
  0x10, 0x61, 0xF8, 0x06, 0x18, 0x20, 0xC1, 0x82, 0x04, 0x30, 0xE0, 0x40,
  0x81, 0x06, 0x0C, 0x18, 0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x18, 0x18,
  0x30, 0x60, 0x81, 0x02, 0x07, 0x0C, 0x20, 0x41, 0x83, 0x04, 0x18, 0x60,
  0x43, 0xF6, 0x30,
};

const GFXglyph NotoSans_Condensed_Italic18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 5, 13, 4, 0, -13 },
  { 10, 5, 5, 6, 2, -13 },
  { 14, 9, 13, 9, 0, -13 },
  { 29, 8, 15, 8, 0, -14 },
  { 44, 10, 13, 12, 1, -13 },
  { 61, 9, 13, 9, 0, -13 },
  { 76, 2, 5, 4, 2, -13 },
  { 78, 6, 16, 5, 0, -13 },
  { 90, 5, 16, 5, -1, -13 },
  { 100, 6, 7, 8, 2, -14 },
  { 106, 7, 9, 9, 1, -11 },
  { 114, 3, 4, 4, -1, -2 },
  { 116, 5, 2, 5, 0, -6 },
  { 118, 2, 2, 4, 0, -2 },
  { 119, 9, 13, 6, -1, -13 },
  { 134, 7, 13, 8, 1, -13 },
  { 146, 5, 13, 8, 2, -13 },
  { 155, 8, 13, 8, 0, -13 },
  { 168, 8, 13, 8, 0, -13 },
  { 181, 8, 13, 8, 0, -13 },
  { 194, 8, 13, 8, 0, -13 },
  { 207, 7, 13, 8, 1, -13 },
  { 219, 8, 13, 8, 1, -13 },
  { 232, 8, 13, 8, 0, -13 },
  { 245, 8, 13, 8, 0, -13 },
  { 258, 4, 10, 4, 0, -10 },
  { 263, 5, 12, 4, -1, -10 },
  { 271, 7, 9, 9, 1, -11 },
  { 279, 7, 5, 9, 1, -9 },
  { 284, 7, 9, 9, 1, -11 },
  { 292, 6, 13, 6, 1, -13 },
  { 302, 11, 15, 12, 1, -13 },
  { 323, 8, 13, 8, -1, -13 },
  { 336, 9, 13, 9, 0, -13 },
  { 351, 8, 13, 8, 1, -13 },
  { 364, 9, 13, 9, 0, -13 },
  { 379, 8, 13, 7, 0, -13 },
  { 392, 8, 13, 7, 0, -13 },
  { 405, 9, 13, 10, 1, -13 },
  { 420, 10, 13, 10, 0, -13 },
  { 437, 7, 13, 5, -1, -13 },
  { 449, 7, 16, 4, -3, -13 },
  { 463, 10, 13, 8, 0, -13 },
  { 480, 6, 13, 7, 0, -13 },
  { 490, 13, 13, 13, 0, -13 },
  { 512, 11, 13, 10, 0, -13 },
  { 530, 9, 13, 10, 1, -13 },
  { 545, 8, 13, 8, 0, -13 },
  { 558, 9, 16, 10, 1, -13 },
  { 576, 8, 13, 8, 0, -13 },
  { 589, 8, 13, 7, 0, -13 },
  { 602, 7, 13, 7, 1, -13 },
  { 614, 9, 13, 10, 1, -13 },
  { 629, 8, 13, 8, 2, -13 },
  { 642, 12, 13, 13, 2, -13 },
  { 662, 10, 13, 8, -1, -13 },
  { 679, 7, 13, 7, 2, -13 },
  { 691, 9, 13, 7, -1, -13 },
  { 706, 6, 16, 5, 0, -13 },
  { 718, 3, 13, 6, 2, -13 },
  { 723, 7, 16, 5, -1, -13 },
  { 737, 8, 7, 8, 0, -13 },
  { 744, 7, 1, 6, -2, 2 },
  { 745, 2, 3, 5, 3, -14 },
  { 746, 7, 10, 8, 1, -10 },
  { 755, 8, 14, 8, 0, -14 },
  { 769, 6, 10, 6, 1, -10 },
  { 777, 8, 14, 8, 1, -14 },
  { 791, 6, 10, 8, 1, -10 },
  { 799, 9, 18, 5, -2, -14 },
  { 820, 8, 14, 8, 0, -10 },
  { 834, 8, 14, 8, 0, -14 },
  { 848, 4, 13, 4, 0, -13 },
  { 855, 6, 17, 4, -2, -13 },
  { 868, 8, 14, 7, 0, -14 },
  { 882, 5, 14, 4, 0, -14 },
  { 891, 12, 10, 12, 0, -10 },
  { 906, 8, 10, 8, 0, -10 },
  { 916, 7, 10, 8, 1, -10 },
  { 925, 9, 14, 8, -1, -10 },
  { 941, 7, 14, 8, 1, -10 },
  { 954, 6, 10, 6, 0, -10 },
  { 962, 6, 10, 6, 0, -10 },
  { 970, 4, 12, 5, 1, -12 },
  { 976, 7, 10, 8, 1, -10 },
  { 985, 7, 10, 7, 1, -10 },
  { 994, 11, 10, 11, 1, -10 },
  { 1008, 9, 10, 7, -1, -10 },
  { 1020, 10, 14, 7, -2, -10 },
  { 1038, 7, 10, 6, -1, -10 },
  { 1047, 7, 16, 6, 0, -13 },
  { 1061, 2, 18, 8, 3, -14 },
  { 1066, 7, 16, 6, -1, -13 },
  { 1080, 7, 3, 9, 1, -8 },
};

const GFXfont NotoSans_Condensed_Italic18pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Italic18pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Italic18pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _NOTOSANS_CONDENSED_ITALIC18PT7B_H_
