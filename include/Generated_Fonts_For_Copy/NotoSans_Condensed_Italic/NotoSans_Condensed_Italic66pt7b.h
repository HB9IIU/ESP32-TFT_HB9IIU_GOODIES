#ifndef _NOTOSANS_CONDENSED_ITALIC66PT7B_H_
#define _NOTOSANS_CONDENSED_ITALIC66PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Italic.ttf
// Size: 66pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Italic66pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00,
  0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03,
  0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x30,
  0x00, 0x3F, 0x07, 0xE7, 0xE1, 0xF8, 0xF8, 0x3F, 0x1F, 0x07, 0xE3, 0xE0,
  0xF8, 0xFC, 0x1F, 0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0x7C, 0x1F, 0x0F, 0x83,
  0xE1, 0xE0, 0x7C, 0x3C, 0x0F, 0x0F, 0x81, 0xE1, 0xF0, 0x3C, 0x3C, 0x0F,
  0x87, 0x81, 0xE0, 0xF0, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00,
  0xF0, 0x1E, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x7C, 0x07, 0x80, 0x00,
  0x3C, 0x07, 0x80, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1F, 0x01, 0xE0, 0x00,
  0x0F, 0x01, 0xF0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x03, 0xC0, 0x78, 0x00,
  0x03, 0xC0, 0x7C, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0xF0, 0x1E, 0x00,
  0x3F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0x01, 0xE0,
  0x00, 0x0F, 0x80, 0xF0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x03, 0xC0, 0x78,
  0x00, 0x01, 0xE0, 0x3C, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x00, 0xF0, 0x1E,
  0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x3C, 0x07,
  0x80, 0x00, 0x1E, 0x03, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xC0,
  0x7C, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0xF0,
  0x1F, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x3E,
  0x07, 0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0F,
  0x80, 0xF0, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x01,
  0xE0, 0x3C, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFC, 0xE3, 0xE0, 0x3F,
  0x0E, 0x04, 0x03, 0xE0, 0xE0, 0x00, 0x3E, 0x1E, 0x00, 0x07, 0xC1, 0xC0,
  0x00, 0x7C, 0x1C, 0x00, 0x07, 0xC1, 0xC0, 0x00, 0x7C, 0x1C, 0x00, 0x07,
  0xC3, 0xC0, 0x00, 0x7E, 0x38, 0x00, 0x03, 0xF3, 0x80, 0x00, 0x3F, 0xB8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xEF, 0xC0, 0x00, 0x0E, 0x7E, 0x00, 0x00, 0xE3, 0xE0,
  0x00, 0x1C, 0x3F, 0x00, 0x01, 0xC1, 0xF0, 0x00, 0x1C, 0x1F, 0x00, 0x01,
  0xC1, 0xF0, 0x00, 0x3C, 0x1F, 0x00, 0x03, 0x83, 0xE0, 0x00, 0x38, 0x3E,
  0x08, 0x03, 0x87, 0xE0, 0xC0, 0x38, 0xFC, 0x0F, 0x87, 0x9F, 0xC0, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x20, 0x07, 0xF8,
  0x00, 0x0F, 0x00, 0x3F, 0xF0, 0x00, 0x7C, 0x01, 0xFF, 0xC0, 0x01, 0xE0,
  0x0F, 0xCF, 0x80, 0x0F, 0x80, 0x3C, 0x1E, 0x00, 0x7C, 0x01, 0xF0, 0x78,
  0x01, 0xE0, 0x07, 0x81, 0xE0, 0x0F, 0x80, 0x3E, 0x07, 0x80, 0x3C, 0x00,
  0xF0, 0x1E, 0x01, 0xF0, 0x03, 0xC0, 0x78, 0x07, 0x80, 0x1F, 0x01, 0xE0,
  0x3C, 0x00, 0x78, 0x07, 0x81, 0xF0, 0x01, 0xE0, 0x1E, 0x07, 0x80, 0x07,
  0x80, 0xF8, 0x3E, 0x00, 0x3E, 0x03, 0xE0, 0xF0, 0x00, 0xF8, 0x0F, 0x07,
  0x80, 0x03, 0xC0, 0x3C, 0x3E, 0x00, 0x0F, 0x01, 0xF0, 0xF0, 0x00, 0x3C,
  0x07, 0x87, 0xC1, 0xF0, 0xF0, 0x1E, 0x1E, 0x1F, 0xE3, 0xC0, 0xF8, 0xF8,
  0xFF, 0xCF, 0x03, 0xC7, 0xC7, 0xFF, 0xBC, 0x1F, 0x1E, 0x3E, 0x3E, 0xF0,
  0x78, 0xF8, 0xF0, 0x7B, 0xE7, 0xE3, 0xC7, 0xC1, 0xE7, 0xFF, 0x1F, 0x1E,
  0x07, 0x9F, 0xF8, 0x78, 0xF8, 0x1F, 0x3F, 0xC3, 0xC3, 0xC0, 0x78, 0x3C,
  0x1F, 0x0F, 0x01, 0xE0, 0x00, 0x78, 0x7C, 0x07, 0x80, 0x03, 0xE1, 0xE0,
  0x1E, 0x00, 0x0F, 0x07, 0x80, 0x78, 0x00, 0x7C, 0x1E, 0x03, 0xE0, 0x03,
  0xE0, 0xF8, 0x0F, 0x80, 0x0F, 0x03, 0xE0, 0x3C, 0x00, 0x7C, 0x0F, 0x80,
  0xF0, 0x01, 0xE0, 0x3C, 0x07, 0xC0, 0x0F, 0x80, 0xF0, 0x1F, 0x00, 0x7C,
  0x03, 0xC0, 0x78, 0x01, 0xE0, 0x0F, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x7C, 0x01, 0xF0, 0x03, 0xE1, 0xE0, 0x07, 0x80,
  0x0F, 0xDF, 0x80, 0x3E, 0x00, 0x1F, 0xFC, 0x01, 0xF0, 0x00, 0x7F, 0xE0,
  0x0F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x3F,
  0x03, 0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x7E,
  0x03, 0xE0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x7C,
  0x07, 0xC0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x7C,
  0x1F, 0x80, 0x00, 0x7E, 0x1F, 0x00, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0x3E,
  0x7E, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xF7, 0xE0, 0x3F, 0x07, 0xE3,
  0xE0, 0x3E, 0x0F, 0xC3, 0xF0, 0x3E, 0x1F, 0x83, 0xF0, 0x7E, 0x1F, 0x01,
  0xF8, 0x7C, 0x3F, 0x01, 0xF8, 0xFC, 0x3E, 0x00, 0xFC, 0xF8, 0x7E, 0x00,
  0xFD, 0xF8, 0x7C, 0x00, 0x7D, 0xF0, 0x7C, 0x00, 0x7F, 0xE0, 0xFC, 0x00,
  0x3F, 0xE0, 0xFC, 0x00, 0x3F, 0xC0, 0xFC, 0x00, 0x3F, 0xC0, 0xFC, 0x00,
  0x3F, 0x80, 0xFC, 0x00, 0x7F, 0x80, 0x7C, 0x00, 0xFF, 0xC0, 0x7E, 0x01,
  0xFF, 0xC0, 0x7F, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0xE7, 0xE0, 0x3F, 0xFF,
  0xC3, 0xF0, 0x1F, 0xFF, 0x83, 0xF0, 0x07, 0xFE, 0x01, 0xF8, 0x00, 0xE0,
  0x00, 0x00, 0x3F, 0x3F, 0x3F, 0x3E, 0x3E, 0x3E, 0x7E, 0x7C, 0x7C, 0x7C,
  0x7C, 0x78, 0x78, 0xF8, 0xF0, 0xF0, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x08, 0x07, 0x80, 0x1C, 0x0F, 0x00, 0x7E, 0x1E, 0x00, 0xFF,
  0x38, 0x01, 0xFF, 0xF1, 0xF8, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xE0, 0x3F, 0x80, 0xC0, 0xFF, 0x00, 0x03, 0xEF, 0x00, 0x0F, 0x9E,
  0x00, 0x3F, 0x3E, 0x00, 0xFC, 0x3C, 0x03, 0xF0, 0x7C, 0x03, 0xC0, 0xF8,
  0x03, 0x80, 0xF8, 0x02, 0x01, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x3F, 0x07, 0xE0, 0x7E,
  0x07, 0xC0, 0xFC, 0x0F, 0x81, 0xF8, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0,
  0x7C, 0x07, 0x80, 0x78, 0x0F, 0x00, 0x7F, 0xFF, 0x7F, 0xFE, 0x7F, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFE, 0x1C, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x30,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFE, 0x3F, 0x80,
  0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x7E, 0x00,
  0xF8, 0x0F, 0x80, 0x1F, 0x03, 0xF0, 0x03, 0xF0, 0x7C, 0x00, 0x7E, 0x1F,
  0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x7C, 0x00, 0x3E, 0x1F, 0x80, 0x07,
  0xC3, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x1F, 0x80, 0x03, 0xE3, 0xF0,
  0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x8F, 0x80, 0x03, 0xF1, 0xF0, 0x00, 0x7E,
  0x7E, 0x00, 0x0F, 0x8F, 0xC0, 0x01, 0xF1, 0xF0, 0x00, 0x7E, 0x3E, 0x00,
  0x0F, 0xC7, 0xC0, 0x01, 0xF8, 0xF8, 0x00, 0x3E, 0x3F, 0x00, 0x0F, 0xC7,
  0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x3E, 0x1F, 0x80, 0x07, 0xC3, 0xE0, 0x01,
  0xF8, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0xC1, 0xF0, 0x01, 0xF8, 0x3E,
  0x00, 0x3E, 0x07, 0xE0, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x7C,
  0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x8F, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE0, 0x3F, 0xF0,
  0x3F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFE, 0x7F, 0xBE, 0x7F, 0x1F, 0x3F, 0x1F,
  0x8F, 0x0F, 0xC7, 0x07, 0xC1, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0,
  0x01, 0xFC, 0x1F, 0xE0, 0x03, 0xC0, 0x1F, 0x80, 0x0C, 0x00, 0x7E, 0x00,
  0x20, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00,
  0x7E, 0x07, 0xF8, 0x01, 0xC0, 0x0F, 0xC0, 0x08, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xFF,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x04, 0x00, 0x07,
  0xE0, 0x30, 0x00, 0x7F, 0x01, 0xF0, 0x1F, 0xF0, 0x0F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3D,
  0xF0, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x3C, 0xF8,
  0x00, 0x01, 0xF3, 0xE0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x7C, 0x7E, 0x00,
  0x01, 0xE1, 0xF0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x01,
  0xE0, 0x7C, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xE0,
  0x3E, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x7C, 0x07, 0xE0, 0x03, 0xE0, 0x1F,
  0x80, 0x0F, 0x80, 0x7C, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xFC, 0x03, 0xE0, 0x03, 0xE0, 0x0F,
  0x00, 0x0F, 0x80, 0x7F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x20, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x80, 0x00, 0xFE, 0x06, 0x00, 0x0F, 0xE0, 0x3E, 0x03, 0xFE, 0x01,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x3A, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0,
  0x01, 0xFE, 0x02, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x83, 0xC0,
  0x01, 0xF1, 0xFF, 0x80, 0x1F, 0x3F, 0xFC, 0x03, 0xF7, 0xFF, 0xE0, 0x3E,
  0xFF, 0xFE, 0x03, 0xFF, 0x07, 0xF0, 0x3F, 0xC0, 0x3F, 0x07, 0xF8, 0x03,
  0xF0, 0x7F, 0x00, 0x1F, 0x07, 0xE0, 0x01, 0xF0, 0x7E, 0x00, 0x1F, 0x07,
  0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0xFC, 0x00,
  0x1F, 0x0F, 0xC0, 0x01, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0,
  0xFC, 0x00, 0x3E, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x07, 0xC0,
  0x07, 0xC0, 0x7C, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x03, 0xF8,
  0x03, 0xF8, 0x7F, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xE0, 0x0F, 0xE0, 0x7F, 0x01, 0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x3F, 0x01,
  0xF0, 0x01, 0xF0, 0x3F, 0x00, 0x1F, 0x03, 0xF0, 0x01, 0xF0, 0x3E, 0x00,
  0x1F, 0x03, 0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x3F, 0x03, 0xF0, 0x03, 0xE0,
  0x3F, 0x00, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0xFC, 0x01, 0xF8,
  0x1F, 0x80, 0x0F, 0xC7, 0xF0, 0x00, 0x7E, 0xFE, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0x00, 0x07, 0xF9, 0xF8, 0x00, 0xFE, 0x0F, 0xC0, 0x1F, 0xC0, 0xFE,
  0x03, 0xF0, 0x07, 0xE0, 0x3E, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x7C,
  0x00, 0x1F, 0x0F, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x01,
  0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F,
  0x80, 0x03, 0xF0, 0xF8, 0x00, 0x3E, 0x0F, 0xC0, 0x07, 0xE0, 0xFE, 0x00,
  0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0x3F, 0x03, 0xF0, 0x07, 0xE0, 0xFC, 0x00, 0x7C, 0x1F, 0x80, 0x0F,
  0x83, 0xE0, 0x01, 0xF0, 0xFC, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0xC3, 0xE0,
  0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x1F, 0x80, 0x03, 0xE3, 0xF0, 0x00, 0xFC,
  0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0xFE, 0x3F, 0x00,
  0x1F, 0x87, 0xE0, 0x07, 0xF0, 0x7C, 0x01, 0xFE, 0x0F, 0xC0, 0x7F, 0xC1,
  0xFE, 0x3F, 0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xF7, 0xC0, 0x3F, 0xFC,
  0xF8, 0x03, 0xFE, 0x3F, 0x00, 0x04, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x60, 0x3F, 0xC0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x70, 0x03,
  0xE0, 0x1F, 0xC0, 0x7F, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0x7C, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x03, 0xFC, 0x07, 0xE0, 0x1F, 0x00,
  0x30, 0x00, 0x00, 0x0E, 0x00, 0x0F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0,
  0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x08, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xFF,
  0x80, 0x7F, 0xFF, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3E, 0x07, 0xF0,
  0x60, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xF7, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0x80, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x3E, 0x00, 0x08, 0x00, 0xF8, 0x1E, 0x00, 0x7F, 0xE0, 0x3C, 0x1F, 0x00,
  0xFF, 0xF8, 0x1E, 0x0F, 0x00, 0xFF, 0xFC, 0x0F, 0x0F, 0x00, 0xFC, 0x3C,
  0x07, 0x87, 0x80, 0xF8, 0x1E, 0x03, 0xC7, 0xC0, 0x78, 0x0F, 0x01, 0xE3,
  0xC0, 0x7C, 0x0F, 0x80, 0xF1, 0xE0, 0x7C, 0x07, 0x80, 0xF9, 0xE0, 0x3C,
  0x03, 0xC0, 0x78, 0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x78, 0x1E, 0x01, 0xF0,
  0x1E, 0x7C, 0x0F, 0x00, 0xF0, 0x0F, 0x3C, 0x0F, 0x80, 0x78, 0x0F, 0x9E,
  0x07, 0xC0, 0x7C, 0x07, 0x8F, 0x03, 0xC0, 0x3E, 0x03, 0xC7, 0x81, 0xE0,
  0x1E, 0x01, 0xE7, 0xC0, 0xF0, 0x0F, 0x01, 0xE3, 0xE0, 0x78, 0x0F, 0x80,
  0xF1, 0xE0, 0x7C, 0x07, 0xC0, 0xF8, 0xF0, 0x3E, 0x07, 0xE0, 0x78, 0x78,
  0x0F, 0x03, 0xF0, 0x78, 0x3C, 0x07, 0x83, 0xF8, 0x7C, 0x1E, 0x03, 0xE3,
  0xBE, 0x7C, 0x0F, 0x01, 0xFF, 0xCF, 0xFC, 0x07, 0x80, 0x7F, 0xC7, 0xFC,
  0x03, 0xE0, 0x1F, 0xC1, 0xFC, 0x01, 0xF0, 0x03, 0x00, 0x10, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x01, 0x80, 0x00, 0x07, 0xF8, 0x0F, 0xC0, 0x00, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x7D, 0xF0, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x0F, 0x9F, 0x00,
  0x00, 0x3E, 0x3C, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x07, 0xC3, 0xC0, 0x00,
  0x1F, 0x0F, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1F,
  0x83, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x03, 0xF0, 0x3E, 0x00, 0x0F, 0x80,
  0xF8, 0x00, 0x7E, 0x03, 0xE0, 0x01, 0xF0, 0x0F, 0x80, 0x07, 0xC0, 0x3E,
  0x00, 0x3F, 0x00, 0xF8, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0x80,
  0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x03, 0xF0, 0x00, 0xF8, 0x0F, 0xC0,
  0x03, 0xE0, 0x3E, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x3E, 0x07, 0xE0, 0x00,
  0xF8, 0x3F, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x3F,
  0x1F, 0x80, 0x00, 0xFC, 0xFC, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x0F, 0xDF,
  0x80, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F,
  0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0xF8,
  0x00, 0x7E, 0x01, 0xF0, 0x00, 0xFC, 0x03, 0xE0, 0x01, 0xF8, 0x0F, 0xC0,
  0x03, 0xF0, 0x1F, 0x80, 0x07, 0xE0, 0x3E, 0x00, 0x0F, 0x80, 0x7C, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x01, 0xF8, 0x07, 0xE0, 0x07,
  0xF0, 0x0F, 0x80, 0x1F, 0xC0, 0x1F, 0x00, 0xFF, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00,
  0x7C, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0xFC, 0x07,
  0xE0, 0x00, 0xF8, 0x0F, 0xC0, 0x01, 0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x3E,
  0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0x7E, 0x07, 0xC0, 0x01, 0xF8, 0x0F, 0x80, 0x03, 0xF0, 0x3F, 0x00,
  0x0F, 0xC0, 0x7E, 0x00, 0x3F, 0x80, 0xF8, 0x01, 0xFE, 0x01, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xC0, 0x07, 0xFC, 0x0F, 0x00, 0x1F, 0xE0, 0x04, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x20, 0x00, 0xFF, 0x07, 0xC0, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x1D, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x7C, 0x03, 0xFC, 0x00, 0xFC, 0x01, 0xFE, 0x00, 0xFC, 0x00, 0xFE,
  0x00, 0xF8, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x3F,
  0x01, 0xF8, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x3F,
  0x01, 0xF0, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x1F,
  0x03, 0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x3F,
  0x07, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x3F,
  0x07, 0xC0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0xFC,
  0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xF8,
  0x1F, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x03, 0xF0,
  0x3F, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x0F, 0xE0, 0x3E, 0x00, 0x1F, 0xC0,
  0x3E, 0x00, 0x3F, 0xC0, 0x7E, 0x00, 0x7F, 0x80, 0x7E, 0x00, 0xFF, 0x00,
  0x7C, 0x07, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFC, 0x0F, 0xE0, 0x07, 0xF8, 0x00, 0x70,
  0x03, 0xFC, 0x00, 0x04, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xF8,
  0x7E, 0x00, 0x3F, 0xFC, 0x1F, 0x00, 0x0F, 0xFF, 0x0F, 0xC0, 0x07, 0xFF,
  0xC3, 0xF0, 0x01, 0xFF, 0xF0, 0xFC, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00,
  0x3E, 0x0F, 0xC0, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x07, 0xE0, 0xFC, 0x00,
  0x01, 0xF8, 0x3F, 0x00, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x1F, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0xF8, 0x07,
  0xE0, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x7F, 0x00, 0x07, 0xE0,
  0x0F, 0xE0, 0x01, 0xF8, 0x03, 0xFC, 0x00, 0x7C, 0x00, 0x7F, 0xC0, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x03,
  0xE0, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x07, 0xC0,
  0x00, 0x7E, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x0F, 0xC0, 0x00, 0x7C, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x0F,
  0xC0, 0x1F, 0x80, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x1F, 0x00,
  0x00, 0xF8, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0x01, 0xF8, 0x03,
  0xF0, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x3F,
  0x00, 0x3E, 0x00, 0x03, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFE, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x0F, 0xC0, 0x00, 0x7C,
  0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0xF8, 0x00,
  0x0F, 0xC0, 0x1F, 0x80, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x1F,
  0x00, 0x01, 0xF8, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x01, 0xF8,
  0x03, 0xF0, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00,
  0x3F, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x7E,
  0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x07, 0xE0,
  0x07, 0xC0, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x0F, 0xC0, 0x00,
  0x7C, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x06,
  0x3F, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0xC0,
  0x1F, 0x80, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xFC,
  0x00, 0x7C, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x1F,
  0x80, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0xF8, 0x07, 0xF0, 0x00, 0x3E, 0x01,
  0xF8, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x01, 0xF8,
  0x3F, 0x80, 0x00, 0x7C, 0x1F, 0xC0, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x00, 0xF8, 0xFE, 0x00, 0x00,
  0x3E, 0x3F, 0x00, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7D, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0x3E,
  0x00, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x1F,
  0x01, 0xF8, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x03, 0xF0, 0x0F, 0x80, 0x00,
  0xFC, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x1F, 0x00,
  0x03, 0xE0, 0x07, 0xE0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xF0, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x0F, 0x80,
  0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00,
  0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0xFF, 0xC0, 0x00, 0x3E, 0xF8, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF0,
  0x03, 0xDF, 0x00, 0x01, 0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0x03, 0xEF, 0x80,
  0x1F, 0x7C, 0x00, 0x0F, 0x9F, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0x7E, 0x00,
  0x7D, 0xF0, 0x00, 0x7C, 0xFC, 0x01, 0xF9, 0xE0, 0x00, 0xF9, 0xF0, 0x03,
  0xE3, 0xC0, 0x03, 0xF3, 0xE0, 0x07, 0xC7, 0xC0, 0x07, 0xCF, 0xC0, 0x0F,
  0x8F, 0x80, 0x1F, 0x9F, 0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x7E,
  0x3E, 0x00, 0xFC, 0x7C, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0xF8, 0x01, 0xF0,
  0xF8, 0x03, 0xE3, 0xF0, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xE0, 0x07, 0xC3,
  0xE0, 0x1F, 0x0F, 0x80, 0x1F, 0x87, 0xC0, 0x7C, 0x1F, 0x00, 0x3E, 0x0F,
  0x80, 0xF8, 0x3E, 0x00, 0x7C, 0x1F, 0x03, 0xE0, 0xFC, 0x00, 0xF8, 0x3E,
  0x07, 0xC1, 0xF8, 0x03, 0xF0, 0x7C, 0x1F, 0x03, 0xE0, 0x07, 0xC0, 0x78,
  0x3E, 0x07, 0xC0, 0x0F, 0x80, 0xF0, 0xF8, 0x1F, 0x80, 0x1F, 0x01, 0xE1,
  0xF0, 0x3F, 0x00, 0x3E, 0x03, 0xC7, 0xC0, 0x7E, 0x00, 0xFC, 0x07, 0xCF,
  0x80, 0xF8, 0x01, 0xF0, 0x0F, 0xBE, 0x01, 0xF0, 0x03, 0xE0, 0x1F, 0x7C,
  0x07, 0xE0, 0x07, 0xC0, 0x3F, 0xF0, 0x0F, 0xC0, 0x0F, 0x80, 0x7F, 0xE0,
  0x1F, 0x00, 0x3F, 0x00, 0xFF, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xFF, 0x00,
  0x7C, 0x00, 0xF8, 0x03, 0xFC, 0x01, 0xF8, 0x01, 0xF0, 0x07, 0xF8, 0x03,
  0xF0, 0x03, 0xE0, 0x0F, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0x03, 0xF0,
  0x07, 0xF8, 0x00, 0x0F, 0x80, 0x1F, 0xE0, 0x00, 0x3E, 0x00, 0x7F, 0x80,
  0x00, 0xF8, 0x01, 0xFE, 0x00, 0x07, 0xE0, 0x0F, 0xFC, 0x00, 0x1F, 0x00,
  0x3F, 0xF0, 0x00, 0x7C, 0x00, 0xFF, 0xC0, 0x01, 0xF0, 0x03, 0xFF, 0x00,
  0x07, 0xC0, 0x0F, 0x7C, 0x00, 0x3F, 0x00, 0x7C, 0xF8, 0x00, 0xF8, 0x01,
  0xF3, 0xE0, 0x03, 0xE0, 0x07, 0xCF, 0x80, 0x0F, 0x80, 0x1F, 0x3E, 0x00,
  0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xF8, 0x03, 0xE1, 0xF0, 0x07, 0xC0, 0x0F,
  0x87, 0xC0, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x7E, 0x03,
  0xF0, 0x07, 0xE0, 0xF8, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x3E, 0x00, 0x7C,
  0x0F, 0x80, 0xF8, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x07, 0xC0, 0x7C, 0x1F,
  0x80, 0x3F, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x07, 0xC1, 0xF0, 0x03, 0xE0,
  0x1F, 0x07, 0xC0, 0x0F, 0x80, 0x7E, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0xFC,
  0x01, 0xF8, 0x03, 0xE3, 0xE0, 0x07, 0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x00,
  0x3E, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0xF8, 0x03, 0xF0, 0x01, 0xF7, 0xE0,
  0x0F, 0x80, 0x07, 0xDF, 0x00, 0x3E, 0x00, 0x1F, 0x7C, 0x00, 0xF8, 0x00,
  0x3F, 0xF0, 0x03, 0xE0, 0x00, 0xFF, 0xC0, 0x1F, 0x80, 0x03, 0xFE, 0x00,
  0x7C, 0x00, 0x0F, 0xF8, 0x01, 0xF0, 0x00, 0x3F, 0xE0, 0x07, 0xC0, 0x00,
  0x7F, 0x80, 0x1F, 0x00, 0x01, 0xFE, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x03,
  0xE0, 0x00, 0x1F, 0xC0, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFE, 0x0F, 0xF0, 0x03,
  0xFC, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x3F, 0x01,
  0xFC, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x03, 0xF0,
  0x7E, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x7E,
  0x3F, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x0F,
  0xCF, 0xC0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x01,
  0xFB, 0xF0, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x00,
  0x7E, 0x7E, 0x00, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0x1F, 0x9F, 0x00, 0x00,
  0x0F, 0xDF, 0x80, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x07, 0xE7, 0xE0, 0x00,
  0x03, 0xF3, 0xF0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x01, 0xF8, 0xFC, 0x00,
  0x00, 0xFC, 0x7E, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x7E, 0x1F, 0x80,
  0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0x1F, 0x80, 0xFC, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x1F, 0xC0, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x1F, 0xC0, 0x07, 0xFC, 0x7F, 0xE0, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xF0, 0x1F, 0xE0, 0x0F, 0xC0, 0x3F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0xFC, 0x03, 0xE0, 0x03, 0xF0, 0x0F,
  0x80, 0x0F, 0xC0, 0x7E, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0xFC, 0x07, 0xC0,
  0x03, 0xF0, 0x1F, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x3E, 0x03, 0xF0, 0x01,
  0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0x3E, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0xFC,
  0x07, 0xE0, 0x07, 0xF0, 0x1F, 0x80, 0x3F, 0x80, 0x7C, 0x03, 0xFC, 0x01,
  0xF0, 0x7F, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x03, 0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x03, 0xF8, 0x01,
  0xF8, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01, 0xF8,
  0x7E, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x3F,
  0x1F, 0x80, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x07,
  0xE7, 0xE0, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00,
  0xF9, 0xF8, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00,
  0x3F, 0x3E, 0x00, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00,
  0x07, 0xCF, 0xC0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x03, 0xF3, 0xF0, 0x00,
  0x01, 0xF9, 0xF8, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0xFC, 0x7E, 0x00,
  0x00, 0x7E, 0x3F, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x3F, 0x0F, 0xC0,
  0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x1F, 0x80, 0xFC,
  0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x1F, 0xE0, 0x07, 0xFC, 0x7F, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xF0, 0x1F, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0xFC, 0x03, 0xE0, 0x03, 0xF0,
  0x0F, 0x80, 0x0F, 0xC0, 0x7E, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0xFC, 0x07,
  0xC0, 0x03, 0xF0, 0x1F, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x3E, 0x03, 0xF0,
  0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0x3E, 0x00, 0x3F, 0x00, 0xF8, 0x01,
  0xFC, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0x80, 0x7F, 0x00, 0x7C, 0x0F, 0xFC,
  0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x7E,
  0x07, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0x7E, 0x00, 0x1F, 0x01,
  0xF8, 0x00, 0x7C, 0x03, 0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x0F, 0xC0, 0x3F,
  0x00, 0x3F, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xE0,
  0x1F, 0x80, 0x1F, 0x80, 0x7E, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0xF8, 0x07,
  0xC0, 0x03, 0xF0, 0x1F, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0xFC, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xF8, 0x01, 0xFF, 0x07, 0xE0, 0x0F, 0xF0, 0x03, 0x00, 0x3F, 0x00,
  0x04, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7F, 0x01, 0x00, 0x03, 0xF8, 0x07, 0x00, 0x1F, 0xE0,
  0x1F, 0xE7, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x7E, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00,
  0x7E, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x07, 0xC0, 0x3E, 0x00,
  0x01, 0xF0, 0x0F, 0x80, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x3F, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0xF8, 0x07,
  0xC0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x07, 0xE0,
  0x3F, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x3F,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00,
  0xF8, 0x07, 0xC0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0x07, 0xE0, 0x3F, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x7C, 0x03, 0xE0,
  0x00, 0x3F, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x03, 0xF0, 0x1F,
  0x80, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x7C,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x3F, 0x00, 0x07,
  0xE0, 0x0F, 0xC0, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x07, 0xFC, 0x7F, 0xC0, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x07, 0xEF, 0x80,
  0x00, 0x7E, 0x7C, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x3F, 0x1F, 0x80, 0x01,
  0xF8, 0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xC1,
  0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xE0, 0x7E, 0x00, 0x3F, 0x03, 0xF0,
  0x01, 0xF8, 0x1F, 0x80, 0x1F, 0x80, 0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x0F,
  0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x3F, 0x00,
  0x3E, 0x01, 0xF0, 0x01, 0xF0, 0x1F, 0x80, 0x0F, 0x80, 0xF8, 0x00, 0x7C,
  0x0F, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0xF8, 0x3F,
  0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3E, 0x1F, 0x80, 0x01, 0xF0, 0xF8, 0x00,
  0x0F, 0x8F, 0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x1F,
  0x3E, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x3E, 0xF8,
  0x00, 0x01, 0xF7, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0xFC, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0xF8, 0x00,
  0x1F, 0xC0, 0x01, 0xFB, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xCF, 0x80, 0x03,
  0xFC, 0x00, 0x3F, 0x3E, 0x00, 0x0F, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x7F,
  0xC0, 0x07, 0xE3, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0x8F, 0x80, 0x0F, 0xFC,
  0x00, 0x7C, 0x3E, 0x00, 0x3F, 0xF0, 0x03, 0xF0, 0xF8, 0x01, 0xF7, 0xC0,
  0x0F, 0x83, 0xE0, 0x07, 0xDF, 0x00, 0x7E, 0x0F, 0x80, 0x1E, 0x7C, 0x01,
  0xF0, 0x3E, 0x00, 0xF9, 0xF0, 0x0F, 0xC0, 0xF8, 0x03, 0xE7, 0xC0, 0x3F,
  0x03, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x7C, 0x07, 0xE0,
  0x3E, 0x01, 0xE1, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0x87, 0xC0, 0xFC, 0x03,
  0xE0, 0x3E, 0x1F, 0x03, 0xF0, 0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0x80, 0x3E,
  0x07, 0xC1, 0xF0, 0x7E, 0x00, 0xF8, 0x1E, 0x07, 0xC1, 0xF0, 0x03, 0xE0,
  0xF8, 0x1F, 0x0F, 0xC0, 0x0F, 0x83, 0xE0, 0x7C, 0x3E, 0x00, 0x3E, 0x1F,
  0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x07, 0xC7, 0xE0, 0x03, 0xE3, 0xE0,
  0x1F, 0x1F, 0x00, 0x0F, 0x8F, 0x80, 0x7C, 0x7C, 0x00, 0x3E, 0x3C, 0x01,
  0xF3, 0xE0, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x03, 0xE7, 0xC0, 0x1F,
  0x7E, 0x00, 0x0F, 0xBE, 0x00, 0x79, 0xF0, 0x00, 0x3E, 0xF8, 0x01, 0xE7,
  0xC0, 0x00, 0xFB, 0xC0, 0x07, 0xBE, 0x00, 0x03, 0xFF, 0x00, 0x1E, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x7B, 0xE0, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x07, 0xC0,
  0x1F, 0x00, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x00,
  0x7E, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x3E, 0x0F, 0x80,
  0x00, 0x03, 0xE1, 0xF8, 0x00, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0x03, 0xF3,
  0xE0, 0x00, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x0F, 0xBE, 0x00, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x1F, 0x3F,
  0x00, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x00, 0x7E, 0x1F, 0x00, 0x00, 0x07,
  0xC1, 0xF0, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x01, 0xF8, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x0F,
  0x80, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0xF8,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xEF, 0xC0, 0x01, 0xFB,
  0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x3F, 0x1F, 0x00, 0x1F, 0x87, 0xC0, 0x07,
  0xE1, 0xF0, 0x03, 0xF0, 0x7C, 0x00, 0xF8, 0x1F, 0x80, 0x7E, 0x07, 0xE0,
  0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0x3E, 0x07, 0xE0, 0x0F, 0x81, 0xF8, 0x03,
  0xE0, 0xFC, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x1F, 0x80, 0x0F, 0xC7, 0xC0,
  0x01, 0xF3, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x7E, 0x00, 0x07, 0xDF,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x07,
  0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF,
  0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x80, 0xF0, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x01, 0xE0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x80,
  0xF0, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x01, 0xE0, 0x3E, 0x07,
  0xC0, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF,
  0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x3E, 0x7C, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x07,
  0x83, 0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x03, 0xE0, 0x01, 0xF0, 0x1F,
  0x00, 0x3E, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x00, 0xF8, 0x07,
  0xC0, 0x0F, 0x80, 0xF8, 0x00, 0x78, 0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x00,
  0x7C, 0x3E, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xEF,
  0xC0, 0x00, 0x1F, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xE0, 0xFC, 0x7E, 0x1F, 0x8F, 0xC3, 0xE0, 0xF8, 0x7C, 0x1E,
  0x07, 0x83, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFF, 0x0F, 0x00, 0x7F,
  0xF9, 0xF0, 0x0F, 0xFF, 0x9F, 0x01, 0xFF, 0xFD, 0xF0, 0x3F, 0x81, 0xFE,
  0x07, 0xF0, 0x1F, 0xE0, 0x7E, 0x00, 0xFE, 0x0F, 0xC0, 0x0F, 0xE0, 0xFC,
  0x00, 0xFC, 0x1F, 0x80, 0x0F, 0xC1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0xFC, 0x3E, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0xF8, 0x7E,
  0x00, 0x0F, 0x87, 0xE0, 0x01, 0xF8, 0x7C, 0x00, 0x1F, 0x87, 0xC0, 0x01,
  0xF0, 0x7C, 0x00, 0x1F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F,
  0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00,
  0xFE, 0x0F, 0xC0, 0x0F, 0xE0, 0xFC, 0x01, 0xFC, 0x0F, 0xC0, 0x3F, 0xC0,
  0x7E, 0x07, 0xFC, 0x07, 0xF0, 0xF7, 0xC0, 0x7F, 0xFE, 0x7C, 0x03, 0xFF,
  0xE7, 0x80, 0x1F, 0xF8, 0x78, 0x00, 0xFF, 0x07, 0x80, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x1F, 0x1F, 0xF8, 0x01, 0xF3, 0xFF,
  0xC0, 0x3F, 0x7F, 0xFC, 0x03, 0xEF, 0xFF, 0xE0, 0x3F, 0xE0, 0x7E, 0x03,
  0xFC, 0x03, 0xE0, 0x3F, 0x80, 0x3F, 0x07, 0xF8, 0x03, 0xF0, 0x7F, 0x00,
  0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0,
  0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0xF8, 0x00, 0x3E, 0x0F, 0x80,
  0x03, 0xE1, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x7E,
  0x1F, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x7C, 0x3F, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0xFC, 0x3F, 0x00, 0x0F, 0x83, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x1F,
  0x07, 0xF0, 0x03, 0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xE0, 0x7F,
  0x80, 0xFC, 0x0F, 0xBC, 0x3F, 0xC0, 0xFB, 0xFF, 0xF8, 0x0F, 0x9F, 0xFF,
  0x00, 0xF1, 0xFF, 0xE0, 0x0F, 0x07, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0xC0, 0x7F, 0x01, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x80, 0x20, 0x3F, 0x81, 0xC0, 0x3F, 0xFF, 0x80, 0x7F,
  0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x1F, 0xF8,
  0xF8, 0x00, 0x7F, 0xF9, 0xF0, 0x01, 0xFF, 0xF3, 0xE0, 0x07, 0xFF, 0xFF,
  0x80, 0x1F, 0xC0, 0xFF, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0xFC, 0x01, 0xFC,
  0x03, 0xF0, 0x03, 0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x1F, 0x80, 0x0F, 0xC0,
  0x3F, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x7E, 0x03,
  0xE0, 0x00, 0xF8, 0x0F, 0xC0, 0x01, 0xF0, 0x1F, 0x80, 0x03, 0xE0, 0x3F,
  0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x3E, 0x03, 0xF0,
  0x00, 0x7C, 0x07, 0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0x80,
  0x07, 0xC0, 0x3F, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x3F, 0x00, 0xFC, 0x00,
  0xFE, 0x01, 0xF8, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x1F,
  0xE0, 0x0F, 0xE0, 0x7F, 0xC0, 0x0F, 0xC1, 0xEF, 0x80, 0x1F, 0xFF, 0x9F,
  0x00, 0x1F, 0xFE, 0x3C, 0x00, 0x1F, 0xF8, 0x78, 0x00, 0x1F, 0xE1, 0xF0,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xFE, 0x00, 0xFF, 0xFE, 0x01, 0xFE, 0xFF, 0x03, 0xF0, 0x3F, 0x07,
  0xE0, 0x1F, 0x07, 0xC0, 0x1F, 0x0F, 0xC0, 0x1F, 0x1F, 0x80, 0x1F, 0x1F,
  0x80, 0x1F, 0x1F, 0x00, 0x3F, 0x3F, 0x00, 0x7E, 0x3E, 0x00, 0xFE, 0x3E,
  0x01, 0xFC, 0x7E, 0x0F, 0xF8, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F,
  0xFF, 0x80, 0xFF, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E,
  0x00, 0x20, 0x7F, 0x00, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x01, 0xFC, 0x20, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x40, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xFC,
  0x3C, 0x00, 0x3F, 0xFC, 0xF8, 0x00, 0xFF, 0xF9, 0xF0, 0x03, 0xFF, 0xFB,
  0xC0, 0x0F, 0xE0, 0x7F, 0x80, 0x3F, 0x80, 0xFF, 0x00, 0x7E, 0x00, 0xFE,
  0x01, 0xF8, 0x01, 0xFC, 0x03, 0xF0, 0x03, 0xF0, 0x0F, 0xC0, 0x07, 0xE0,
  0x1F, 0x80, 0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x3F, 0x01,
  0xF0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0xF8, 0x0F, 0xC0, 0x01, 0xF0, 0x1F,
  0x80, 0x07, 0xE0, 0x3E, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x1F, 0x01, 0xF8,
  0x00, 0x3E, 0x03, 0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x01, 0xF8, 0x0F, 0xC0,
  0x03, 0xE0, 0x1F, 0x80, 0x0F, 0xC0, 0x3F, 0x00, 0x1F, 0x80, 0x7E, 0x00,
  0x7F, 0x00, 0xFC, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x0F,
  0xF0, 0x07, 0xE0, 0x3F, 0xE0, 0x07, 0xE0, 0xF7, 0xC0, 0x0F, 0xFF, 0xDF,
  0x80, 0x0F, 0xFF, 0xBE, 0x00, 0x1F, 0xFC, 0x7C, 0x00, 0x0F, 0xF0, 0xF8,
  0x00, 0x07, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x18,
  0x00, 0x7F, 0x00, 0x3C, 0x01, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7C, 0x1F, 0x80, 0x0F, 0x8F, 0xFC, 0x01, 0xF3, 0xFF,
  0xC0, 0x7E, 0xFF, 0xF8, 0x0F, 0xBF, 0xFF, 0x81, 0xFF, 0x03, 0xF0, 0x3F,
  0xC0, 0x7E, 0x07, 0xF0, 0x07, 0xC1, 0xFC, 0x00, 0xF8, 0x3F, 0x80, 0x1F,
  0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x07, 0xE0,
  0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x83, 0xE0, 0x03, 0xF0,
  0xFC, 0x00, 0x7C, 0x1F, 0x80, 0x0F, 0x83, 0xE0, 0x01, 0xF0, 0x7C, 0x00,
  0x7E, 0x0F, 0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xF0, 0x7E, 0x00, 0x3E, 0x0F,
  0x80, 0x07, 0xC1, 0xF0, 0x01, 0xF8, 0x3E, 0x00, 0x3E, 0x0F, 0xC0, 0x07,
  0xC1, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x3F, 0x07, 0xC0, 0x07, 0xE1, 0xF8,
  0x00, 0xF8, 0x3F, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0xFC,
  0x1F, 0x00, 0x1F, 0x80, 0x00, 0x18, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x10, 0x1F, 0x00, 0x7E, 0x01,
  0xF0, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x3E, 0x03,
  0xF0, 0x03, 0xE0, 0x7E, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0xE0, 0xFC, 0x00,
  0x7C, 0x1F, 0x80, 0x07, 0xC3, 0xF0, 0x00, 0x7C, 0x7E, 0x00, 0x07, 0xCF,
  0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0xFB, 0xF0, 0x00,
  0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFE,
  0xF8, 0x00, 0x1F, 0xCF, 0x80, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x0F, 0xC0,
  0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x07, 0xE0, 0x03, 0xE0, 0x7E, 0x00, 0x3E,
  0x03, 0xE0, 0x07, 0xE0, 0x3E, 0x00, 0x7C, 0x03, 0xF0, 0x07, 0xC0, 0x3F,
  0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0xFC, 0x01, 0xF8, 0x0F,
  0x80, 0x1F, 0x80, 0xF8, 0x00, 0xF8, 0x0F, 0x80, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x78, 0x7F, 0xC0, 0xFF,
  0xC0, 0x1E, 0x3F, 0xF8, 0x7F, 0xF8, 0x0F, 0x9F, 0xFF, 0x3F, 0xFF, 0x03,
  0xEF, 0xFF, 0xDF, 0xFF, 0xC0, 0xFF, 0x83, 0xFF, 0x83, 0xF0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFC, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xC1, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x7E, 0x00, 0x7E, 0x00, 0x7C,
  0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC3, 0xF0,
  0x03, 0xF0, 0x03, 0xE0, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x87, 0xE0, 0x07, 0xE0, 0x07,
  0xE1, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC3, 0xF0, 0x03,
  0xF0, 0x03, 0xE0, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x03, 0xE0, 0x07, 0xE1,
  0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC3, 0xF0, 0x01, 0xF0,
  0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x0F, 0x0F, 0xFC, 0x00, 0xF1, 0xFF, 0xE0, 0x1F, 0x3F,
  0xFE, 0x01, 0xF7, 0xFF, 0xF0, 0x1F, 0xF8, 0x3F, 0x01, 0xFE, 0x03, 0xF0,
  0x3F, 0xC0, 0x1F, 0x03, 0xF8, 0x01, 0xF0, 0x3F, 0x80, 0x3F, 0x03, 0xF0,
  0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xE0, 0x7E, 0x00, 0x3E,
  0x07, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x7E, 0x07, 0xC0, 0x07, 0xE0, 0xFC,
  0x00, 0x7C, 0x0F, 0xC0, 0x07, 0xC0, 0xF8, 0x00, 0x7C, 0x0F, 0x80, 0x0F,
  0xC1, 0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0x81, 0xF8, 0x00, 0xF8, 0x1F,
  0x00, 0x1F, 0x81, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0x83, 0xF0, 0x01,
  0xF0, 0x3F, 0x00, 0x1F, 0x03, 0xE0, 0x03, 0xF0, 0x3E, 0x00, 0x3F, 0x07,
  0xE0, 0x03, 0xE0, 0x7E, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00,
  0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xFF, 0x00,
  0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xFE, 0x0F,
  0xE0, 0x7E, 0x01, 0xF8, 0x1F, 0x00, 0x3E, 0x0F, 0xC0, 0x0F, 0xC3, 0xE0,
  0x03, 0xF1, 0xF8, 0x00, 0xFC, 0x7C, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xCF,
  0x80, 0x03, 0xF3, 0xE0, 0x00, 0xFD, 0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x0F,
  0xDF, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0xF9, 0xF0, 0x00, 0x7E, 0xFC, 0x00,
  0x1F, 0xBF, 0x00, 0x07, 0xEF, 0xC0, 0x01, 0xF3, 0xF0, 0x00, 0xFC, 0xF8,
  0x00, 0x3F, 0x3E, 0x00, 0x0F, 0x8F, 0xC0, 0x07, 0xE3, 0xF0, 0x01, 0xF0,
  0xFC, 0x00, 0xFC, 0x1F, 0x00, 0x7E, 0x07, 0xE0, 0x3F, 0x81, 0xFC, 0x1F,
  0xC0, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x1E,
  0x1F, 0xF8, 0x00, 0x1E, 0x3F, 0xFC, 0x00, 0x3E, 0x7F, 0xFC, 0x00, 0x3E,
  0xFD, 0xFE, 0x00, 0x3F, 0xE0, 0x7E, 0x00, 0x3F, 0xC0, 0x3E, 0x00, 0x3F,
  0x80, 0x3F, 0x00, 0x7F, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0xF8,
  0x00, 0x3E, 0x01, 0xF8, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x7E, 0x01, 0xF0,
  0x00, 0x7E, 0x01, 0xF0, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x7C, 0x03, 0xF0,
  0x00, 0xFC, 0x03, 0xF0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0xF8, 0x03, 0xF0,
  0x01, 0xF8, 0x03, 0xF0, 0x01, 0xF0, 0x07, 0xF0, 0x03, 0xF0, 0x07, 0xF0,
  0x03, 0xE0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xF8, 0x0F, 0xC0, 0x07, 0xFC,
  0x3F, 0xC0, 0x0F, 0xBF, 0xFF, 0x80, 0x0F, 0x9F, 0xFF, 0x00, 0x0F, 0x8F,
  0xFE, 0x00, 0x0F, 0x87, 0xF8, 0x00, 0x1F, 0x81, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xFF, 0x0F, 0x00, 0x7F, 0xF9, 0xF0, 0x0F, 0xFF, 0x9F,
  0x01, 0xFF, 0xFD, 0xE0, 0x3F, 0x81, 0xFE, 0x07, 0xF0, 0x1F, 0xE0, 0x7E,
  0x00, 0xFE, 0x0F, 0xC0, 0x0F, 0xE0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x0F,
  0xC1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x3E,
  0x00, 0x0F, 0x87, 0xE0, 0x00, 0xF8, 0x7E, 0x00, 0x0F, 0x87, 0xE0, 0x01,
  0xF8, 0x7C, 0x00, 0x1F, 0x87, 0xC0, 0x01, 0xF0, 0xFC, 0x00, 0x1F, 0x0F,
  0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xE0, 0xFC, 0x00,
  0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0xFE, 0x0F, 0xC0, 0x0F, 0xE0,
  0xFC, 0x01, 0xFC, 0x0F, 0xC0, 0x3F, 0xC0, 0xFE, 0x07, 0xFC, 0x07, 0xE0,
  0xF7, 0xC0, 0x7F, 0xFE, 0xFC, 0x03, 0xFF, 0xCF, 0x80, 0x3F, 0xF8, 0xF8,
  0x00, 0xFF, 0x0F, 0x80, 0x03, 0x81, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7C, 0x07, 0x87, 0xF0, 0x1E, 0x3F, 0xC0, 0xF9, 0xFF, 0x03,
  0xEF, 0xF8, 0x0F, 0xFE, 0x20, 0x3F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF0, 0x7F, 0xDF, 0xC0, 0xFC, 0x03, 0x83, 0xF0, 0x01, 0x07,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x20, 0x03, 0xF0, 0x78, 0x1F, 0xE0, 0xFF,
  0xFF, 0x81, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x81, 0x0F, 0xFF, 0x8F, 0xFF,
  0xE3, 0xFF, 0xF9, 0xFF, 0xFE, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F,
  0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC1, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8,
  0x03, 0xFE, 0x00, 0x1C, 0x00, 0x03, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x3E,
  0x07, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0xE0, 0x7C,
  0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xC0, 0xFC, 0x00, 0x7C, 0x0F, 0x80, 0x07,
  0xC0, 0xF8, 0x00, 0xFC, 0x0F, 0x80, 0x0F, 0x81, 0xF8, 0x00, 0xF8, 0x1F,
  0x00, 0x0F, 0x81, 0xF0, 0x01, 0xF8, 0x1F, 0x00, 0x1F, 0x83, 0xF0, 0x01,
  0xF0, 0x3F, 0x00, 0x1F, 0x03, 0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x3F, 0x03,
  0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x3E, 0x07, 0xE0, 0x03, 0xE0, 0x7C, 0x00,
  0x7E, 0x07, 0xC0, 0x07, 0xE0, 0x7C, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xC0,
  0xFC, 0x01, 0xFC, 0x0F, 0xC0, 0x1F, 0xC0, 0xFC, 0x03, 0xFC, 0x0F, 0xC0,
  0x7F, 0x80, 0xFE, 0x1F, 0xF8, 0x07, 0xFF, 0xEF, 0x80, 0x7F, 0xFC, 0xF8,
  0x03, 0xFF, 0x8F, 0x80, 0x1F, 0xF0, 0xF0, 0x00, 0x38, 0x00, 0x00, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x7C, 0xF8,
  0x00, 0xFC, 0xF8, 0x00, 0xF8, 0xF8, 0x01, 0xF8, 0xF8, 0x01, 0xF0, 0xF8,
  0x03, 0xF0, 0xF8, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x07, 0xE0, 0xF8,
  0x07, 0xC0, 0xF8, 0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x1F, 0x80, 0xF8,
  0x1F, 0x00, 0x78, 0x3F, 0x00, 0x78, 0x3E, 0x00, 0x7C, 0x7E, 0x00, 0x7C,
  0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7D,
  0xF0, 0x00, 0x7D, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xF8, 0x00, 0xFC, 0x00,
  0x7F, 0xE0, 0x07, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xC0, 0x0F, 0xBE, 0x00,
  0x7F, 0x00, 0x7E, 0xF8, 0x03, 0xFC, 0x01, 0xF3, 0xE0, 0x0F, 0xF0, 0x07,
  0xCF, 0x80, 0x7F, 0xC0, 0x3E, 0x3E, 0x01, 0xEF, 0x00, 0xF8, 0xF8, 0x0F,
  0xBC, 0x07, 0xE3, 0xE0, 0x3C, 0xF0, 0x1F, 0x0F, 0x80, 0xF3, 0xC0, 0x7C,
  0x3E, 0x07, 0xCF, 0x03, 0xE0, 0xF8, 0x1E, 0x3C, 0x0F, 0x83, 0xE0, 0xF8,
  0xF0, 0x7E, 0x0F, 0x83, 0xC3, 0xC1, 0xF0, 0x3E, 0x0F, 0x0F, 0x07, 0xC0,
  0xF8, 0x7C, 0x3C, 0x3E, 0x03, 0xE1, 0xE1, 0xF0, 0xF8, 0x0F, 0x8F, 0x87,
  0xC7, 0xC0, 0x3E, 0x3C, 0x1F, 0x1F, 0x00, 0xF8, 0xF0, 0x7C, 0x7C, 0x03,
  0xE7, 0xC1, 0xF3, 0xE0, 0x0F, 0x9E, 0x07, 0xCF, 0x80, 0x3E, 0xF8, 0x1F,
  0x7C, 0x00, 0xFB, 0xC0, 0x7D, 0xF0, 0x03, 0xEF, 0x01, 0xF7, 0xC0, 0x0F,
  0xFC, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0xFE, 0x00,
  0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x07, 0xE0, 0x03, 0xE0, 0x1F, 0x80, 0x07,
  0xE0, 0x3E, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x1F,
  0x07, 0xC0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x7C,
  0xF8, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0x7C, 0x00,
  0x00, 0x7C, 0xFC, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x03, 0xE1, 0xF0, 0x00,
  0x0F, 0xC3, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7C, 0x07, 0xC0, 0x01,
  0xF8, 0x0F, 0x80, 0x07, 0xE0, 0x1F, 0x80, 0x0F, 0x80, 0x3F, 0x00, 0x3F,
  0x00, 0x3E, 0x00, 0xFC, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x00,
  0x3E, 0x00, 0x0F, 0xC0, 0x0F, 0x80, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF8,
  0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F,
  0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x7C,
  0x07, 0xE0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x01,
  0xF0, 0x3E, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x1F, 0x07, 0xC0, 0x00,
  0x07, 0xC1, 0xF0, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x00, 0x7C, 0x3E, 0x00,
  0x00, 0x1F, 0x1F, 0x80, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x01, 0xF3, 0xF0,
  0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x03, 0xDF,
  0x00, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x23, 0xFE, 0x00,
  0x04, 0xFF, 0xF0, 0x01, 0xBF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xF6, 0x00, 0x1F, 0xFC, 0x80, 0x00, 0x7C,
  0x00,
};

const GFXglyph NotoSans_Condensed_Italic66pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 16, 48, 16, 1, -47 },
  { 97, 19, 17, 23, 7, -47 },
  { 138, 33, 47, 32, 1, -47 },
  { 332, 28, 54, 29, 1, -50 },
  { 521, 38, 49, 44, 4, -48 },
  { 754, 32, 49, 33, 0, -48 },
  { 950, 8, 17, 13, 7, -47 },
  { 967, 20, 57, 18, 2, -47 },
  { 1110, 21, 57, 18, -5, -47 },
  { 1260, 23, 24, 28, 7, -50 },
  { 1329, 27, 31, 31, 3, -39 },
  { 1434, 12, 16, 14, -3, -7 },
  { 1458, 16, 5, 18, 1, -20 },
  { 1468, 7, 9, 14, 1, -8 },
  { 1476, 31, 47, 23, -3, -47 },
  { 1659, 27, 49, 29, 2, -48 },
  { 1825, 17, 47, 29, 8, -47 },
  { 1925, 30, 48, 29, -1, -48 },
  { 2105, 29, 49, 29, 0, -48 },
  { 2283, 30, 47, 29, -1, -47 },
  { 2460, 29, 48, 29, 0, -47 },
  { 2634, 28, 49, 29, 2, -48 },
  { 2806, 28, 47, 29, 3, -47 },
  { 2971, 28, 49, 29, 1, -48 },
  { 3143, 27, 49, 29, 1, -48 },
  { 3309, 14, 37, 15, 0, -36 },
  { 3374, 17, 45, 15, -3, -36 },
  { 3470, 27, 31, 31, 3, -39 },
  { 3575, 26, 18, 31, 3, -32 },
  { 3634, 27, 31, 31, 3, -39 },
  { 3739, 22, 49, 22, 2, -48 },
  { 3874, 41, 53, 44, 2, -47 },
  { 4146, 30, 47, 30, -4, -47 },
  { 4323, 31, 47, 32, 1, -47 },
  { 4506, 31, 49, 29, 3, -48 },
  { 4696, 32, 47, 35, 1, -47 },
  { 4884, 29, 47, 27, 1, -47 },
  { 5055, 29, 47, 25, 1, -47 },
  { 5226, 34, 49, 36, 3, -48 },
  { 5435, 36, 47, 36, 1, -47 },
  { 5647, 26, 47, 18, -3, -47 },
  { 5800, 26, 60, 15, -10, -47 },
  { 5995, 34, 47, 30, 1, -47 },
  { 6195, 20, 47, 25, 1, -47 },
  { 6313, 47, 47, 47, 1, -47 },
  { 6590, 38, 47, 38, 1, -47 },
  { 6814, 33, 49, 37, 3, -48 },
  { 7017, 30, 47, 30, 1, -47 },
  { 7194, 33, 59, 37, 3, -48 },
  { 7438, 30, 47, 31, 1, -47 },
  { 7615, 30, 49, 27, -1, -48 },
  { 7799, 26, 47, 26, 5, -47 },
  { 7952, 34, 48, 35, 3, -47 },
  { 8156, 29, 47, 30, 6, -47 },
  { 8327, 46, 47, 47, 6, -47 },
  { 8598, 36, 47, 28, -4, -47 },
  { 8810, 26, 47, 27, 6, -47 },
  { 8963, 32, 47, 26, -2, -47 },
  { 9151, 25, 58, 19, -1, -47 },
  { 9333, 11, 47, 23, 7, -47 },
  { 9398, 24, 58, 19, -4, -47 },
  { 9572, 28, 26, 30, 1, -47 },
  { 9663, 23, 4, 22, -6, 6 },
  { 9675, 9, 10, 17, 10, -50 },
  { 9687, 28, 37, 31, 2, -36 },
  { 9817, 28, 51, 31, 1, -50 },
  { 9996, 23, 37, 24, 2, -36 },
  { 10103, 31, 51, 31, 2, -50 },
  { 10301, 24, 37, 28, 2, -36 },
  { 10412, 33, 66, 17, -8, -50 },
  { 10685, 31, 52, 31, -1, -36 },
  { 10887, 27, 50, 30, 1, -50 },
  { 11056, 15, 49, 14, 1, -49 },
  { 11148, 24, 65, 14, -8, -49 },
  { 11343, 28, 50, 26, 1, -50 },
  { 11518, 16, 50, 14, 1, -50 },
  { 11618, 42, 36, 46, 1, -36 },
  { 11807, 28, 36, 30, 0, -36 },
  { 11933, 26, 37, 30, 2, -36 },
  { 12054, 32, 52, 31, -3, -36 },
  { 12262, 28, 52, 31, 2, -36 },
  { 12444, 22, 36, 21, 1, -36 },
  { 12543, 23, 37, 23, 0, -36 },
  { 12650, 18, 44, 18, 2, -43 },
  { 12749, 28, 36, 31, 2, -35 },
  { 12875, 24, 35, 25, 4, -35 },
  { 12980, 38, 35, 39, 4, -35 },
  { 13147, 31, 35, 25, -3, -35 },
  { 13283, 34, 51, 25, -6, -35 },
  { 13500, 25, 35, 22, -2, -35 },
  { 13610, 25, 57, 22, 1, -47 },
  { 13789, 5, 66, 28, 12, -50 },
  { 13831, 25, 57, 22, -4, -47 },
  { 14010, 27, 9, 31, 3, -28 },
};

const GFXfont NotoSans_Condensed_Italic66pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Italic66pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Italic66pt7bGlyphs,
  0x20, 0x7E, 90
};

#endif // _NOTOSANS_CONDENSED_ITALIC66PT7B_H_
