#ifndef _NOTOSANS_CONDENSED_ITALIC59PT7B_H_
#define _NOTOSANS_CONDENSED_ITALIC59PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Italic.ttf
// Size: 59pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Italic59pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0,
  0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xE0, 0x02, 0x00, 0x00, 0x3F, 0x0F, 0x9F, 0x0F, 0x8F, 0x87, 0xC7,
  0xC3, 0xE3, 0xC1, 0xF3, 0xE0, 0xF1, 0xF0, 0x78, 0xF8, 0x7C, 0x78, 0x3E,
  0x3C, 0x1E, 0x1E, 0x0F, 0x0E, 0x07, 0x8F, 0x03, 0x87, 0x81, 0xC3, 0xC1,
  0xE0, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xE0, 0x78,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x38, 0x0E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xF0,
  0x3C, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0xFF, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x00,
  0x70, 0x1C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xE0,
  0x70, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x81, 0xC0,
  0x00, 0x78, 0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x3F,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0x80,
  0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x0E, 0x03, 0x80,
  0x00, 0xF0, 0x3C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x01,
  0xC0, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0x78, 0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x81, 0xFD, 0xCF, 0x80, 0xF8, 0xE0, 0xC0, 0xF8, 0x70, 0x00,
  0x78, 0x30, 0x00, 0x3C, 0x38, 0x00, 0x1E, 0x1C, 0x00, 0x0F, 0x0E, 0x00,
  0x07, 0x87, 0x00, 0x03, 0xC3, 0x00, 0x01, 0xF3, 0x80, 0x00, 0xFD, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x06, 0xFC, 0x00, 0x07,
  0x3E, 0x00, 0x03, 0x8F, 0x80, 0x01, 0xC7, 0xC0, 0x00, 0xE3, 0xE0, 0x00,
  0x60, 0xF0, 0x00, 0x70, 0x78, 0x00, 0x38, 0x7C, 0x00, 0x1C, 0x3E, 0x10,
  0x0E, 0x3E, 0x0C, 0x06, 0x1F, 0x07, 0xC7, 0x3F, 0x03, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x01, 0x00, 0x7F, 0x00, 0x07,
  0x80, 0x3F, 0xE0, 0x01, 0xE0, 0x1F, 0xF8, 0x00, 0xF0, 0x0F, 0x8F, 0x00,
  0x78, 0x03, 0xC3, 0xC0, 0x1E, 0x01, 0xE0, 0xF0, 0x0F, 0x00, 0x78, 0x3C,
  0x03, 0xC0, 0x3C, 0x0F, 0x01, 0xE0, 0x0F, 0x03, 0xC0, 0xF0, 0x03, 0xC0,
  0xF0, 0x3C, 0x01, 0xE0, 0x3C, 0x1E, 0x00, 0x78, 0x0F, 0x07, 0x80, 0x1E,
  0x03, 0x83, 0xC0, 0x07, 0x81, 0xE0, 0xF0, 0x01, 0xE0, 0x78, 0x78, 0x00,
  0x70, 0x1E, 0x3C, 0x00, 0x3C, 0x0F, 0x0F, 0x07, 0x0F, 0x03, 0xC7, 0x87,
  0xF3, 0xC0, 0xF1, 0xE3, 0xFE, 0xF0, 0x78, 0xF1, 0xFF, 0xDC, 0x1E, 0x78,
  0xF0, 0xF7, 0x8F, 0x1E, 0x3C, 0x3D, 0xFF, 0xCF, 0x1E, 0x0F, 0x3F, 0xE3,
  0xC7, 0x83, 0xCF, 0xF1, 0xE3, 0xC0, 0xF0, 0x70, 0xF8, 0xF0, 0x3C, 0x00,
  0x3C, 0x3C, 0x0F, 0x00, 0x1E, 0x1E, 0x03, 0xC0, 0x07, 0x87, 0x80, 0xF0,
  0x03, 0xC1, 0xE0, 0x78, 0x00, 0xF0, 0x78, 0x1E, 0x00, 0x78, 0x1E, 0x07,
  0x80, 0x3C, 0x07, 0x01, 0xE0, 0x0F, 0x03, 0xC0, 0xF0, 0x07, 0x80, 0xF0,
  0x3C, 0x01, 0xE0, 0x3C, 0x0F, 0x00, 0xF0, 0x0F, 0x07, 0x80, 0x7C, 0x01,
  0xC1, 0xE0, 0x1E, 0x00, 0x78, 0xF0, 0x0F, 0x00, 0x1F, 0xF8, 0x03, 0xC0,
  0x03, 0xFC, 0x01, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F,
  0xFE, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF0, 0x3C,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0xF8, 0x0F, 0x00, 0x07, 0xC0, 0x78, 0x00,
  0x3E, 0x07, 0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C,
  0x1F, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0x7D, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFD,
  0xF0, 0x1F, 0x0F, 0xCF, 0x81, 0xF0, 0xFC, 0x3E, 0x0F, 0x87, 0xC1, 0xF0,
  0x78, 0x7C, 0x0F, 0xC7, 0xC3, 0xE0, 0x3E, 0x3C, 0x3E, 0x01, 0xF3, 0xE1,
  0xF0, 0x07, 0xDE, 0x0F, 0x00, 0x3F, 0xF0, 0xF8, 0x00, 0xFF, 0x07, 0xC0,
  0x07, 0xF8, 0x3E, 0x00, 0x3F, 0x81, 0xF0, 0x01, 0xF8, 0x0F, 0x80, 0x1F,
  0xE0, 0x3E, 0x01, 0xFF, 0x01, 0xF8, 0x1F, 0xFC, 0x0F, 0xFF, 0xFB, 0xE0,
  0x3F, 0xFF, 0x9F, 0x80, 0xFF, 0xF0, 0x7C, 0x03, 0xFF, 0x03, 0xF0, 0x03,
  0x00, 0x00, 0x00, 0x3F, 0x3E, 0x3E, 0x3E, 0x3E, 0x3C, 0x7C, 0x7C, 0x78,
  0x78, 0x78, 0x78, 0x70, 0xF0, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0xF0, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03,
  0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x06, 0x07, 0x80, 0x78, 0x78, 0x0F, 0xE7, 0x00, 0xFF,
  0xF0, 0xF7, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xF8, 0x00,
  0x7F, 0x80, 0x0F, 0xBC, 0x01, 0xF3, 0xC0, 0x3E, 0x1E, 0x07, 0xE1, 0xE0,
  0x3C, 0x1F, 0x01, 0x80, 0xF8, 0x08, 0x0F, 0x00, 0x00, 0x80, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x7C, 0x1F, 0x03,
  0xE0, 0xFC, 0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x03, 0xC0, 0xF8, 0x1E, 0x07,
  0x80, 0xF0, 0x3C, 0x00, 0x7F, 0xFD, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0x39,
  0xFF, 0xFF, 0xFF, 0xFF, 0x88, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x01,
  0xF8, 0x7E, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x1E, 0x07,
  0xC0, 0x1E, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x1F,
  0x00, 0x1E, 0x1F, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x3E, 0x00, 0x3E, 0x3E,
  0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C,
  0x00, 0x3E, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x78, 0x00, 0x7C, 0xF8,
  0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8,
  0x00, 0xF8, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xF8,
  0x03, 0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x07, 0xC0, 0xF8, 0x0F, 0xC0, 0xF8,
  0x0F, 0x80, 0x7C, 0x1F, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x3E, 0x00, 0xFC,
  0x03, 0xF8, 0x0F, 0xF0, 0x7F, 0xE1, 0xFF, 0x87, 0xFF, 0x1F, 0xBE, 0xFE,
  0x7D, 0xF0, 0xF1, 0xC3, 0xE1, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x01, 0xF0, 0x1F, 0x80,
  0x1C, 0x01, 0xF0, 0x02, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xFF, 0x00,
  0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3C, 0x07,
  0xE0, 0x0C, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF0, 0x20, 0x00, 0xFC, 0x0E, 0x00, 0xFE, 0x03,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1D, 0xE0, 0x00, 0x07, 0xBC, 0x00, 0x01, 0xEF, 0x80, 0x00,
  0x3D, 0xF0, 0x00, 0x0F, 0x3C, 0x00, 0x03, 0xC7, 0x80, 0x00, 0xF9, 0xF0,
  0x00, 0x1E, 0x3E, 0x00, 0x07, 0x87, 0xC0, 0x01, 0xF0, 0xF0, 0x00, 0x3C,
  0x1E, 0x00, 0x0F, 0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x78, 0x1F, 0x00,
  0x1E, 0x03, 0xC0, 0x07, 0x80, 0xF8, 0x01, 0xF0, 0x1F, 0x00, 0x3C, 0x03,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xE0, 0x1E,
  0x00, 0x7C, 0x07, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8,
  0x01, 0xFF, 0xFE, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0x87, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x80,
  0x03, 0xF0, 0x38, 0x03, 0xF8, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x03,
  0xFF, 0xF0, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1E, 0x02, 0x00, 0x1F, 0x1F, 0xE0, 0x0F, 0x9F, 0xF8, 0x07, 0xDF, 0xFE,
  0x03, 0xDF, 0xFF, 0x83, 0xFC, 0x0F, 0xC1, 0xFC, 0x03, 0xE0, 0xFC, 0x01,
  0xF0, 0x7E, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x3F, 0x00, 0x1F, 0x1F, 0x00,
  0x0F, 0x8F, 0x80, 0x07, 0x87, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE1, 0xF0,
  0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x1F,
  0x00, 0x3E, 0x07, 0x80, 0x3E, 0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x3F, 0x00,
  0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x1F, 0xE7, 0xF0, 0x0F, 0x80, 0xFC, 0x0F,
  0x80, 0x3E, 0x07, 0xC0, 0x1F, 0x03, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xC1,
  0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x1E, 0x00, 0xF8,
  0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x7C, 0x03, 0xF0, 0x7C, 0x00, 0xF8, 0xFC,
  0x00, 0x3E, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xEF, 0xC0, 0x0F, 0xC3, 0xE0, 0x0F, 0xC0,
  0xF8, 0x0F, 0x80, 0x7E, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x87, 0xC0,
  0x03, 0xC3, 0xE0, 0x01, 0xF1, 0xF0, 0x00, 0xF8, 0xF0, 0x00, 0x7C, 0x78,
  0x00, 0x3C, 0x3C, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x87,
  0xC0, 0x0F, 0x83, 0xF0, 0x0F, 0xC0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x00, 0x08, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFC, 0x01, 0xFF,
  0xFE, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0xC0,
  0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x1F, 0x00,
  0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00,
  0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x3F, 0x1F, 0x00, 0x7F, 0x1F, 0x00,
  0x7E, 0x1F, 0x80, 0xFE, 0x0F, 0xC1, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xBE, 0x07, 0xFF, 0x3C, 0x03, 0xFC, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x80, 0x80, 0x7F, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFC,
  0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x1F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0xFC, 0x07, 0xC0, 0x20, 0x00,
  0x00, 0x1C, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80,
  0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1C,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xE0,
  0x3E, 0x08, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x07, 0xC0, 0x00, 0xFE, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03,
  0xE0, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x1E,
  0x01, 0xE0, 0x00, 0x00, 0xE0, 0x3E, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x78, 0x01, 0xF8, 0x0F, 0x07, 0x80, 0x7F, 0xF0, 0x70, 0xF0,
  0x0F, 0xFE, 0x07, 0x0E, 0x03, 0xFF, 0xE0, 0x71, 0xE0, 0x3C, 0x1E, 0x07,
  0x1E, 0x07, 0x81, 0xE0, 0x73, 0xC0, 0xF0, 0x3C, 0x0F, 0x3C, 0x0F, 0x03,
  0xC0, 0xF3, 0x81, 0xE0, 0x3C, 0x0F, 0x78, 0x1E, 0x03, 0xC0, 0xF7, 0x83,
  0xC0, 0x78, 0x0F, 0x78, 0x3C, 0x07, 0x80, 0xE7, 0x03, 0xC0, 0x78, 0x1E,
  0x70, 0x38, 0x07, 0x81, 0xEF, 0x07, 0x80, 0xF0, 0x1C, 0xF0, 0x78, 0x0F,
  0x03, 0xCF, 0x07, 0x81, 0xF0, 0x3C, 0xF0, 0x78, 0x1F, 0x07, 0x8F, 0x07,
  0x81, 0xF0, 0x78, 0xF0, 0x78, 0x3F, 0x0F, 0x0F, 0x07, 0xC7, 0x71, 0xE0,
  0xF0, 0x3F, 0xE7, 0xFE, 0x0F, 0x03, 0xFC, 0x7F, 0xC0, 0xF0, 0x1F, 0x83,
  0xF0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x06,
  0x00, 0x00, 0xFF, 0x07, 0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xBE, 0x00,
  0x00, 0xF7, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0x9F, 0x00, 0x01, 0xF1,
  0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x87, 0x80, 0x01, 0xE0, 0xF0, 0x00,
  0x7C, 0x1E, 0x00, 0x0F, 0x83, 0xC0, 0x03, 0xE0, 0x78, 0x00, 0x7C, 0x0F,
  0x00, 0x0F, 0x01, 0xE0, 0x03, 0xE0, 0x3C, 0x00, 0x7C, 0x07, 0x80, 0x1F,
  0x00, 0xF0, 0x03, 0xE0, 0x1E, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x07, 0xC0,
  0x07, 0xC0, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE1,
  0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x8F, 0xC0, 0x01, 0xF1, 0xF0, 0x00,
  0x3E, 0x7E, 0x00, 0x07, 0xCF, 0x80, 0x00, 0xFB, 0xF0, 0x00, 0x1F, 0x7C,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0xF8, 0x1F, 0xE0,
  0x1F, 0x00, 0x7E, 0x01, 0xF0, 0x03, 0xE0, 0x1F, 0x00, 0x3E, 0x01, 0xF0,
  0x03, 0xF0, 0x1E, 0x00, 0x3E, 0x03, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x3E,
  0x03, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x7E, 0x03, 0xC0, 0x07, 0xC0, 0x7C,
  0x00, 0xFC, 0x07, 0xC0, 0x1F, 0x80, 0x7C, 0x07, 0xF0, 0x07, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F,
  0x80, 0xFE, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x3F, 0x01, 0xF0, 0x01,
  0xF0, 0x1F, 0x00, 0x1F, 0x01, 0xF0, 0x01, 0xF0, 0x1E, 0x00, 0x1F, 0x03,
  0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x03, 0xE0, 0x01, 0xF0, 0x3E, 0x00,
  0x3F, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x7E, 0x07, 0xC0, 0x0F, 0xE0,
  0x7C, 0x01, 0xFC, 0x07, 0xC0, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFC, 0x01, 0xFC, 0x03, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x38, 0x01, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0x83, 0xFE, 0x00, 0xF8, 0x07, 0xF0,
  0x07, 0xC0, 0x0F, 0xC0, 0x3E, 0x00, 0x7E, 0x01, 0xF0, 0x01, 0xF0, 0x0F,
  0x80, 0x0F, 0x80, 0xF8, 0x00, 0x7E, 0x07, 0xC0, 0x01, 0xF0, 0x3E, 0x00,
  0x0F, 0x81, 0xF0, 0x00, 0x7C, 0x0F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1F,
  0x07, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x7E, 0x1F,
  0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x3E, 0x00,
  0x07, 0xC1, 0xF0, 0x00, 0x7E, 0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1F,
  0x07, 0xC0, 0x01, 0xF8, 0x3E, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x7C, 0x1F,
  0x00, 0x07, 0xE0, 0xF8, 0x00, 0x7E, 0x07, 0xC0, 0x03, 0xF0, 0x3E, 0x00,
  0x3F, 0x03, 0xE0, 0x03, 0xF0, 0x1F, 0x00, 0x3F, 0x80, 0xF8, 0x03, 0xF8,
  0x07, 0xC0, 0x7F, 0x80, 0x3E, 0x1F, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFC, 0x03, 0xE0, 0x1F, 0xC0, 0x01, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0x8F, 0x80, 0x0F, 0xFE, 0x3E,
  0x00, 0x7F, 0xF0, 0xF8, 0x01, 0xFF, 0xC3, 0xE0, 0x00, 0x1F, 0x0F, 0x80,
  0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00,
  0x3E, 0x0F, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F,
  0x03, 0xE0, 0x00, 0x7C, 0x0F, 0xC0, 0x01, 0xF0, 0x1F, 0x00, 0x07, 0xC0,
  0x7E, 0x00, 0x1F, 0x01, 0xFC, 0x00, 0x78, 0x03, 0xF8, 0x03, 0xE0, 0x07,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0xF8,
  0x00, 0x3E, 0x01, 0xF0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x3E, 0x01, 0xF0,
  0x00, 0x7C, 0x01, 0xF0, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x7C, 0x03, 0xE0,
  0x00, 0x7C, 0x03, 0xE0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0xF8, 0x03, 0xE0,
  0x00, 0xF8, 0x03, 0xC0, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0xF8, 0x07, 0xC0,
  0x00, 0xF0, 0x07, 0xC0, 0x01, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0x80,
  0x03, 0xE0, 0x0F, 0x80, 0x03, 0xE0, 0x1F, 0x00, 0x03, 0xE0, 0x1F, 0x00,
  0x03, 0xE0, 0x1F, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x07, 0xC0, 0x1E, 0x00,
  0x07, 0xC0, 0x3E, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x07, 0x80, 0x3E, 0x00,
  0x0F, 0x80, 0x3E, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x0F, 0x80, 0x7C, 0x00,
  0x0F, 0x80, 0x7C, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0,
  0x0F, 0xFF, 0xC0, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x43, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x7E, 0x01, 0xF0, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x0F, 0x80, 0x7E,
  0x00, 0x3E, 0x00, 0xF8, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0xF8, 0x0F, 0xC0,
  0x01, 0xF0, 0x3F, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0x1F, 0x07, 0xE0, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x7C, 0x7E, 0x00, 0x00,
  0xF0, 0xF8, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x0F,
  0xBF, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xF7,
  0xC0, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7C, 0x1F,
  0x00, 0x00, 0xF8, 0x3E, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x07, 0xC0, 0x7C,
  0x00, 0x0F, 0x80, 0xF8, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x3E, 0x03, 0xF0,
  0x00, 0xF8, 0x03, 0xE0, 0x01, 0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x0F, 0x80,
  0x07, 0xC0, 0x1F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x1F, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xE0, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x07, 0xBC, 0x00, 0x0F, 0xFC, 0x01, 0xEF, 0x00, 0x03, 0xFF, 0x00, 0x7B,
  0xC0, 0x00, 0xF7, 0xC0, 0x3E, 0xF0, 0x00, 0x7D, 0xE0, 0x0F, 0xBC, 0x00,
  0x1E, 0xF8, 0x03, 0xEF, 0x00, 0x0F, 0xBE, 0x00, 0xF3, 0xC0, 0x03, 0xCF,
  0x80, 0x3C, 0xF0, 0x01, 0xF3, 0xC0, 0x1F, 0x3C, 0x00, 0x79, 0xF0, 0x07,
  0xCF, 0x00, 0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0x1F, 0x00, 0x78, 0xF8,
  0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x01, 0xE1, 0xE0, 0x0F, 0x8F, 0x80, 0xF8,
  0xF8, 0x03, 0xE3, 0xE0, 0x3C, 0x3E, 0x00, 0xF0, 0x78, 0x1F, 0x0F, 0x80,
  0x3C, 0x1E, 0x07, 0x83, 0xE0, 0x1F, 0x07, 0x83, 0xE0, 0xF0, 0x07, 0xC1,
  0xE0, 0xF0, 0x7C, 0x01, 0xF0, 0x78, 0x7C, 0x1F, 0x00, 0x78, 0x1E, 0x1E,
  0x07, 0xC0, 0x1E, 0x07, 0x8F, 0x81, 0xF0, 0x0F, 0x81, 0xE3, 0xC0, 0xF8,
  0x03, 0xE0, 0x78, 0xF0, 0x3E, 0x00, 0xF8, 0x1E, 0x78, 0x0F, 0x80, 0x3C,
  0x07, 0x9E, 0x03, 0xE0, 0x1F, 0x01, 0xFF, 0x80, 0xF0, 0x07, 0xC0, 0x7F,
  0xC0, 0x7C, 0x01, 0xF0, 0x1F, 0xF0, 0x1F, 0x00, 0x78, 0x07, 0xF8, 0x07,
  0xC0, 0x1E, 0x00, 0xFE, 0x01, 0xF0, 0x0F, 0x80, 0x3F, 0x00, 0x78, 0x03,
  0xE0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00,
  0xF8, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x3F, 0x80, 0x01,
  0xE0, 0x0F, 0xE0, 0x00, 0xF8, 0x03, 0xF8, 0x00, 0x3E, 0x00, 0xFE, 0x00,
  0x0F, 0x80, 0x7F, 0x80, 0x03, 0xE0, 0x1F, 0xF0, 0x00, 0xF0, 0x07, 0xFC,
  0x00, 0x7C, 0x01, 0xEF, 0x00, 0x1F, 0x00, 0x7B, 0xC0, 0x07, 0xC0, 0x3E,
  0xF8, 0x01, 0xE0, 0x0F, 0xBE, 0x00, 0x78, 0x03, 0xC7, 0x80, 0x3E, 0x00,
  0xF1, 0xE0, 0x0F, 0x80, 0x3C, 0x7C, 0x03, 0xE0, 0x1F, 0x1F, 0x00, 0xF0,
  0x07, 0xC7, 0xC0, 0x7C, 0x01, 0xF0, 0xF0, 0x1F, 0x00, 0x78, 0x3C, 0x07,
  0xC0, 0x3E, 0x0F, 0x81, 0xF0, 0x0F, 0x83, 0xE0, 0x78, 0x03, 0xE0, 0x78,
  0x3E, 0x00, 0xF8, 0x1E, 0x0F, 0x80, 0x3C, 0x07, 0xC3, 0xE0, 0x1F, 0x01,
  0xF0, 0xF8, 0x07, 0xC0, 0x3C, 0x3C, 0x01, 0xF0, 0x0F, 0x1F, 0x00, 0x78,
  0x03, 0xE7, 0xC0, 0x1E, 0x00, 0xF9, 0xF0, 0x0F, 0x80, 0x3E, 0x78, 0x03,
  0xE0, 0x07, 0x9E, 0x00, 0xF8, 0x01, 0xEF, 0x80, 0x3C, 0x00, 0x7F, 0xE0,
  0x1F, 0x00, 0x1F, 0xF8, 0x07, 0xC0, 0x03, 0xFC, 0x01, 0xF0, 0x00, 0xFF,
  0x00, 0x7C, 0x00, 0x3F, 0xC0, 0x1E, 0x00, 0x0F, 0xF0, 0x0F, 0x80, 0x01,
  0xFC, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x3C, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x7E, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x7E, 0x00, 0x3E, 0x07, 0xE0, 0x01, 0xF8,
  0x3E, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF1, 0xF8,
  0x00, 0x0F, 0x8F, 0x80, 0x00, 0x7C, 0xFC, 0x00, 0x03, 0xE7, 0xC0, 0x00,
  0x1F, 0x3E, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x3E,
  0xF8, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0xFB, 0xF0,
  0x00, 0x07, 0xDF, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x01, 0xF7, 0xC0, 0x00,
  0x1F, 0xBE, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x7E,
  0x7C, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x1F, 0x1F, 0x00, 0x01, 0xF0, 0xF8,
  0x00, 0x0F, 0x87, 0xC0, 0x00, 0xFC, 0x3E, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0x7C, 0x07, 0xC0, 0x07, 0xE0, 0x3F, 0x00, 0x7E, 0x01, 0xFC, 0x0F, 0xE0,
  0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0xF8, 0x7F, 0x80,
  0x7C, 0x03, 0xF0, 0x1F, 0x00, 0x7C, 0x07, 0xC0, 0x1F, 0x01, 0xF0, 0x07,
  0xC0, 0x7C, 0x01, 0xF0, 0x3E, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x03, 0xE0,
  0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x3C, 0x00, 0x7C, 0x1F, 0x00, 0x3F, 0x07,
  0xC0, 0x0F, 0x81, 0xF0, 0x07, 0xE0, 0x7C, 0x01, 0xF0, 0x3E, 0x01, 0xFC,
  0x0F, 0x80, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xC0, 0x1F, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x7E, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x7E, 0x00, 0x3E, 0x07, 0xE0, 0x01, 0xF8, 0x3E, 0x00, 0x07,
  0xC3, 0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x0F, 0x8F,
  0x80, 0x00, 0x7C, 0xFC, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x1F, 0x3E, 0x00,
  0x00, 0xFB, 0xF0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x01,
  0xF7, 0xC0, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x07, 0xDF,
  0x00, 0x00, 0x3E, 0xF8, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1F, 0xBE, 0x00,
  0x00, 0xF9, 0xF0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x7E, 0x7C, 0x00, 0x03,
  0xE3, 0xE0, 0x00, 0x1F, 0x1F, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x0F, 0x87,
  0xC0, 0x00, 0xFC, 0x3E, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x07, 0xC0,
  0x07, 0xE0, 0x3F, 0x00, 0x7E, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xC0, 0x0F, 0x83, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x01,
  0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0xE0, 0x3E, 0x00, 0xFC, 0x0F,
  0x80, 0x1F, 0x81, 0xF0, 0x03, 0xE0, 0x3E, 0x00, 0x7C, 0x07, 0xC0, 0x0F,
  0x80, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x7E, 0x07, 0xC0, 0x0F, 0x80, 0xF8,
  0x03, 0xF0, 0x1F, 0x00, 0xFC, 0x07, 0xC0, 0x7F, 0x00, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0x07,
  0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x01,
  0xE0, 0x3E, 0x00, 0x7C, 0x07, 0xC0, 0x0F, 0x80, 0xF8, 0x01, 0xF0, 0x1F,
  0x00, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x3E,
  0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x80, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x3E,
  0x07, 0xC0, 0x07, 0xC0, 0xF8, 0x00, 0xFC, 0x1F, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFC, 0x07, 0x80, 0x7E, 0x00, 0x20, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x80, 0x07, 0xF0, 0x1E, 0x03, 0xFC, 0x03, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xE0, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x03,
  0xE0, 0x3E, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0xF8,
  0x1F, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x7C, 0x0F,
  0x80, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1E, 0x03, 0xE0,
  0x00, 0xF8, 0x0F, 0x80, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0x3E, 0x07, 0xC0, 0x01, 0xF0, 0x1F, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x1F,
  0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF0, 0x3E, 0x00, 0x0F, 0x80,
  0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0xF8, 0x1F, 0x00, 0x03, 0xE0, 0x7C,
  0x00, 0x0F, 0x01, 0xF0, 0x00, 0x7C, 0x07, 0xC0, 0x01, 0xF0, 0x3E, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0xF8, 0x0F, 0x80, 0x03,
  0xE0, 0x3E, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x7E, 0x03, 0xE0, 0x01, 0xF0,
  0x0F, 0x80, 0x07, 0xC0, 0x3E, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x01,
  0xF8, 0x1F, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x05, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x3E,
  0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xE3, 0xE0, 0x00,
  0xF8, 0x78, 0x00, 0x7E, 0x1E, 0x00, 0x1F, 0x07, 0x80, 0x0F, 0xC1, 0xE0,
  0x03, 0xE0, 0x78, 0x00, 0xF8, 0x1E, 0x00, 0x7C, 0x07, 0x80, 0x1F, 0x01,
  0xE0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x07, 0xC0, 0x7C,
  0x01, 0xF0, 0x3F, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x07, 0xC1,
  0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x07,
  0xC7, 0xC0, 0x01, 0xF1, 0xF0, 0x00, 0x7C, 0x78, 0x00, 0x1F, 0x3E, 0x00,
  0x07, 0xCF, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x7D, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xFE, 0x00, 0x0F,
  0xC0, 0x03, 0xEF, 0x80, 0x03, 0xE0, 0x00, 0xFB, 0xE0, 0x01, 0xF8, 0x00,
  0x7C, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xCF,
  0x80, 0x0F, 0xE0, 0x03, 0xE3, 0xE0, 0x03, 0xF8, 0x00, 0xF8, 0xF8, 0x01,
  0xFE, 0x00, 0x7C, 0x3E, 0x00, 0x7F, 0x80, 0x1F, 0x0F, 0x80, 0x3F, 0xE0,
  0x07, 0xC3, 0xE0, 0x0F, 0x78, 0x03, 0xE0, 0xF8, 0x03, 0xDE, 0x00, 0xF8,
  0x3E, 0x01, 0xF7, 0x80, 0x7C, 0x0F, 0x80, 0x79, 0xE0, 0x1F, 0x03, 0xE0,
  0x3E, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xC7,
  0x80, 0xF8, 0x0F, 0x81, 0xE1, 0xE0, 0x7C, 0x03, 0xE0, 0x78, 0x78, 0x1F,
  0x00, 0xF8, 0x3E, 0x1E, 0x07, 0x80, 0x3E, 0x0F, 0x07, 0x83, 0xE0, 0x0F,
  0x83, 0xC1, 0xE0, 0xF8, 0x03, 0xE1, 0xE0, 0x78, 0x7C, 0x00, 0xF8, 0x78,
  0x1E, 0x1F, 0x00, 0x3E, 0x3E, 0x07, 0x87, 0x80, 0x0F, 0x8F, 0x01, 0xE3,
  0xE0, 0x03, 0xE7, 0xC0, 0x78, 0xF0, 0x00, 0xF9, 0xE0, 0x1E, 0x7C, 0x00,
  0x3E, 0x78, 0x07, 0x9F, 0x00, 0x0F, 0xBE, 0x01, 0xE7, 0x80, 0x03, 0xEF,
  0x00, 0x7B, 0xE0, 0x00, 0xFB, 0xC0, 0x1E, 0xF0, 0x00, 0x3F, 0xE0, 0x07,
  0xBC, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x1E, 0x01, 0xF8, 0x00, 0x1F, 0x01,
  0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x1F, 0x07,
  0xC0, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x0F, 0x9F,
  0x00, 0x00, 0x0F, 0x9E, 0x00, 0x00, 0x07, 0xBE, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00, 0x7C, 0xF8,
  0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x01, 0xF0, 0x78,
  0x00, 0x03, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xC0, 0x7C,
  0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x1F, 0x00, 0x3E,
  0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x3E, 0x78, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0xF8,
  0x7C, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0x7C, 0x03, 0xF0, 0x7C, 0x03, 0xE0,
  0x3C, 0x07, 0xC0, 0x3C, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x80,
  0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x1E, 0x3E, 0x00, 0x1E, 0x3C, 0x00,
  0x1E, 0x7C, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x08, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x00, 0xF8, 0x3E, 0x0F,
  0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x7C, 0x1F, 0x07, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF8, 0x3E, 0x0F, 0x81, 0xE0, 0x78, 0x1E, 0x07,
  0x81, 0xE0, 0x7C, 0x1F, 0x07, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF8,
  0x3E, 0x0F, 0x83, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x7C, 0x1F, 0x07,
  0xC0, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xF3, 0xC0,
  0x00, 0x79, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x7C, 0x3C, 0x00, 0x3C, 0x1F,
  0x00, 0x3E, 0x07, 0x80, 0x1E, 0x03, 0xC0, 0x1F, 0x01, 0xF0, 0x0F, 0x00,
  0x78, 0x0F, 0x00, 0x3C, 0x07, 0x80, 0x1F, 0x07, 0x80, 0x07, 0x87, 0xC0,
  0x03, 0xC3, 0xC0, 0x01, 0xF3, 0xE0, 0x00, 0x79, 0xE0, 0x00, 0x3D, 0xF0,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xF8, 0xF8, 0x7C, 0x7C, 0x3C, 0x3E, 0x1E, 0x0F, 0x0F, 0x00, 0x3F, 0x07,
  0x80, 0x7F, 0xE3, 0xC0, 0x7F, 0xFB, 0xE0, 0x7F, 0xFD, 0xE0, 0x7F, 0x0E,
  0xF0, 0x3F, 0x03, 0xF8, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x1F, 0x00,
  0x3E, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0xC3, 0xE0,
  0x03, 0xE3, 0xE0, 0x01, 0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x78,
  0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x0F,
  0x80, 0x0F, 0x87, 0xC0, 0x0F, 0xC3, 0xE0, 0x07, 0xC1, 0xF0, 0x07, 0xE0,
  0xF8, 0x03, 0xF0, 0x7C, 0x03, 0xF8, 0x3E, 0x03, 0xFC, 0x1F, 0x83, 0xFC,
  0x07, 0xFF, 0xDE, 0x03, 0xFF, 0xCF, 0x00, 0xFF, 0xC7, 0x80, 0x3F, 0xC3,
  0xC0, 0x07, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x3F, 0x00, 0x1F, 0x3F, 0xE0, 0x07, 0x9F, 0xFC, 0x03, 0xEF, 0xFF,
  0x80, 0xFF, 0x87, 0xE0, 0x3F, 0xC0, 0xF8, 0x0F, 0xE0, 0x3F, 0x03, 0xF0,
  0x07, 0xC1, 0xF8, 0x01, 0xF0, 0x7E, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x07,
  0xC0, 0x07, 0xC1, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x3E,
  0x0F, 0x80, 0x0F, 0x83, 0xC0, 0x03, 0xE0, 0xF0, 0x00, 0xF8, 0x7C, 0x00,
  0x7C, 0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x07, 0xC1, 0xF0, 0x03, 0xF0, 0xFC,
  0x00, 0xF8, 0x3F, 0x00, 0x3E, 0x0F, 0xC0, 0x1F, 0x03, 0xF0, 0x0F, 0xC0,
  0xFC, 0x03, 0xE0, 0x7F, 0x81, 0xF8, 0x1F, 0xFF, 0xFC, 0x07, 0x9F, 0xFE,
  0x01, 0xE7, 0xFF, 0x00, 0xF0, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x07, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xF0, 0x60,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x20, 0x7F, 0xBE, 0x03,
  0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x03, 0xF0, 0xF8, 0x00,
  0xFF, 0xCF, 0x80, 0x1F, 0xFE, 0xF8, 0x03, 0xFF, 0xEF, 0x00, 0x7F, 0x0F,
  0xF0, 0x07, 0xC0, 0x7F, 0x00, 0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x3F, 0x01,
  0xF0, 0x03, 0xE0, 0x1F, 0x00, 0x3E, 0x03, 0xE0, 0x03, 0xE0, 0x3E, 0x00,
  0x3E, 0x07, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x3C, 0x07, 0xC0, 0x07, 0xC0,
  0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x07, 0xC0, 0xF8, 0x00, 0x78, 0x0F, 0x80,
  0x0F, 0x80, 0xF8, 0x00, 0xF8, 0x0F, 0x80, 0x0F, 0x80, 0xF8, 0x01, 0xF8,
  0x0F, 0x80, 0x1F, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0x80, 0x3F, 0x00, 0xF8,
  0x07, 0xF0, 0x0F, 0x80, 0xFF, 0x00, 0xFC, 0x1F, 0xE0, 0x07, 0xFF, 0xDE,
  0x00, 0x7F, 0xF9, 0xE0, 0x03, 0xFF, 0x1E, 0x00, 0x1F, 0xE1, 0xC0, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0x00, 0x7F, 0xFC, 0x07,
  0xFF, 0xF0, 0x7E, 0x0F, 0x83, 0xE0, 0x3C, 0x3E, 0x01, 0xE3, 0xE0, 0x0F,
  0x1F, 0x00, 0x79, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0x78, 0x03, 0xE7, 0xC0,
  0x3F, 0x3E, 0x0F, 0xF1, 0xFF, 0xFF, 0x1F, 0xFF, 0xE0, 0xFF, 0xFC, 0x07,
  0xFF, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x03, 0x07, 0xF8, 0xF8, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE,
  0x01, 0xFF, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xE1,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xFC,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE1, 0xE0, 0x07, 0xFE, 0x3C, 0x01,
  0xFF, 0xEF, 0x80, 0x7F, 0xFD, 0xE0, 0x1F, 0xC3, 0xFC, 0x03, 0xE0, 0x3F,
  0x80, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0x7E, 0x07, 0xC0, 0x0F, 0x80, 0xF8,
  0x01, 0xF0, 0x3E, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0xC0, 0xF8, 0x00, 0xF8,
  0x3E, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0xC0, 0xF8, 0x00, 0xF8, 0x1E, 0x00,
  0x1F, 0x07, 0xC0, 0x03, 0xC0, 0xF8, 0x00, 0xF8, 0x1F, 0x00, 0x1F, 0x03,
  0xE0, 0x03, 0xE0, 0x7C, 0x00, 0xFC, 0x0F, 0x80, 0x1F, 0x01, 0xF0, 0x07,
  0xE0, 0x3E, 0x00, 0xFC, 0x07, 0xC0, 0x3F, 0x80, 0xF8, 0x0F, 0xF0, 0x1F,
  0x83, 0xFC, 0x01, 0xFF, 0xF7, 0x80, 0x3F, 0xFD, 0xF0, 0x03, 0xFF, 0x3E,
  0x00, 0x3F, 0xC7, 0xC0, 0x00, 0xC0, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x80, 0x0F, 0xC0, 0x1C, 0x07,
  0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x8F, 0xE0,
  0x07, 0xCF, 0xF8, 0x03, 0xCF, 0xFE, 0x03, 0xEF, 0xFF, 0x81, 0xFF, 0x0F,
  0xC0, 0xFE, 0x03, 0xE0, 0x7E, 0x01, 0xF0, 0x3F, 0x00, 0xF8, 0x3F, 0x00,
  0x7C, 0x1F, 0x80, 0x3E, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x03, 0xC0,
  0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x7C,
  0x00, 0xF0, 0x3C, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x0F,
  0x80, 0x1F, 0x07, 0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xC1,
  0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xE0, 0x78, 0x01, 0xF0, 0x7C, 0x00, 0xF8,
  0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x1E, 0x0F, 0x80, 0x1F,
  0x00, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF8, 0x00, 0x87, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x7C, 0x01, 0xE0,
  0x3E, 0x00, 0xF8, 0x1F, 0x80, 0x3E, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x03,
  0xC1, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x7E, 0x00, 0x1F, 0x3F, 0x00,
  0x07, 0x8F, 0x80, 0x01, 0xE7, 0xC0, 0x00, 0xFB, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x7F,
  0x3E, 0x00, 0x1F, 0x8F, 0x80, 0x07, 0xC3, 0xE0, 0x01, 0xE0, 0xF8, 0x00,
  0xF8, 0x1F, 0x00, 0x3E, 0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x03, 0xE0, 0x7C,
  0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3F, 0x01, 0xF0, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x01, 0xE1,
  0xFC, 0x07, 0xF0, 0x03, 0xC7, 0xFC, 0x1F, 0xF0, 0x07, 0x9F, 0xFC, 0xFF,
  0xF0, 0x0F, 0x7F, 0xFB, 0xFF, 0xE0, 0x3F, 0xE1, 0xF7, 0x87, 0xE0, 0x7F,
  0x03, 0xFC, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x0F, 0x81, 0xF8, 0x07, 0xE0,
  0x1F, 0x07, 0xE0, 0x0F, 0x80, 0x3E, 0x0F, 0xC0, 0x1F, 0x00, 0x78, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x78, 0x01, 0xF0,
  0x07, 0xC1, 0xF0, 0x03, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0x80, 0x1E, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x1E, 0x00, 0x7C,
  0x01, 0xF0, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0xF8, 0x03, 0xE0, 0x07, 0x81,
  0xF0, 0x07, 0xC0, 0x1F, 0x03, 0xC0, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x1F,
  0x00, 0x7C, 0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0xF0, 0x03, 0xE0, 0x0F, 0x83, 0xE0, 0x07,
  0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x01, 0xE1,
  0xFC, 0x00, 0xF1, 0xFF, 0x00, 0x79, 0xFF, 0xC0, 0x7D, 0xFF, 0xF0, 0x3F,
  0xE1, 0xF8, 0x1F, 0xE0, 0x7C, 0x0F, 0xE0, 0x3E, 0x07, 0xE0, 0x1F, 0x07,
  0xE0, 0x0F, 0x83, 0xF0, 0x07, 0xC1, 0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xE0,
  0x7C, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x3E,
  0x0F, 0x80, 0x1E, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x07,
  0xC1, 0xF0, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x7C, 0x00,
  0xF8, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x3C, 0x0F, 0x00, 0x3E, 0x0F, 0x80,
  0x1F, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x03, 0xC1, 0xF0,
  0x03, 0xE0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0xC0, 0x7E, 0x0F, 0xC0, 0xF8, 0x0F, 0x83, 0xE0, 0x1F, 0x0F, 0x80,
  0x1F, 0x1F, 0x00, 0x3E, 0x7C, 0x00, 0x7C, 0xF8, 0x00, 0xF9, 0xF0, 0x01,
  0xF7, 0xC0, 0x03, 0xEF, 0x80, 0x07, 0xDF, 0x00, 0x0F, 0xBC, 0x00, 0x1E,
  0xF8, 0x00, 0x7D, 0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x03, 0xEF,
  0x80, 0x0F, 0x9F, 0x00, 0x1F, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0xF8, 0xF8,
  0x01, 0xF1, 0xF0, 0x07, 0xC3, 0xF0, 0x1F, 0x83, 0xE0, 0x7E, 0x07, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x78, 0x3F, 0x00, 0x07, 0x8F, 0xF8, 0x00, 0x79, 0xFF, 0xC0,
  0x07, 0xBF, 0xFE, 0x00, 0xFF, 0x87, 0xE0, 0x0F, 0xF0, 0x3E, 0x00, 0xFE,
  0x01, 0xF0, 0x0F, 0xC0, 0x1F, 0x01, 0xF8, 0x01, 0xF0, 0x1F, 0x80, 0x1F,
  0x01, 0xF0, 0x01, 0xF0, 0x1F, 0x00, 0x1F, 0x01, 0xF0, 0x01, 0xF0, 0x3E,
  0x00, 0x1E, 0x03, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x3E, 0x03, 0xC0, 0x03,
  0xE0, 0x3C, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xC0, 0x7C, 0x00, 0x7C, 0x07,
  0xC0, 0x07, 0xC0, 0x7C, 0x00, 0x7C, 0x07, 0xC0, 0x0F, 0x80, 0xFC, 0x00,
  0xF8, 0x0F, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x01,
  0xFE, 0x07, 0xE0, 0x1F, 0xFF, 0xFC, 0x01, 0xF7, 0xFF, 0x80, 0x1F, 0x3F,
  0xF0, 0x01, 0xE1, 0xFC, 0x00, 0x3E, 0x06, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x87, 0x80, 0x7F, 0xE3,
  0xC0, 0x7F, 0xFB, 0xE0, 0x7F, 0xFD, 0xE0, 0x7F, 0x0E, 0xF0, 0x3E, 0x03,
  0xF8, 0x3E, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x1F, 0x00, 0x3E, 0x0F, 0x80,
  0x1F, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0xC7, 0xE0, 0x03, 0xE3, 0xE0,
  0x01, 0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0x7C, 0x7C,
  0x00, 0x3C, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x87,
  0xC0, 0x0F, 0xC3, 0xE0, 0x07, 0xC1, 0xF0, 0x07, 0xE0, 0xF8, 0x03, 0xF0,
  0x7C, 0x03, 0xF8, 0x3E, 0x03, 0xFC, 0x1F, 0x83, 0xFC, 0x07, 0xFF, 0xDE,
  0x03, 0xFF, 0xDF, 0x00, 0xFF, 0xCF, 0x80, 0x3F, 0xC7, 0xC0, 0x03, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE1, 0xF8, 0x0F, 0x1F, 0xC0,
  0x79, 0xFC, 0x03, 0xDF, 0xE0, 0x3D, 0xFF, 0x01, 0xEE, 0x00, 0x0F, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0x80,
  0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFC, 0x07, 0x07, 0xC0, 0x10, 0x3E, 0x00,
  0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x20, 0x07, 0xE1, 0x80, 0x7E, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF,
  0x03, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x03, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07,
  0xFF, 0x3F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F,
  0xC0, 0x3F, 0xC0, 0x04, 0x00, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0x81,
  0xE0, 0x07, 0xC1, 0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0xF8,
  0x3E, 0x00, 0x78, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x1F,
  0x07, 0xC0, 0x0F, 0x03, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x03,
  0xE0, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0xF0, 0x3C, 0x00, 0xF8, 0x3E, 0x00,
  0x7C, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x1F, 0x03, 0xC0,
  0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x07, 0xE0, 0xF8, 0x07, 0xE0, 0x7C,
  0x03, 0xF0, 0x3E, 0x03, 0xF8, 0x1F, 0x83, 0xFC, 0x0F, 0xFF, 0xFE, 0x03,
  0xFF, 0xDE, 0x01, 0xFF, 0xCF, 0x00, 0x7F, 0x87, 0x80, 0x06, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xBE, 0x00, 0x3E,
  0xF8, 0x01, 0xF1, 0xE0, 0x07, 0xC7, 0x80, 0x3E, 0x1E, 0x00, 0xF8, 0x78,
  0x07, 0xC1, 0xE0, 0x1F, 0x07, 0x80, 0x78, 0x1E, 0x03, 0xE0, 0x78, 0x0F,
  0x01, 0xE0, 0x7C, 0x07, 0x81, 0xE0, 0x1E, 0x0F, 0x80, 0x78, 0x3E, 0x01,
  0xE1, 0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x3E, 0x00, 0x7C, 0xF8, 0x01, 0xF3,
  0xC0, 0x07, 0xDF, 0x00, 0x1F, 0x78, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xFC, 0x00, 0xF8,
  0x01, 0xEF, 0x00, 0x7E, 0x00, 0xFB, 0xC0, 0x1F, 0x80, 0x3E, 0xF0, 0x0F,
  0xE0, 0x1F, 0x3C, 0x03, 0xF8, 0x07, 0xCF, 0x01, 0xEE, 0x01, 0xE3, 0xC0,
  0x7F, 0x80, 0xF8, 0xF0, 0x1F, 0xE0, 0x3C, 0x3C, 0x0F, 0x78, 0x1F, 0x0F,
  0x03, 0xDE, 0x07, 0xC3, 0xC1, 0xE7, 0x81, 0xE0, 0xF0, 0x79, 0xE0, 0xF8,
  0x3C, 0x1E, 0x78, 0x3C, 0x0F, 0x0F, 0x1E, 0x1F, 0x03, 0xC3, 0xC7, 0x87,
  0xC0, 0xF1, 0xE1, 0xE1, 0xE0, 0x3C, 0x78, 0x78, 0xF8, 0x0F, 0x1E, 0x1E,
  0x3C, 0x03, 0xCF, 0x07, 0x9F, 0x00, 0xF3, 0xC1, 0xE7, 0x80, 0x3D, 0xE0,
  0x79, 0xE0, 0x0F, 0x78, 0x1E, 0xF8, 0x03, 0xDE, 0x07, 0xBC, 0x00, 0xFF,
  0x01, 0xEF, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x0F, 0xE0, 0x1F, 0xE0, 0x03,
  0xF8, 0x07, 0xF8, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x7F, 0x00,
  0x0F, 0xC0, 0x1F, 0x80, 0x03, 0xE0, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x03,
  0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x0F, 0x80, 0xFC, 0x00,
  0x78, 0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x07, 0xC3,
  0xE0, 0x00, 0x3C, 0x7C, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x0F,
  0xBE, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x3E, 0x3E, 0x00, 0x03, 0xE1, 0xE0,
  0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0xF8, 0x1F, 0x00, 0x1F,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x00, 0xF8, 0x0F, 0xC0, 0x0F,
  0xC0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x78, 0x00, 0x7C, 0x00, 0xF0, 0x01,
  0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x07, 0x80, 0x1F,
  0x00, 0x0F, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x3E, 0x01, 0xE0,
  0x00, 0x7C, 0x07, 0xC0, 0x00, 0xF8, 0x0F, 0x80, 0x01, 0xF0, 0x3E, 0x00,
  0x03, 0xE0, 0x7C, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00,
  0x1F, 0x0F, 0x80, 0x00, 0x1E, 0x1F, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00,
  0x78, 0xF8, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x03,
  0xCF, 0x00, 0x00, 0x07, 0xBE, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x1E,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0x07, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0x80, 0x01, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x3E, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF9, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x7F, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x03, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0x80, 0x03, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x01, 0x3F,
  0xE0, 0x01, 0x7F, 0xF8, 0x07, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFE, 0x80, 0x0F, 0xFC, 0x80, 0x03, 0xF0,
};

const GFXglyph NotoSans_Condensed_Italic59pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 14, 43, 14, 1, -42 },
  { 77, 17, 15, 21, 6, -42 },
  { 109, 29, 42, 29, 1, -42 },
  { 262, 25, 48, 26, 1, -45 },
  { 412, 34, 44, 39, 3, -43 },
  { 599, 29, 44, 30, 0, -43 },
  { 759, 8, 15, 12, 6, -42 },
  { 774, 19, 51, 16, 1, -42 },
  { 896, 18, 51, 16, -4, -42 },
  { 1011, 20, 22, 25, 6, -45 },
  { 1066, 23, 28, 28, 3, -35 },
  { 1147, 11, 15, 13, -3, -7 },
  { 1168, 14, 4, 16, 1, -18 },
  { 1175, 6, 8, 13, 1, -7 },
  { 1181, 28, 42, 20, -3, -42 },
  { 1328, 24, 44, 26, 2, -43 },
  { 1460, 15, 42, 26, 7, -42 },
  { 1539, 27, 43, 26, -1, -43 },
  { 1685, 26, 44, 26, 0, -43 },
  { 1828, 27, 42, 26, -1, -42 },
  { 1970, 26, 43, 26, 0, -42 },
  { 2110, 25, 44, 26, 2, -43 },
  { 2248, 25, 42, 26, 3, -42 },
  { 2380, 25, 44, 26, 1, -43 },
  { 2518, 24, 44, 26, 1, -43 },
  { 2650, 12, 33, 13, 0, -32 },
  { 2700, 15, 40, 13, -3, -32 },
  { 2775, 23, 28, 28, 3, -35 },
  { 2856, 23, 16, 28, 3, -29 },
  { 2902, 24, 28, 28, 3, -35 },
  { 2986, 20, 44, 20, 2, -43 },
  { 3096, 36, 47, 39, 2, -42 },
  { 3308, 27, 42, 27, -4, -42 },
  { 3450, 28, 42, 28, 1, -42 },
  { 3597, 27, 44, 26, 3, -43 },
  { 3746, 29, 42, 31, 1, -42 },
  { 3899, 26, 42, 24, 1, -42 },
  { 4036, 26, 42, 23, 1, -42 },
  { 4173, 30, 44, 32, 3, -43 },
  { 4338, 32, 42, 32, 1, -42 },
  { 4506, 22, 42, 16, -2, -42 },
  { 4622, 24, 53, 13, -9, -42 },
  { 4781, 31, 42, 27, 1, -42 },
  { 4944, 18, 42, 22, 1, -42 },
  { 5039, 42, 42, 42, 1, -42 },
  { 5260, 34, 42, 34, 1, -42 },
  { 5439, 29, 44, 33, 3, -43 },
  { 5599, 26, 42, 27, 1, -42 },
  { 5736, 29, 53, 33, 3, -43 },
  { 5929, 27, 42, 27, 1, -42 },
  { 6071, 27, 44, 24, -1, -43 },
  { 6220, 23, 42, 23, 5, -42 },
  { 6341, 30, 43, 31, 3, -42 },
  { 6503, 26, 42, 26, 5, -42 },
  { 6640, 42, 42, 42, 5, -42 },
  { 6861, 32, 42, 25, -3, -42 },
  { 7029, 24, 42, 24, 5, -42 },
  { 7155, 29, 42, 23, -2, -42 },
  { 7308, 22, 51, 17, -1, -42 },
  { 7449, 10, 42, 20, 6, -42 },
  { 7502, 22, 51, 17, -4, -42 },
  { 7643, 25, 24, 27, 1, -42 },
  { 7718, 20, 4, 20, -5, 5 },
  { 7728, 8, 9, 15, 9, -45 },
  { 7737, 25, 33, 28, 2, -32 },
  { 7841, 26, 46, 28, 0, -45 },
  { 7991, 20, 33, 21, 2, -32 },
  { 8074, 28, 46, 28, 2, -45 },
  { 8235, 21, 33, 25, 2, -32 },
  { 8322, 29, 59, 15, -7, -45 },
  { 8536, 27, 46, 28, 0, -32 },
  { 8692, 25, 45, 27, 0, -45 },
  { 8833, 14, 43, 13, 0, -43 },
  { 8909, 22, 57, 13, -8, -43 },
  { 9066, 26, 45, 24, 0, -45 },
  { 9213, 15, 45, 12, 0, -45 },
  { 9298, 39, 32, 41, 0, -32 },
  { 9454, 25, 32, 27, 0, -32 },
  { 9554, 23, 33, 27, 2, -32 },
  { 9649, 28, 46, 28, -2, -32 },
  { 9810, 25, 46, 28, 2, -32 },
  { 9954, 21, 32, 18, 0, -32 },
  { 10038, 21, 33, 21, 0, -32 },
  { 10125, 16, 40, 16, 2, -39 },
  { 10205, 25, 33, 27, 2, -32 },
  { 10309, 22, 32, 22, 3, -32 },
  { 10397, 34, 32, 35, 4, -32 },
  { 10533, 28, 32, 23, -3, -32 },
  { 10645, 31, 46, 22, -6, -32 },
  { 10824, 23, 32, 20, -2, -32 },
  { 10916, 22, 51, 20, 1, -42 },
  { 11057, 4, 59, 25, 11, -45 },
  { 11087, 22, 51, 20, -3, -42 },
  { 11228, 24, 8, 28, 3, -25 },
};

const GFXfont NotoSans_Condensed_Italic59pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Italic59pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Italic59pt7bGlyphs,
  0x20, 0x7E, 80
};

#endif // _NOTOSANS_CONDENSED_ITALIC59PT7B_H_
