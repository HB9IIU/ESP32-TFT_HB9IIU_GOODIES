#ifndef _NOTOSANS_CONDENSED_ITALIC37PT7B_H_
#define _NOTOSANS_CONDENSED_ITALIC37PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Italic.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Italic37pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xC0, 0xE0, 0x78, 0x1E, 0x07, 0x01, 0xC0, 0x70, 0x3C, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0C, 0x07, 0x01, 0xC0, 0x70, 0x18, 0x06, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x07, 0x01, 0xE0, 0xF0, 0x1C, 0x00, 0x79, 0xDC,
  0x77, 0x1D, 0x8E, 0xE3, 0xB8, 0xEE, 0x33, 0x0C, 0xC3, 0x00, 0x00, 0x71,
  0xC0, 0x0C, 0x30, 0x03, 0x86, 0x00, 0x61, 0xC0, 0x0C, 0x30, 0x03, 0x86,
  0x00, 0x61, 0xC0, 0xFF, 0xFF, 0x1F, 0xFF, 0xE0, 0x71, 0xC0, 0x0C, 0x30,
  0x01, 0x86, 0x00, 0x70, 0xC0, 0x0C, 0x38, 0x01, 0x86, 0x00, 0x70, 0xC0,
  0x7F, 0xFF, 0x1F, 0xFF, 0xE0, 0x70, 0xC0, 0x0C, 0x38, 0x01, 0x86, 0x00,
  0x30, 0xC0, 0x0E, 0x38, 0x01, 0x87, 0x00, 0x30, 0xC0, 0x0E, 0x38, 0x00,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0xFE, 0x03, 0xFF, 0x07, 0xFF,
  0x0E, 0x62, 0x0E, 0x60, 0x0C, 0x60, 0x0C, 0x60, 0x0C, 0x40, 0x0E, 0xC0,
  0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x01, 0xBC,
  0x01, 0x9C, 0x01, 0x1C, 0x03, 0x1C, 0x03, 0x1C, 0x43, 0x38, 0xF3, 0xF8,
  0xFF, 0xF0, 0x7F, 0xC0, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x07, 0x00, 0x10, 0x7C, 0x03, 0x07, 0x70, 0x38, 0x73, 0x83, 0x83, 0x0C,
  0x18, 0x38, 0x61, 0xC1, 0x87, 0x0C, 0x0C, 0x38, 0xE0, 0x61, 0xCE, 0x07,
  0x0C, 0x60, 0x38, 0x67, 0x01, 0xC7, 0x31, 0xEE, 0x33, 0xBF, 0xF3, 0x99,
  0x9F, 0xF9, 0x9C, 0x6F, 0x9C, 0xC3, 0x38, 0xCE, 0x18, 0x0E, 0x70, 0xC0,
  0x63, 0x0E, 0x07, 0x18, 0x70, 0x70, 0xC3, 0x83, 0x0E, 0x18, 0x38, 0x71,
  0xC1, 0x83, 0x8C, 0x1C, 0x0C, 0xE1, 0xC0, 0x7E, 0x0C, 0x01, 0xE0, 0x00,
  0x70, 0x00, 0x7F, 0x00, 0x3F, 0xE0, 0x0E, 0x38, 0x03, 0x0E, 0x01, 0xC3,
  0x80, 0x70, 0xE0, 0x1C, 0x38, 0x07, 0x1C, 0x01, 0xCF, 0x00, 0x3F, 0x80,
  0x0F, 0xC0, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x1C, 0x73, 0x87, 0x38,
  0xE3, 0x9C, 0x3C, 0xE7, 0x07, 0x73, 0xC1, 0xFC, 0xE0, 0x3E, 0x38, 0x0F,
  0x0E, 0x03, 0xC3, 0xC1, 0xF8, 0x79, 0xFE, 0x1F, 0xF3, 0x83, 0xF8, 0x70,
  0x7B, 0x9C, 0xE6, 0x73, 0x98, 0xC0, 0x00, 0x60, 0x1C, 0x07, 0x01, 0xC0,
  0x30, 0x0E, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x03, 0x80,
  0xE0, 0x1C, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x06, 0x00, 0xC0, 0x1C,
  0x03, 0x80, 0x30, 0x00, 0x01, 0xC0, 0x0C, 0x00, 0xC0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0x60, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0,
  0x1C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x1C, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x18, 0x00, 0xC1, 0x8E,
  0x0F, 0x70, 0x7F, 0xFC, 0x7F, 0xE1, 0xE3, 0x1F, 0x01, 0xDC, 0x3C, 0x60,
  0xC3, 0x82, 0x1C, 0x00, 0x80, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x3C, 0x70, 0xE3, 0x87, 0x1C, 0x30, 0xE0, 0xFF,
  0xFF, 0xEF, 0xEE, 0x00, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xF0, 0x03, 0xF0, 0x1F, 0xF0, 0x38, 0xF0, 0xE0, 0xE3,
  0xC1, 0xC7, 0x03, 0x8E, 0x07, 0x38, 0x0E, 0x70, 0x1C, 0xE0, 0x3B, 0x80,
  0x77, 0x00, 0xEE, 0x03, 0x9C, 0x07, 0x38, 0x0E, 0xE0, 0x1D, 0xC0, 0x7B,
  0x80, 0xE7, 0x01, 0xCE, 0x07, 0x1C, 0x0E, 0x38, 0x3C, 0x38, 0x70, 0x7B,
  0xC0, 0xFF, 0x00, 0xFC, 0x00, 0x03, 0xC1, 0xF0, 0xF8, 0xFE, 0x7B, 0xBC,
  0xE6, 0x38, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0xFF, 0x01, 0xFF, 0xC0, 0x70, 0xF0, 0x20,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x7F, 0xFC, 0x7F, 0xFC, 0x3F, 0xFE, 0x00,
  0x00, 0xF8, 0x03, 0xFC, 0x0F, 0xFE, 0x06, 0x0F, 0x04, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x07, 0xF0, 0x07, 0xC0, 0x07, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x80, 0x70,
  0xE3, 0xF0, 0xFF, 0xE0, 0xFF, 0x80, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x1F,
  0x00, 0x1E, 0x00, 0x36, 0x00, 0x7E, 0x00, 0x6E, 0x00, 0xEE, 0x01, 0xCC,
  0x03, 0x9C, 0x03, 0x1C, 0x07, 0x1C, 0x0E, 0x1C, 0x0C, 0x38, 0x1C, 0x38,
  0x38, 0x38, 0x30, 0x38, 0x70, 0x38, 0xE0, 0x70, 0xFF, 0xFE, 0xFF, 0xFE,
  0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x03, 0xFF, 0x03, 0xFF, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1F, 0xE0, 0x1F, 0xF8,
  0x1C, 0xF8, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x80, 0x78, 0xE1, 0xF0,
  0xFF, 0xE0, 0xFF, 0x80, 0x00, 0x1F, 0x00, 0xFF, 0x01, 0xFE, 0x03, 0xC0,
  0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x38, 0xE0, 0x3B, 0xF0, 0x77, 0xF8, 0x7C, 0x38, 0x78, 0x3C, 0x70, 0x1C,
  0x70, 0x1C, 0xF0, 0x1C, 0xE0, 0x1C, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x38,
  0xF0, 0x70, 0x70, 0x70, 0x79, 0xE0, 0x3F, 0xC0, 0x1F, 0x80, 0x3F, 0xFE,
  0x7F, 0xFC, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00,
  0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x70,
  0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x01,
  0xC0, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x00, 0x00,
  0x78, 0x01, 0xFE, 0x03, 0xFF, 0x07, 0x07, 0x0F, 0x07, 0x0E, 0x07, 0x0E,
  0x07, 0x0E, 0x07, 0x0E, 0x07, 0x0E, 0x0E, 0x07, 0x1C, 0x07, 0xF8, 0x03,
  0xF0, 0x03, 0xE0, 0x0F, 0xF0, 0x1E, 0x78, 0x38, 0x38, 0x78, 0x1C, 0x70,
  0x1C, 0xF0, 0x1C, 0xE0, 0x1C, 0xE0, 0x1C, 0xF0, 0x1C, 0x70, 0x38, 0x78,
  0x78, 0x3F, 0xF0, 0x1F, 0xC0, 0x00, 0xF0, 0x01, 0xFC, 0x07, 0xFE, 0x07,
  0x0E, 0x0E, 0x0F, 0x0E, 0x07, 0x1C, 0x07, 0x1C, 0x07, 0x1C, 0x07, 0x3C,
  0x07, 0x38, 0x0F, 0x38, 0x0E, 0x3C, 0x1E, 0x1C, 0x1E, 0x1F, 0x7E, 0x0F,
  0xEE, 0x0F, 0xDC, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x70, 0x00, 0x70, 0x00, 0xE0, 0xC7, 0xC0, 0xFF, 0x80, 0xFF, 0x00, 0x0E,
  0x0F, 0x0F, 0x0E, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x70, 0xF0, 0xF0, 0xF0, 0x01, 0x80, 0xF0, 0x3C, 0x0E,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x0C, 0x07, 0x01,
  0x80, 0xE0, 0x00, 0x00, 0x02, 0x00, 0x1C, 0x00, 0xF8, 0x07, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x00, 0x06, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x01, 0x80, 0x03, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0x70, 0x00,
  0x80, 0x00, 0x03, 0xC0, 0xFF, 0x0F, 0xFC, 0x30, 0xE0, 0x07, 0x80, 0x1C,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x78, 0x07, 0x80, 0x78, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0xC0, 0x0F, 0x01, 0xC0, 0x38, 0x01,
  0xC0, 0xE0, 0x01, 0x83, 0x80, 0x03, 0x86, 0x00, 0x07, 0x1C, 0x1F, 0xC6,
  0x30, 0x7F, 0x0C, 0xE1, 0x86, 0x19, 0x87, 0x1C, 0x37, 0x1C, 0x38, 0xEC,
  0x30, 0x61, 0xD8, 0x60, 0xC3, 0x31, 0xC3, 0x86, 0xE3, 0x87, 0x0D, 0xC6,
  0x0C, 0x3B, 0x8C, 0x38, 0x67, 0x1C, 0x71, 0xCE, 0x39, 0xF7, 0x1C, 0x3E,
  0x7C, 0x38, 0x38, 0xF0, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xE0, 0x30, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x77, 0x00,
  0x77, 0x00, 0x67, 0x00, 0xE7, 0x00, 0xE7, 0x01, 0xC7, 0x01, 0xC7, 0x03,
  0x87, 0x03, 0x87, 0x07, 0x07, 0x07, 0x07, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F,
  0xFF, 0x1C, 0x07, 0x1C, 0x07, 0x38, 0x07, 0x38, 0x07, 0x78, 0x07, 0x70,
  0x07, 0xF0, 0x07, 0xE0, 0x07, 0x03, 0xFE, 0x00, 0xFF, 0xE0, 0x78, 0x78,
  0x1C, 0x0F, 0x07, 0x01, 0xC1, 0xC0, 0x70, 0x70, 0x1C, 0x38, 0x0F, 0x0E,
  0x03, 0x83, 0x81, 0xE0, 0xE0, 0xF0, 0x7F, 0xF0, 0x1F, 0xF8, 0x07, 0xFF,
  0x81, 0xC0, 0xE0, 0x70, 0x3C, 0x3C, 0x07, 0x0E, 0x01, 0xC3, 0x80, 0x70,
  0xE0, 0x3C, 0x38, 0x0E, 0x1C, 0x07, 0x87, 0x03, 0xC1, 0xFF, 0xF0, 0x7F,
  0xF0, 0x3F, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0xF8,
  0x60, 0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x7E, 0xF0, 0x1F, 0xF8, 0x07,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x1E, 0x3E, 0x03, 0x81, 0xE0,
  0x70, 0x1C, 0x0E, 0x03, 0x81, 0xC0, 0x78, 0x70, 0x0F, 0x0E, 0x01, 0xE1,
  0xC0, 0x3C, 0x38, 0x07, 0x8F, 0x00, 0xF1, 0xC0, 0x1C, 0x38, 0x03, 0x87,
  0x00, 0x70, 0xE0, 0x1E, 0x3C, 0x03, 0x87, 0x00, 0x70, 0xE0, 0x1C, 0x1C,
  0x07, 0x83, 0x80, 0xE0, 0xE0, 0x3C, 0x1C, 0x1F, 0x03, 0xFF, 0xC0, 0x7F,
  0xE0, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x81, 0xFF, 0x81, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xC0, 0x70, 0x00,
  0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x7F, 0xF0, 0x00,
  0x03, 0xFF, 0x81, 0xFF, 0x81, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03,
  0xC0, 0x01, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0x38, 0x00, 0x3C, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x1F,
  0xFC, 0x0F, 0xFF, 0x03, 0xE0, 0xE0, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x00,
  0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x0F, 0x00, 0x01, 0xC0, 0x7F, 0x38, 0x0F, 0xE7, 0x03, 0xF8, 0xE0, 0x07,
  0x1C, 0x00, 0xE3, 0x80, 0x1C, 0x70, 0x07, 0x0E, 0x00, 0xE1, 0xC0, 0x1C,
  0x3C, 0x03, 0x83, 0xC0, 0x70, 0x7E, 0x3C, 0x07, 0xFF, 0x80, 0x3F, 0xE0,
  0x00, 0x03, 0x80, 0x78, 0x1C, 0x03, 0x81, 0xE0, 0x1C, 0x0E, 0x00, 0xE0,
  0x70, 0x07, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x81, 0xC0, 0x1C, 0x0E, 0x00,
  0xE0, 0x70, 0x07, 0x03, 0x80, 0x70, 0x1F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F,
  0xFF, 0xE0, 0x70, 0x0F, 0x03, 0x80, 0x70, 0x3C, 0x03, 0x81, 0xC0, 0x1C,
  0x0E, 0x00, 0xE0, 0x70, 0x0E, 0x03, 0x80, 0x70, 0x38, 0x03, 0x81, 0xC0,
  0x1C, 0x0E, 0x00, 0xE0, 0x70, 0x0E, 0x07, 0x80, 0x70, 0x00, 0x03, 0xFE,
  0x03, 0xF0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0xFC,
  0x00, 0x03, 0x80, 0xF0, 0x38, 0x1C, 0x07, 0x03, 0xC0, 0x70, 0x78, 0x07,
  0x0F, 0x00, 0x70, 0xE0, 0x07, 0x1C, 0x00, 0xE3, 0xC0, 0x0E, 0x78, 0x00,
  0xE7, 0x00, 0x0E, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00,
  0x1E, 0xE0, 0x01, 0xCF, 0x00, 0x3C, 0x70, 0x03, 0x87, 0x00, 0x38, 0x70,
  0x03, 0x83, 0x80, 0x38, 0x38, 0x07, 0x03, 0x80, 0x70, 0x3C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x0F, 0x01, 0xE0, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x38, 0x07, 0x00, 0x70, 0x07, 0xFF, 0x7F, 0xEF, 0xFE, 0x03, 0xC0, 0x03,
  0xE0, 0x78, 0x00, 0xF8, 0x1F, 0x80, 0x1F, 0x03, 0xF0, 0x07, 0xE0, 0x7E,
  0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x01, 0xB8, 0x07, 0xE0, 0x77, 0x01, 0xDC,
  0x0E, 0xE0, 0x3B, 0x81, 0xDC, 0x0E, 0x70, 0x3B, 0x81, 0xDC, 0x0E, 0x70,
  0x73, 0x81, 0xCE, 0x0E, 0x70, 0x39, 0xC3, 0x8E, 0x07, 0x18, 0x73, 0xC0,
  0xE3, 0x1C, 0x70, 0x38, 0x63, 0x8E, 0x07, 0x0C, 0xE1, 0xC0, 0xE1, 0x9C,
  0x38, 0x1C, 0x3B, 0x0F, 0x03, 0x87, 0xE1, 0xC0, 0xE0, 0xF8, 0x38, 0x1C,
  0x1F, 0x07, 0x03, 0x83, 0xC0, 0xE0, 0x70, 0x78, 0x38, 0x1C, 0x0E, 0x07,
  0x00, 0x03, 0xC0, 0x1C, 0x0F, 0x00, 0xE0, 0x7C, 0x03, 0x81, 0xF0, 0x0E,
  0x07, 0xE0, 0x38, 0x1F, 0x80, 0xE0, 0x6E, 0x07, 0x03, 0x98, 0x1C, 0x0E,
  0x70, 0x70, 0x39, 0xC1, 0xC0, 0xE7, 0x06, 0x07, 0x1C, 0x38, 0x1C, 0x30,
  0xE0, 0x70, 0xE3, 0x81, 0xC3, 0x8E, 0x07, 0x0E, 0x70, 0x38, 0x19, 0xC0,
  0xE0, 0x77, 0x03, 0x81, 0xDC, 0x0E, 0x07, 0x70, 0x38, 0x1D, 0x81, 0xC0,
  0x3E, 0x07, 0x00, 0xF8, 0x1C, 0x03, 0xE0, 0x70, 0x0F, 0x03, 0x80, 0x1C,
  0x00, 0x00, 0x7C, 0x00, 0x7F, 0xC0, 0x3F, 0xF8, 0x1E, 0x1E, 0x0F, 0x03,
  0xC7, 0x80, 0xF1, 0xC0, 0x1C, 0xE0, 0x07, 0x38, 0x01, 0xDE, 0x00, 0x77,
  0x00, 0x1D, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3B, 0x80,
  0x0E, 0xE0, 0x03, 0xB8, 0x01, 0xEE, 0x00, 0x73, 0x80, 0x1C, 0xE0, 0x0F,
  0x38, 0x03, 0x8F, 0x01, 0xC3, 0xC0, 0xF0, 0x7C, 0xF8, 0x0F, 0xFC, 0x01,
  0xFC, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0x81, 0xE3, 0xE0, 0xE0, 0xF0, 0x70,
  0x38, 0x38, 0x1C, 0x1C, 0x0E, 0x1C, 0x07, 0x0E, 0x03, 0x87, 0x03, 0xC3,
  0x81, 0xC3, 0xC1, 0xE1, 0xC3, 0xE0, 0xFF, 0xE0, 0x7F, 0xE0, 0x3F, 0x80,
  0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x7F, 0xC0, 0x3F, 0xF8, 0x1E, 0x1E, 0x0F, 0x03, 0xC7, 0x80, 0xF1,
  0xC0, 0x1C, 0xE0, 0x07, 0x38, 0x01, 0xDE, 0x00, 0x77, 0x00, 0x1D, 0xC0,
  0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3B, 0x80, 0x0E, 0xE0, 0x03,
  0xB8, 0x01, 0xEE, 0x00, 0x73, 0x80, 0x1C, 0xE0, 0x0F, 0x38, 0x03, 0x8F,
  0x01, 0xC3, 0xC0, 0xF0, 0x7C, 0xF8, 0x0F, 0xFC, 0x01, 0xFC, 0x00, 0x07,
  0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78,
  0x00, 0x03, 0xFE, 0x01, 0xFF, 0x81, 0xE3, 0xE0, 0xE0, 0xF0, 0x70, 0x38,
  0x38, 0x1C, 0x1C, 0x0E, 0x1C, 0x07, 0x0E, 0x03, 0x87, 0x03, 0xC3, 0x81,
  0xC3, 0xC1, 0xE1, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xC0, 0x38, 0xE0, 0x3C,
  0x70, 0x1C, 0x38, 0x0E, 0x1E, 0x07, 0x07, 0x03, 0x83, 0x83, 0x81, 0xC1,
  0xC0, 0xF0, 0xE0, 0x38, 0x70, 0x1C, 0x78, 0x0E, 0x00, 0x00, 0x7C, 0x03,
  0xFF, 0x07, 0xFF, 0x0F, 0x87, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x80, 0xF0, 0xFF, 0xF0, 0xFF,
  0xE0, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0,
  0x00, 0x0E, 0x01, 0xE3, 0x80, 0x38, 0x70, 0x07, 0x0E, 0x00, 0xE1, 0xC0,
  0x38, 0x38, 0x07, 0x0E, 0x00, 0xE1, 0xC0, 0x1C, 0x38, 0x03, 0x87, 0x00,
  0xE1, 0xE0, 0x1C, 0x38, 0x03, 0x87, 0x00, 0x70, 0xE0, 0x1E, 0x1C, 0x03,
  0x87, 0x80, 0x70, 0xE0, 0x0E, 0x1C, 0x01, 0xC3, 0x80, 0x70, 0x70, 0x0E,
  0x0E, 0x01, 0xC1, 0xC0, 0x70, 0x3C, 0x1E, 0x07, 0xEF, 0x80, 0x7F, 0xE0,
  0x07, 0xF8, 0x00, 0xE0, 0x07, 0xF0, 0x03, 0xB8, 0x03, 0x9C, 0x01, 0xCE,
  0x01, 0xC7, 0x00, 0xE1, 0xC0, 0xF0, 0xE0, 0x70, 0x70, 0x78, 0x38, 0x38,
  0x1C, 0x1C, 0x0E, 0x1C, 0x07, 0x0E, 0x03, 0x8E, 0x01, 0xC7, 0x00, 0xE7,
  0x00, 0x73, 0x80, 0x3B, 0xC0, 0x1D, 0xC0, 0x0E, 0xE0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x00, 0xE0,
  0x0E, 0x01, 0xF8, 0x07, 0x80, 0xFE, 0x01, 0xE0, 0x3B, 0x80, 0xF8, 0x0E,
  0xE0, 0x3E, 0x07, 0x38, 0x0F, 0x81, 0xCE, 0x07, 0xE0, 0xF3, 0x81, 0xB8,
  0x38, 0xE0, 0xEE, 0x0E, 0x38, 0x3B, 0x87, 0x0E, 0x1C, 0xE1, 0xC3, 0x87,
  0x38, 0xF0, 0xE1, 0x8E, 0x38, 0x38, 0xE3, 0x8E, 0x0E, 0x38, 0xE7, 0x03,
  0x9C, 0x39, 0xC0, 0xE7, 0x0E, 0xE0, 0x39, 0x83, 0xB8, 0x0E, 0xE0, 0xEE,
  0x03, 0xB0, 0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x03, 0xE0, 0x0F, 0x80,
  0xF8, 0x03, 0xE0, 0x3E, 0x00, 0xF0, 0x0F, 0x00, 0x3C, 0x03, 0xC0, 0x00,
  0x03, 0x80, 0xF0, 0x3C, 0x0E, 0x01, 0xC1, 0xC0, 0x1C, 0x1C, 0x01, 0xC3,
  0x80, 0x1C, 0x78, 0x01, 0xC7, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x0F,
  0xC0, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x03, 0xB8, 0x00, 0x73, 0x80, 0x07, 0x38, 0x00,
  0xE1, 0xC0, 0x1E, 0x1C, 0x01, 0xC1, 0xC0, 0x38, 0x1C, 0x07, 0x81, 0xC0,
  0x70, 0x1E, 0x0F, 0x00, 0xE0, 0xE0, 0x1E, 0xE0, 0x39, 0xC0, 0xE3, 0x81,
  0xC7, 0x07, 0x0E, 0x0E, 0x1C, 0x38, 0x38, 0xF0, 0x31, 0xC0, 0x77, 0x00,
  0xEE, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x0E, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x07, 0xFF, 0xC1, 0xFF, 0xE0, 0x00,
  0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xF0,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xE0,
  0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0xFF, 0xE0,
  0xFF, 0xF8, 0x3F, 0xFC, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0xF0, 0x3F,
  0xC0, 0xFE, 0x00, 0xE3, 0x8E, 0x38, 0xE1, 0x86, 0x1C, 0x71, 0xC7, 0x1C,
  0x30, 0xC3, 0x8E, 0x38, 0xE3, 0x8E, 0x18, 0x61, 0xC7, 0x1C, 0x70, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x00, 0x1C, 0x07, 0xF0, 0x1F, 0xC0, 0xFF, 0x00, 0x01, 0xC0, 0x03,
  0xC0, 0x0F, 0x80, 0x1B, 0x00, 0x77, 0x00, 0xCE, 0x03, 0x8C, 0x06, 0x1C,
  0x1C, 0x38, 0x70, 0x30, 0xE0, 0x73, 0x80, 0xE7, 0x00, 0xDC, 0x01, 0xC0,
  0xFF, 0xFF, 0xFF, 0xF1, 0xC3, 0x8E, 0x18, 0x30, 0x03, 0xE7, 0x07, 0xF7,
  0x0F, 0x37, 0x1E, 0x1E, 0x3C, 0x1E, 0x38, 0x0E, 0x38, 0x0E, 0x70, 0x1C,
  0x70, 0x1C, 0x70, 0x1C, 0x70, 0x1C, 0xE0, 0x1C, 0xE0, 0x38, 0xE0, 0x38,
  0xE0, 0x78, 0xE0, 0x78, 0xF0, 0xF8, 0x71, 0xB0, 0x7F, 0x30, 0x3E, 0x70,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x0E, 0x7C, 0x0E, 0xFE, 0x0F, 0xDF, 0x0F, 0x07,
  0x0F, 0x07, 0x1E, 0x07, 0x1E, 0x07, 0x1C, 0x07, 0x1C, 0x07, 0x18, 0x07,
  0x38, 0x0F, 0x38, 0x0E, 0x38, 0x0E, 0x38, 0x0E, 0x78, 0x1C, 0x78, 0x1C,
  0x78, 0x38, 0x7C, 0x78, 0x6F, 0xF0, 0xE7, 0xE0, 0x03, 0xF8, 0x3F, 0xC3,
  0xEC, 0x3C, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xF0, 0x03,
  0xC6, 0x1F, 0xF0, 0x3F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x03,
  0xE7, 0x01, 0xFD, 0xC0, 0xF3, 0x60, 0x78, 0x78, 0x3C, 0x1E, 0x0E, 0x03,
  0x83, 0x81, 0xE1, 0xC0, 0x70, 0x70, 0x1C, 0x1C, 0x07, 0x0F, 0x01, 0xC3,
  0x80, 0x70, 0xE0, 0x38, 0x38, 0x0E, 0x0E, 0x07, 0x83, 0x81, 0xE0, 0xF0,
  0xF8, 0x1C, 0x6C, 0x07, 0xF7, 0x00, 0xF9, 0xC0, 0x03, 0xF0, 0x1F, 0xE0,
  0xF3, 0x87, 0x07, 0x3C, 0x1C, 0xE0, 0x77, 0x83, 0x9C, 0x1E, 0x71, 0xF1,
  0xFF, 0x8F, 0xF8, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xF0, 0x01, 0xE1, 0x87, 0xFE, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xC8, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x0F,
  0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF3, 0x81, 0xFD, 0xC1,
  0xE6, 0xE1, 0xE1, 0xE0, 0xE0, 0xF0, 0xE0, 0x78, 0x70, 0x3C, 0x70, 0x1C,
  0x38, 0x0E, 0x1C, 0x07, 0x0E, 0x03, 0x8E, 0x03, 0xC7, 0x01, 0xC3, 0x80,
  0xE1, 0xC0, 0xF0, 0xE0, 0x78, 0x78, 0x7C, 0x1C, 0x7C, 0x0F, 0xEE, 0x03,
  0xE7, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0,
  0x40, 0xF0, 0x3F, 0xF0, 0x1F, 0xF0, 0x03, 0xE0, 0x00, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x0E, 0x7C, 0x0E, 0xFE, 0x0F, 0xFF, 0x0F, 0x0F, 0x0E, 0x07, 0x1E,
  0x07, 0x1C, 0x0E, 0x1C, 0x0E, 0x1C, 0x0E, 0x1C, 0x0E, 0x38, 0x0E, 0x38,
  0x1C, 0x38, 0x1C, 0x38, 0x1C, 0x70, 0x1C, 0x70, 0x1C, 0x70, 0x38, 0x70,
  0x38, 0x70, 0x38, 0xE0, 0x38, 0x03, 0x83, 0xC1, 0xE0, 0x60, 0x00, 0x00,
  0x00, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC1, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x1C, 0x0E, 0x07, 0x03, 0x83, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x03, 0xF0, 0x0F,
  0xC0, 0x3C, 0x00, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x07, 0x0E, 0x0E, 0x0E,
  0x1C, 0x0E, 0x3C, 0x0E, 0x78, 0x1C, 0x70, 0x1C, 0xE0, 0x1D, 0xC0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x3F, 0xC0, 0x3D, 0xC0, 0x38, 0xE0, 0x38, 0xE0, 0x70,
  0xE0, 0x70, 0xE0, 0x70, 0x70, 0x70, 0x70, 0x70, 0x70, 0xE0, 0x78, 0x03,
  0x81, 0xC0, 0xE0, 0x60, 0x70, 0x38, 0x1C, 0x0E, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0xE0, 0x70, 0x38, 0x1C, 0x0C, 0x0E, 0x07, 0x03, 0x81, 0xC1,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x1C, 0x00, 0x0E, 0x7C, 0x3E, 0x0E, 0xFE,
  0x7F, 0x0F, 0xDE, 0xEF, 0x0F, 0x0F, 0x87, 0x0E, 0x0F, 0x07, 0x1E, 0x0F,
  0x07, 0x1C, 0x0E, 0x07, 0x1C, 0x0E, 0x07, 0x1C, 0x0E, 0x07, 0x1C, 0x1C,
  0x0E, 0x38, 0x1C, 0x0E, 0x38, 0x1C, 0x0E, 0x38, 0x1C, 0x0E, 0x38, 0x1C,
  0x1C, 0x70, 0x38, 0x1C, 0x70, 0x38, 0x1C, 0x70, 0x38, 0x1C, 0x70, 0x38,
  0x1C, 0x70, 0x38, 0x38, 0xE0, 0x70, 0x38, 0x0E, 0x7C, 0x0E, 0xFE, 0x0F,
  0xFF, 0x0F, 0x0F, 0x0F, 0x07, 0x1E, 0x07, 0x1C, 0x0E, 0x1C, 0x0E, 0x1C,
  0x0E, 0x3C, 0x0E, 0x38, 0x0E, 0x38, 0x1C, 0x38, 0x1C, 0x38, 0x1C, 0x70,
  0x1C, 0x70, 0x3C, 0x70, 0x38, 0x70, 0x38, 0x70, 0x38, 0xE0, 0x38, 0x03,
  0xF0, 0x0F, 0xF0, 0x3D, 0xF0, 0xE0, 0xE3, 0xC1, 0xC7, 0x01, 0xCE, 0x03,
  0xB8, 0x0F, 0x70, 0x1C, 0xE0, 0x3B, 0xC0, 0x77, 0x00, 0xEE, 0x01, 0xDC,
  0x07, 0x38, 0x0E, 0x70, 0x3C, 0xF0, 0xF0, 0xF3, 0xC1, 0xFF, 0x00, 0xFC,
  0x00, 0x07, 0x3E, 0x03, 0xBF, 0x81, 0xF9, 0xE0, 0xF8, 0x70, 0x78, 0x38,
  0x78, 0x1C, 0x3C, 0x0E, 0x1C, 0x07, 0x0E, 0x03, 0x87, 0x01, 0xC7, 0x00,
  0xE3, 0x80, 0xE1, 0xC0, 0x70, 0xE0, 0x38, 0xF0, 0x38, 0x78, 0x1C, 0x3C,
  0x1C, 0x1F, 0x1E, 0x0F, 0xFE, 0x0E, 0x7E, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0xE7, 0x07, 0xF7, 0x0F, 0x37, 0x1E, 0x1E, 0x1C,
  0x1E, 0x38, 0x1E, 0x38, 0x1E, 0x70, 0x1C, 0x70, 0x1C, 0x70, 0x1C, 0x70,
  0x1C, 0xE0, 0x1C, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x78, 0xE0, 0x78, 0xF0,
  0xF8, 0x71, 0xF0, 0x7F, 0x70, 0x3E, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x0E, 0x78, 0x77, 0xC3, 0xFC, 0x1B, 0x00, 0xF0, 0x0F, 0x00, 0x78,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x00, 0x07, 0xF0,
  0x7F, 0xC7, 0x9C, 0x78, 0x23, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0x80, 0x1C,
  0x81, 0xC6, 0x1E, 0x3F, 0xE1, 0xFE, 0x00, 0x06, 0x01, 0x80, 0xE0, 0x38,
  0x1F, 0xDF, 0xF7, 0xFC, 0x70, 0x1C, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x0E, 0x03, 0x80, 0xE0, 0x3C, 0x87, 0xE1,
  0xF8, 0x1C, 0x07, 0x1C, 0x0E, 0x1C, 0x0E, 0x1C, 0x0E, 0x3C, 0x0E, 0x38,
  0x0E, 0x38, 0x1C, 0x38, 0x1C, 0x38, 0x1C, 0x70, 0x1C, 0x70, 0x3C, 0x70,
  0x38, 0x70, 0x38, 0x70, 0x38, 0xE0, 0x78, 0xE0, 0x70, 0xE0, 0xF0, 0xF3,
  0xF0, 0x7F, 0x70, 0x3E, 0x70, 0xE0, 0x3F, 0x80, 0xEE, 0x03, 0xB8, 0x1C,
  0xE0, 0x73, 0x83, 0x8E, 0x0E, 0x38, 0x70, 0xE1, 0xC3, 0x8E, 0x06, 0x38,
  0x19, 0xC0, 0x67, 0x01, 0x98, 0x06, 0xE0, 0x1B, 0x80, 0x7C, 0x01, 0xF0,
  0x07, 0x80, 0x1E, 0x00, 0xE0, 0x78, 0x1F, 0x81, 0xE0, 0xEE, 0x0F, 0x83,
  0xB8, 0x3E, 0x1C, 0xE1, 0xF8, 0x73, 0x87, 0xE1, 0xCE, 0x1B, 0x8E, 0x38,
  0xEE, 0x38, 0xE3, 0x39, 0xC3, 0x9C, 0xE7, 0x0E, 0x73, 0x98, 0x39, 0x8E,
  0xE0, 0xEE, 0x3B, 0x83, 0xB0, 0xDC, 0x0F, 0xC3, 0x70, 0x3F, 0x0D, 0x80,
  0xF8, 0x3E, 0x03, 0xE0, 0xF0, 0x0F, 0x03, 0xC0, 0x3C, 0x0F, 0x00, 0x07,
  0x03, 0xC1, 0xC1, 0xE0, 0x70, 0x70, 0x0E, 0x38, 0x03, 0x9E, 0x00, 0xE7,
  0x00, 0x1B, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x0F, 0x80, 0x03, 0xF0, 0x01, 0xDC, 0x00, 0xE7, 0x00, 0x79, 0xC0, 0x1C,
  0x38, 0x0E, 0x0E, 0x07, 0x83, 0x83, 0xC0, 0xF0, 0x07, 0x00, 0xE0, 0xE0,
  0x38, 0x1C, 0x07, 0x03, 0x81, 0xC0, 0x70, 0x38, 0x06, 0x0E, 0x00, 0xC1,
  0xC0, 0x18, 0x70, 0x03, 0x8E, 0x00, 0x71, 0x80, 0x0E, 0x70, 0x01, 0xCE,
  0x00, 0x3B, 0x80, 0x07, 0x70, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x03, 0xF0, 0x00,
  0x7C, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0x80, 0x0E,
  0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0xC0, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x01, 0xC0,
  0x8F, 0xFC, 0x3F, 0xF0, 0x00, 0x7C, 0x03, 0xE0, 0x1E, 0x00, 0x70, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x0E, 0x00, 0x78, 0x0F, 0xC0, 0x3C, 0x00, 0xF8, 0x00, 0xF0, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0C, 0x00, 0x38, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xC0,
  0x0F, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x03, 0x80, 0x0F,
  0xC0, 0x0E, 0x00, 0xF8, 0x07, 0x80, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x1E,
  0x03, 0xF0, 0x0F, 0x80, 0x38, 0x00, 0x7E, 0x03, 0xFF, 0x9F, 0x1F, 0xFC,
  0x0F, 0xC0,
};

const GFXglyph NotoSans_Condensed_Italic37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 10, 26, 9, 0, -26 },
  { 34, 10, 9, 13, 4, -26 },
  { 46, 19, 26, 18, 0, -26 },
  { 108, 16, 30, 16, 0, -28 },
  { 168, 21, 27, 25, 2, -27 },
  { 239, 18, 27, 19, 0, -27 },
  { 300, 5, 9, 7, 4, -26 },
  { 306, 11, 33, 10, 1, -27 },
  { 352, 12, 33, 10, -3, -27 },
  { 402, 13, 14, 15, 4, -28 },
  { 425, 15, 18, 18, 2, -22 },
  { 459, 7, 9, 8, -2, -4 },
  { 467, 8, 2, 10, 1, -11 },
  { 469, 4, 4, 8, 1, -4 },
  { 471, 18, 26, 13, -2, -26 },
  { 530, 15, 27, 16, 1, -27 },
  { 581, 10, 26, 16, 4, -26 },
  { 614, 17, 27, 16, -1, -27 },
  { 672, 16, 27, 16, 0, -27 },
  { 726, 16, 27, 16, 0, -27 },
  { 780, 16, 26, 16, 0, -26 },
  { 832, 16, 27, 16, 1, -27 },
  { 886, 15, 26, 16, 2, -26 },
  { 935, 16, 27, 16, 0, -27 },
  { 989, 16, 27, 16, 0, -27 },
  { 1043, 8, 20, 8, 0, -20 },
  { 1063, 10, 25, 8, -2, -20 },
  { 1095, 15, 17, 18, 2, -22 },
  { 1127, 15, 10, 18, 2, -18 },
  { 1146, 15, 17, 18, 2, -22 },
  { 1178, 13, 27, 12, 1, -27 },
  { 1222, 23, 30, 25, 1, -27 },
  { 1309, 16, 26, 17, -2, -26 },
  { 1361, 18, 26, 18, 0, -26 },
  { 1420, 17, 27, 17, 2, -27 },
  { 1478, 19, 26, 19, 0, -26 },
  { 1540, 17, 26, 15, 0, -26 },
  { 1596, 17, 26, 14, 0, -26 },
  { 1652, 19, 27, 20, 2, -27 },
  { 1717, 21, 26, 20, 0, -26 },
  { 1786, 15, 26, 10, -2, -26 },
  { 1835, 15, 33, 8, -6, -26 },
  { 1897, 20, 26, 17, 0, -26 },
  { 1962, 12, 26, 14, 0, -26 },
  { 2001, 27, 26, 26, 0, -26 },
  { 2089, 22, 26, 21, 0, -26 },
  { 2161, 18, 27, 21, 2, -27 },
  { 2222, 17, 26, 17, 0, -26 },
  { 2278, 18, 33, 21, 2, -27 },
  { 2353, 17, 26, 17, 0, -26 },
  { 2409, 16, 27, 15, 0, -27 },
  { 2463, 14, 26, 14, 3, -26 },
  { 2509, 19, 26, 20, 2, -26 },
  { 2571, 17, 26, 17, 3, -26 },
  { 2627, 26, 26, 26, 3, -26 },
  { 2712, 20, 26, 15, -2, -26 },
  { 2777, 15, 26, 15, 3, -26 },
  { 2826, 18, 26, 15, -1, -26 },
  { 2885, 14, 33, 11, -1, -27 },
  { 2943, 6, 26, 13, 4, -26 },
  { 2963, 14, 33, 11, -3, -27 },
  { 3021, 15, 14, 17, 1, -26 },
  { 3048, 12, 2, 12, -3, 3 },
  { 3051, 6, 6, 10, 5, -28 },
  { 3056, 16, 20, 17, 1, -20 },
  { 3096, 16, 28, 17, 0, -28 },
  { 3152, 13, 20, 13, 1, -20 },
  { 3185, 18, 28, 17, 1, -28 },
  { 3248, 14, 20, 15, 1, -20 },
  { 3283, 18, 37, 9, -4, -28 },
  { 3367, 17, 29, 17, 0, -20 },
  { 3429, 16, 28, 17, 0, -28 },
  { 3485, 9, 27, 8, 0, -27 },
  { 3516, 14, 36, 8, -5, -27 },
  { 3579, 16, 28, 15, 0, -28 },
  { 3635, 9, 28, 8, 0, -28 },
  { 3667, 24, 20, 26, 0, -20 },
  { 3727, 16, 20, 17, 0, -20 },
  { 3767, 15, 20, 17, 1, -20 },
  { 3805, 17, 29, 17, -1, -20 },
  { 3867, 16, 29, 17, 1, -20 },
  { 3925, 13, 20, 12, 0, -20 },
  { 3958, 13, 20, 13, 0, -20 },
  { 3991, 10, 24, 10, 1, -24 },
  { 4021, 16, 20, 17, 1, -20 },
  { 4061, 14, 20, 14, 2, -20 },
  { 4096, 22, 20, 22, 2, -20 },
  { 4151, 18, 20, 14, -2, -20 },
  { 4196, 19, 29, 14, -3, -20 },
  { 4265, 14, 20, 12, -1, -20 },
  { 4300, 14, 32, 12, 1, -26 },
  { 4356, 2, 37, 16, 7, -28 },
  { 4366, 14, 32, 12, -2, -26 },
  { 4422, 15, 4, 18, 2, -15 },
};

const GFXfont NotoSans_Condensed_Italic37pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Italic37pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Italic37pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _NOTOSANS_CONDENSED_ITALIC37PT7B_H_
