#ifndef _NOTOSANS_CONDENSED_ITALIC35PT7B_H_
#define _NOTOSANS_CONDENSED_ITALIC35PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Italic.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Italic35pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x83, 0xC1, 0xC0, 0xE0, 0x70, 0x38, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x01, 0x81, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x1C, 0x00, 0x00, 0x00,
  0x03, 0x81, 0xC1, 0xE0, 0x70, 0x00, 0x73, 0xDC, 0xE6, 0x3B, 0x8E, 0xE3,
  0x38, 0xCC, 0x73, 0x1C, 0xC6, 0x00, 0x00, 0x61, 0x80, 0x38, 0xC0, 0x0C,
  0x30, 0x03, 0x0C, 0x01, 0xC7, 0x00, 0x61, 0x80, 0x18, 0x60, 0x7F, 0xFF,
  0x1F, 0xFF, 0xC0, 0xC3, 0x00, 0x31, 0xC0, 0x18, 0x60, 0x06, 0x18, 0x01,
  0x86, 0x00, 0xE3, 0x01, 0xFF, 0xFC, 0xFF, 0xFE, 0x07, 0x1C, 0x01, 0x86,
  0x00, 0x61, 0x80, 0x38, 0xE0, 0x0C, 0x30, 0x03, 0x0C, 0x00, 0xC7, 0x00,
  0x61, 0x80, 0x00, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x70, 0x03,
  0xFF, 0x07, 0xFE, 0x0E, 0x66, 0x0C, 0x40, 0x1C, 0x40, 0x1C, 0xC0, 0x1C,
  0xC0, 0x0E, 0xC0, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01,
  0x78, 0x01, 0x38, 0x03, 0x38, 0x03, 0x38, 0x03, 0x38, 0x82, 0x38, 0xE2,
  0xF0, 0xFF, 0xE0, 0x7F, 0xC0, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0F, 0x00, 0xC1, 0xF8, 0x1C, 0x39, 0x81, 0x83, 0x18, 0x30, 0x71,
  0x87, 0x06, 0x18, 0x60, 0x61, 0x8E, 0x0E, 0x18, 0xC0, 0xC3, 0x9C, 0x0C,
  0x31, 0x80, 0xC3, 0x33, 0xEC, 0x77, 0x7F, 0xC6, 0x66, 0x3F, 0xEE, 0xE3,
  0x7C, 0xCC, 0x30, 0x18, 0xC3, 0x03, 0x9C, 0x70, 0x31, 0x87, 0x07, 0x18,
  0x60, 0x61, 0x86, 0x0C, 0x18, 0xE1, 0xC1, 0x8C, 0x18, 0x19, 0xC3, 0x81,
  0xF8, 0x70, 0x0F, 0x00, 0x01, 0xF8, 0x01, 0xFE, 0x00, 0xE7, 0x00, 0xE1,
  0x80, 0x70, 0xC0, 0x38, 0xE0, 0x1C, 0x70, 0x0E, 0x70, 0x07, 0x38, 0x03,
  0xB8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0xFC, 0x00, 0xFE, 0x1C, 0xE7, 0x0E,
  0xE1, 0xCE, 0x70, 0xE7, 0x30, 0x3F, 0x38, 0x1F, 0x9C, 0x07, 0x8E, 0x03,
  0x87, 0x03, 0xE1, 0xC7, 0xF0, 0xFF, 0xBC, 0x3F, 0x0E, 0x00, 0x77, 0x7E,
  0xEE, 0xCC, 0xC0, 0x00, 0xE0, 0x30, 0x0E, 0x03, 0x80, 0x60, 0x1C, 0x07,
  0x00, 0xE0, 0x18, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x30, 0x06, 0x00, 0xE0, 0x0C, 0x00, 0x01, 0xC0,
  0x38, 0x03, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x70, 0x0C,
  0x03, 0x80, 0xE0, 0x38, 0x00, 0x03, 0x00, 0x1C, 0x00, 0xE0, 0x86, 0x07,
  0x30, 0x7F, 0xBC, 0x7F, 0xE0, 0xEF, 0x0F, 0x01, 0xCC, 0x1E, 0x70, 0x63,
  0x81, 0x0C, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x38, 0x71,
  0xC3, 0x86, 0x1C, 0x30, 0xE0, 0xFF, 0xFF, 0xFE, 0x77, 0xF7, 0x00, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00,
  0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x1F, 0xE0, 0x73, 0xC3, 0x87, 0x1C,
  0x1C, 0x70, 0x73, 0x81, 0xCE, 0x07, 0x38, 0x1D, 0xC0, 0x77, 0x01, 0xDC,
  0x07, 0x70, 0x1D, 0x80, 0xEE, 0x03, 0xB8, 0x0E, 0xE0, 0x3B, 0x81, 0xCE,
  0x07, 0x38, 0x18, 0xE0, 0xE3, 0x87, 0x07, 0x3C, 0x1F, 0xE0, 0x3F, 0x00,
  0x03, 0x83, 0xC3, 0xE7, 0xF7, 0xB7, 0xB9, 0x1C, 0x0E, 0x07, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x60, 0x70, 0x38, 0x1C, 0x0E, 0x06, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0xE0, 0x70, 0x00, 0x01, 0xFC, 0x03, 0xFE, 0x07, 0x8F, 0x02,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x7F, 0xF8, 0x7F, 0xF8, 0xFF, 0xF8, 0x03, 0xF8, 0x1F, 0xF8, 0x3C,
  0x78, 0x20, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1C,
  0x00, 0x78, 0x03, 0xE0, 0x3F, 0x00, 0x7C, 0x01, 0x3E, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x10, 0x1E,
  0x30, 0x78, 0x7F, 0xE0, 0xFF, 0x80, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0xF8,
  0x01, 0xF0, 0x06, 0xC0, 0x1F, 0x80, 0x77, 0x00, 0xCE, 0x03, 0x98, 0x0E,
  0x70, 0x18, 0xE0, 0x71, 0xC1, 0xC3, 0x83, 0x06, 0x0C, 0x1C, 0x38, 0x38,
  0x60, 0x71, 0xFF, 0xFB, 0xFF, 0xF0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x38,
  0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00,
  0x7F, 0x80, 0xFF, 0x81, 0x07, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x90, 0x1E, 0x30, 0x78,
  0x7F, 0xE0, 0xFF, 0x80, 0x00, 0xFE, 0x03, 0xFC, 0x0F, 0x08, 0x38, 0x00,
  0xE0, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x73, 0x81, 0xDF,
  0xC3, 0xFF, 0x87, 0x87, 0x8E, 0x07, 0x1C, 0x0E, 0x70, 0x1C, 0xE0, 0x39,
  0xC0, 0x73, 0x80, 0xE7, 0x03, 0x8E, 0x07, 0x0E, 0x1C, 0x1E, 0x78, 0x1F,
  0xE0, 0x1F, 0x80, 0x3F, 0xFE, 0x7F, 0xF9, 0xFF, 0xF0, 0x00, 0xC0, 0x03,
  0x80, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00,
  0x0C, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x38,
  0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00,
  0xE0, 0x00, 0x01, 0xFC, 0x03, 0xFE, 0x07, 0x0E, 0x0E, 0x0E, 0x0E, 0x07,
  0x0E, 0x07, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x1C, 0x07, 0x3C, 0x07, 0xF8,
  0x03, 0xE0, 0x07, 0xE0, 0x1E, 0xF0, 0x3C, 0x70, 0x78, 0x38, 0x70, 0x38,
  0x70, 0x38, 0xE0, 0x18, 0xE0, 0x38, 0xE0, 0x38, 0x70, 0x38, 0x78, 0xF0,
  0x3F, 0xE0, 0x1F, 0xC0, 0x01, 0xF8, 0x0F, 0xF8, 0x1C, 0x70, 0x70, 0x71,
  0xC0, 0xE3, 0x81, 0xC7, 0x03, 0x8C, 0x07, 0x38, 0x0E, 0x70, 0x1C, 0xE0,
  0x79, 0xC0, 0xE1, 0xC3, 0xC3, 0xFF, 0x83, 0xF7, 0x03, 0x8E, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x3C, 0x20, 0xF0, 0x7F,
  0xC0, 0xFE, 0x00, 0x0E, 0x1C, 0x78, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x38, 0xF1, 0xE3, 0xC0, 0x03, 0x81, 0xC1, 0xE0,
  0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x1C, 0x0E, 0x0E, 0x07, 0x03, 0x03, 0x81, 0x81, 0x80, 0x00,
  0x04, 0x00, 0x30, 0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E,
  0x00, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xC0, 0x03, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80,
  0x03, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3C, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x3F, 0x03, 0xF0, 0x0F,
  0x00, 0x30, 0x00, 0x80, 0x00, 0x1F, 0xC3, 0xFE, 0x38, 0xF2, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x18, 0x03, 0x80, 0x38, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF,
  0x80, 0x1E, 0x07, 0x00, 0xE0, 0x0E, 0x07, 0x00, 0x18, 0x38, 0x00, 0x61,
  0xC0, 0x01, 0xC6, 0x0F, 0xE7, 0x38, 0x7F, 0x0C, 0xC3, 0x8C, 0x33, 0x1C,
  0x71, 0xD8, 0x61, 0xC7, 0x63, 0x86, 0x19, 0x8C, 0x18, 0x6E, 0x30, 0xE1,
  0xB8, 0xC3, 0x8C, 0xC3, 0x0C, 0x33, 0x0C, 0x71, 0xCC, 0x31, 0xC6, 0x30,
  0xFD, 0xF0, 0xC1, 0xE7, 0x83, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xF0, 0x30, 0x01, 0xFF, 0xC0, 0x01, 0xFC, 0x00,
  0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x6E,
  0x00, 0xEE, 0x00, 0xCE, 0x01, 0xCE, 0x01, 0xCE, 0x03, 0x8E, 0x03, 0x8E,
  0x07, 0x0E, 0x07, 0x0E, 0x07, 0xFE, 0x0F, 0xFE, 0x0F, 0xFE, 0x1C, 0x0E,
  0x1C, 0x06, 0x38, 0x06, 0x38, 0x07, 0x78, 0x07, 0x70, 0x07, 0xF0, 0x07,
  0xE0, 0x07, 0x03, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0xE0, 0xF0, 0x70,
  0x38, 0x30, 0x1C, 0x38, 0x0E, 0x1C, 0x0F, 0x0E, 0x07, 0x07, 0x07, 0x87,
  0x07, 0x83, 0xFF, 0x01, 0xFF, 0x80, 0xE1, 0xE0, 0x70, 0x78, 0x70, 0x1C,
  0x38, 0x0E, 0x1C, 0x07, 0x0E, 0x03, 0x86, 0x03, 0xC7, 0x01, 0xC3, 0x81,
  0xE1, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xC0, 0x00, 0x01, 0xFE, 0x03, 0xFF,
  0x07, 0xC6, 0x0F, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x60, 0x3F, 0xE0, 0x1F, 0xE0, 0x03, 0xF8,
  0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x1C, 0x1E, 0x07, 0x03, 0x81, 0x80, 0xE0,
  0xE0, 0x3C, 0x38, 0x07, 0x0E, 0x01, 0xC3, 0x80, 0x71, 0xC0, 0x3C, 0x70,
  0x0E, 0x1C, 0x03, 0x87, 0x00, 0xE1, 0xC0, 0x38, 0xE0, 0x1E, 0x38, 0x07,
  0x0E, 0x01, 0xC3, 0x80, 0xE0, 0xC0, 0x78, 0x70, 0x3C, 0x1C, 0x1E, 0x07,
  0xFF, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x07, 0xFF, 0x07,
  0xFE, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x1C, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0xFF, 0xE0, 0x03, 0xFF, 0x07,
  0xFF, 0x07, 0xFE, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0xFF, 0xF0, 0x7C, 0x78, 0x3C, 0x02, 0x1E, 0x00, 0x0F, 0x00,
  0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x7F, 0x38, 0x1F, 0x8E, 0x00, 0xE3, 0x80, 0x38, 0xE0,
  0x0E, 0x38, 0x03, 0x8E, 0x01, 0xC3, 0x80, 0x70, 0xE0, 0x1C, 0x3C, 0x07,
  0x07, 0xC3, 0xC0, 0xFF, 0xE0, 0x1F, 0xF0, 0x00, 0x03, 0x80, 0x70, 0x70,
  0x0E, 0x07, 0x00, 0xE0, 0x70, 0x0E, 0x07, 0x00, 0xE0, 0x60, 0x1C, 0x0E,
  0x01, 0xC0, 0xE0, 0x1C, 0x0E, 0x01, 0xC0, 0xE0, 0x1C, 0x0C, 0x03, 0x81,
  0xFF, 0xF8, 0x1F, 0xFF, 0x81, 0xC0, 0x38, 0x1C, 0x03, 0x03, 0x80, 0x70,
  0x38, 0x07, 0x03, 0x80, 0x70, 0x38, 0x07, 0x03, 0x00, 0x60, 0x70, 0x0E,
  0x07, 0x00, 0xE0, 0x70, 0x0E, 0x07, 0x00, 0xE0, 0xE0, 0x1C, 0x00, 0x07,
  0xF8, 0x7F, 0xC0, 0x70, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x1F, 0xE0, 0xFF, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x03, 0xF8, 0x0F, 0xC0, 0x1C, 0x00,
  0x03, 0x81, 0xE0, 0xE0, 0x78, 0x1C, 0x0E, 0x03, 0x83, 0x80, 0x70, 0xE0,
  0x0C, 0x38, 0x03, 0x8F, 0x00, 0x71, 0xC0, 0x0E, 0x70, 0x01, 0xDC, 0x00,
  0x77, 0x80, 0x0E, 0xE0, 0x01, 0xFC, 0x00, 0x3D, 0xC0, 0x07, 0x38, 0x01,
  0xC7, 0x00, 0x38, 0xE0, 0x07, 0x0E, 0x00, 0xE1, 0xC0, 0x1C, 0x38, 0x07,
  0x07, 0x80, 0xE0, 0x70, 0x1C, 0x0E, 0x03, 0x81, 0xC0, 0xE0, 0x3C, 0x00,
  0x03, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x18, 0x07, 0x00, 0xE0, 0x1F, 0xFB, 0xFF, 0xFF, 0xE0, 0x03,
  0xC0, 0x07, 0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x03, 0xE0, 0xF8, 0x03, 0xF0,
  0x7C, 0x01, 0xB0, 0x36, 0x01, 0xF8, 0x3B, 0x00, 0xDC, 0x1D, 0x80, 0xEE,
  0x0E, 0xC0, 0x76, 0x06, 0x60, 0x77, 0x07, 0x30, 0x3B, 0x83, 0x98, 0x39,
  0xC1, 0xCE, 0x1C, 0xE0, 0xE7, 0x1C, 0x60, 0x63, 0x8E, 0x70, 0x71, 0xCE,
  0x38, 0x38, 0xE7, 0x1C, 0x1C, 0x77, 0x0E, 0x0E, 0x3B, 0x8E, 0x06, 0x1D,
  0x87, 0x07, 0x0F, 0xC3, 0x83, 0x83, 0xC1, 0xC1, 0xC1, 0xE0, 0xE0, 0xC0,
  0xE0, 0xE0, 0xE0, 0x70, 0x70, 0x00, 0x03, 0x80, 0x38, 0x3C, 0x03, 0x81,
  0xF0, 0x1C, 0x0F, 0x80, 0xE0, 0x7C, 0x07, 0x03, 0x60, 0x30, 0x3B, 0x83,
  0x81, 0xDC, 0x1C, 0x0E, 0xE0, 0xE0, 0x63, 0x07, 0x07, 0x18, 0x30, 0x38,
  0xE3, 0x81, 0xC7, 0x1C, 0x0E, 0x38, 0xE0, 0x60, 0xC7, 0x07, 0x07, 0x30,
  0x38, 0x3B, 0x81, 0xC1, 0xDC, 0x0E, 0x06, 0xE0, 0x60, 0x36, 0x07, 0x01,
  0xF0, 0x38, 0x0F, 0x81, 0xC0, 0x7C, 0x0E, 0x01, 0xE0, 0xE0, 0x0E, 0x00,
  0x01, 0xFC, 0x01, 0xFF, 0x01, 0xE3, 0xC1, 0xC0, 0xE1, 0xC0, 0x39, 0xE0,
  0x1C, 0xE0, 0x0E, 0xF0, 0x07, 0x70, 0x03, 0xB8, 0x01, 0xFC, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3B, 0x80, 0x1D, 0xC0, 0x0E, 0xE0, 0x0F,
  0x70, 0x07, 0x38, 0x03, 0x9C, 0x03, 0x8E, 0x03, 0xC7, 0x83, 0xC1, 0xE3,
  0xC0, 0xFF, 0xC0, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x07, 0xFE, 0x07, 0xFE,
  0x07, 0x0F, 0x07, 0x07, 0x06, 0x07, 0x0E, 0x07, 0x0E, 0x07, 0x0E, 0x07,
  0x0E, 0x07, 0x1C, 0x0E, 0x1C, 0x1E, 0x1C, 0x7C, 0x1F, 0xF8, 0x1F, 0xE0,
  0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x01, 0xFC, 0x01, 0xFF,
  0x01, 0xE3, 0xC1, 0xC0, 0xE1, 0xC0, 0x39, 0xE0, 0x1C, 0xE0, 0x0E, 0xF0,
  0x07, 0x70, 0x03, 0xB8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x3B, 0x80, 0x1D, 0xC0, 0x0E, 0xE0, 0x0F, 0x70, 0x07, 0x38, 0x03,
  0x9C, 0x03, 0x8E, 0x03, 0xC7, 0x83, 0xC1, 0xE3, 0xC0, 0xFF, 0xC0, 0x1F,
  0xC0, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0xC0, 0x03, 0xF8, 0x07, 0xFE, 0x07, 0xFF, 0x07, 0x0F, 0x07, 0x07,
  0x06, 0x07, 0x0E, 0x07, 0x0E, 0x07, 0x0E, 0x07, 0x0E, 0x07, 0x1C, 0x0E,
  0x1C, 0x1E, 0x1F, 0xFC, 0x1F, 0xF0, 0x1F, 0xE0, 0x38, 0xE0, 0x38, 0x60,
  0x38, 0x70, 0x38, 0x70, 0x30, 0x70, 0x70, 0x78, 0x70, 0x38, 0x70, 0x38,
  0x70, 0x38, 0xE0, 0x3C, 0x01, 0xFE, 0x07, 0xFF, 0x0F, 0x9E, 0x0E, 0x02,
  0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x80, 0xF0,
  0xF3, 0xE0, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0E,
  0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x00, 0x1C,
  0x03, 0x8E, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0x71, 0x80, 0x31, 0xC0, 0x38,
  0xE0, 0x1C, 0x70, 0x0E, 0x38, 0x07, 0x38, 0x07, 0x1C, 0x03, 0x8E, 0x01,
  0xC7, 0x00, 0xE3, 0x80, 0x73, 0x80, 0x71, 0xC0, 0x38, 0xE0, 0x1C, 0x70,
  0x0E, 0x38, 0x0E, 0x1C, 0x07, 0x0E, 0x03, 0x87, 0x03, 0x83, 0xC7, 0xC0,
  0xFF, 0xC0, 0x3F, 0x80, 0x00, 0xE0, 0x0F, 0xE0, 0x0E, 0xE0, 0x1E, 0xE0,
  0x1C, 0xE0, 0x1C, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x70, 0xE0, 0x70, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE1, 0xC0, 0x61, 0xC0, 0x61, 0xC0, 0x63, 0x80, 0x63,
  0x80, 0x67, 0x00, 0x67, 0x00, 0x6E, 0x00, 0x6E, 0x00, 0x6C, 0x00, 0x7C,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0xE0, 0x1C, 0x03, 0xF0, 0x0E,
  0x03, 0xB8, 0x0F, 0x01, 0xDC, 0x07, 0x81, 0xCE, 0x07, 0xC0, 0xE7, 0x03,
  0xE0, 0x73, 0x83, 0xF0, 0x71, 0xC1, 0xF8, 0x38, 0xE0, 0xDC, 0x38, 0x70,
  0xEE, 0x1C, 0x38, 0x67, 0x0E, 0x1C, 0x73, 0x8E, 0x0E, 0x39, 0xC7, 0x07,
  0x18, 0xE7, 0x03, 0x9C, 0x73, 0x81, 0xCC, 0x39, 0x80, 0xEE, 0x1D, 0xC0,
  0x76, 0x0E, 0xE0, 0x3B, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0x81, 0xF0,
  0x07, 0xC0, 0xF8, 0x03, 0xC0, 0x7C, 0x01, 0xE0, 0x3C, 0x00, 0xF0, 0x1E,
  0x00, 0x00, 0x03, 0x80, 0xE0, 0x70, 0x38, 0x0E, 0x07, 0x00, 0xC1, 0xC0,
  0x1C, 0x70, 0x03, 0x8E, 0x00, 0x73, 0x80, 0x0E, 0x70, 0x00, 0xDC, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x1D, 0x80, 0x07, 0x38, 0x00, 0xE7, 0x00, 0x38, 0xE0, 0x0F,
  0x1C, 0x01, 0xC3, 0x80, 0x70, 0x38, 0x0E, 0x07, 0x03, 0x80, 0xE0, 0xE0,
  0x1C, 0x00, 0xE0, 0x1F, 0x80, 0xEE, 0x03, 0x98, 0x1C, 0x70, 0x71, 0xC3,
  0x87, 0x1C, 0x1C, 0x70, 0x73, 0x81, 0xCE, 0x03, 0x70, 0x0D, 0xC0, 0x3E,
  0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x07, 0xFF,
  0x83, 0xFF, 0x81, 0xFF, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xF0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x3C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0x80, 0x01, 0xFF, 0xC1, 0xFF,
  0xE0, 0xFF, 0xF0, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0xE0, 0x07, 0x00, 0x30,
  0x01, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0xE0, 0x7F, 0x03, 0xF8, 0x00, 0xC3, 0x0E, 0x38, 0xE3, 0x8E,
  0x18, 0x61, 0x87, 0x1C, 0x71, 0xC3, 0x0C, 0x30, 0xE3, 0x8E, 0x38, 0xE1,
  0x86, 0x1C, 0x03, 0xF8, 0x1F, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30,
  0x01, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x0F,
  0xE0, 0x7E, 0x03, 0xF0, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF8,
  0x07, 0xE0, 0x39, 0x80, 0xC7, 0x07, 0x1C, 0x18, 0x30, 0xE0, 0xE3, 0x03,
  0x9C, 0x06, 0x60, 0x1F, 0x80, 0x30, 0xFF, 0xFF, 0xFF, 0xE3, 0x9C, 0x63,
  0x8C, 0x03, 0xC6, 0x1F, 0xDC, 0x7D, 0xF8, 0xE1, 0xE3, 0x81, 0xC7, 0x03,
  0x9C, 0x07, 0x38, 0x0E, 0x70, 0x18, 0xC0, 0x73, 0x80, 0xE7, 0x01, 0xCE,
  0x07, 0x1C, 0x0E, 0x38, 0x3C, 0x70, 0x78, 0xF1, 0xF0, 0xFE, 0xC0, 0xF9,
  0x80, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0x80, 0x07, 0x00, 0x0E, 0x78, 0x1D, 0xF8, 0x36, 0x78, 0x78, 0x71,
  0xE0, 0xE3, 0xC1, 0xC7, 0x03, 0x8E, 0x07, 0x38, 0x0E, 0x70, 0x1C, 0xE0,
  0x39, 0xC0, 0xE3, 0x81, 0xCE, 0x03, 0x9E, 0x0E, 0x3C, 0x3C, 0x7C, 0xF0,
  0xDF, 0xC3, 0x9F, 0x00, 0x03, 0xF0, 0xFF, 0x1F, 0x31, 0xC0, 0x38, 0x03,
  0x80, 0x70, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0x70, 0x87, 0xF8, 0x3F, 0x80, 0x00, 0x03, 0x80,
  0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18,
  0x00, 0x1C, 0x03, 0xCE, 0x07, 0xF7, 0x07, 0xDF, 0x83, 0x87, 0x83, 0x81,
  0xC1, 0xC0, 0xE1, 0xC0, 0x70, 0xE0, 0x38, 0x70, 0x38, 0x38, 0x1C, 0x38,
  0x0E, 0x1C, 0x07, 0x0E, 0x07, 0x07, 0x03, 0x83, 0x83, 0xC1, 0xC1, 0xE0,
  0xF1, 0xF0, 0x3F, 0xB0, 0x0F, 0x98, 0x00, 0x03, 0xE0, 0x7F, 0x87, 0x9E,
  0x38, 0x73, 0x83, 0x9C, 0x1D, 0xC1, 0xCE, 0x1E, 0x7F, 0xE7, 0xFC, 0x3E,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x43, 0xFE,
  0x0F, 0xF0, 0x00, 0x07, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xFC, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE3, 0x07, 0xF7, 0x0F, 0xBF, 0x0E,
  0x1E, 0x1C, 0x0E, 0x1C, 0x0E, 0x38, 0x0E, 0x38, 0x0E, 0x38, 0x1C, 0x38,
  0x1C, 0x70, 0x1C, 0x70, 0x1C, 0x70, 0x38, 0x70, 0x38, 0x70, 0x78, 0x70,
  0x78, 0x79, 0xF8, 0x3F, 0xB0, 0x1F, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0xE0, 0xC3, 0xC0, 0xFF, 0x80, 0xFF, 0x00, 0x03,
  0x80, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80,
  0x07, 0x00, 0x0E, 0x78, 0x1D, 0xF8, 0x37, 0x78, 0x78, 0x71, 0xE0, 0xE3,
  0x81, 0xC7, 0x03, 0x8E, 0x0E, 0x38, 0x1C, 0x70, 0x38, 0xE0, 0x71, 0xC0,
  0xE3, 0x03, 0x8E, 0x07, 0x1C, 0x0E, 0x38, 0x1C, 0x70, 0x30, 0xC0, 0xE3,
  0x81, 0xC0, 0x03, 0x07, 0x07, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x0E, 0x0E,
  0x0C, 0x1C, 0x1C, 0x1C, 0x1C, 0x38, 0x38, 0x38, 0x38, 0x30, 0x70, 0x70,
  0x70, 0x70, 0x60, 0xE0, 0x00, 0x30, 0x07, 0x00, 0x70, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x38, 0x03, 0x80, 0x30, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01,
  0xC0, 0x1C, 0x03, 0xC0, 0xF8, 0x0F, 0x00, 0x03, 0x80, 0x07, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x0E,
  0x1C, 0x38, 0x38, 0xF0, 0x61, 0xC1, 0xC7, 0x03, 0x9C, 0x07, 0x70, 0x0D,
  0xC0, 0x1B, 0x80, 0x7F, 0x00, 0xF7, 0x01, 0xCE, 0x03, 0x1C, 0x0E, 0x1C,
  0x1C, 0x38, 0x38, 0x70, 0x70, 0xE0, 0xC0, 0xE3, 0x81, 0xC0, 0x03, 0x81,
  0xC1, 0xC0, 0xE0, 0x70, 0x38, 0x18, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x18, 0x1C, 0x0E, 0x07, 0x03, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x30, 0x38, 0x00, 0x0E, 0x78, 0x7C, 0x1B, 0xF9, 0xF8, 0x36,
  0x77, 0x78, 0x78, 0x78, 0x71, 0xE0, 0xE0, 0xE3, 0x81, 0xC1, 0xC7, 0x07,
  0x03, 0x8E, 0x0E, 0x06, 0x38, 0x1C, 0x1C, 0x70, 0x38, 0x38, 0xE0, 0x60,
  0x71, 0xC1, 0xC0, 0xE3, 0x83, 0x81, 0x8E, 0x07, 0x07, 0x1C, 0x0E, 0x0E,
  0x38, 0x18, 0x1C, 0x70, 0x70, 0x38, 0xC0, 0xE0, 0xE3, 0x81, 0xC1, 0xC0,
  0x0E, 0x78, 0x1B, 0xF8, 0x37, 0xF8, 0x78, 0x71, 0xE0, 0xE3, 0x81, 0xC7,
  0x03, 0x8E, 0x0E, 0x38, 0x1C, 0x70, 0x38, 0xE0, 0x71, 0xC0, 0xE3, 0x83,
  0x8E, 0x07, 0x1C, 0x0E, 0x38, 0x1C, 0x70, 0x30, 0xC0, 0xE3, 0x81, 0xC0,
  0x03, 0xE0, 0x3F, 0xC1, 0xE7, 0x87, 0x0E, 0x38, 0x1C, 0xE0, 0x77, 0x01,
  0xDC, 0x07, 0x70, 0x1F, 0x80, 0x6E, 0x03, 0xB8, 0x0E, 0xE0, 0x3B, 0x81,
  0xCE, 0x07, 0x38, 0x38, 0x71, 0xE1, 0xFF, 0x03, 0xF0, 0x00, 0x07, 0x3C,
  0x06, 0x7E, 0x06, 0xCF, 0x07, 0x87, 0x0F, 0x07, 0x0F, 0x07, 0x0E, 0x07,
  0x0E, 0x07, 0x0C, 0x07, 0x1C, 0x07, 0x1C, 0x07, 0x1C, 0x0E, 0x1C, 0x0E,
  0x3C, 0x0E, 0x3C, 0x1C, 0x3C, 0x3C, 0x3E, 0x78, 0x37, 0xF0, 0x73, 0xE0,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0x03, 0xC6, 0x1F, 0xDC, 0x7D, 0xF8, 0xE1, 0xE3,
  0x81, 0xC7, 0x03, 0x9C, 0x07, 0x38, 0x0E, 0x70, 0x38, 0xE0, 0x73, 0x80,
  0xE7, 0x01, 0xCE, 0x07, 0x1C, 0x0E, 0x38, 0x3C, 0x70, 0x78, 0xF3, 0xF0,
  0xFE, 0xC0, 0xFB, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x70, 0xCF, 0x0D, 0xF0,
  0xF0, 0x1E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x30, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x00,
  0x07, 0xE1, 0xFF, 0x1C, 0x73, 0x80, 0x38, 0x03, 0x80, 0x38, 0x01, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0xC3, 0xCF, 0xF8, 0xFF, 0x00, 0x06, 0x07, 0x03, 0x01, 0x83, 0xFB, 0xFD,
  0xFE, 0x30, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0xE1, 0xF0, 0x1C, 0x0E, 0x38, 0x1C, 0x70,
  0x71, 0xC0, 0xE3, 0x81, 0xC7, 0x03, 0x8E, 0x06, 0x18, 0x1C, 0x70, 0x38,
  0xE0, 0x71, 0xC0, 0xE3, 0x83, 0x86, 0x07, 0x1C, 0x0E, 0x38, 0x3C, 0x70,
  0xF8, 0xF3, 0xE0, 0xFE, 0xC1, 0xF9, 0x80, 0xE0, 0x3F, 0x03, 0xB8, 0x1D,
  0xC1, 0xCE, 0x0E, 0x70, 0x63, 0x87, 0x1C, 0x30, 0xE3, 0x87, 0x1C, 0x39,
  0xC1, 0xCE, 0x06, 0xE0, 0x37, 0x01, 0xB0, 0x0F, 0x80, 0x78, 0x03, 0xC0,
  0x1C, 0x00, 0xE0, 0x70, 0x7E, 0x0F, 0x07, 0xE0, 0xF0, 0x7E, 0x1F, 0x0E,
  0xE1, 0xB0, 0xEE, 0x3F, 0x1C, 0xE3, 0x71, 0xCE, 0x37, 0x18, 0xE7, 0x73,
  0x8E, 0x67, 0x38, 0xEE, 0x77, 0x0E, 0xC7, 0x70, 0xEC, 0x76, 0x0F, 0xC7,
  0xE0, 0xF8, 0x7C, 0x0F, 0x87, 0xC0, 0xF0, 0x7C, 0x0F, 0x07, 0x80, 0xF0,
  0x78, 0x00, 0x07, 0x07, 0x83, 0x83, 0x81, 0xC3, 0x80, 0x63, 0x80, 0x39,
  0xC0, 0x1D, 0xC0, 0x0E, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xE0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x73, 0x00, 0x39, 0xC0, 0x38, 0xE0,
  0x38, 0x70, 0x1C, 0x1C, 0x3C, 0x0E, 0x00, 0x07, 0x01, 0xC1, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0C, 0x07, 0x07, 0x01, 0xC1, 0xC0, 0x70, 0xE0, 0x0C,
  0x38, 0x03, 0x1C, 0x00, 0xC7, 0x00, 0x33, 0x80, 0x0C, 0xE0, 0x03, 0x30,
  0x00, 0xDC, 0x00, 0x36, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xF8, 0x7F, 0xC3,
  0xFE, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0x80, 0x38,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07,
  0xFE, 0x3F, 0xF0, 0x00, 0x78, 0x0F, 0x80, 0x78, 0x07, 0x00, 0x38, 0x01,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xE0,
  0x0E, 0x03, 0xE0, 0x1C, 0x00, 0x78, 0x00, 0xC0, 0x07, 0x00, 0x30, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xF0,
  0x03, 0xE0, 0x0F, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0x80, 0x1F, 0x00,
  0x78, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0xE0, 0x0F, 0x01, 0xF8,
  0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x38, 0x0F, 0xC0, 0x7C, 0x02, 0x00, 0x00, 0x30,
  0x07, 0xF8, 0x1F, 0xFF, 0xE0, 0xFE, 0x80, 0xF0,
};

const GFXglyph NotoSans_Condensed_Italic35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 9, 25, 9, 0, -25 },
  { 30, 10, 9, 12, 4, -25 },
  { 42, 18, 25, 17, 0, -25 },
  { 99, 16, 29, 15, 0, -27 },
  { 157, 20, 25, 23, 2, -25 },
  { 220, 17, 25, 18, 0, -25 },
  { 274, 4, 9, 7, 4, -25 },
  { 279, 11, 31, 9, 1, -25 },
  { 322, 11, 31, 9, -3, -25 },
  { 365, 13, 13, 15, 3, -27 },
  { 387, 14, 17, 17, 2, -21 },
  { 417, 7, 9, 8, -2, -4 },
  { 425, 8, 3, 10, 1, -11 },
  { 428, 4, 4, 8, 0, -4 },
  { 430, 17, 25, 12, -2, -25 },
  { 484, 14, 25, 15, 1, -25 },
  { 528, 9, 25, 15, 4, -25 },
  { 557, 16, 25, 15, -1, -25 },
  { 607, 15, 25, 15, 0, -25 },
  { 654, 15, 25, 15, 0, -25 },
  { 701, 15, 25, 15, 0, -25 },
  { 748, 15, 25, 15, 1, -25 },
  { 795, 15, 25, 15, 2, -25 },
  { 842, 16, 25, 15, 0, -25 },
  { 892, 15, 25, 15, 0, -25 },
  { 939, 7, 19, 8, 0, -19 },
  { 956, 9, 24, 8, -2, -19 },
  { 983, 14, 17, 17, 2, -21 },
  { 1013, 14, 10, 17, 2, -17 },
  { 1031, 14, 17, 17, 2, -21 },
  { 1061, 12, 25, 12, 1, -25 },
  { 1099, 22, 28, 23, 1, -25 },
  { 1176, 16, 25, 16, -2, -25 },
  { 1226, 17, 25, 17, 0, -25 },
  { 1280, 16, 25, 16, 2, -25 },
  { 1330, 18, 25, 18, 0, -25 },
  { 1387, 16, 25, 14, 0, -25 },
  { 1437, 16, 25, 13, 0, -25 },
  { 1487, 18, 25, 19, 2, -25 },
  { 1544, 20, 25, 19, 0, -25 },
  { 1607, 13, 25, 10, -1, -25 },
  { 1648, 14, 32, 8, -5, -25 },
  { 1704, 19, 25, 16, 0, -25 },
  { 1764, 11, 25, 13, 0, -25 },
  { 1799, 25, 25, 25, 0, -25 },
  { 1878, 21, 25, 20, 0, -25 },
  { 1944, 17, 25, 20, 2, -25 },
  { 1998, 16, 25, 16, 0, -25 },
  { 2048, 17, 31, 20, 2, -25 },
  { 2114, 16, 25, 16, 0, -25 },
  { 2164, 16, 25, 15, 0, -25 },
  { 2214, 13, 25, 14, 3, -25 },
  { 2255, 17, 25, 19, 2, -25 },
  { 2309, 16, 25, 16, 3, -25 },
  { 2359, 25, 25, 25, 3, -25 },
  { 2438, 19, 25, 15, -2, -25 },
  { 2498, 14, 25, 14, 3, -25 },
  { 2542, 17, 25, 14, -1, -25 },
  { 2596, 13, 31, 10, -1, -25 },
  { 2647, 6, 25, 12, 4, -25 },
  { 2666, 13, 31, 10, -2, -25 },
  { 2717, 14, 14, 16, 1, -25 },
  { 2742, 12, 2, 12, -3, 3 },
  { 2745, 5, 6, 9, 5, -27 },
  { 2749, 15, 19, 16, 1, -19 },
  { 2785, 15, 27, 16, 0, -27 },
  { 2836, 12, 19, 13, 1, -19 },
  { 2865, 17, 27, 16, 1, -27 },
  { 2923, 13, 19, 15, 1, -19 },
  { 2954, 17, 35, 9, -4, -27 },
  { 3029, 16, 27, 16, 0, -19 },
  { 3083, 15, 27, 16, 0, -27 },
  { 3134, 8, 26, 7, 0, -26 },
  { 3160, 12, 34, 7, -4, -26 },
  { 3211, 15, 27, 14, 0, -27 },
  { 3262, 9, 27, 7, 0, -27 },
  { 3293, 23, 19, 24, 0, -19 },
  { 3348, 15, 19, 16, 0, -19 },
  { 3384, 14, 19, 16, 1, -19 },
  { 3418, 16, 27, 16, -1, -19 },
  { 3472, 15, 27, 16, 1, -19 },
  { 3523, 12, 19, 11, 0, -19 },
  { 3552, 12, 19, 12, 0, -19 },
  { 3581, 9, 23, 9, 1, -23 },
  { 3607, 15, 19, 16, 1, -19 },
  { 3643, 13, 19, 13, 2, -19 },
  { 3674, 20, 19, 21, 2, -19 },
  { 3722, 17, 19, 14, -2, -19 },
  { 3763, 18, 27, 13, -3, -19 },
  { 3824, 13, 19, 12, -1, -19 },
  { 3855, 13, 31, 12, 1, -25 },
  { 3906, 3, 35, 15, 6, -27 },
  { 3920, 13, 31, 12, -2, -25 },
  { 3971, 14, 5, 17, 2, -15 },
};

const GFXfont NotoSans_Condensed_Italic35pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Italic35pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Italic35pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _NOTOSANS_CONDENSED_ITALIC35PT7B_H_
