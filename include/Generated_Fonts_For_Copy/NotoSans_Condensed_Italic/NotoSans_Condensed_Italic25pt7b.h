#ifndef _NOTOSANS_CONDENSED_ITALIC25PT7B_H_
#define _NOTOSANS_CONDENSED_ITALIC25PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Italic.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Italic25pt7bBitmaps[] PROGMEM = {
  0x00, 0x0C, 0x30, 0xC7, 0x18, 0x61, 0x86, 0x30, 0xC3, 0x0C, 0x20, 0x00,
  0x18, 0xE3, 0x80, 0xEF, 0x9B, 0x36, 0x6C, 0xD1, 0x26, 0x00, 0x03, 0x30,
  0x11, 0x80, 0x88, 0x0C, 0xC0, 0x66, 0x1F, 0xFC, 0xFF, 0xE1, 0x98, 0x08,
  0xC0, 0xC4, 0x06, 0x61, 0xFF, 0xCF, 0xFE, 0x19, 0x80, 0x8C, 0x04, 0x40,
  0x66, 0x03, 0x30, 0x00, 0x01, 0x80, 0x20, 0x1F, 0x07, 0xF1, 0xB2, 0x64,
  0x0C, 0x81, 0xD0, 0x1E, 0x01, 0xC0, 0x1C, 0x02, 0xC0, 0x58, 0x1B, 0x02,
  0x66, 0x5C, 0xFF, 0x07, 0x80, 0x60, 0x08, 0x00, 0x1C, 0x0C, 0x6C, 0x30,
  0x98, 0x43, 0x31, 0x86, 0x66, 0x08, 0xCC, 0x11, 0xB0, 0x62, 0x4E, 0xCD,
  0xBC, 0xF6, 0xCD, 0xCD, 0x98, 0x32, 0x30, 0x4C, 0x41, 0x98, 0x86, 0x33,
  0x0C, 0x66, 0x30, 0xD8, 0xC0, 0xE0, 0x07, 0x80, 0xFC, 0x0C, 0xC0, 0x8C,
  0x18, 0xC1, 0x9C, 0x0D, 0x80, 0xF0, 0x0E, 0x01, 0xE0, 0x36, 0x36, 0x36,
  0xC3, 0x6C, 0x1C, 0xC1, 0xCC, 0x3C, 0x7F, 0xC7, 0xCE, 0x7B, 0x6D, 0x20,
  0x06, 0x18, 0x30, 0xC3, 0x06, 0x18, 0x30, 0x61, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x0C, 0x00, 0x06, 0x06, 0x06, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x06, 0x06, 0x06, 0x0E, 0x0C,
  0x0C, 0x18, 0x18, 0x30, 0x60, 0xC0, 0x0E, 0x06, 0x13, 0x1F, 0x91, 0xF8,
  0xE0, 0xD8, 0xCC, 0x23, 0x00, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x3F,
  0xFF, 0xFC, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x33, 0x76, 0x4C, 0x7F,
  0xF0, 0x7F, 0x80, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00,
  0xC0, 0x30, 0x06, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x03,
  0x00, 0x60, 0x18, 0x00, 0x0F, 0x07, 0xE1, 0x9C, 0xC3, 0x30, 0xD8, 0x36,
  0x0D, 0x83, 0xC1, 0xB0, 0x6C, 0x1B, 0x06, 0xC3, 0xB0, 0xCC, 0x33, 0x18,
  0xFC, 0x1E, 0x00, 0x0E, 0x38, 0xF7, 0x6C, 0xC3, 0x06, 0x0C, 0x18, 0x70,
  0xC1, 0x83, 0x06, 0x18, 0x30, 0x60, 0xC0, 0x07, 0xC0, 0xFE, 0x0C, 0x70,
  0x03, 0x00, 0x30, 0x07, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x03, 0x00, 0x7F, 0xCF, 0xF8, 0x0F, 0x83,
  0xF8, 0x43, 0x80, 0x30, 0x06, 0x01, 0x80, 0x30, 0x1C, 0x1F, 0x03, 0xE0,
  0x0E, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x64, 0x1C, 0xFF, 0x1F, 0xC0, 0x00,
  0xE0, 0x1C, 0x07, 0x01, 0xE0, 0x2C, 0x0D, 0x83, 0x30, 0xCC, 0x19, 0x86,
  0x31, 0x86, 0x31, 0xCF, 0xFD, 0xFF, 0x80, 0xC0, 0x18, 0x06, 0x00, 0xC0,
  0x0F, 0xE1, 0xFC, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x0C, 0x01, 0xF8, 0x3F,
  0x80, 0x30, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0x64, 0x1C, 0xFF, 0x1F,
  0xC0, 0x03, 0xC3, 0xF1, 0xC0, 0x60, 0x30, 0x0C, 0x06, 0x01, 0xBC, 0x7F,
  0xB8, 0x6C, 0x1B, 0x06, 0xC1, 0xB0, 0x6C, 0x33, 0x0C, 0x7E, 0x1F, 0x00,
  0x3F, 0xEF, 0xFC, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x06,
  0x01, 0xC0, 0x30, 0x0E, 0x01, 0x80, 0x70, 0x0C, 0x03, 0x80, 0x60, 0x1C,
  0x00, 0x07, 0xC1, 0xFC, 0x61, 0x8C, 0x31, 0x86, 0x30, 0xC6, 0x30, 0x7C,
  0x0F, 0x03, 0xE0, 0xC6, 0x30, 0xCE, 0x1D, 0x81, 0xB0, 0x67, 0x0C, 0x77,
  0x07, 0xC0, 0x07, 0x81, 0xF8, 0x63, 0x1C, 0x33, 0x06, 0x60, 0xCC, 0x39,
  0x86, 0x30, 0xC7, 0x78, 0x7B, 0x00, 0x60, 0x18, 0x03, 0x00, 0xC0, 0x38,
  0xFE, 0x1F, 0x00, 0x08, 0xCE, 0x20, 0x00, 0x00, 0x00, 0x00, 0xCE, 0x70,
  0x04, 0x31, 0xC2, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x31, 0x86, 0x10,
  0xC0, 0x00, 0x40, 0x30, 0x3C, 0x3C, 0x3C, 0x3C, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0C, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFC, 0x80, 0x38, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x1C, 0x1E, 0x1E,
  0x1E, 0x0E, 0x02, 0x00, 0x3E, 0x7F, 0x43, 0x03, 0x03, 0x03, 0x06, 0x0C,
  0x18, 0x30, 0x30, 0x60, 0x60, 0x00, 0x00, 0xC0, 0xE0, 0xC0, 0x01, 0xF0,
  0x0F, 0xF8, 0x30, 0x30, 0xC0, 0x33, 0x00, 0x64, 0x3E, 0x58, 0xC8, 0xB3,
  0x31, 0x44, 0x67, 0x98, 0xCF, 0x31, 0x1E, 0x46, 0x28, 0x8C, 0xD1, 0xAB,
  0x23, 0xDC, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC3, 0x00, 0xFC, 0x00,
  0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0x60, 0x36, 0x03, 0x60, 0x66,
  0x06, 0x60, 0xC6, 0x0F, 0xE1, 0xFF, 0x18, 0x73, 0x83, 0x30, 0x33, 0x03,
  0x60, 0x3E, 0x03, 0x0F, 0xC0, 0xFE, 0x0C, 0x71, 0x83, 0x18, 0x31, 0x83,
  0x18, 0x61, 0x8E, 0x3F, 0x83, 0xFC, 0x30, 0xC3, 0x06, 0x70, 0x66, 0x0E,
  0x60, 0xC6, 0x1C, 0x7F, 0x8F, 0xE0, 0x03, 0xF0, 0xFE, 0x1C, 0x21, 0x80,
  0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x7F, 0x03, 0xF0, 0x0F, 0xC0, 0x7F,
  0x03, 0x1C, 0x30, 0x61, 0x83, 0x8C, 0x1C, 0x60, 0xE3, 0x07, 0x30, 0x31,
  0x81, 0x8C, 0x0C, 0x60, 0xE7, 0x06, 0x30, 0x71, 0x83, 0x0C, 0x70, 0x7F,
  0x07, 0xF0, 0x00, 0x0F, 0xE1, 0xFC, 0x30, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x3F, 0x87, 0xF0, 0xC0, 0x18, 0x07, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x7F, 0x1F, 0xE0, 0x0F, 0xE1, 0xFC, 0x30, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x3F, 0x87, 0xF0, 0xC0, 0x18, 0x07, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x18, 0x00, 0x03, 0xF0, 0x7F, 0xC7, 0x04, 0x30, 0x03,
  0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x0F, 0xB0, 0x19, 0x80,
  0xCC, 0x06, 0x60, 0x33, 0x83, 0x0C, 0x18, 0x7F, 0xC0, 0xFE, 0x00, 0x0C,
  0x0C, 0x30, 0x30, 0xC1, 0x86, 0x06, 0x18, 0x18, 0x60, 0x61, 0x81, 0x86,
  0x0C, 0x3F, 0xF0, 0xFF, 0xC3, 0x03, 0x0C, 0x1C, 0x70, 0x61, 0x81, 0x86,
  0x06, 0x18, 0x18, 0x60, 0xE3, 0x83, 0x00, 0x0F, 0xC7, 0xC0, 0x60, 0x18,
  0x06, 0x01, 0x80, 0xC0, 0x30, 0x0C, 0x03, 0x01, 0xC0, 0x60, 0x18, 0x06,
  0x01, 0x80, 0xC0, 0x38, 0x3F, 0x00, 0x00, 0xC0, 0x30, 0x0C, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x07, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x03, 0x80, 0xC0, 0x30, 0x1C, 0x3E, 0x0E, 0x00, 0x0C,
  0x18, 0x61, 0x83, 0x1C, 0x31, 0xC1, 0x8C, 0x0C, 0xC0, 0x6C, 0x03, 0xE0,
  0x36, 0x01, 0xF0, 0x0E, 0xC0, 0x66, 0x07, 0x30, 0x31, 0xC1, 0x86, 0x0C,
  0x30, 0x61, 0x86, 0x0E, 0x00, 0x0C, 0x0C, 0x0C, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x30, 0x30, 0x30, 0x30, 0x70, 0x60, 0x60, 0x60, 0x7F, 0xFF, 0x0E,
  0x01, 0xC3, 0x80, 0xF0, 0xE0, 0x3C, 0x78, 0x1E, 0x1E, 0x07, 0x87, 0x83,
  0x61, 0xA0, 0xD8, 0x48, 0x6C, 0x32, 0x1B, 0x0C, 0xCC, 0xC3, 0x33, 0x30,
  0xCD, 0x8C, 0x63, 0x66, 0x18, 0xD1, 0x86, 0x3C, 0x61, 0x8E, 0x18, 0x63,
  0x86, 0x30, 0xC3, 0x00, 0x0E, 0x06, 0x1C, 0x18, 0x38, 0x30, 0xF0, 0x61,
  0xA0, 0xC3, 0x61, 0x86, 0xC6, 0x09, 0x8C, 0x33, 0x18, 0x63, 0x30, 0xC6,
  0x61, 0x8D, 0x86, 0x1B, 0x0C, 0x16, 0x18, 0x3C, 0x30, 0x70, 0x60, 0xE1,
  0x81, 0xC0, 0x07, 0xC0, 0x7F, 0x87, 0x0C, 0x70, 0x63, 0x03, 0xB8, 0x1D,
  0x80, 0xEC, 0x06, 0x60, 0x37, 0x01, 0xB0, 0x0D, 0x80, 0xEC, 0x06, 0x60,
  0x33, 0x83, 0x0C, 0x38, 0x7F, 0x81, 0xF8, 0x00, 0x0F, 0x80, 0xFE, 0x0C,
  0x61, 0x87, 0x18, 0x71, 0x87, 0x18, 0x61, 0x86, 0x30, 0xC3, 0xFC, 0x3F,
  0x03, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0x07,
  0xC0, 0x7F, 0x87, 0x0C, 0x70, 0x63, 0x03, 0xB8, 0x1D, 0x80, 0xEC, 0x06,
  0x60, 0x37, 0x01, 0xB0, 0x0D, 0x80, 0xEC, 0x06, 0x60, 0x33, 0x83, 0x0C,
  0x38, 0x7F, 0x81, 0xF8, 0x01, 0x80, 0x06, 0x00, 0x30, 0x01, 0xC0, 0x0F,
  0x80, 0xFE, 0x0C, 0x61, 0x87, 0x18, 0x71, 0x87, 0x18, 0x61, 0x86, 0x31,
  0xC3, 0xF8, 0x3F, 0x03, 0x30, 0x73, 0x06, 0x38, 0x61, 0x86, 0x18, 0x61,
  0x8C, 0x1C, 0x07, 0xC3, 0xFC, 0x60, 0x9C, 0x03, 0x00, 0x60, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x64, 0x18,
  0xFF, 0x1F, 0xC0, 0xFF, 0xFF, 0xF0, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x70, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x38, 0x00, 0x18, 0x18, 0xC1, 0xCE, 0x0C, 0x60, 0x63, 0x03, 0x18, 0x18,
  0xC1, 0xCC, 0x0C, 0x60, 0x63, 0x03, 0x18, 0x18, 0xC1, 0x8C, 0x0C, 0x60,
  0x63, 0x07, 0x1C, 0x30, 0x7F, 0x01, 0xF0, 0x00, 0xC0, 0x78, 0x1F, 0x03,
  0x60, 0x6C, 0x19, 0x83, 0x30, 0xC6, 0x18, 0x47, 0x08, 0xC1, 0x98, 0x36,
  0x06, 0xC0, 0xF0, 0x1E, 0x03, 0x80, 0x70, 0x0C, 0x00, 0xC0, 0xC0, 0xF0,
  0x30, 0x6C, 0x1C, 0x1B, 0x07, 0x0E, 0xC3, 0xC3, 0x30, 0xF0, 0xCC, 0x6C,
  0x63, 0x1B, 0x18, 0xC4, 0xCC, 0x33, 0x33, 0x0C, 0xCC, 0xC3, 0x63, 0x60,
  0xD8, 0xD8, 0x34, 0x3C, 0x0F, 0x0F, 0x03, 0xC3, 0xC0, 0xE0, 0xE0, 0x38,
  0x38, 0x00, 0x0C, 0x18, 0x61, 0x83, 0x0C, 0x18, 0xC0, 0x6E, 0x03, 0x60,
  0x1E, 0x00, 0xF0, 0x03, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x01, 0x98, 0x1C,
  0xC0, 0xC6, 0x0C, 0x30, 0x61, 0x86, 0x0E, 0x00, 0xC0, 0xF0, 0x66, 0x19,
  0x8C, 0x63, 0x19, 0x86, 0x61, 0xB0, 0x78, 0x0E, 0x03, 0x00, 0xC0, 0x30,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x38, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x60,
  0x06, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x30, 0x07, 0x00, 0x60, 0x0C, 0x00,
  0xC0, 0x18, 0x03, 0x80, 0x30, 0x06, 0x00, 0x7F, 0x8F, 0xF8, 0x07, 0xC1,
  0xF0, 0x40, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x18, 0x06, 0x01, 0x80, 0x7C,
  0x3E, 0x00, 0x8C, 0xCC, 0xCC, 0xC4, 0x66, 0x66, 0x66, 0x62, 0x33, 0x07,
  0xC1, 0xE0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x18, 0x06, 0x01, 0x80, 0x60, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x78, 0x3E, 0x00, 0x03, 0x00, 0xE0, 0x1C, 0x06, 0xC0, 0x98, 0x33, 0x04,
  0x31, 0x86, 0x60, 0xDC, 0x0C, 0xFF, 0xFF, 0xD9, 0x90, 0x0E, 0x23, 0xE8,
  0xE7, 0x38, 0xE6, 0x1C, 0xC3, 0x30, 0x66, 0x0C, 0xC1, 0x98, 0x73, 0x0C,
  0x63, 0x8E, 0xF0, 0xF6, 0x00, 0x0C, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80,
  0x33, 0x07, 0xF0, 0xE7, 0x38, 0x67, 0x0C, 0xC1, 0x98, 0x33, 0x0E, 0xC1,
  0x98, 0x33, 0x0E, 0x61, 0x8B, 0xE3, 0x78, 0x00, 0x06, 0x8F, 0x8E, 0x4E,
  0x06, 0x07, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0F, 0xC3, 0xE0,
  0x00, 0x30, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0xCE, 0x1F, 0xC3, 0x9C,
  0x71, 0xC6, 0x1C, 0x61, 0x8C, 0x18, 0xC1, 0x8C, 0x18, 0xC3, 0x8C, 0x30,
  0xC7, 0x0F, 0xF0, 0x7B, 0x00, 0x06, 0x0F, 0x8C, 0x6E, 0x36, 0x1F, 0x1B,
  0xF9, 0xF8, 0xC0, 0x60, 0x30, 0x18, 0x0F, 0x63, 0xF0, 0x00, 0xF0, 0x1F,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x30, 0x0F, 0xC0, 0x30, 0x03, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x38, 0x0F, 0x00, 0xE0, 0x00, 0x02,
  0x01, 0xF4, 0x73, 0x9C, 0x73, 0x0E, 0x61, 0x98, 0x33, 0x06, 0x60, 0xCC,
  0x39, 0x86, 0x31, 0xC7, 0xF8, 0x7B, 0x00, 0x60, 0x18, 0x03, 0x10, 0xE3,
  0xF8, 0x7C, 0x00, 0x0C, 0x01, 0x80, 0x30, 0x0E, 0x01, 0x80, 0x33, 0x07,
  0xF0, 0xE7, 0x38, 0x66, 0x1C, 0xC3, 0x18, 0x63, 0x0C, 0xC1, 0x98, 0x63,
  0x0C, 0x61, 0x8C, 0x33, 0x0E, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x61, 0x8C,
  0x30, 0xC3, 0x0C, 0x61, 0x86, 0x18, 0x63, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x00, 0x00, 0x18, 0x0C, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x0C, 0x06, 0x03, 0x01, 0x81, 0x83, 0xC1, 0xC0, 0x0C,
  0x01, 0x80, 0x30, 0x0E, 0x01, 0x80, 0x30, 0x46, 0x30, 0xCC, 0x33, 0x86,
  0x60, 0xD8, 0x1F, 0x03, 0xE0, 0xEC, 0x19, 0x83, 0x18, 0x63, 0x0C, 0x63,
  0x0E, 0x00, 0x0C, 0x30, 0xC7, 0x18, 0x61, 0x86, 0x30, 0xC3, 0x0C, 0x31,
  0x86, 0x18, 0x61, 0x8C, 0x00, 0x01, 0x86, 0x1F, 0xDF, 0x14, 0xF3, 0x38,
  0xE3, 0x30, 0xC3, 0x30, 0xC3, 0x30, 0xC3, 0x30, 0xC3, 0x61, 0x86, 0x61,
  0x86, 0x61, 0x86, 0x61, 0x86, 0x61, 0x86, 0xC3, 0x0C, 0x01, 0x83, 0xF8,
  0x53, 0x9C, 0x33, 0x8E, 0x61, 0x8C, 0x31, 0x86, 0x60, 0xCC, 0x31, 0x86,
  0x30, 0xCE, 0x19, 0x87, 0x00, 0x06, 0x07, 0xE3, 0x19, 0x86, 0x61, 0xF8,
  0x7C, 0x1B, 0x06, 0xC1, 0xB0, 0x6C, 0x33, 0x0C, 0xFE, 0x1F, 0x00, 0x00,
  0xC0, 0xDE, 0x0A, 0x71, 0xC3, 0x1C, 0x31, 0x83, 0x18, 0x31, 0x87, 0x30,
  0x63, 0x06, 0x30, 0xE3, 0x0C, 0x2F, 0x86, 0xF0, 0x60, 0x06, 0x00, 0x60,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x04, 0x07, 0xD3, 0x9D, 0xC7, 0x61, 0xD8,
  0x6C, 0x1B, 0x06, 0xC1, 0xB0, 0xEC, 0x33, 0x1C, 0xFF, 0x1E, 0xC0, 0x70,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x30, 0x01, 0x8F, 0xC5, 0xA7, 0x03, 0x81,
  0x80, 0xC0, 0x60, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x06, 0x00, 0x0E, 0x1F,
  0xCC, 0x4E, 0x07, 0x01, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x01, 0x80, 0xCF,
  0xE7, 0xE0, 0x18, 0x43, 0x3F, 0x31, 0x86, 0x18, 0x61, 0x8C, 0x30, 0xC3,
  0x0F, 0x3C, 0x30, 0xCC, 0x36, 0x0D, 0x86, 0x61, 0x98, 0x6E, 0x1B, 0x06,
  0xC3, 0x30, 0xCC, 0x73, 0xFC, 0x7B, 0x00, 0xC1, 0xF0, 0x64, 0x31, 0x0C,
  0x66, 0x19, 0x86, 0xC1, 0xB0, 0x78, 0x1E, 0x07, 0x81, 0xC0, 0x70, 0x00,
  0x87, 0x0E, 0x1C, 0x68, 0xF1, 0xA3, 0xCC, 0x8B, 0x32, 0x6C, 0xC9, 0x36,
  0x2C, 0xD8, 0xB3, 0xC2, 0x8F, 0x0E, 0x38, 0x30, 0xE0, 0xC3, 0x80, 0x18,
  0x71, 0x8C, 0x0D, 0xC0, 0xD8, 0x0F, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x1B,
  0x03, 0x30, 0x33, 0x06, 0x30, 0xC1, 0x80, 0x1C, 0x38, 0x61, 0x83, 0x18,
  0x18, 0xC0, 0xCC, 0x06, 0x60, 0x36, 0x01, 0xB0, 0x0D, 0x80, 0x78, 0x03,
  0xC0, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x03, 0x00, 0x38, 0x07, 0x80,
  0x38, 0x00, 0x1F, 0xC0, 0x60, 0x38, 0x0C, 0x06, 0x03, 0x80, 0xC0, 0x60,
  0x18, 0x0C, 0x06, 0x01, 0xFC, 0xFE, 0x00, 0x01, 0xC0, 0xF0, 0x60, 0x18,
  0x06, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x06, 0x07, 0x03, 0xC0, 0x38, 0x06,
  0x01, 0x80, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x38, 0x06, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C, 0x07, 0x01, 0xC0, 0x60, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0xE0, 0xF0, 0xC0, 0x60, 0x60, 0x30,
  0x18, 0x0C, 0x0C, 0x06, 0x0F, 0x06, 0x00, 0x7C, 0x73, 0xF8, 0x38,
};

const GFXglyph NotoSans_Condensed_Italic25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 6, 18, 6, 0, -18 },
  { 15, 7, 7, 9, 3, -18 },
  { 22, 13, 18, 12, 0, -18 },
  { 52, 11, 20, 11, 0, -19 },
  { 80, 15, 18, 17, 1, -18 },
  { 114, 12, 18, 13, 0, -18 },
  { 141, 3, 7, 5, 3, -18 },
  { 144, 7, 22, 7, 1, -18 },
  { 164, 8, 22, 7, -2, -18 },
  { 186, 9, 9, 10, 2, -19 },
  { 197, 10, 12, 12, 1, -15 },
  { 212, 4, 6, 5, -1, -3 },
  { 215, 6, 2, 7, 0, -8 },
  { 217, 3, 3, 5, 0, -3 },
  { 219, 11, 18, 9, -1, -18 },
  { 244, 10, 18, 11, 1, -18 },
  { 267, 7, 18, 11, 3, -18 },
  { 283, 12, 18, 11, -1, -18 },
  { 310, 11, 18, 11, 0, -18 },
  { 335, 11, 18, 11, 0, -18 },
  { 360, 11, 18, 11, 0, -18 },
  { 385, 10, 18, 11, 1, -18 },
  { 408, 11, 18, 11, 1, -18 },
  { 433, 11, 18, 11, 0, -18 },
  { 458, 11, 18, 11, 0, -18 },
  { 483, 5, 14, 6, 0, -14 },
  { 492, 6, 17, 6, -1, -14 },
  { 505, 10, 12, 12, 1, -15 },
  { 520, 10, 7, 12, 1, -12 },
  { 529, 10, 12, 12, 1, -15 },
  { 544, 8, 18, 8, 1, -18 },
  { 562, 15, 20, 17, 1, -18 },
  { 600, 12, 18, 11, -2, -18 },
  { 627, 12, 18, 12, 0, -18 },
  { 654, 12, 18, 11, 1, -18 },
  { 681, 13, 18, 13, 0, -18 },
  { 711, 11, 18, 10, 0, -18 },
  { 736, 11, 18, 10, 0, -18 },
  { 761, 13, 18, 14, 1, -18 },
  { 791, 14, 18, 14, 0, -18 },
  { 823, 10, 18, 7, -1, -18 },
  { 846, 10, 23, 6, -4, -18 },
  { 875, 13, 18, 11, 0, -18 },
  { 905, 8, 18, 9, 0, -18 },
  { 923, 18, 18, 18, 0, -18 },
  { 964, 15, 18, 14, 0, -18 },
  { 998, 13, 18, 14, 1, -18 },
  { 1028, 12, 18, 11, 0, -18 },
  { 1055, 13, 22, 14, 1, -18 },
  { 1091, 12, 18, 12, 0, -18 },
  { 1118, 11, 18, 10, 0, -18 },
  { 1143, 10, 18, 10, 2, -18 },
  { 1166, 13, 18, 13, 1, -18 },
  { 1196, 11, 18, 11, 2, -18 },
  { 1221, 18, 18, 18, 2, -18 },
  { 1262, 13, 18, 10, -1, -18 },
  { 1292, 10, 18, 10, 2, -18 },
  { 1315, 12, 18, 10, -1, -18 },
  { 1342, 10, 22, 7, -1, -18 },
  { 1370, 4, 18, 9, 3, -18 },
  { 1379, 10, 22, 7, -2, -18 },
  { 1407, 11, 10, 11, 0, -18 },
  { 1421, 8, 2, 8, -2, 2 },
  { 1423, 3, 4, 6, 4, -19 },
  { 1425, 11, 14, 12, 1, -14 },
  { 1445, 11, 19, 12, 0, -19 },
  { 1472, 9, 14, 9, 1, -14 },
  { 1488, 12, 19, 12, 1, -19 },
  { 1517, 9, 14, 10, 1, -14 },
  { 1533, 12, 25, 6, -3, -19 },
  { 1571, 11, 20, 12, 0, -14 },
  { 1599, 11, 19, 12, 0, -19 },
  { 1626, 6, 18, 5, 0, -18 },
  { 1640, 9, 24, 5, -3, -18 },
  { 1667, 11, 19, 10, 0, -19 },
  { 1694, 6, 19, 5, 0, -19 },
  { 1709, 16, 14, 17, 0, -14 },
  { 1737, 11, 14, 12, 0, -14 },
  { 1757, 10, 14, 11, 1, -14 },
  { 1775, 12, 20, 12, -1, -14 },
  { 1805, 10, 20, 12, 1, -14 },
  { 1830, 9, 14, 8, 0, -14 },
  { 1846, 9, 14, 9, 0, -14 },
  { 1862, 6, 16, 7, 1, -16 },
  { 1874, 10, 13, 12, 1, -13 },
  { 1891, 10, 13, 9, 1, -13 },
  { 1908, 14, 13, 15, 2, -13 },
  { 1931, 12, 13, 10, -1, -13 },
  { 1951, 13, 19, 9, -2, -13 },
  { 1982, 10, 13, 8, -1, -13 },
  { 1999, 10, 22, 8, 0, -18 },
  { 2027, 2, 25, 11, 4, -19 },
  { 2034, 9, 22, 8, -1, -18 },
  { 2059, 10, 3, 12, 1, -10 },
};

const GFXfont NotoSans_Condensed_Italic25pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Italic25pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Italic25pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _NOTOSANS_CONDENSED_ITALIC25PT7B_H_
