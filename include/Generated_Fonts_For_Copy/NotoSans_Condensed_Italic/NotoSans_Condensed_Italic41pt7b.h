#ifndef _NOTOSANS_CONDENSED_ITALIC41PT7B_H_
#define _NOTOSANS_CONDENSED_ITALIC41PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Italic.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Italic41pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xC1, 0xE0, 0x78, 0x1E, 0x07, 0x01, 0xC0, 0xF0, 0x3C, 0x0E,
  0x03, 0x80, 0xE0, 0x78, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x30, 0x00, 0x00, 0x00, 0x00, 0x60, 0x3C, 0x0F, 0x03, 0xC0,
  0xE0, 0x00, 0x38, 0xF3, 0x8E, 0x78, 0xE7, 0x0E, 0x70, 0xE7, 0x1C, 0x71,
  0xC6, 0x1C, 0xE1, 0xCE, 0x18, 0x00, 0x38, 0x70, 0x01, 0x83, 0x00, 0x1C,
  0x38, 0x00, 0xE1, 0xC0, 0x06, 0x0C, 0x00, 0x70, 0xE0, 0x03, 0x87, 0x00,
  0x18, 0x30, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC, 0x03, 0x06,
  0x00, 0x38, 0x70, 0x01, 0xC3, 0x80, 0x0C, 0x18, 0x00, 0xE1, 0xC0, 0x07,
  0x0E, 0x00, 0x30, 0x60, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x80, 0xC1, 0x80,
  0x06, 0x0C, 0x00, 0x70, 0xE0, 0x03, 0x87, 0x00, 0x18, 0x30, 0x01, 0xC3,
  0x80, 0x0E, 0x1C, 0x00, 0x60, 0xC0, 0x07, 0x0E, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0xF0,
  0x79, 0xB8, 0x3C, 0xC2, 0x0E, 0x30, 0x03, 0x8C, 0x00, 0xE3, 0x00, 0x38,
  0xC0, 0x0F, 0x60, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x0D, 0xE0, 0x03, 0x78, 0x00, 0xCE, 0x00, 0x63, 0x80,
  0x18, 0xE0, 0x06, 0x38, 0x81, 0x9E, 0x18, 0x4F, 0x0F, 0xFF, 0x83, 0xFF,
  0xC0, 0x1F, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x0F, 0xC0, 0x1C, 0x0F, 0xE0, 0x38, 0x1C, 0xE0,
  0x30, 0x38, 0x60, 0x70, 0x38, 0x60, 0xE0, 0x30, 0x60, 0xE0, 0x70, 0xE1,
  0xC0, 0x70, 0xE1, 0x80, 0x60, 0xE3, 0x80, 0x60, 0xE7, 0x00, 0xE0, 0xC7,
  0x00, 0xE1, 0xCE, 0x3C, 0xE1, 0xCE, 0x7E, 0xE3, 0x9C, 0xFE, 0x63, 0x99,
  0xC7, 0x7F, 0x39, 0x87, 0x7E, 0x73, 0x87, 0x18, 0x73, 0x87, 0x00, 0xE3,
  0x07, 0x00, 0xC7, 0x06, 0x01, 0xC7, 0x0E, 0x03, 0x87, 0x0E, 0x03, 0x87,
  0x0E, 0x07, 0x07, 0x0C, 0x06, 0x07, 0x1C, 0x0E, 0x07, 0x1C, 0x1C, 0x07,
  0x38, 0x1C, 0x07, 0xF0, 0x38, 0x03, 0xE0, 0x00, 0x1C, 0x00, 0x0F, 0xF0,
  0x01, 0xFF, 0x00, 0x1C, 0x78, 0x03, 0xC3, 0x80, 0x38, 0x38, 0x03, 0x83,
  0x80, 0x38, 0x78, 0x03, 0x87, 0x00, 0x38, 0xF0, 0x03, 0x8E, 0x00, 0x39,
  0xC0, 0x03, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F,
  0xF0, 0xF1, 0xC7, 0x0E, 0x3C, 0x78, 0xE7, 0x87, 0x9E, 0x70, 0x39, 0xC7,
  0x03, 0xFC, 0xF0, 0x1F, 0x8F, 0x01, 0xF0, 0xF0, 0x0F, 0x0F, 0x01, 0xF0,
  0xF0, 0x3F, 0x07, 0xFF, 0x78, 0x7F, 0xE7, 0x81, 0xFC, 0x3C, 0x3C, 0xE7,
  0x9E, 0x71, 0xC7, 0x18, 0x63, 0x80, 0x00, 0x78, 0x07, 0x00, 0x78, 0x03,
  0x80, 0x38, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x00,
  0x78, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C,
  0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x01,
  0x80, 0x0E, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0,
  0x0E, 0x00, 0x70, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E,
  0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0x80, 0x38, 0x03, 0xC0, 0x3C, 0x00,
  0x01, 0xC0, 0x07, 0x00, 0x18, 0x10, 0xE0, 0x73, 0x83, 0xFE, 0x37, 0xFF,
  0xC1, 0xFF, 0x07, 0x80, 0x7E, 0x03, 0xDC, 0x1E, 0x38, 0x70, 0xE0, 0xC3,
  0xC0, 0x04, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x0F, 0x0E, 0x1E, 0x1C, 0x1C, 0x38, 0x38,
  0x70, 0x70, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x6F, 0xFF, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F,
  0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00,
  0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x30, 0x00, 0x7F,
  0x00, 0xFF, 0xC0, 0x79, 0xE0, 0x78, 0x70, 0x78, 0x3C, 0x38, 0x1E, 0x3C,
  0x0F, 0x1C, 0x07, 0x8E, 0x03, 0xCF, 0x01, 0xE7, 0x00, 0xF3, 0x80, 0x73,
  0xC0, 0x39, 0xE0, 0x1C, 0xE0, 0x0E, 0x70, 0x0F, 0x38, 0x07, 0x9C, 0x03,
  0x9E, 0x01, 0xCF, 0x01, 0xE7, 0x80, 0xE3, 0xC0, 0x71, 0xE0, 0x78, 0xF0,
  0x38, 0x38, 0x3C, 0x1C, 0x3C, 0x0F, 0xFC, 0x03, 0xFC, 0x00, 0xFC, 0x00,
  0x01, 0xE0, 0xF8, 0x3F, 0x0F, 0xE3, 0xFD, 0xF7, 0x3C, 0xE2, 0x1C, 0x07,
  0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x1E, 0x03, 0x80, 0x70, 0x0E, 0x03,
  0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xE0, 0x38, 0x07, 0x00,
  0xE0, 0x3C, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x1F, 0xF0, 0x0F, 0xFF, 0x01,
  0xF3, 0xE0, 0x38, 0x1E, 0x02, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3F, 0xFF, 0x0F, 0xFF,
  0xE1, 0xFF, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x7F, 0xC0, 0x7F, 0xF8, 0x1E,
  0x3E, 0x02, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0xFF, 0x00,
  0x3F, 0x00, 0x1F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x0F, 0x08, 0x07, 0xC3, 0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1B, 0x80,
  0x0E, 0xE0, 0x07, 0x70, 0x01, 0xDC, 0x00, 0xE7, 0x00, 0x71, 0xC0, 0x1C,
  0xF0, 0x0E, 0x38, 0x07, 0x0E, 0x03, 0x83, 0x80, 0xE1, 0xE0, 0x70, 0x78,
  0x38, 0x1C, 0x0E, 0x07, 0x07, 0x01, 0xC3, 0x80, 0xF0, 0xFF, 0xFF, 0xBF,
  0xFF, 0xEF, 0xFF, 0xF0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F,
  0xF8, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x3F, 0xC0, 0x1F, 0xFC, 0x07,
  0xFF, 0x80, 0x83, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78,
  0x00, 0x3C, 0x20, 0x1F, 0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0x7F, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xC2, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0xF0, 0x00, 0x39, 0xF8, 0x0E, 0xFF, 0x07, 0xFB, 0xE1, 0xF0, 0x78,
  0x78, 0x0E, 0x1E, 0x03, 0x87, 0x00, 0xE1, 0xC0, 0x38, 0x70, 0x0E, 0x3C,
  0x03, 0x8F, 0x01, 0xE3, 0xC0, 0x78, 0x70, 0x1C, 0x1C, 0x0F, 0x07, 0x87,
  0x81, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xF0, 0x00, 0x3F, 0xFF, 0x9F, 0xFF,
  0xCF, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00,
  0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00,
  0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0,
  0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C,
  0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x3F, 0xC0, 0x1F, 0xF8, 0x0F, 0x1F, 0x07, 0x83, 0xC1, 0xC0, 0x70,
  0x70, 0x1C, 0x3C, 0x07, 0x0F, 0x01, 0xC1, 0xC0, 0xF0, 0x70, 0x78, 0x1E,
  0x3C, 0x03, 0xDE, 0x00, 0xFF, 0x00, 0x1F, 0x00, 0x1F, 0xE0, 0x0F, 0xBC,
  0x07, 0x87, 0x03, 0xC1, 0xE1, 0xE0, 0x38, 0x70, 0x0F, 0x1C, 0x03, 0xCF,
  0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x0E, 0x1C, 0x07, 0x87, 0x81, 0xE1, 0xFB,
  0xF0, 0x3F, 0xF8, 0x07, 0xF8, 0x00, 0x00, 0x70, 0x00, 0xFE, 0x01, 0xFF,
  0x81, 0xF3, 0xE0, 0xF0, 0xF0, 0xF0, 0x38, 0x70, 0x1C, 0x78, 0x0E, 0x3C,
  0x07, 0x9C, 0x03, 0x8E, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0xF1, 0xC0, 0x78,
  0xE0, 0x7C, 0x78, 0x7E, 0x3F, 0xFE, 0x0F, 0xF7, 0x03, 0xF3, 0x80, 0x03,
  0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x78, 0x00, 0x78, 0x1F, 0xF8, 0x0F, 0xF8, 0x07, 0xF0, 0x00, 0x07, 0x0F,
  0x0F, 0x0F, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x78, 0xF8, 0xF8, 0xF0, 0x01, 0xC0, 0x7C, 0x0F,
  0x81, 0xE0, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x78, 0x0F, 0x01,
  0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x03, 0x80, 0x00, 0x00, 0x01,
  0x00, 0x07, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x03, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0x00, 0x1F, 0x00, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x00, 0xF8, 0x00, 0xE0, 0x00, 0x80, 0x00,
  0x01, 0xC0, 0x3F, 0xC1, 0xFF, 0x87, 0x9F, 0x10, 0x3C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x18,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x07, 0x80, 0x3E,
  0x00, 0xF8, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x0F, 0x81, 0xE0, 0x07, 0x80, 0x1C, 0x03, 0xC0, 0x03, 0x81, 0xE0, 0x00,
  0xE0, 0x70, 0x00, 0x18, 0x38, 0x00, 0x06, 0x0C, 0x0F, 0xF1, 0xC7, 0x07,
  0xF8, 0x71, 0x83, 0x8E, 0x1C, 0xE1, 0xC3, 0x87, 0x30, 0x60, 0xE1, 0x9C,
  0x38, 0x30, 0x67, 0x0C, 0x1C, 0x19, 0xC7, 0x07, 0x0E, 0x61, 0xC1, 0xC3,
  0x98, 0x70, 0xE0, 0xC6, 0x18, 0x38, 0x73, 0x86, 0x0E, 0x18, 0xE1, 0xC7,
  0x8E, 0x38, 0x73, 0x63, 0x0E, 0x1F, 0xDF, 0xC3, 0x83, 0xE3, 0xE0, 0x60,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x80, 0x60, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3B, 0x80, 0x07, 0x70, 0x01, 0xCE,
  0x00, 0x39, 0xC0, 0x0F, 0x38, 0x01, 0xC7, 0x00, 0x78, 0xE0, 0x0E, 0x1C,
  0x03, 0xC3, 0x80, 0x70, 0x70, 0x0E, 0x0F, 0x03, 0xC1, 0xE0, 0x7F, 0xFC,
  0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0xF0, 0x1E, 0x1C, 0x03, 0xC7, 0x80, 0x78,
  0xF0, 0x0F, 0x3C, 0x01, 0xE7, 0x80, 0x3C, 0xE0, 0x03, 0xBC, 0x00, 0x7F,
  0x00, 0x0E, 0x01, 0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x38, 0x1E,
  0x03, 0x80, 0xF0, 0x78, 0x0F, 0x07, 0x80, 0xF0, 0x70, 0x0F, 0x07, 0x00,
  0xE0, 0x70, 0x1E, 0x0F, 0x01, 0xC0, 0xF0, 0x7C, 0x0F, 0xFF, 0x80, 0xFF,
  0xC0, 0x0F, 0xFE, 0x01, 0xE0, 0xF0, 0x1E, 0x07, 0x81, 0xC0, 0x38, 0x1C,
  0x03, 0xC3, 0xC0, 0x3C, 0x3C, 0x03, 0xC3, 0xC0, 0x38, 0x38, 0x07, 0x83,
  0x80, 0x78, 0x78, 0x0F, 0x07, 0x81, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xC0,
  0xFF, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x0F, 0xFC, 0x07, 0xFF, 0x81, 0xF9,
  0xE0, 0x7C, 0x04, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1C, 0x00,
  0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x20, 0x1F, 0xFC, 0x03, 0xFF, 0x80,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x07,
  0x03, 0xE0, 0x38, 0x0F, 0x03, 0xC0, 0x78, 0x1E, 0x01, 0xE0, 0xE0, 0x0F,
  0x07, 0x00, 0x78, 0x38, 0x03, 0xC3, 0xC0, 0x1E, 0x1E, 0x00, 0xF0, 0xE0,
  0x07, 0x87, 0x00, 0x38, 0x38, 0x01, 0xC3, 0xC0, 0x1E, 0x1E, 0x00, 0xF0,
  0xE0, 0x07, 0x87, 0x00, 0x78, 0x78, 0x03, 0xC3, 0xC0, 0x1C, 0x1C, 0x01,
  0xE0, 0xE0, 0x1E, 0x07, 0x01, 0xF0, 0x78, 0x1F, 0x03, 0xC3, 0xF0, 0x1F,
  0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x7F,
  0xF8, 0x0F, 0xFF, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xFF, 0xE0,
  0x3F, 0xFC, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFF,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00,
  0x1F, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x1E, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x03, 0xFF, 0x80, 0x7F, 0xFE, 0x07, 0xF3,
  0xE0, 0x7C, 0x03, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0xFC, 0xF0, 0x1F, 0xC7, 0x80,
  0xFE, 0x3C, 0x00, 0x71, 0xC0, 0x07, 0x8E, 0x00, 0x3C, 0x70, 0x01, 0xC3,
  0xC0, 0x0E, 0x1E, 0x00, 0x70, 0xF0, 0x07, 0x83, 0xC0, 0x38, 0x1F, 0x01,
  0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x03, 0x80, 0x3C,
  0x1E, 0x00, 0xF0, 0x78, 0x03, 0x81, 0xC0, 0x0E, 0x07, 0x00, 0x78, 0x3C,
  0x01, 0xE0, 0xF0, 0x07, 0x03, 0x80, 0x1C, 0x0E, 0x00, 0x70, 0x38, 0x03,
  0xC1, 0xE0, 0x0F, 0x07, 0x80, 0x38, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x81,
  0xFF, 0xFE, 0x0F, 0x00, 0x78, 0x3C, 0x01, 0xC0, 0xE0, 0x07, 0x03, 0x80,
  0x3C, 0x0E, 0x00, 0xF0, 0x78, 0x03, 0xC1, 0xC0, 0x0E, 0x07, 0x00, 0x38,
  0x1C, 0x01, 0xE0, 0xF0, 0x07, 0x83, 0xC0, 0x1C, 0x0E, 0x00, 0x70, 0x38,
  0x01, 0xC0, 0xE0, 0x0F, 0x00, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03,
  0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x7F,
  0xC0, 0xFF, 0xC0, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x8F, 0x00, 0xFF,
  0x00, 0xFE, 0x00, 0xF8, 0x00, 0x01, 0xC0, 0x7C, 0x0F, 0x01, 0xE0, 0x3C,
  0x0F, 0x00, 0xE0, 0x78, 0x03, 0x83, 0xC0, 0x1E, 0x0E, 0x00, 0x78, 0x78,
  0x01, 0xC3, 0xC0, 0x07, 0x1E, 0x00, 0x1C, 0xF0, 0x00, 0xF3, 0xC0, 0x03,
  0xDE, 0x00, 0x0E, 0xF0, 0x00, 0x3B, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0x78, 0x00, 0x79, 0xE0, 0x01, 0xC3, 0x80, 0x0F, 0x0E, 0x00,
  0x3C, 0x3C, 0x00, 0xE0, 0xF0, 0x03, 0x81, 0xC0, 0x0E, 0x07, 0x80, 0x78,
  0x1E, 0x01, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0xC0, 0xF0, 0x0F,
  0x00, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1E,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0xFE, 0xFF, 0xFF, 0xFF,
  0x00, 0x01, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xE0, 0x3F, 0x00, 0x1F,
  0x80, 0xFC, 0x00, 0x7E, 0x03, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x0F, 0xC0,
  0x77, 0x00, 0x77, 0x01, 0xDC, 0x01, 0xDC, 0x07, 0x70, 0x0E, 0xF0, 0x1D,
  0xC0, 0x3B, 0xC0, 0xF7, 0x01, 0xCE, 0x03, 0x9C, 0x07, 0x38, 0x0E, 0x70,
  0x39, 0xE0, 0x39, 0xC0, 0xE7, 0x80, 0xE7, 0x07, 0x9C, 0x07, 0x9C, 0x1C,
  0x70, 0x1C, 0x70, 0xF1, 0xC0, 0x70, 0xE3, 0x8F, 0x01, 0xC3, 0x9E, 0x3C,
  0x0F, 0x0E, 0x70, 0xE0, 0x3C, 0x3B, 0xC3, 0x80, 0xE0, 0xEE, 0x0E, 0x03,
  0x83, 0xB8, 0x78, 0x0E, 0x0F, 0xC1, 0xE0, 0x78, 0x3F, 0x07, 0x01, 0xC0,
  0xF8, 0x1C, 0x07, 0x03, 0xE0, 0x70, 0x1C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x00, 0x01, 0xE0, 0x07, 0x03, 0xE0, 0x0F, 0x03, 0xE0, 0x0F, 0x03,
  0xE0, 0x0E, 0x03, 0xF0, 0x0E, 0x07, 0x70, 0x0E, 0x07, 0x70, 0x1E, 0x07,
  0x70, 0x1E, 0x07, 0x78, 0x1C, 0x07, 0x38, 0x1C, 0x0F, 0x38, 0x1C, 0x0E,
  0x38, 0x3C, 0x0E, 0x38, 0x38, 0x0E, 0x1C, 0x38, 0x0E, 0x1C, 0x38, 0x1E,
  0x1C, 0x38, 0x1C, 0x1C, 0x78, 0x1C, 0x1E, 0x70, 0x1C, 0x0E, 0x70, 0x3C,
  0x0E, 0x70, 0x3C, 0x0E, 0x70, 0x38, 0x0F, 0xF0, 0x38, 0x07, 0xE0, 0x38,
  0x07, 0xE0, 0x78, 0x07, 0xE0, 0x70, 0x07, 0xE0, 0x70, 0x03, 0xC0, 0x70,
  0x03, 0xC0, 0xF0, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x0F, 0xF8, 0x01, 0xFF,
  0xC0, 0x3E, 0x7E, 0x07, 0x81, 0xE0, 0xF0, 0x0F, 0x0E, 0x00, 0xF1, 0xE0,
  0x07, 0x3C, 0x00, 0x73, 0xC0, 0x07, 0x38, 0x00, 0x77, 0x80, 0x07, 0x78,
  0x00, 0x77, 0x00, 0x0F, 0x70, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0E, 0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xE0, 0x01, 0xCE, 0x00, 0x3C,
  0xF0, 0x03, 0xCF, 0x00, 0x78, 0xF0, 0x07, 0x8F, 0x00, 0xF0, 0x78, 0x1E,
  0x07, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x7F,
  0xF0, 0x0F, 0xFF, 0x01, 0xC1, 0xF0, 0x38, 0x1E, 0x0F, 0x03, 0xC1, 0xE0,
  0x38, 0x38, 0x07, 0x07, 0x01, 0xE0, 0xE0, 0x3C, 0x3C, 0x07, 0x87, 0x81,
  0xE0, 0xE0, 0x3C, 0x1C, 0x0F, 0x03, 0x9F, 0xC0, 0xFF, 0xF0, 0x1F, 0xFC,
  0x03, 0xF0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x0F, 0xF8, 0x01, 0xFF,
  0xC0, 0x3E, 0x7E, 0x07, 0x81, 0xE0, 0xF0, 0x0F, 0x0E, 0x00, 0xF1, 0xE0,
  0x07, 0x3C, 0x00, 0x73, 0xC0, 0x07, 0x38, 0x00, 0x77, 0x80, 0x07, 0x78,
  0x00, 0x77, 0x00, 0x0F, 0x70, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0E, 0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xE0, 0x01, 0xCE, 0x00, 0x3C,
  0xF0, 0x03, 0xCF, 0x00, 0x78, 0xF0, 0x07, 0x8F, 0x00, 0xF0, 0x78, 0x1E,
  0x07, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x01, 0xC1, 0xF0,
  0x38, 0x1E, 0x0F, 0x03, 0xC1, 0xE0, 0x38, 0x38, 0x07, 0x07, 0x01, 0xE0,
  0xE0, 0x3C, 0x3C, 0x07, 0x07, 0x81, 0xE0, 0xE0, 0x7C, 0x1C, 0x1F, 0x03,
  0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0x87, 0x00, 0x70, 0xE0, 0x1E,
  0x1E, 0x03, 0xC3, 0xC0, 0x70, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0xF0, 0x78,
  0x1E, 0x0F, 0x03, 0xC1, 0xC0, 0x38, 0x38, 0x07, 0x8F, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x7F, 0xF0, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0x80, 0x83, 0xC0,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00,
  0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x0C, 0x07, 0x83,
  0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xF0, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x78, 0x70, 0x03, 0x83, 0x80,
  0x1C, 0x1C, 0x00, 0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0x78, 0x70, 0x03, 0x83,
  0x80, 0x1C, 0x1C, 0x01, 0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0x70, 0x70, 0x03,
  0x83, 0x80, 0x1C, 0x1C, 0x01, 0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0x70, 0x70,
  0x03, 0x83, 0x80, 0x1C, 0x3C, 0x01, 0xE1, 0xE0, 0x0F, 0x0E, 0x00, 0x70,
  0x70, 0x03, 0x83, 0x80, 0x3C, 0x1C, 0x01, 0xC0, 0xF0, 0x1E, 0x07, 0x81,
  0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x01, 0xFE, 0x00, 0x00, 0xE0, 0x03,
  0xF8, 0x01, 0xEE, 0x00, 0x7B, 0x80, 0x3C, 0xE0, 0x0F, 0x38, 0x03, 0x8E,
  0x01, 0xE3, 0x80, 0x70, 0xE0, 0x3C, 0x38, 0x0E, 0x0E, 0x07, 0x83, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x3C, 0x0E, 0x0E, 0x03, 0x87, 0x80, 0xE1, 0xC0,
  0x38, 0xF0, 0x0E, 0x38, 0x03, 0x9E, 0x00, 0xF7, 0x00, 0x3D, 0xC0, 0x0F,
  0xE0, 0x03, 0xB8, 0x00, 0x6E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x00, 0xE0, 0x0F, 0x00, 0x7F, 0x00, 0x78, 0x07, 0xB8,
  0x07, 0xC0, 0x39, 0xC0, 0x3E, 0x01, 0xCE, 0x01, 0xF0, 0x1E, 0x70, 0x1F,
  0x80, 0xE3, 0x80, 0xFC, 0x0F, 0x1C, 0x0E, 0xE0, 0x70, 0xE0, 0x77, 0x03,
  0x87, 0x03, 0xB8, 0x3C, 0x38, 0x39, 0xC1, 0xC1, 0xC1, 0xCE, 0x1E, 0x0E,
  0x1C, 0x70, 0xE0, 0x70, 0xE3, 0x87, 0x03, 0x8E, 0x1C, 0x70, 0x1C, 0x70,
  0xE3, 0x80, 0xE3, 0x87, 0x3C, 0x07, 0x38, 0x39, 0xC0, 0x39, 0xC1, 0xCE,
  0x01, 0xDC, 0x0E, 0xE0, 0x0E, 0xE0, 0x77, 0x00, 0x77, 0x03, 0xF8, 0x03,
  0xF0, 0x1F, 0x80, 0x1F, 0x80, 0xDC, 0x00, 0xF8, 0x07, 0xC0, 0x07, 0xC0,
  0x3E, 0x00, 0x3E, 0x01, 0xF0, 0x01, 0xE0, 0x0F, 0x00, 0x0F, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x3C, 0x07, 0x01, 0xE0, 0x1C, 0x07, 0x00, 0x78,
  0x3C, 0x01, 0xE0, 0xE0, 0x03, 0x87, 0x80, 0x0E, 0x3C, 0x00, 0x38, 0xE0,
  0x00, 0xF7, 0x80, 0x01, 0xDC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x07, 0x70, 0x00, 0x3D, 0xC0, 0x00, 0xE7, 0x00, 0x07, 0x9E, 0x00,
  0x3C, 0x78, 0x00, 0xE0, 0xE0, 0x07, 0x83, 0x80, 0x3C, 0x0E, 0x00, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x03, 0xC0, 0xF0, 0x07, 0x00, 0xE0, 0x0F,
  0xE0, 0x1E, 0xE0, 0x1E, 0xF0, 0x3C, 0xF0, 0x38, 0xF0, 0x78, 0x70, 0x70,
  0x70, 0xF0, 0x70, 0xE0, 0x71, 0xC0, 0x73, 0xC0, 0x7B, 0x80, 0x3F, 0x80,
  0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00,
  0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x7F,
  0xFC, 0x0F, 0xFF, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01,
  0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x07, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xFF, 0xF0,
  0x7F, 0xFE, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0x01, 0xFE, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x80, 0x7F,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xE1, 0xC1, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x38, 0x70, 0xE1, 0xC3,
  0x87, 0x0E, 0x1E, 0x1C, 0x38, 0x70, 0xE0, 0x00, 0xFF, 0x01, 0xFE, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0x60, 0x00, 0x78, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x3B, 0x80, 0x1D, 0xC0, 0x1C, 0x70, 0x0E, 0x38,
  0x0E, 0x1C, 0x07, 0x07, 0x07, 0x03, 0x87, 0x01, 0xC3, 0x80, 0x73, 0x80,
  0x39, 0xC0, 0x1D, 0xC0, 0x07, 0x7F, 0xFE, 0xFF, 0xFB, 0xFF, 0xF0, 0xF1,
  0xC7, 0x8E, 0x18, 0x70, 0x01, 0xF1, 0xC1, 0xFE, 0x70, 0xFF, 0xF8, 0x3C,
  0x3E, 0x1E, 0x07, 0x87, 0x01, 0xE3, 0xC0, 0x78, 0xE0, 0x1C, 0x78, 0x07,
  0x1E, 0x01, 0xC7, 0x00, 0xF1, 0xC0, 0x38, 0x70, 0x0E, 0x3C, 0x03, 0x8F,
  0x01, 0xE3, 0xC0, 0x78, 0xF0, 0x3C, 0x3C, 0x0F, 0x07, 0x07, 0xC1, 0xF7,
  0x70, 0x7F, 0x9C, 0x0F, 0xC6, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00,
  0x07, 0x00, 0x01, 0xCF, 0xC0, 0x77, 0xF8, 0x3F, 0xFE, 0x0F, 0xC3, 0xC3,
  0xE0, 0xF0, 0xF0, 0x3C, 0x3C, 0x0F, 0x1E, 0x03, 0xC7, 0x80, 0xF1, 0xC0,
  0x3C, 0x70, 0x0E, 0x1C, 0x03, 0x8F, 0x00, 0xE3, 0x80, 0x78, 0xE0, 0x1C,
  0x38, 0x0F, 0x1E, 0x03, 0xC7, 0x81, 0xE1, 0xF0, 0x78, 0x7F, 0x7C, 0x19,
  0xFE, 0x0E, 0x3F, 0x00, 0x01, 0xFE, 0x0F, 0xF8, 0x3F, 0xF0, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x01, 0xE0, 0x83, 0xEF, 0x03, 0xFE, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x1F, 0x3C, 0x07,
  0xFB, 0xC0, 0xFF, 0xF8, 0x0F, 0x0F, 0x81, 0xE0, 0x78, 0x1C, 0x07, 0x83,
  0xC0, 0x70, 0x38, 0x07, 0x07, 0x80, 0x70, 0x78, 0x07, 0x07, 0x00, 0xF0,
  0x70, 0x0E, 0x0F, 0x00, 0xE0, 0xF0, 0x1E, 0x0F, 0x01, 0xE0, 0xF0, 0x1E,
  0x0F, 0x03, 0xC0, 0xF0, 0x7C, 0x07, 0x07, 0xC0, 0x7D, 0xDC, 0x07, 0xF9,
  0x80, 0x3F, 0x38, 0x00, 0x01, 0xFC, 0x0F, 0xF8, 0x3E, 0x78, 0x70, 0x71,
  0xE0, 0xE7, 0x81, 0xCE, 0x03, 0x9C, 0x0F, 0x78, 0x3C, 0xE7, 0xF1, 0xFF,
  0xC3, 0xFE, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x01, 0xE0, 0x43, 0xF7, 0x83, 0xFF, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xA0, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xC0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0xE0, 0x7F, 0x9C, 0x1F, 0xFF,
  0x03, 0xC3, 0xE0, 0xF0, 0x3C, 0x1C, 0x07, 0x87, 0x80, 0xE0, 0xE0, 0x1C,
  0x3C, 0x03, 0x87, 0x80, 0xF0, 0xE0, 0x1E, 0x1C, 0x03, 0x87, 0x80, 0x70,
  0xF0, 0x1E, 0x1E, 0x03, 0xC3, 0xC0, 0x78, 0x78, 0x1E, 0x0F, 0x07, 0xC0,
  0xE1, 0xF8, 0x1F, 0x77, 0x03, 0xFD, 0xE0, 0x3F, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x40, 0x38, 0x0C,
  0x1F, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x01, 0xF8, 0x00, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x0F, 0x00, 0x07, 0x00, 0x03, 0x9F, 0x81, 0xDF, 0xE1, 0xFF, 0xF0, 0xF8,
  0x38, 0x78, 0x1C, 0x3C, 0x0E, 0x1C, 0x07, 0x1E, 0x03, 0x8F, 0x03, 0xC7,
  0x01, 0xE3, 0x80, 0xE1, 0xC0, 0x71, 0xE0, 0x38, 0xE0, 0x3C, 0x70, 0x1E,
  0x38, 0x0E, 0x3C, 0x07, 0x1E, 0x03, 0x8E, 0x03, 0xC7, 0x01, 0xC3, 0x80,
  0xE3, 0xC0, 0x70, 0x01, 0xC0, 0xF0, 0x3C, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x01, 0xC0, 0xF0, 0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x78, 0x1E,
  0x07, 0x01, 0xC0, 0x70, 0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x78, 0x1E, 0x07,
  0x01, 0xC0, 0x70, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x70,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x70,
  0x01, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0xF0, 0x70, 0x78, 0x3C, 0x3C, 0x0F,
  0x0E, 0x03, 0x87, 0x00, 0xE3, 0xC0, 0x39, 0xE0, 0x1E, 0xF0, 0x07, 0x78,
  0x01, 0xDE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xBC, 0x03, 0xCF, 0x00,
  0xE1, 0xC0, 0x38, 0x70, 0x1E, 0x1E, 0x07, 0x87, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0F, 0x0F, 0x03, 0xC0, 0x01, 0xC0, 0x70, 0x3C, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x1E, 0x07, 0x01, 0xC0, 0x70, 0x3C, 0x0F, 0x03, 0x80,
  0xE0, 0x38, 0x1E, 0x07, 0x81, 0xC0, 0x70, 0x1C, 0x0F, 0x03, 0x80, 0xE0,
  0x38, 0x1E, 0x07, 0x81, 0xC0, 0x70, 0x1C, 0x0F, 0x00, 0x07, 0x3F, 0x0F,
  0x80, 0xCF, 0xE7, 0xF8, 0x3B, 0xFF, 0xFF, 0x87, 0xC3, 0xF0, 0xF0, 0xF0,
  0x3C, 0x1E, 0x1E, 0x07, 0x83, 0xC3, 0x80, 0xE0, 0x78, 0xF0, 0x3C, 0x0E,
  0x1E, 0x07, 0x01, 0xC3, 0x80, 0xE0, 0x38, 0x70, 0x1C, 0x0F, 0x0E, 0x03,
  0x81, 0xE3, 0xC0, 0xF0, 0x38, 0x70, 0x1C, 0x07, 0x0E, 0x03, 0x80, 0xE1,
  0xC0, 0x70, 0x3C, 0x78, 0x1E, 0x07, 0x8F, 0x03, 0xC0, 0xE1, 0xC0, 0x70,
  0x1C, 0x38, 0x0E, 0x03, 0x87, 0x01, 0xC0, 0xF1, 0xE0, 0x78, 0x1C, 0x00,
  0x07, 0x3F, 0x03, 0xBF, 0xC3, 0xBF, 0xE1, 0xF8, 0x70, 0xF8, 0x38, 0x78,
  0x1C, 0x38, 0x0E, 0x3C, 0x07, 0x1E, 0x07, 0x8E, 0x03, 0xC7, 0x01, 0xC7,
  0x80, 0xE3, 0xC0, 0x71, 0xC0, 0x78, 0xE0, 0x3C, 0x70, 0x1C, 0x78, 0x0E,
  0x3C, 0x07, 0x1C, 0x07, 0x8E, 0x03, 0x87, 0x01, 0xC7, 0x80, 0xE0, 0x01,
  0xFC, 0x07, 0xFE, 0x0F, 0xFE, 0x0E, 0x0F, 0x1E, 0x07, 0x3C, 0x07, 0x38,
  0x07, 0x38, 0x07, 0x78, 0x07, 0x70, 0x07, 0x70, 0x07, 0x70, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0E, 0xF0, 0x0E, 0xF0, 0x1E, 0xF0, 0x1C, 0x70, 0x3C, 0x78,
  0x78, 0x7F, 0xF0, 0x3F, 0xE0, 0x1F, 0xC0, 0x01, 0xCF, 0xC0, 0x1D, 0xFE,
  0x03, 0xBB, 0xE0, 0x3F, 0x0F, 0x03, 0xE0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x78, 0x0F, 0x07, 0x80, 0xF0, 0x70, 0x0F, 0x07, 0x00, 0xE0, 0x70,
  0x0E, 0x0F, 0x00, 0xE0, 0xE0, 0x1E, 0x0E, 0x01, 0xC0, 0xE0, 0x1C, 0x0E,
  0x03, 0xC1, 0xE0, 0x78, 0x1F, 0x07, 0x81, 0xFD, 0xF0, 0x1D, 0xFE, 0x03,
  0xCF, 0xC0, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xF1, 0xC1, 0xFE, 0x70, 0xFF, 0xF8, 0x3C, 0x3E,
  0x1E, 0x07, 0x87, 0x01, 0xE3, 0xC0, 0x70, 0xE0, 0x1C, 0x78, 0x07, 0x1E,
  0x03, 0xC7, 0x00, 0xF1, 0xC0, 0x38, 0x70, 0x0E, 0x3C, 0x07, 0x8F, 0x01,
  0xE3, 0xC0, 0x78, 0xF0, 0x3C, 0x3C, 0x1F, 0x0F, 0x07, 0xC1, 0xF7, 0x70,
  0x7F, 0xBC, 0x0F, 0xCE, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x07, 0x3E, 0x0C, 0xF8, 0x3B, 0xF0, 0x7E, 0x00, 0xF8,
  0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xF8, 0x1F,
  0xFC, 0x7C, 0xF0, 0xE0, 0x21, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE2, 0x03, 0x87, 0xBF, 0x0F, 0xFC,
  0x1F, 0xF0, 0x00, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x80, 0xE0, 0x3F, 0xDF,
  0xFB, 0xFF, 0x1E, 0x03, 0x80, 0x70, 0x0E, 0x03, 0xC0, 0x78, 0x0E, 0x01,
  0xC0, 0x38, 0x0F, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x80,
  0xFA, 0x0F, 0xC1, 0xF8, 0x00, 0x0E, 0x03, 0x87, 0x01, 0xC7, 0x80, 0xE3,
  0x80, 0xF1, 0xC0, 0x78, 0xE0, 0x38, 0xF0, 0x1C, 0x78, 0x0E, 0x38, 0x0F,
  0x1C, 0x07, 0x0E, 0x03, 0x8F, 0x01, 0xC7, 0x81, 0xE3, 0x80, 0xF1, 0xC0,
  0x70, 0xE0, 0x78, 0xF0, 0x3C, 0x78, 0x3E, 0x3C, 0x3F, 0x0F, 0xFF, 0x07,
  0xFB, 0x81, 0xF9, 0xC0, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0x77, 0x81, 0xE7,
  0x03, 0x8E, 0x0F, 0x1C, 0x1C, 0x38, 0x38, 0x70, 0xE0, 0xE1, 0xC1, 0xC7,
  0x83, 0x8E, 0x07, 0x3C, 0x0E, 0x70, 0x1D, 0xE0, 0x3B, 0x80, 0x77, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x00, 0xF0, 0x3C,
  0x07, 0xF0, 0x3C, 0x0F, 0xF0, 0x7C, 0x0E, 0xF0, 0x7C, 0x0E, 0xF0, 0x6C,
  0x1C, 0xF0, 0xFC, 0x1C, 0xF0, 0xFC, 0x3C, 0xF1, 0xDC, 0x38, 0xF1, 0xDC,
  0x38, 0xF1, 0x9C, 0x70, 0xF3, 0x9C, 0x70, 0xF3, 0x9C, 0xF0, 0xF7, 0x1C,
  0xE0, 0xF7, 0x1C, 0xE0, 0xE6, 0x1D, 0xC0, 0xEE, 0x1D, 0xC0, 0xEE, 0x1F,
  0x80, 0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0xF8, 0x1F, 0x00, 0xF8, 0x1F,
  0x00, 0xF8, 0x1E, 0x00, 0x07, 0x81, 0xE0, 0x70, 0x38, 0x0E, 0x0F, 0x01,
  0xC3, 0xC0, 0x3C, 0x70, 0x03, 0x9C, 0x00, 0x77, 0x80, 0x0E, 0xE0, 0x01,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07,
  0xF0, 0x01, 0xEE, 0x00, 0x39, 0xC0, 0x0E, 0x38, 0x03, 0xC7, 0x80, 0x70,
  0x70, 0x1E, 0x0E, 0x07, 0x81, 0xE1, 0xE0, 0x3C, 0x00, 0x03, 0xC0, 0x3C,
  0x07, 0x01, 0xE0, 0x1C, 0x07, 0x00, 0x70, 0x1C, 0x01, 0xC0, 0xF0, 0x07,
  0x03, 0x80, 0x1C, 0x1E, 0x00, 0x70, 0x70, 0x01, 0xC3, 0xC0, 0x07, 0x0E,
  0x00, 0x1C, 0x78, 0x00, 0x71, 0xC0, 0x01, 0xCF, 0x00, 0x07, 0x38, 0x00,
  0x1C, 0xE0, 0x00, 0x77, 0x00, 0x01, 0xDC, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x3F, 0xF8, 0x00, 0xE0, 0x03, 0xC0, 0x0F,
  0x00, 0x1C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0,
  0x07, 0xFF, 0x8F, 0xFE, 0x1F, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0xFC, 0x03,
  0xF0, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x0F,
  0x00, 0xFC, 0x01, 0xE0, 0x03, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x3C,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x03,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x78, 0x00,
  0x7E, 0x00, 0x3C, 0x01, 0xF0, 0x0F, 0x80, 0x1C, 0x00, 0x78, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x03, 0xC0, 0x07, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0x3E,
  0x01, 0xFF, 0x81, 0xFF, 0xFF, 0xC1, 0xFF, 0x80, 0x7E,
};

const GFXglyph NotoSans_Condensed_Italic41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 10, 29, 10, 1, -29 },
  { 38, 12, 10, 15, 4, -29 },
  { 53, 21, 29, 20, 0, -29 },
  { 130, 18, 33, 18, 0, -31 },
  { 205, 24, 30, 27, 2, -30 },
  { 295, 20, 30, 21, 0, -30 },
  { 370, 6, 10, 8, 4, -29 },
  { 378, 13, 35, 11, 1, -29 },
  { 435, 13, 35, 11, -3, -29 },
  { 492, 14, 15, 17, 4, -31 },
  { 519, 16, 19, 19, 2, -24 },
  { 557, 8, 10, 9, -2, -5 },
  { 567, 9, 4, 11, 1, -13 },
  { 572, 4, 5, 9, 1, -5 },
  { 575, 19, 29, 14, -2, -29 },
  { 644, 17, 30, 18, 1, -30 },
  { 708, 11, 29, 18, 5, -29 },
  { 748, 19, 30, 18, -1, -30 },
  { 820, 18, 30, 18, 0, -30 },
  { 888, 18, 29, 18, 0, -29 },
  { 954, 18, 29, 18, 0, -29 },
  { 1020, 18, 30, 18, 1, -30 },
  { 1088, 17, 29, 18, 2, -29 },
  { 1150, 18, 30, 18, 0, -30 },
  { 1218, 17, 30, 18, 1, -30 },
  { 1282, 8, 22, 9, 0, -22 },
  { 1304, 11, 27, 9, -2, -22 },
  { 1342, 16, 19, 19, 2, -24 },
  { 1380, 16, 11, 19, 2, -20 },
  { 1402, 16, 19, 19, 2, -24 },
  { 1440, 14, 30, 14, 1, -30 },
  { 1493, 26, 33, 27, 1, -29 },
  { 1601, 19, 29, 18, -3, -29 },
  { 1670, 20, 29, 20, 0, -29 },
  { 1743, 19, 30, 18, 2, -30 },
  { 1815, 21, 29, 22, 0, -29 },
  { 1892, 19, 29, 17, 0, -29 },
  { 1961, 19, 29, 16, 0, -29 },
  { 2030, 21, 30, 22, 2, -30 },
  { 2109, 22, 29, 22, 1, -29 },
  { 2189, 16, 29, 11, -2, -29 },
  { 2247, 16, 37, 9, -6, -29 },
  { 2321, 22, 29, 19, 0, -29 },
  { 2401, 13, 29, 16, 0, -29 },
  { 2449, 30, 29, 29, 0, -29 },
  { 2558, 24, 29, 23, 0, -29 },
  { 2645, 20, 30, 23, 2, -30 },
  { 2720, 19, 29, 19, 0, -29 },
  { 2789, 20, 37, 23, 2, -30 },
  { 2882, 19, 29, 19, 0, -29 },
  { 2951, 18, 30, 17, 0, -30 },
  { 3019, 16, 29, 16, 3, -29 },
  { 3077, 21, 29, 22, 2, -29 },
  { 3154, 18, 29, 18, 4, -29 },
  { 3220, 29, 29, 29, 4, -29 },
  { 3326, 22, 29, 17, -2, -29 },
  { 3406, 16, 29, 16, 4, -29 },
  { 3464, 19, 29, 16, -1, -29 },
  { 3533, 16, 36, 12, -1, -29 },
  { 3605, 7, 29, 14, 4, -29 },
  { 3631, 16, 36, 12, -3, -29 },
  { 3703, 17, 16, 18, 1, -29 },
  { 3737, 15, 3, 14, -4, 3 },
  { 3743, 6, 6, 11, 6, -31 },
  { 3748, 18, 22, 19, 1, -22 },
  { 3798, 18, 31, 19, 0, -31 },
  { 3868, 15, 22, 15, 1, -22 },
  { 3910, 20, 31, 19, 1, -31 },
  { 3988, 15, 22, 17, 1, -22 },
  { 4030, 20, 41, 11, -5, -31 },
  { 4133, 19, 32, 19, 0, -22 },
  { 4209, 17, 31, 19, 0, -31 },
  { 4275, 10, 30, 9, 0, -30 },
  { 4313, 15, 40, 9, -5, -30 },
  { 4388, 18, 31, 16, 0, -31 },
  { 4458, 10, 31, 9, 0, -31 },
  { 4497, 27, 22, 28, 0, -22 },
  { 4572, 17, 22, 19, 0, -22 },
  { 4619, 16, 22, 19, 1, -22 },
  { 4663, 20, 32, 19, -2, -22 },
  { 4743, 18, 32, 19, 1, -22 },
  { 4815, 15, 22, 13, 0, -22 },
  { 4857, 15, 22, 14, 0, -22 },
  { 4899, 11, 27, 11, 1, -27 },
  { 4937, 17, 22, 19, 1, -22 },
  { 4984, 15, 22, 15, 2, -22 },
  { 5026, 24, 22, 24, 2, -22 },
  { 5092, 19, 22, 16, -2, -22 },
  { 5145, 22, 32, 16, -4, -22 },
  { 5233, 15, 22, 14, -1, -22 },
  { 5275, 15, 35, 14, 1, -29 },
  { 5341, 3, 41, 17, 7, -31 },
  { 5357, 15, 35, 14, -2, -29 },
  { 5423, 16, 5, 19, 2, -17 },
};

const GFXfont NotoSans_Condensed_Italic41pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Italic41pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Italic41pt7bGlyphs,
  0x20, 0x7E, 56
};

#endif // _NOTOSANS_CONDENSED_ITALIC41PT7B_H_
