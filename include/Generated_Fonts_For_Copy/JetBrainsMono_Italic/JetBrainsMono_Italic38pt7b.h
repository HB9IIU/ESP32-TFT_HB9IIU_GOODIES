#ifndef _JETBRAINSMONO_ITALIC38PT7B_H_
#define _JETBRAINSMONO_ITALIC38PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Italic.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Italic38pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0xF0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x7E, 0x3F, 0x0F, 0x00, 0x78, 0x7B, 0xC3,
  0xDE, 0x1C, 0xF0, 0xE7, 0x0F, 0x38, 0x79, 0xC3, 0xDE, 0x1C, 0xF0, 0xE7,
  0x07, 0x38, 0x39, 0xC1, 0xC0, 0x00, 0x38, 0x18, 0x01, 0xC0, 0xE0, 0x07,
  0x03, 0x80, 0x1C, 0x0C, 0x00, 0xE0, 0x70, 0x03, 0x81, 0xC0, 0x0E, 0x0E,
  0x00, 0x70, 0x38, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF0, 0x38, 0x1C, 0x00,
  0xE0, 0x70, 0x03, 0x83, 0x80, 0x1C, 0x0E, 0x00, 0x70, 0x38, 0x01, 0xC1,
  0xC0, 0x0E, 0x07, 0x00, 0x38, 0x1C, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8,
  0x1C, 0x0E, 0x00, 0x60, 0x70, 0x03, 0x81, 0xC0, 0x0E, 0x06, 0x00, 0x30,
  0x38, 0x01, 0xC0, 0xE0, 0x07, 0x03, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x07,
  0xF0, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0x9B, 0xE0, 0xF3, 0x9E, 0x0E,
  0x38, 0xE1, 0xE3, 0x0E, 0x1E, 0x30, 0x01, 0xE3, 0x00, 0x1E, 0x30, 0x01,
  0xE3, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0x80, 0x06, 0xF8, 0x00, 0xE7, 0x80, 0x0E, 0x3C, 0x00, 0xC3,
  0xC0, 0x0C, 0x3C, 0xF0, 0xC3, 0x8F, 0x0C, 0x38, 0xF1, 0xC7, 0x87, 0x9C,
  0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x01, 0xF0, 0x01,
  0xC1, 0xFE, 0x00, 0xE0, 0x7F, 0xC0, 0x70, 0x38, 0x70, 0x38, 0x0E, 0x1C,
  0x0C, 0x07, 0x07, 0x07, 0x01, 0xC1, 0xC3, 0x80, 0x70, 0x71, 0xC0, 0x1C,
  0x1C, 0xE0, 0x07, 0x0E, 0x70, 0x01, 0xFF, 0x98, 0x00, 0x3F, 0xCE, 0x00,
  0x03, 0xC7, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE1,
  0x80, 0x00, 0x71, 0xFC, 0x00, 0x1D, 0xFF, 0x00, 0x0E, 0x71, 0xE0, 0x07,
  0x38, 0x38, 0x03, 0x8E, 0x0E, 0x01, 0xC3, 0x83, 0x80, 0xE0, 0xE0, 0xC0,
  0x38, 0x38, 0x70, 0x1C, 0x0E, 0x1C, 0x0E, 0x03, 0xDE, 0x07, 0x00, 0xFF,
  0x83, 0x80, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF0,
  0x0F, 0x07, 0x80, 0x70, 0x1C, 0x07, 0x80, 0xE0, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x7C, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x81, 0xE7, 0x1E, 0x1E, 0x78, 0x70,
  0xE3, 0xC3, 0xCF, 0x1C, 0x0E, 0xF0, 0xE0, 0x7F, 0x07, 0x01, 0xF0, 0x78,
  0x0F, 0x83, 0xC0, 0x7C, 0x1E, 0x03, 0xE0, 0xF0, 0x7F, 0x83, 0xFF, 0x9C,
  0x1F, 0xF8, 0xF0, 0x7F, 0x83, 0xC0, 0x7B, 0xDC, 0xEF, 0x7B, 0xDE, 0xE7,
  0x39, 0xC0, 0x00, 0x03, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF0,
  0x03, 0xE0, 0x03, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xE0, 0x07, 0xC0,
  0x01, 0xC0, 0x00, 0x40, 0x03, 0x00, 0x07, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x01, 0xFC, 0x03, 0xE0, 0x07, 0x80, 0x08,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x70, 0x06, 0x07, 0x03, 0x78, 0x71, 0xFF, 0xE6, 0x7F, 0xFF, 0x6F,
  0xF1, 0xFF, 0xF8, 0x00, 0xE0, 0x00, 0x1F, 0x00, 0x03, 0xB8, 0x00, 0x73,
  0xC0, 0x0F, 0x3C, 0x01, 0xE1, 0xE0, 0x3C, 0x1E, 0x07, 0x80, 0xF0, 0x18,
  0x0C, 0x00, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0x0F, 0xC3, 0xE0, 0xF0, 0x7C, 0x1E, 0x0F,
  0x83, 0xC1, 0xE0, 0x78, 0x1C, 0x0F, 0x03, 0x80, 0x7F, 0xFB, 0xFF, 0xFF,
  0xFE, 0x38, 0xFB, 0xF7, 0xEF, 0xDF, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x1F, 0xF8, 0x07, 0xFF, 0xC0, 0xF8, 0x3E, 0x0F, 0x01, 0xE1, 0xE0,
  0x0E, 0x1C, 0x00, 0xE1, 0xC0, 0x0E, 0x3C, 0x00, 0xE3, 0xC0, 0x0E, 0x38,
  0x00, 0xE3, 0x80, 0x1E, 0x38, 0xF1, 0xE3, 0x8F, 0x1C, 0x78, 0xF1, 0xC7,
  0x8F, 0x1C, 0x70, 0x01, 0xC7, 0x00, 0x3C, 0x70, 0x03, 0xC7, 0x00, 0x38,
  0x70, 0x03, 0x8F, 0x00, 0x38, 0xF0, 0x07, 0x87, 0x00, 0xF0, 0x78, 0x1F,
  0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0x3F,
  0x00, 0x7F, 0x80, 0x7F, 0xC0, 0xF9, 0xC0, 0xF8, 0xE0, 0x70, 0x70, 0x30,
  0x38, 0x20, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00,
  0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x7F,
  0xF0, 0x1F, 0xFF, 0x07, 0xC1, 0xF0, 0xE0, 0x1E, 0x3C, 0x01, 0xC7, 0x00,
  0x39, 0xE0, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0xFF, 0xF3, 0xFF, 0xFE,
  0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x80, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xCF, 0x00, 0x79, 0xE0, 0x0F, 0x3C, 0x01, 0xC7, 0x80, 0x78,
  0x78, 0x1E, 0x0F, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0x70, 0x3C, 0x1E, 0x07, 0x87, 0x80, 0xE1, 0xE0, 0x1C,
  0x78, 0x03, 0x8E, 0x00, 0x71, 0xC0, 0x1E, 0x3F, 0xFF, 0xC7, 0xFF, 0xF9,
  0xFF, 0xFE, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x00, 0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF,
  0x87, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0x80, 0x00, 0x73, 0xF8, 0x0E, 0xFF, 0x81, 0xFF, 0xF8,
  0x7E, 0x0F, 0x0F, 0x00, 0xF1, 0xE0, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x3C, 0x01, 0xE3,
  0x80, 0x78, 0x78, 0x1F, 0x0F, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F, 0xF8, 0x00,
  0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x1C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x70,
  0x00, 0x3D, 0xF8, 0x1F, 0xFF, 0x0F, 0xFF, 0xE3, 0xE0, 0x7D, 0xF0, 0x0F,
  0x78, 0x03, 0xDC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xEF, 0x00, 0x7B, 0xC0, 0x1C, 0x78, 0x1F, 0x1F, 0xFF, 0x83, 0xFF,
  0xC0, 0x3F, 0xC0, 0x7F, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xF0, 0x07, 0xB8, 0x01, 0xEE, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00,
  0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00,
  0x07, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xF0, 0x1F,
  0xFF, 0x03, 0xC1, 0xF0, 0xF0, 0x1E, 0x1C, 0x01, 0xC7, 0x80, 0x38, 0xF0,
  0x0F, 0x1E, 0x01, 0xC3, 0xC0, 0x78, 0x3C, 0x1E, 0x07, 0xC7, 0x80, 0x7F,
  0xE0, 0x03, 0xF0, 0x01, 0xFF, 0x00, 0x7C, 0xF8, 0x1E, 0x0F, 0x07, 0x80,
  0xF1, 0xE0, 0x0E, 0x38, 0x01, 0xC7, 0x00, 0x39, 0xE0, 0x07, 0x3C, 0x01,
  0xE7, 0x80, 0x38, 0x78, 0x1F, 0x0F, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F, 0xF8,
  0x00, 0x03, 0xFC, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xF8, 0x3E, 0x3C, 0x07,
  0x9E, 0x00, 0xF7, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xEE,
  0x00, 0x3B, 0x80, 0x1E, 0xF0, 0x07, 0xBE, 0x03, 0xC7, 0xE7, 0xF1, 0xFF,
  0xF8, 0x3F, 0xFC, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0x70, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01,
  0xC0, 0x01, 0xF0, 0x00, 0x0F, 0x0F, 0xCF, 0xE7, 0xF1, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x7E,
  0x3F, 0x1F, 0x8F, 0x80, 0x01, 0xE0, 0x3F, 0x07, 0xF0, 0x7F, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x03,
  0xC0, 0x3C, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x30, 0x00, 0x3C, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x1F, 0x00, 0x06, 0x00, 0x03, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xF0, 0x00, 0x18, 0x00, 0x01, 0x00, 0x7F, 0xFF, 0xDF,
  0xFF, 0xF7, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFC,
  0xFF, 0xFF, 0x00, 0x10, 0x00, 0x06, 0x00, 0x01, 0xE0, 0x00, 0x7E, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x01, 0xF0, 0x00, 0x1C, 0x00, 0x1F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x3F,
  0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x0F, 0x00, 0x03, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x1F, 0xF0, 0x3F, 0xFC, 0x01, 0xFC, 0x00,
  0x3E, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x0F, 0xF8, 0x1F, 0xE0, 0x1F, 0xC0, 0x1E,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x78, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1E, 0x01, 0xE0, 0x78,
  0x01, 0xC0, 0xE0, 0x03, 0xC3, 0x80, 0x03, 0x87, 0x00, 0x07, 0x1C, 0x00,
  0x0E, 0x38, 0x00, 0x1C, 0x70, 0x3F, 0x70, 0xE0, 0xFF, 0xE3, 0xC3, 0xC3,
  0xC7, 0x07, 0x03, 0x8E, 0x0E, 0x07, 0x1C, 0x38, 0x0E, 0x38, 0x70, 0x38,
  0x70, 0xE0, 0x70, 0xE1, 0xC0, 0xE3, 0x83, 0x81, 0xC7, 0x07, 0x03, 0x8E,
  0x0E, 0x0F, 0x1C, 0x1C, 0x1C, 0x38, 0x3F, 0xD8, 0x70, 0x7F, 0xF1, 0xE0,
  0x3C, 0xE3, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x1F, 0xC0, 0x03, 0xB8, 0x00, 0x77, 0x00, 0x1E, 0xE0, 0x03, 0x9C, 0x00,
  0xF3, 0x80, 0x1C, 0x70, 0x03, 0x8E, 0x00, 0xF1, 0xE0, 0x1C, 0x3C, 0x07,
  0x83, 0x80, 0xE0, 0x70, 0x3C, 0x0E, 0x07, 0x81, 0xC0, 0xE0, 0x38, 0x3F,
  0xFF, 0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x38, 0x03, 0xC7, 0x00, 0x79, 0xE0,
  0x0F, 0x38, 0x00, 0xEF, 0x00, 0x1D, 0xC0, 0x03, 0xF8, 0x00, 0x70, 0x0F,
  0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xE0, 0x7E, 0x0E, 0x01, 0xE1,
  0xE0, 0x1E, 0x1E, 0x00, 0xE1, 0xC0, 0x0E, 0x1C, 0x01, 0xE1, 0xC0, 0x1C,
  0x1C, 0x03, 0xC3, 0xC0, 0x78, 0x3F, 0xFF, 0x03, 0xFF, 0xC0, 0x3F, 0xFF,
  0x03, 0x80, 0xF8, 0x38, 0x03, 0x83, 0x80, 0x3C, 0x78, 0x03, 0xC7, 0x80,
  0x3C, 0x70, 0x03, 0xC7, 0x00, 0x38, 0x70, 0x07, 0x87, 0x00, 0x78, 0xF0,
  0x1F, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0x00, 0xFE, 0x00,
  0x7F, 0xE0, 0x3F, 0xFE, 0x07, 0x83, 0xE1, 0xE0, 0x3C, 0x78, 0x03, 0x8F,
  0x00, 0x71, 0xC0, 0x0E, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x71, 0xC0,
  0x0E, 0x38, 0x03, 0xC7, 0x80, 0xF0, 0xF0, 0x3E, 0x0F, 0xFF, 0x81, 0xFF,
  0xE0, 0x0F, 0xF0, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x07,
  0x07, 0xE0, 0xE0, 0x3E, 0x3C, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x07, 0x1C,
  0x01, 0xE3, 0x80, 0x3C, 0x70, 0x07, 0x9E, 0x00, 0xE3, 0xC0, 0x1C, 0x78,
  0x03, 0x8E, 0x00, 0xF1, 0xC0, 0x1E, 0x38, 0x03, 0xCF, 0x00, 0x71, 0xE0,
  0x0E, 0x3C, 0x01, 0xC7, 0x00, 0x78, 0xE0, 0x0F, 0x1C, 0x01, 0xC3, 0x80,
  0x78, 0xF0, 0x3E, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xE0, 0x00, 0x0F,
  0xFF, 0xF8, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0,
  0xFF, 0xFE, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0xFF, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1F,
  0xFF, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xE0, 0x3F, 0xFE, 0x07, 0x83,
  0xE1, 0xE0, 0x3C, 0x78, 0x03, 0x8F, 0x00, 0x71, 0xC0, 0x0E, 0x38, 0x00,
  0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00,
  0x1C, 0x3F, 0xE3, 0x87, 0xFC, 0xF0, 0xFF, 0x9E, 0x00, 0xF3, 0xC0, 0x1E,
  0x70, 0x03, 0x8E, 0x00, 0x71, 0xC0, 0x0E, 0x38, 0x03, 0xC7, 0x80, 0xF0,
  0xF0, 0x3E, 0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0x0F, 0x00,
  0x70, 0xF0, 0x0F, 0x0E, 0x00, 0xF0, 0xE0, 0x0F, 0x0E, 0x00, 0xE1, 0xE0,
  0x0E, 0x1E, 0x00, 0xE1, 0xE0, 0x1E, 0x1C, 0x01, 0xE1, 0xC0, 0x1E, 0x1C,
  0x01, 0xC3, 0xC0, 0x1C, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3,
  0x80, 0x3C, 0x38, 0x03, 0x83, 0x80, 0x38, 0x78, 0x03, 0x87, 0x80, 0x78,
  0x70, 0x07, 0x87, 0x00, 0x78, 0x70, 0x07, 0x07, 0x00, 0x70, 0xF0, 0x07,
  0x0F, 0x00, 0x70, 0xF0, 0x0F, 0x0E, 0x00, 0xF0, 0x07, 0xFF, 0xF0, 0x7F,
  0xFE, 0x0F, 0xFF, 0xE0, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x07, 0xFF,
  0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x0F, 0x00,
  0x38, 0x78, 0x01, 0xC3, 0xC0, 0x1E, 0x1E, 0x01, 0xE0, 0x78, 0x1F, 0x03,
  0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0x00, 0x3C, 0x38,
  0x01, 0xE0, 0xE0, 0x0F, 0x03, 0x80, 0x38, 0x0E, 0x01, 0xE0, 0x78, 0x0F,
  0x01, 0xE0, 0x38, 0x07, 0x81, 0xE0, 0x1C, 0x0F, 0x00, 0x70, 0x38, 0x01,
  0xC1, 0xE0, 0x0F, 0x0F, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0x80, 0x0E, 0x0E, 0x00, 0x38, 0x3C, 0x01, 0xE0, 0xF0, 0x07, 0x81, 0xC0,
  0x1E, 0x07, 0x80, 0x70, 0x1E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xF0, 0x1C,
  0x03, 0xC0, 0xF0, 0x07, 0x03, 0xC0, 0x1E, 0x0E, 0x00, 0x78, 0x38, 0x00,
  0xF0, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x80, 0x7C,
  0x3E, 0x01, 0xE0, 0xF8, 0x0F, 0x83, 0xF0, 0x36, 0x0D, 0xC1, 0xF8, 0x37,
  0x07, 0xE0, 0xDC, 0x3B, 0x87, 0x70, 0xEE, 0x1C, 0xC7, 0x70, 0x73, 0x9D,
  0xC1, 0xCE, 0xE7, 0x07, 0x3B, 0x9C, 0x1C, 0xFC, 0x70, 0x71, 0xF3, 0xC3,
  0xC7, 0x8E, 0x0F, 0x1E, 0x38, 0x38, 0x00, 0xE0, 0xE0, 0x03, 0x83, 0x80,
  0x1E, 0x0E, 0x00, 0x78, 0x78, 0x01, 0xC1, 0xE0, 0x07, 0x07, 0x00, 0x1C,
  0x1C, 0x00, 0x70, 0x70, 0x03, 0xC1, 0xC0, 0x0F, 0x0F, 0x00, 0x38, 0x3C,
  0x00, 0xE0, 0x0F, 0x80, 0x70, 0xF8, 0x07, 0x0F, 0x80, 0xF0, 0xF8, 0x0F,
  0x1D, 0xC0, 0xE1, 0xDC, 0x0E, 0x1D, 0xC0, 0xE1, 0xDC, 0x0E, 0x1D, 0xC1,
  0xE1, 0xCE, 0x1E, 0x1C, 0xE1, 0xE3, 0xCE, 0x1C, 0x3C, 0xE1, 0xC3, 0x8E,
  0x1C, 0x38, 0x71, 0xC3, 0x87, 0x3C, 0x38, 0x73, 0xC7, 0x87, 0x38, 0x78,
  0x73, 0x87, 0x03, 0xB8, 0x70, 0x3B, 0x87, 0x03, 0xB8, 0x70, 0x3B, 0x8F,
  0x03, 0xF0, 0xF0, 0x3F, 0x0E, 0x01, 0xF0, 0xE0, 0x1F, 0x0E, 0x01, 0xF0,
  0x00, 0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0xF8, 0x3C, 0x1F, 0x1E, 0x03, 0xCF,
  0x00, 0x73, 0xC0, 0x1C, 0xE0, 0x07, 0x38, 0x03, 0xCE, 0x00, 0xF7, 0x80,
  0x3D, 0xE0, 0x0E, 0x78, 0x03, 0x9C, 0x00, 0xE7, 0x00, 0x79, 0xC0, 0x1E,
  0xF0, 0x07, 0xBC, 0x01, 0xCF, 0x00, 0x73, 0x80, 0x1C, 0xE0, 0x07, 0x38,
  0x03, 0xCE, 0x00, 0xE3, 0xC0, 0x78, 0xF0, 0x3C, 0x1F, 0xFF, 0x07, 0xFF,
  0x80, 0x7F, 0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x1C,
  0x07, 0xE0, 0xE0, 0x0F, 0x0F, 0x00, 0x38, 0x78, 0x01, 0xC3, 0xC0, 0x0E,
  0x1C, 0x00, 0x70, 0xE0, 0x03, 0x87, 0x00, 0x3C, 0x78, 0x03, 0xC3, 0xC0,
  0x3E, 0x1E, 0x0F, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xC0, 0x3F, 0xF0, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xF8, 0x07, 0xFF,
  0xC0, 0xF8, 0x3E, 0x0F, 0x01, 0xE1, 0xE0, 0x0E, 0x1C, 0x00, 0xE1, 0xC0,
  0x0E, 0x3C, 0x00, 0xE3, 0xC0, 0x0E, 0x3C, 0x01, 0xE3, 0x80, 0x1E, 0x38,
  0x01, 0xE3, 0x80, 0x1C, 0x78, 0x01, 0xC7, 0x80, 0x1C, 0x78, 0x03, 0xC7,
  0x00, 0x3C, 0x70, 0x03, 0xC7, 0x00, 0x38, 0x70, 0x03, 0x8F, 0x00, 0x38,
  0xF0, 0x07, 0x87, 0x00, 0xF0, 0x78, 0x1F, 0x07, 0xFF, 0xE0, 0x3F, 0xFC,
  0x00, 0xFF, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x0F, 0xFE, 0x00,
  0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xE0, 0x7E, 0x0E, 0x01, 0xF1, 0xE0, 0x0F,
  0x1E, 0x00, 0xF1, 0xE0, 0x0F, 0x1C, 0x00, 0xF1, 0xC0, 0x0F, 0x1C, 0x01,
  0xE3, 0xC0, 0x1E, 0x3C, 0x07, 0xC3, 0xFF, 0xF8, 0x3F, 0xFF, 0x03, 0xFF,
  0xC0, 0x38, 0x38, 0x07, 0x83, 0xC0, 0x78, 0x3C, 0x07, 0x81, 0xC0, 0x70,
  0x1E, 0x07, 0x01, 0xE0, 0x70, 0x1E, 0x07, 0x00, 0xF0, 0xF0, 0x0F, 0x0F,
  0x00, 0xF0, 0xE0, 0x07, 0x8E, 0x00, 0x78, 0x00, 0x7F, 0x00, 0x1F, 0xFC,
  0x07, 0xFF, 0xC0, 0x78, 0x3E, 0x0F, 0x01, 0xE0, 0xE0, 0x0E, 0x1E, 0x00,
  0xE1, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xCF,
  0x00, 0x38, 0xF0, 0x03, 0x8F, 0x00, 0x78, 0xF8, 0x0F, 0x07, 0xFF, 0xE0,
  0x3F, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x70, 0xE0, 0x0F, 0x0E, 0x00, 0xF0, 0xE0, 0x0F, 0x1E, 0x00,
  0xE1, 0xE0, 0x0E, 0x1E, 0x00, 0xE1, 0xC0, 0x0E, 0x1C, 0x01, 0xE1, 0xC0,
  0x1E, 0x1C, 0x01, 0xE3, 0xC0, 0x1C, 0x3C, 0x01, 0xC3, 0xC0, 0x1C, 0x38,
  0x03, 0xC3, 0x80, 0x3C, 0x38, 0x03, 0xC7, 0x80, 0x38, 0x78, 0x03, 0x87,
  0x80, 0x38, 0x70, 0x07, 0x87, 0x00, 0x78, 0x70, 0x07, 0x07, 0x80, 0xF0,
  0x78, 0x1E, 0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0xFF, 0x00, 0xE0, 0x01,
  0xFC, 0x00, 0x3B, 0x80, 0x0F, 0x70, 0x01, 0xCE, 0x00, 0x79, 0xE0, 0x0E,
  0x3C, 0x01, 0xC7, 0x80, 0x78, 0xF0, 0x0E, 0x0E, 0x03, 0xC1, 0xC0, 0x70,
  0x38, 0x0E, 0x07, 0x03, 0xC0, 0xE0, 0x70, 0x1C, 0x1E, 0x03, 0x83, 0x80,
  0x78, 0xF0, 0x0F, 0x1C, 0x01, 0xE3, 0x80, 0x1C, 0xF0, 0x03, 0x9C, 0x00,
  0x77, 0x80, 0x0E, 0xE0, 0x01, 0xDC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x00, 0x00, 0x38, 0x3C, 0x1E, 0x70, 0x78, 0x38, 0xE0,
  0xF0, 0x71, 0xC3, 0xE0, 0xE7, 0x86, 0xC3, 0x8F, 0x0D, 0x87, 0x1E, 0x1B,
  0x0E, 0x38, 0x76, 0x1C, 0x70, 0xDC, 0x70, 0xE1, 0xB8, 0xE1, 0xC7, 0x71,
  0xC3, 0x8C, 0xE7, 0x07, 0x19, 0x8E, 0x0E, 0x33, 0x1C, 0x1C, 0xE6, 0x38,
  0x39, 0x8C, 0xE0, 0x73, 0x19, 0xC0, 0xEE, 0x33, 0x81, 0xD8, 0x67, 0x03,
  0xB0, 0xDC, 0x07, 0x61, 0xB8, 0x0F, 0xC3, 0x70, 0x1F, 0x06, 0xC0, 0x3E,
  0x0F, 0x80, 0x6C, 0x1F, 0x00, 0xF0, 0x3E, 0x01, 0xE0, 0x78, 0x07, 0xC0,
  0xF0, 0x00, 0x07, 0x80, 0x0F, 0x07, 0x80, 0x1E, 0x03, 0x80, 0x3C, 0x03,
  0xC0, 0x78, 0x03, 0xC0, 0x78, 0x01, 0xC0, 0xF0, 0x01, 0xE1, 0xE0, 0x00,
  0xE1, 0xC0, 0x00, 0xE3, 0xC0, 0x00, 0xF7, 0x80, 0x00, 0x77, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xEE, 0x00, 0x01, 0xCF, 0x00, 0x03,
  0xC7, 0x00, 0x07, 0x87, 0x80, 0x07, 0x07, 0x80, 0x0F, 0x03, 0x80, 0x1E,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x78, 0x01, 0xE0, 0xF0,
  0x00, 0xF0, 0xF0, 0x00, 0xFF, 0x00, 0x0E, 0x70, 0x01, 0xE7, 0x80, 0x1C,
  0x78, 0x03, 0x83, 0x80, 0x78, 0x3C, 0x07, 0x03, 0xC0, 0xF0, 0x1C, 0x1E,
  0x01, 0xE1, 0xC0, 0x1E, 0x3C, 0x00, 0xE7, 0x80, 0x0E, 0x70, 0x00, 0xFF,
  0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x00, 0x0E, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00,
  0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x03, 0xFE,
  0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00,
  0xFF, 0x81, 0xFF, 0x07, 0xFE, 0x00, 0xF0, 0x0F, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0xC0, 0x3C, 0x01, 0xC0,
  0x1C, 0x01, 0xE0, 0x1E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0xF0,
  0x07, 0x00, 0x70, 0x07, 0x80, 0x78, 0x03, 0x80, 0x38, 0x03, 0x80, 0x3C,
  0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x1E, 0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x0F,
  0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0,
  0x01, 0xC0, 0xFF, 0x81, 0xFF, 0x07, 0xFE, 0x00, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x3E, 0x00, 0x1F, 0x80, 0x1D, 0xC0, 0x1C, 0x60, 0x0E, 0x38, 0x0E,
  0x1C, 0x0F, 0x0E, 0x07, 0x03, 0x07, 0x01, 0xC3, 0x80, 0xE3, 0x80, 0x73,
  0xC0, 0x1F, 0xC0, 0x0E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0x00,
  0xF0, 0xE0, 0xE1, 0xE1, 0xE0, 0x03, 0xF9, 0xE0, 0xFF, 0xBC, 0x3F, 0xFF,
  0x8F, 0x83, 0xE1, 0xE0, 0x3C, 0x78, 0x07, 0x8F, 0x00, 0xF1, 0xC0, 0x1E,
  0x38, 0x03, 0xC7, 0x00, 0x79, 0xE0, 0x0E, 0x3C, 0x01, 0xC7, 0x00, 0x38,
  0xE0, 0x0F, 0x1C, 0x01, 0xE3, 0x80, 0x3C, 0x78, 0x0F, 0x0F, 0x03, 0xE1,
  0xFF, 0xDC, 0x1F, 0xF7, 0x81, 0xFC, 0xF0, 0x0F, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x71,
  0xFC, 0x1C, 0xFF, 0x87, 0x7F, 0xE1, 0xF0, 0x7C, 0xF8, 0x0F, 0x3C, 0x03,
  0xCF, 0x00, 0x73, 0x80, 0x3C, 0xE0, 0x0F, 0x38, 0x03, 0xDE, 0x00, 0xE7,
  0x80, 0x39, 0xE0, 0x0E, 0x70, 0x03, 0x9C, 0x01, 0xE7, 0x00, 0x79, 0xE0,
  0x3C, 0xF8, 0x1F, 0x3F, 0xFF, 0x8F, 0x7F, 0xC3, 0x8F, 0xE0, 0x03, 0xFC,
  0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0xF8, 0x3E, 0x3C, 0x07, 0x9E, 0x00, 0xE7,
  0x00, 0x39, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x73, 0x80, 0x3C, 0xF0, 0x0E,
  0x3C, 0x0F, 0x87, 0xFF, 0xC1, 0xFF, 0xE0, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x3F, 0x9E, 0x07, 0xFD, 0xE0, 0xFF, 0xFE, 0x1F,
  0x07, 0xC1, 0xE0, 0x3C, 0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x38, 0x03, 0xC3,
  0x80, 0x3C, 0x38, 0x03, 0xC7, 0x80, 0x38, 0x78, 0x03, 0x87, 0x00, 0x38,
  0x70, 0x07, 0x87, 0x00, 0x78, 0x70, 0x07, 0x87, 0x80, 0xF0, 0x78, 0x1F,
  0x07, 0xFF, 0x70, 0x3F, 0xEF, 0x01, 0xFC, 0xF0, 0x03, 0xFC, 0x07, 0xFF,
  0x07, 0xFF, 0xC7, 0x80, 0xF3, 0x80, 0x7B, 0xC0, 0x1D, 0xC0, 0x0E, 0xE0,
  0x07, 0x70, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xDE, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x02, 0xE0, 0x0E, 0x78, 0x0F, 0x1F, 0xFF,
  0x0F, 0xFF, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03,
  0xF1, 0xC3, 0xFE, 0xF1, 0xFF, 0xFC, 0xF8, 0x3E, 0x3C, 0x07, 0x9E, 0x01,
  0xE7, 0x80, 0x79, 0xC0, 0x1E, 0x70, 0x07, 0x9C, 0x01, 0xEF, 0x00, 0x73,
  0xC0, 0x1C, 0xF0, 0x07, 0x3C, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x7C, 0x7C,
  0x7E, 0x1F, 0xFB, 0x83, 0xFC, 0xE0, 0x38, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x1F, 0xFE, 0x07, 0xFF, 0x03,
  0xFE, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x71, 0xFC, 0x1D, 0xFF, 0x87, 0x7F,
  0xE1, 0xF0, 0x7C, 0xF8, 0x0F, 0x3C, 0x03, 0xCF, 0x00, 0x73, 0x80, 0x3C,
  0xE0, 0x0F, 0x38, 0x03, 0xDE, 0x00, 0xE7, 0x80, 0x39, 0xE0, 0x0E, 0x70,
  0x07, 0x9C, 0x01, 0xE7, 0x00, 0x79, 0xC0, 0x1C, 0xF0, 0x07, 0x3C, 0x01,
  0xCE, 0x00, 0x73, 0x80, 0x3C, 0x00, 0x06, 0x00, 0x01, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x01, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x3F, 0xFF, 0xF7,
  0xFF, 0xFD, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x40, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x00,
  0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xC0, 0x00, 0x3C, 0x00, 0x1F, 0x80, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x0F, 0x1C, 0x01,
  0xE1, 0xC0, 0x3C, 0x1C, 0x07, 0x81, 0xC0, 0xF8, 0x3C, 0x0F, 0x03, 0xC1,
  0xE0, 0x3C, 0x3C, 0x03, 0x87, 0x80, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x7F,
  0xF0, 0x07, 0x87, 0x80, 0x78, 0x78, 0x07, 0x03, 0xC0, 0x70, 0x3C, 0x07,
  0x01, 0xE0, 0xF0, 0x1E, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x0E, 0x00, 0x78,
  0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1F, 0xFF, 0x0F, 0xFE, 0x03, 0xFE, 0x1D, 0xF3, 0xE0, 0xFF,
  0xFF, 0x87, 0x9F, 0x3C, 0x38, 0x70, 0xE3, 0xC3, 0x87, 0x1C, 0x1C, 0x38,
  0xE0, 0xC1, 0xC7, 0x0E, 0x0E, 0x38, 0x70, 0xF1, 0xC3, 0x87, 0x1E, 0x1C,
  0x38, 0xF0, 0xE1, 0xC7, 0x06, 0x0E, 0x38, 0x30, 0x71, 0xC3, 0x87, 0x8E,
  0x1C, 0x3C, 0x70, 0xE1, 0xC7, 0x87, 0x0E, 0x38, 0x38, 0x71, 0xC1, 0x83,
  0x8E, 0x1C, 0x3C, 0x00, 0x1E, 0x7F, 0x07, 0x7F, 0xE1, 0xDF, 0xF8, 0x7C,
  0x1F, 0x3E, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x1C, 0xE0, 0x0F, 0x38, 0x03,
  0xCE, 0x00, 0xF7, 0x80, 0x39, 0xE0, 0x0E, 0x78, 0x03, 0x9C, 0x01, 0xE7,
  0x00, 0x79, 0xC0, 0x1E, 0x70, 0x07, 0x3C, 0x01, 0xCF, 0x00, 0x73, 0x80,
  0x1C, 0xE0, 0x0F, 0x00, 0x03, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0xC7, 0xC1,
  0xF3, 0xC0, 0x7B, 0xC0, 0x3D, 0xC0, 0x0E, 0xE0, 0x0F, 0x70, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xDE, 0x00, 0xEE, 0x00, 0x77, 0x00, 0x3B, 0x80, 0x3D,
  0xC0, 0x1C, 0xF0, 0x1E, 0x78, 0x1E, 0x1F, 0xFF, 0x0F, 0xFF, 0x01, 0xFE,
  0x00, 0x0F, 0x3F, 0x81, 0xCF, 0xF8, 0x3B, 0xFF, 0x07, 0xC1, 0xF1, 0xF0,
  0x1E, 0x3C, 0x03, 0xC7, 0x80, 0x38, 0xE0, 0x0F, 0x1C, 0x01, 0xE3, 0x80,
  0x3C, 0xF0, 0x07, 0x1E, 0x00, 0xE3, 0xC0, 0x1C, 0x70, 0x03, 0x8E, 0x00,
  0xF1, 0xC0, 0x1E, 0x7C, 0x07, 0x8F, 0xC1, 0xF1, 0xFF, 0xFC, 0x39, 0xFF,
  0x07, 0x1F, 0xC0, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x00, 0x03, 0xF9, 0xE0, 0xFF,
  0xBC, 0x3F, 0xFF, 0x8F, 0x83, 0xE1, 0xE0, 0x3C, 0x78, 0x07, 0x8E, 0x00,
  0xF1, 0xC0, 0x1E, 0x38, 0x03, 0xCF, 0x00, 0x71, 0xE0, 0x0E, 0x3C, 0x01,
  0xC7, 0x00, 0x38, 0xE0, 0x0F, 0x1C, 0x01, 0xE3, 0x80, 0x3C, 0x78, 0x0F,
  0x0F, 0x03, 0xE1, 0xFF, 0xDC, 0x1F, 0xF7, 0x81, 0xFC, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x1C, 0xFE, 0x07, 0x7F, 0xC3, 0xFF, 0xF8, 0xFC, 0x1F,
  0x3C, 0x03, 0xCF, 0x00, 0xF3, 0x80, 0x3C, 0xE0, 0x0F, 0x38, 0x03, 0xDE,
  0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x78, 0x0F,
  0x1C, 0x01, 0xCF, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x07,
  0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0xF0, 0x07, 0x3E, 0x03, 0xC7, 0xFF, 0xE0, 0xFF, 0xF0,
  0x1F, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0xFE, 0x01,
  0xFF, 0x80, 0x3F, 0xE0, 0x1C, 0x00, 0xE3, 0x80, 0x3C, 0x70, 0x07, 0x9E,
  0x00, 0xE3, 0xC0, 0x1C, 0x78, 0x03, 0x8E, 0x00, 0x71, 0xC0, 0x1E, 0x38,
  0x03, 0xC7, 0x00, 0x79, 0xE0, 0x0E, 0x3C, 0x01, 0xC7, 0x80, 0x38, 0xE0,
  0x0F, 0x1C, 0x01, 0xE3, 0x80, 0x38, 0x78, 0x0F, 0x0F, 0x03, 0xC0, 0xFF,
  0xF8, 0x1F, 0xFC, 0x00, 0xFF, 0x00, 0xE0, 0x03, 0xFC, 0x00, 0xEF, 0x00,
  0x7B, 0xC0, 0x1E, 0x70, 0x07, 0x1C, 0x03, 0xC7, 0x00, 0xE1, 0xC0, 0x78,
  0x78, 0x1C, 0x1E, 0x0F, 0x03, 0x83, 0x80, 0xE1, 0xE0, 0x38, 0x70, 0x0E,
  0x3C, 0x03, 0xCE, 0x00, 0xF7, 0x80, 0x1D, 0xC0, 0x07, 0xF0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x00, 0x00, 0xE0, 0xF0, 0x7E, 0x0F, 0x07, 0xE0,
  0xF0, 0xEE, 0x1B, 0x0E, 0xE1, 0xB0, 0xEE, 0x1B, 0x0C, 0xE3, 0x31, 0xCE,
  0x33, 0x1C, 0xE3, 0x31, 0x8E, 0x63, 0x38, 0xE6, 0x33, 0x8E, 0x63, 0x30,
  0xEE, 0x37, 0x0E, 0xC3, 0x70, 0xEC, 0x36, 0x0F, 0xC3, 0xE0, 0xF8, 0x3E,
  0x0F, 0x83, 0xC0, 0xF8, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x38, 0x00, 0x0F,
  0x00, 0x3C, 0x1E, 0x01, 0xE0, 0x78, 0x0F, 0x00, 0xF0, 0x78, 0x03, 0xC3,
  0xC0, 0x07, 0x8F, 0x00, 0x1E, 0x78, 0x00, 0x3B, 0xC0, 0x00, 0x7E, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFE, 0x00, 0x07,
  0x38, 0x00, 0x3C, 0xF0, 0x01, 0xE3, 0xC0, 0x0F, 0x07, 0x80, 0x78, 0x1E,
  0x03, 0xC0, 0x3C, 0x0F, 0x00, 0xF0, 0xF8, 0x01, 0xE0, 0x3C, 0x01, 0xCE,
  0x00, 0xF3, 0x80, 0x3C, 0xE0, 0x0E, 0x78, 0x03, 0x9E, 0x00, 0xE7, 0x80,
  0x39, 0xC0, 0x1E, 0x70, 0x07, 0x9C, 0x01, 0xEF, 0x00, 0x73, 0xC0, 0x1C,
  0xF0, 0x07, 0x3C, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x7C, 0x7E, 0xFE, 0x1F,
  0xFB, 0x83, 0xFC, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x1F, 0xFE, 0x07, 0xFF, 0x03, 0xFE, 0x00,
  0x1F, 0xFF, 0xE3, 0xFF, 0xF8, 0x7F, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xFF, 0xFC, 0x7F, 0xFF, 0x8F,
  0xFF, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x3F, 0x00, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x01, 0xF0, 0x07, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x07, 0xC0, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x78, 0x3C, 0x1C, 0x0E, 0x07, 0x03, 0x83, 0xC1, 0xE0, 0xF0, 0x70,
  0x38, 0x1C, 0x1E, 0x0F, 0x07, 0x83, 0x81, 0xC0, 0xE0, 0x70, 0x78, 0x3C,
  0x1E, 0x0E, 0x07, 0x03, 0x83, 0xC1, 0xE0, 0xF0, 0x70, 0x38, 0x1C, 0x1E,
  0x00, 0x03, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x3F,
  0xF0, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x1F, 0xE0, 0x03, 0xF8, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x80, 0xE7, 0xF8, 0x1D, 0xFF, 0x83, 0xB8, 0x78,
  0xF7, 0x0F, 0xBC, 0xE0, 0xFF, 0xBC, 0x0F, 0xE0, 0x00, 0x20,
};

const GFXglyph JetBrainsMono_Italic38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 23, 0, -1 },
  { 1, 9, 28, 23, 7, -28 },
  { 33, 13, 12, 23, 7, -28 },
  { 53, 22, 28, 23, 1, -28 },
  { 130, 20, 38, 23, 2, -33 },
  { 225, 26, 28, 23, -1, -28 },
  { 316, 21, 28, 23, 1, -28 },
  { 390, 5, 12, 23, 11, -28 },
  { 398, 16, 37, 23, 6, -32 },
  { 472, 15, 37, 23, 2, -32 },
  { 542, 20, 19, 23, 2, -23 },
  { 590, 18, 17, 23, 3, -21 },
  { 629, 10, 12, 23, 4, -6 },
  { 644, 13, 3, 23, 5, -14 },
  { 649, 7, 6, 23, 7, -6 },
  { 655, 22, 36, 23, 1, -32 },
  { 754, 20, 28, 23, 2, -28 },
  { 824, 17, 28, 23, 2, -28 },
  { 884, 19, 28, 23, 2, -28 },
  { 951, 19, 28, 23, 2, -28 },
  { 1018, 19, 28, 23, 2, -28 },
  { 1085, 19, 28, 23, 2, -28 },
  { 1152, 18, 28, 23, 2, -28 },
  { 1215, 18, 28, 23, 5, -28 },
  { 1278, 19, 28, 23, 2, -28 },
  { 1345, 18, 28, 23, 4, -28 },
  { 1408, 9, 21, 23, 7, -21 },
  { 1432, 12, 27, 23, 4, -21 },
  { 1473, 18, 21, 23, 3, -23 },
  { 1521, 18, 13, 23, 3, -19 },
  { 1551, 18, 21, 23, 2, -23 },
  { 1599, 16, 28, 23, 5, -28 },
  { 1655, 23, 35, 23, 0, -28 },
  { 1756, 19, 28, 23, 0, -28 },
  { 1823, 20, 28, 23, 2, -28 },
  { 1893, 19, 28, 23, 3, -28 },
  { 1960, 19, 28, 23, 2, -28 },
  { 2027, 21, 28, 23, 2, -28 },
  { 2101, 21, 28, 23, 2, -28 },
  { 2175, 19, 28, 23, 3, -28 },
  { 2242, 20, 28, 23, 2, -28 },
  { 2312, 20, 28, 23, 2, -28 },
  { 2382, 21, 28, 23, 1, -28 },
  { 2456, 22, 28, 23, 2, -28 },
  { 2533, 16, 28, 23, 3, -28 },
  { 2589, 22, 28, 23, 1, -28 },
  { 2666, 20, 28, 23, 2, -28 },
  { 2736, 18, 28, 23, 3, -28 },
  { 2799, 21, 28, 23, 2, -28 },
  { 2873, 20, 35, 23, 2, -28 },
  { 2961, 20, 28, 23, 2, -28 },
  { 3031, 20, 28, 23, 2, -28 },
  { 3101, 19, 28, 23, 4, -28 },
  { 3168, 20, 28, 23, 2, -28 },
  { 3238, 19, 28, 23, 5, -28 },
  { 3305, 23, 28, 23, 2, -28 },
  { 3386, 24, 28, 23, 0, -28 },
  { 3470, 20, 28, 23, 4, -28 },
  { 3540, 20, 28, 23, 2, -28 },
  { 3610, 15, 36, 23, 5, -32 },
  { 3678, 12, 36, 23, 6, -32 },
  { 3732, 15, 36, 23, 3, -32 },
  { 3800, 17, 15, 23, 3, -28 },
  { 3832, 19, 3, 23, 0, 1 },
  { 3840, 7, 5, 23, 10, -30 },
  { 3845, 19, 21, 23, 2, -21 },
  { 3895, 18, 28, 23, 2, -28 },
  { 3958, 18, 21, 23, 3, -21 },
  { 4006, 20, 28, 23, 2, -28 },
  { 4076, 17, 21, 23, 3, -21 },
  { 4121, 26, 35, 23, -2, -28 },
  { 4235, 18, 28, 23, 3, -21 },
  { 4298, 18, 28, 23, 2, -28 },
  { 4361, 19, 30, 23, 1, -30 },
  { 4433, 20, 37, 23, 0, -30 },
  { 4526, 20, 28, 23, 2, -28 },
  { 4596, 16, 28, 23, 4, -28 },
  { 4652, 21, 21, 23, 1, -21 },
  { 4708, 18, 21, 23, 2, -21 },
  { 4756, 17, 21, 23, 3, -21 },
  { 4801, 19, 28, 23, 1, -21 },
  { 4868, 19, 28, 23, 2, -21 },
  { 4935, 18, 21, 23, 3, -21 },
  { 4983, 18, 21, 23, 2, -21 },
  { 5031, 18, 27, 23, 3, -27 },
  { 5092, 19, 21, 23, 2, -21 },
  { 5142, 18, 21, 23, 4, -21 },
  { 5190, 20, 21, 23, 3, -21 },
  { 5243, 22, 21, 23, 0, -21 },
  { 5301, 18, 28, 23, 3, -21 },
  { 5364, 19, 21, 23, 2, -21 },
  { 5414, 20, 36, 23, 3, -32 },
  { 5504, 9, 36, 23, 7, -32 },
  { 5545, 19, 36, 23, 1, -32 },
  { 5631, 19, 8, 23, 2, -17 },
};

const GFXfont JetBrainsMono_Italic38pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Italic38pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Italic38pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _JETBRAINSMONO_ITALIC38PT7B_H_
