#ifndef _JETBRAINSMONO_ITALIC21PT7B_H_
#define _JETBRAINSMONO_ITALIC21PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Italic.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Italic21pt7bBitmaps[] PROGMEM = {
  0x00, 0x19, 0xCC, 0x63, 0x18, 0xC4, 0x21, 0x10, 0x00, 0x73, 0x80, 0x67,
  0x8F, 0x16, 0x6C, 0xD9, 0x80, 0x03, 0x10, 0x31, 0x81, 0x88, 0x08, 0x43,
  0xFF, 0x86, 0x20, 0x21, 0x03, 0x18, 0x18, 0x83, 0xFF, 0x3F, 0xF8, 0x62,
  0x02, 0x30, 0x31, 0x81, 0x88, 0x00, 0x01, 0x00, 0x60, 0x0C, 0x07, 0xE1,
  0xAE, 0x64, 0xCC, 0x99, 0x90, 0x36, 0x07, 0xC0, 0x3E, 0x03, 0xC0, 0x4C,
  0x09, 0xB3, 0x36, 0x6C, 0x7F, 0x87, 0xC0, 0x20, 0x04, 0x01, 0x80, 0x1F,
  0x06, 0x22, 0x10, 0xC4, 0x41, 0x89, 0x83, 0x36, 0x07, 0xD8, 0x03, 0x60,
  0x00, 0x80, 0x02, 0x70, 0x0D, 0xF0, 0x36, 0x60, 0xCC, 0xC3, 0x11, 0x84,
  0x36, 0x30, 0x38, 0x00, 0x01, 0x00, 0xFC, 0x1C, 0xE1, 0x86, 0x18, 0x01,
  0x80, 0x1C, 0x01, 0xC0, 0x3E, 0x36, 0x66, 0x63, 0x66, 0x3C, 0x61, 0x86,
  0x3C, 0x77, 0xC3, 0xC6, 0x7B, 0x6D, 0x80, 0x00, 0x81, 0xC1, 0x81, 0x81,
  0x81, 0x80, 0xC0, 0x60, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x18, 0x0E, 0x03, 0x80, 0x40, 0x10, 0x0E, 0x03, 0x80, 0xE0,
  0x30, 0x18, 0x04, 0x02, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x18,
  0x0C, 0x0C, 0x0C, 0x1C, 0x1C, 0x08, 0x00, 0x06, 0x00, 0xC0, 0x18, 0x23,
  0x1F, 0x5E, 0x7F, 0x03, 0x00, 0xD0, 0x33, 0x0C, 0x70, 0x84, 0x00, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x07, 0xFF, 0xFF, 0x83, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x3C, 0xE3, 0x18, 0x63, 0x00, 0xFF, 0xFC, 0xFF, 0x80, 0x00, 0x38,
  0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x03,
  0x00, 0x18, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00,
  0x30, 0x03, 0x00, 0x38, 0x00, 0x03, 0x03, 0xF8, 0x63, 0x98, 0x32, 0x06,
  0xC0, 0xD8, 0x13, 0x32, 0x6E, 0xCC, 0x99, 0x03, 0x60, 0x6C, 0x09, 0xC3,
  0x1D, 0xC1, 0xF0, 0x07, 0x07, 0xC3, 0x30, 0x8C, 0x03, 0x00, 0xC0, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x04, 0x3F, 0xFF, 0xF8, 0x03, 0x03,
  0xF8, 0xE3, 0x18, 0x36, 0x06, 0x00, 0x80, 0x30, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x00, 0xC0, 0x3F, 0xE7, 0xFC, 0x3F, 0xE0, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x1C, 0x03, 0xE0, 0x0C, 0x00, 0xC0, 0x18, 0x02, 0x60,
  0xCC, 0x18, 0xEE, 0x0F, 0x80, 0x00, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x07,
  0x01, 0x8C, 0xC3, 0x60, 0xD8, 0x2F, 0xFB, 0xFE, 0x01, 0x80, 0x60, 0x18,
  0x1F, 0xE6, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x7F, 0x0F, 0xF3, 0x86, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x4C, 0x18, 0xEE, 0x0F, 0x80, 0x03, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x06, 0x83, 0xF9, 0xC7, 0x60, 0xF0, 0x3C, 0x0F, 0x03,
  0xC1, 0x9D, 0xC3, 0xE0, 0xFF, 0xF0, 0x2C, 0x1A, 0x0C, 0x03, 0x01, 0x80,
  0x60, 0x30, 0x0C, 0x06, 0x03, 0x80, 0xC0, 0x60, 0x18, 0x0C, 0x00, 0x03,
  0x03, 0xF8, 0x63, 0x18, 0x33, 0x06, 0x61, 0x8C, 0x60, 0xF8, 0x1F, 0x06,
  0x31, 0x83, 0x20, 0x6C, 0x0D, 0x83, 0x1D, 0xE1, 0xF0, 0x06, 0x0F, 0xE7,
  0x1D, 0x83, 0xC0, 0xF0, 0x3C, 0x0F, 0x06, 0x73, 0x9F, 0xC0, 0x60, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0x33, 0xDC, 0x00, 0x00, 0x00, 0x07, 0x39,
  0xC0, 0x0C, 0x3C, 0x78, 0x00, 0x00, 0x00, 0x00, 0x04, 0x30, 0xE1, 0x86,
  0x0C, 0x30, 0x00, 0x00, 0x40, 0x30, 0x38, 0x78, 0x78, 0x38, 0x0C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x30, 0x04, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x40, 0x0C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x70, 0x1C,
  0x1E, 0x1E, 0x1E, 0x0E, 0x02, 0x00, 0x7E, 0x0F, 0x03, 0x03, 0x03, 0x03,
  0x06, 0x3C, 0x20, 0x60, 0x60, 0x00, 0x00, 0xE0, 0xE0, 0x01, 0x80, 0x7F,
  0x07, 0x0C, 0x20, 0x23, 0x01, 0x90, 0x08, 0x8F, 0x4C, 0x66, 0x66, 0x33,
  0x31, 0x99, 0x8C, 0x88, 0x64, 0x42, 0x63, 0xF3, 0x0E, 0x98, 0x00, 0xC0,
  0x03, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x03, 0x80, 0x70, 0x1A, 0x03, 0x40,
  0x4C, 0x19, 0x83, 0x30, 0xC6, 0x18, 0xC7, 0xF8, 0xFF, 0x18, 0x66, 0x04,
  0xC0, 0xB0, 0x18, 0x3F, 0xC6, 0x38, 0xC1, 0x98, 0x33, 0x04, 0x41, 0x9F,
  0xE3, 0xFC, 0x61, 0xCC, 0x19, 0x83, 0x20, 0x6C, 0x19, 0xFF, 0x3F, 0x80,
  0x03, 0x01, 0xF8, 0x63, 0x98, 0x33, 0x06, 0x40, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x04, 0x0C, 0xC3, 0x1D, 0xC1, 0xF0, 0x3F, 0x86,
  0x38, 0xC3, 0x98, 0x33, 0x04, 0x41, 0x98, 0x33, 0x06, 0x60, 0xCC, 0x19,
  0x83, 0x20, 0xCC, 0x19, 0xFE, 0x3F, 0x00, 0x3F, 0xE6, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0F, 0xF3, 0xFC, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x04,
  0x01, 0xFF, 0x3F, 0xE0, 0x3F, 0xF3, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02,
  0x00, 0x7F, 0xC7, 0xFC, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x00, 0x03, 0x01, 0xF8, 0x63, 0x98, 0x33, 0x06, 0x40, 0x18,
  0x03, 0x00, 0x67, 0xCC, 0xF9, 0x83, 0x30, 0x64, 0x08, 0xC3, 0x1D, 0xC1,
  0xF0, 0x30, 0x66, 0x0C, 0xC1, 0x98, 0x33, 0x0C, 0x41, 0x9F, 0xF3, 0xFE,
  0x60, 0xCC, 0x19, 0x82, 0x20, 0xCC, 0x19, 0x83, 0x30, 0x60, 0x1F, 0xE4,
  0x40, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0xFF, 0x3F, 0xE0, 0x03, 0xF0, 0x03, 0x00, 0x20,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x00, 0xC6,
  0x0C, 0x61, 0xC7, 0xF8, 0x3F, 0x00, 0x30, 0x73, 0x06, 0x30, 0xC3, 0x18,
  0x31, 0x82, 0x30, 0x7E, 0x07, 0xE0, 0x63, 0x06, 0x30, 0x63, 0x04, 0x18,
  0xC1, 0x8C, 0x18, 0xC0, 0xC0, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x20, 0x18, 0x06, 0x01, 0x80, 0x60, 0x1F, 0xFF, 0xF8,
  0x38, 0x73, 0x8E, 0x38, 0xA2, 0x9E, 0x69, 0x66, 0xB6, 0x6E, 0x46, 0xEC,
  0x60, 0xC4, 0x0C, 0xC0, 0xCC, 0x0C, 0xC0, 0x8C, 0x18, 0xC1, 0x80, 0x38,
  0x67, 0x0C, 0xE1, 0x9E, 0x32, 0xC4, 0xD9, 0x99, 0x33, 0x26, 0x66, 0xCC,
  0xD9, 0x9A, 0x21, 0x4C, 0x29, 0x87, 0x30, 0xE0, 0x03, 0x01, 0xF8, 0x63,
  0x18, 0x33, 0x06, 0x40, 0x98, 0x33, 0x06, 0x60, 0xCC, 0x19, 0x83, 0x30,
  0x64, 0x18, 0xC3, 0x1D, 0xC1, 0xF0, 0x3F, 0xC3, 0x0E, 0x30, 0x63, 0x06,
  0x30, 0x62, 0x06, 0x60, 0xC7, 0xFC, 0x7F, 0x06, 0x00, 0x60, 0x04, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x00, 0x03, 0x03, 0xF8, 0x63, 0x98, 0x32, 0x06,
  0xC0, 0xD8, 0x13, 0x06, 0x60, 0xCC, 0x19, 0x83, 0x60, 0x6C, 0x09, 0xC3,
  0x1D, 0xC1, 0xF0, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x3F, 0xC6, 0x1C,
  0xC1, 0x98, 0x33, 0x06, 0x40, 0xD8, 0x73, 0xFC, 0x66, 0x0C, 0x61, 0x8C,
  0x21, 0x8C, 0x19, 0x83, 0x30, 0x70, 0x03, 0x01, 0xF8, 0x63, 0x98, 0x33,
  0x06, 0x60, 0x0C, 0x00, 0xF0, 0x0F, 0x80, 0x30, 0x03, 0x00, 0x6C, 0x0D,
  0x83, 0x1D, 0xE1, 0xF0, 0x7F, 0xF0, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0C,
  0x00, 0x30, 0x66, 0x0C, 0xC1, 0x98, 0x33, 0x04, 0xC1, 0x98, 0x33, 0x06,
  0x60, 0xCC, 0x19, 0x83, 0x20, 0xC6, 0x18, 0xEE, 0x0F, 0x80, 0xC0, 0xF0,
  0x6C, 0x1B, 0x04, 0xC3, 0x30, 0xCC, 0x63, 0x18, 0xC4, 0x13, 0x04, 0xC1,
  0xE0, 0x78, 0x1C, 0x07, 0x00, 0x63, 0x1B, 0x39, 0x99, 0x4C, 0xCE, 0x66,
  0xF2, 0x25, 0xB1, 0x2D, 0x89, 0x48, 0x5A, 0x42, 0x96, 0x14, 0xB0, 0xE5,
  0x0E, 0x38, 0x71, 0xC3, 0x8C, 0x00, 0x18, 0x38, 0xC1, 0x83, 0x18, 0x19,
  0x80, 0xCC, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x6C, 0x06, 0x60,
  0x73, 0x03, 0x0C, 0x30, 0x63, 0x01, 0x80, 0xC0, 0x6C, 0x19, 0x83, 0x30,
  0xC3, 0x30, 0x66, 0x0D, 0x80, 0xE0, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x0C, 0x00, 0x3F, 0xE0, 0x0C, 0x03, 0x00, 0xC0, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x06, 0x01, 0xFF, 0x3F,
  0xE0, 0x1F, 0x18, 0x18, 0x10, 0x30, 0x30, 0x30, 0x30, 0x30, 0x20, 0x60,
  0x60, 0x60, 0x60, 0x60, 0x60, 0xC0, 0xC0, 0xF8, 0xE0, 0xC1, 0x83, 0x02,
  0x06, 0x0C, 0x18, 0x30, 0x30, 0x60, 0xC1, 0x81, 0x03, 0x06, 0x0C, 0x18,
  0x18, 0x1F, 0x03, 0x03, 0x03, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x04,
  0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x08, 0x18, 0xF8, 0x0E, 0x05, 0x06, 0xC2,
  0x63, 0x13, 0x09, 0x07, 0x83, 0xFF, 0xC0, 0xCC, 0x0E, 0x63, 0xE8, 0xC3,
  0x30, 0x66, 0x0C, 0xC1, 0x98, 0x33, 0x04, 0x41, 0x8C, 0x31, 0xDE, 0x1E,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xDC, 0x3F, 0xCC, 0x36, 0x0D, 0x83, 0x60,
  0xD8, 0x36, 0x0D, 0x86, 0xE1, 0xBD, 0xCD, 0xE0, 0x07, 0x07, 0xF3, 0x0D,
  0x83, 0x60, 0x18, 0x06, 0x01, 0x80, 0x40, 0xD8, 0x67, 0x70, 0xF8, 0x00,
  0x60, 0x0C, 0x01, 0x87, 0x31, 0xF4, 0x61, 0x98, 0x33, 0x06, 0x60, 0xCC,
  0x19, 0x82, 0x20, 0xC6, 0x18, 0xEF, 0x0F, 0x60, 0x0F, 0x07, 0xE3, 0x0D,
  0x83, 0x60, 0xDF, 0xF7, 0xFD, 0x00, 0x40, 0x18, 0x67, 0x30, 0xF8, 0x00,
  0xFC, 0x07, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x7F, 0xE0, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x0C, 0x03, 0xF0, 0x0F, 0x00, 0x00, 0x0E, 0x63, 0xE8,
  0xC3, 0x30, 0x66, 0x0C, 0xC1, 0x98, 0x33, 0x04, 0x61, 0x8E, 0x70, 0xF6,
  0x00, 0xC0, 0x18, 0x06, 0x1F, 0xC3, 0xE0, 0x30, 0x0C, 0x03, 0x00, 0xDC,
  0x3F, 0xCC, 0x36, 0x0D, 0x83, 0x60, 0xD8, 0x36, 0x0D, 0x06, 0xC1, 0xB0,
  0x6C, 0x18, 0x03, 0x80, 0xC0, 0x00, 0x00, 0x3F, 0x0F, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x10, 0x0C, 0x03, 0x0F, 0xFF, 0xFF, 0x00, 0xE0,
  0x1C, 0x00, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x30, 0x06, 0x00, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x18, 0x03, 0x00, 0xE3, 0xF8,
  0x7C, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x33, 0x0C, 0x43, 0x98, 0xE3,
  0x18, 0x7E, 0x0F, 0xC1, 0x98, 0x31, 0x8C, 0x31, 0x83, 0x30, 0x70, 0xFC,
  0x04, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x20, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0xFC, 0x7E, 0x36, 0x63, 0xFF, 0x33, 0x33, 0x23, 0x22, 0x26,
  0x22, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x44, 0x6C, 0x44, 0x37, 0x0F,
  0xF3, 0x0D, 0x83, 0x60, 0xD8, 0x36, 0x0D, 0x83, 0x41, 0xB0, 0x6C, 0x1B,
  0x06, 0x0F, 0x07, 0xE3, 0x0D, 0x83, 0x60, 0xD8, 0x36, 0x0D, 0x83, 0x41,
  0x98, 0x67, 0x70, 0xF8, 0x1B, 0x83, 0xFC, 0x61, 0x98, 0x33, 0x06, 0x60,
  0xCC, 0x19, 0x83, 0x30, 0xCE, 0x19, 0xEE, 0x37, 0x86, 0x00, 0xC0, 0x10,
  0x06, 0x00, 0x0E, 0x63, 0xE8, 0xC3, 0x30, 0x66, 0x0C, 0xC1, 0x98, 0x33,
  0x04, 0xC1, 0x8C, 0x31, 0xDE, 0x3E, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x18,
  0x33, 0x87, 0xF8, 0xE3, 0x18, 0x32, 0x04, 0xC1, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x60, 0x00, 0x0F, 0x0F, 0xF3, 0x0D, 0x80, 0x70, 0x0F,
  0x81, 0xF8, 0x06, 0x00, 0xB0, 0x67, 0x39, 0xFC, 0x0C, 0x03, 0x01, 0x83,
  0xFF, 0xFF, 0xC6, 0x01, 0x80, 0x60, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0F, 0xC1, 0xF0, 0x30, 0x66, 0x09, 0x83, 0x30, 0x66, 0x0C, 0xC1, 0x98,
  0x33, 0x06, 0x41, 0x8C, 0x31, 0xDC, 0x1F, 0x00, 0xC0, 0xF0, 0x3C, 0x19,
  0x86, 0x63, 0x18, 0xC6, 0x61, 0x98, 0x24, 0x0B, 0x03, 0x80, 0xE0, 0x8C,
  0x71, 0x8A, 0x31, 0x4A, 0x69, 0x49, 0x29, 0x29, 0x65, 0x28, 0xA5, 0x1C,
  0xE3, 0x1C, 0x63, 0x00, 0x38, 0x31, 0x86, 0x18, 0xC0, 0xCC, 0x0D, 0x80,
  0x70, 0x07, 0x00, 0xF0, 0x19, 0x83, 0x18, 0x70, 0xCE, 0x0E, 0x30, 0x66,
  0x08, 0x83, 0x30, 0x66, 0x0C, 0xC1, 0x98, 0x33, 0x04, 0x61, 0x8E, 0xF0,
  0xF6, 0x00, 0xC0, 0x18, 0x06, 0x1F, 0xC3, 0xE0, 0x3F, 0xCF, 0xF0, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0F, 0xFB, 0xFE, 0x01,
  0xE0, 0x60, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0C, 0x1F,
  0x00, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x80,
  0x3C, 0x00, 0x18, 0xC6, 0x23, 0x18, 0xC6, 0x31, 0x98, 0xC6, 0x31, 0x8C,
  0x46, 0x30, 0x1E, 0x00, 0xE0, 0x0C, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80,
  0x30, 0x07, 0x00, 0x3C, 0x18, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x03, 0x03, 0xC0, 0x00, 0x10, 0x0F, 0x8D, 0xB9, 0x63, 0xEC, 0x38,
};

const GFXglyph JetBrainsMono_Italic21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 5, 15, 13, 4, -15 },
  { 11, 7, 6, 13, 4, -15 },
  { 17, 13, 15, 13, 0, -15 },
  { 42, 11, 21, 13, 1, -18 },
  { 71, 15, 15, 13, -1, -15 },
  { 100, 12, 16, 13, 0, -16 },
  { 124, 3, 6, 13, 6, -15 },
  { 127, 9, 21, 13, 3, -18 },
  { 151, 9, 21, 13, 1, -18 },
  { 175, 11, 11, 13, 1, -13 },
  { 191, 11, 10, 13, 1, -12 },
  { 205, 6, 6, 13, 2, -3 },
  { 210, 7, 2, 13, 3, -8 },
  { 212, 3, 3, 13, 4, -3 },
  { 214, 13, 19, 13, 0, -17 },
  { 245, 11, 16, 13, 1, -16 },
  { 267, 10, 15, 13, 1, -15 },
  { 286, 11, 16, 13, 1, -16 },
  { 308, 11, 15, 13, 1, -15 },
  { 329, 10, 15, 13, 1, -15 },
  { 348, 11, 15, 13, 1, -15 },
  { 369, 10, 15, 13, 1, -15 },
  { 388, 10, 15, 13, 3, -15 },
  { 407, 11, 16, 13, 1, -16 },
  { 429, 10, 16, 13, 2, -16 },
  { 449, 5, 12, 13, 4, -12 },
  { 457, 7, 15, 13, 2, -12 },
  { 471, 10, 12, 13, 2, -13 },
  { 486, 11, 6, 13, 1, -10 },
  { 495, 10, 12, 13, 1, -13 },
  { 510, 8, 15, 13, 3, -15 },
  { 525, 13, 20, 13, 0, -16 },
  { 558, 11, 15, 13, 0, -15 },
  { 579, 11, 15, 13, 1, -15 },
  { 600, 11, 16, 13, 1, -16 },
  { 622, 11, 15, 13, 1, -15 },
  { 643, 11, 15, 13, 1, -15 },
  { 664, 12, 15, 13, 1, -15 },
  { 687, 11, 16, 13, 1, -16 },
  { 709, 11, 15, 13, 1, -15 },
  { 730, 11, 15, 13, 1, -15 },
  { 751, 12, 15, 13, 0, -15 },
  { 774, 12, 15, 13, 1, -15 },
  { 797, 10, 15, 13, 1, -15 },
  { 816, 12, 15, 13, 1, -15 },
  { 839, 11, 15, 13, 1, -15 },
  { 860, 11, 16, 13, 1, -16 },
  { 882, 12, 15, 13, 1, -15 },
  { 905, 11, 20, 13, 1, -16 },
  { 933, 11, 15, 13, 1, -15 },
  { 954, 11, 16, 13, 1, -16 },
  { 976, 11, 15, 13, 2, -15 },
  { 997, 11, 15, 13, 1, -15 },
  { 1018, 10, 15, 13, 3, -15 },
  { 1037, 13, 15, 13, 1, -15 },
  { 1062, 13, 15, 13, 0, -15 },
  { 1087, 11, 15, 13, 2, -15 },
  { 1108, 11, 15, 13, 1, -15 },
  { 1129, 8, 19, 13, 3, -17 },
  { 1148, 7, 19, 13, 3, -17 },
  { 1165, 8, 19, 13, 2, -17 },
  { 1184, 9, 8, 13, 2, -15 },
  { 1193, 10, 1, 13, 0, 1 },
  { 1195, 3, 2, 13, 6, -16 },
  { 1196, 11, 12, 13, 1, -12 },
  { 1213, 10, 15, 13, 1, -15 },
  { 1232, 10, 12, 13, 1, -12 },
  { 1247, 11, 15, 13, 1, -15 },
  { 1268, 10, 12, 13, 1, -12 },
  { 1283, 14, 19, 13, -1, -15 },
  { 1317, 11, 16, 13, 1, -12 },
  { 1339, 10, 15, 13, 1, -15 },
  { 1358, 10, 16, 13, 1, -16 },
  { 1378, 11, 20, 13, 0, -16 },
  { 1406, 11, 15, 13, 1, -15 },
  { 1427, 9, 15, 13, 2, -15 },
  { 1444, 12, 12, 13, 0, -12 },
  { 1462, 10, 12, 13, 1, -12 },
  { 1477, 10, 12, 13, 1, -12 },
  { 1492, 11, 16, 13, 0, -12 },
  { 1514, 11, 16, 13, 1, -12 },
  { 1536, 11, 12, 13, 1, -12 },
  { 1553, 10, 12, 13, 1, -12 },
  { 1568, 10, 15, 13, 2, -15 },
  { 1587, 11, 12, 13, 1, -12 },
  { 1604, 10, 12, 13, 2, -12 },
  { 1619, 11, 12, 13, 2, -12 },
  { 1636, 12, 12, 13, 0, -12 },
  { 1654, 11, 16, 13, 1, -12 },
  { 1676, 10, 12, 13, 1, -12 },
  { 1691, 11, 19, 13, 2, -17 },
  { 1718, 5, 19, 13, 4, -17 },
  { 1730, 11, 19, 13, 0, -17 },
  { 1757, 11, 5, 13, 1, -10 },
};

const GFXfont JetBrainsMono_Italic21pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Italic21pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Italic21pt7bGlyphs,
  0x20, 0x7E, 28
};

#endif // _JETBRAINSMONO_ITALIC21PT7B_H_
