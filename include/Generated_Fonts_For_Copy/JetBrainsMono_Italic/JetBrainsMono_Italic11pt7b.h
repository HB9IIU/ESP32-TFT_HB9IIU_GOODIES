#ifndef _JETBRAINSMONO_ITALIC11PT7B_H_
#define _JETBRAINSMONO_ITALIC11PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Italic.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Italic11pt7bBitmaps[] PROGMEM = {
  0x00, 0x69, 0x24, 0x86, 0xDA, 0xA0, 0x14, 0x29, 0xF9, 0x42, 0x9F, 0x94,
  0x48, 0x08, 0x23, 0xCD, 0x70, 0xC1, 0x85, 0x59, 0xE2, 0x08, 0x72, 0xA9,
  0x63, 0x81, 0xC6, 0x95, 0x4E, 0x38, 0x92, 0x08, 0x55, 0x68, 0x9F, 0xE8,
  0x16, 0x48, 0x88, 0x88, 0x86, 0x63, 0x11, 0x11, 0x22, 0x6C, 0x21, 0x3E,
  0x45, 0x48, 0x21, 0x3E, 0x46, 0x00, 0x69, 0x40, 0xE0, 0xF0, 0x06, 0x08,
  0x20, 0x41, 0x02, 0x08, 0x10, 0x41, 0x80, 0x7A, 0x63, 0x5A, 0xC6, 0x5E,
  0x18, 0xA4, 0x84, 0x10, 0x41, 0x3F, 0x7C, 0x42, 0x33, 0x32, 0x1E, 0x78,
  0x88, 0x60, 0x86, 0x5E, 0x18, 0x88, 0x98, 0xF8, 0x42, 0x7A, 0x21, 0xE0,
  0x86, 0x5E, 0x11, 0x11, 0xE8, 0xC6, 0x5E, 0x7E, 0x20, 0x84, 0x10, 0x84,
  0x10, 0x7A, 0x52, 0xE5, 0x46, 0x5E, 0x7C, 0x63, 0x17, 0x08, 0x88, 0x60,
  0x05, 0x80, 0x30, 0x00, 0x64, 0x48, 0x08, 0xD9, 0x06, 0x08, 0xF8, 0x3E,
  0x82, 0x0C, 0x17, 0x40, 0xE1, 0x12, 0xC8, 0x08, 0x3C, 0x85, 0x0A, 0xE9,
  0x54, 0xA7, 0x40, 0x80, 0xE0, 0x18, 0x62, 0x8A, 0x29, 0xE4, 0xA1, 0x7A,
  0x63, 0xE9, 0xC6, 0x5E, 0x7A, 0x61, 0x08, 0x46, 0x5E, 0x7A, 0x63, 0x18,
  0xC6, 0x5C, 0x7D, 0x08, 0x3E, 0x82, 0x08, 0x3C, 0x7D, 0x08, 0x3E, 0x82,
  0x08, 0x20, 0x7A, 0x61, 0x0B, 0xC6, 0x5E, 0x4A, 0x63, 0xF8, 0xCA, 0x52,
  0x79, 0x08, 0x42, 0x10, 0x9E, 0x1C, 0x10, 0x41, 0x04, 0x28, 0x9C, 0x4D,
  0x29, 0x38, 0xA2, 0x49, 0x26, 0x42, 0x11, 0x08, 0x42, 0x1F, 0x26, 0xD9,
  0xB2, 0xA4, 0x48, 0x91, 0x44, 0x25, 0x95, 0x55, 0x55, 0x54, 0xB2, 0x7A,
  0x63, 0x18, 0xC6, 0x5E, 0x79, 0x38, 0xA2, 0xF2, 0x08, 0x20, 0x7A, 0x63,
  0x18, 0xC6, 0x5E, 0x20, 0x80, 0x7A, 0x63, 0x3E, 0x4A, 0x53, 0x3C, 0x96,
  0x0C, 0x08, 0x14, 0x9E, 0xFC, 0x82, 0x08, 0x20, 0x82, 0x10, 0x4A, 0x63,
  0x18, 0xC6, 0x5E, 0x86, 0x24, 0x94, 0x51, 0x46, 0x18, 0xB6, 0xDB, 0xB6,
  0xDB, 0x69, 0x24, 0x66, 0x48, 0xA0, 0x83, 0x05, 0x12, 0x46, 0x85, 0x25,
  0x14, 0x20, 0x82, 0x10, 0x3C, 0x10, 0x84, 0x30, 0x84, 0x3E, 0x74, 0x44,
  0x88, 0x88, 0x8C, 0x92, 0x24, 0x92, 0x24, 0x71, 0x11, 0x12, 0x22, 0x2E,
  0x31, 0x95, 0x10, 0xF8, 0x90, 0x7C, 0x63, 0x19, 0x78, 0x42, 0x3F, 0x18,
  0xC6, 0x5E, 0x7C, 0x61, 0x09, 0xF8, 0x08, 0x5F, 0x18, 0xC6, 0x5E, 0x74,
  0x7F, 0x09, 0x78, 0x07, 0x08, 0x08, 0x3E, 0x10, 0x10, 0x10, 0x10, 0x10,
  0xE0, 0x7C, 0x63, 0x19, 0x38, 0x5C, 0x42, 0x2F, 0x98, 0xC6, 0x52, 0x08,
  0x60, 0x1C, 0x10, 0x41, 0x04, 0xFC, 0x04, 0x30, 0x0E, 0x08, 0x20, 0x82,
  0x10, 0x4E, 0x00, 0x42, 0x23, 0x2E, 0x52, 0x53, 0xE1, 0x08, 0x84, 0x21,
  0x0F, 0x7D, 0x55, 0x55, 0x96, 0xB0, 0xBE, 0x63, 0x19, 0x48, 0x74, 0x63,
  0x19, 0x78, 0x7D, 0x14, 0x51, 0x49, 0xE8, 0x20, 0x7C, 0x63, 0x29, 0x78,
  0x42, 0x7E, 0x61, 0x08, 0x40, 0x7C, 0x38, 0x21, 0x78, 0x21, 0x3E, 0x44,
  0x21, 0x0E, 0x8C, 0x63, 0x19, 0x78, 0x8C, 0x54, 0xA6, 0x30, 0xA6, 0xAE,
  0xBA, 0x92, 0x40, 0x64, 0xA1, 0x0C, 0x4B, 0x30, 0x8C, 0x63, 0x19, 0x38,
  0x5C, 0x7C, 0x21, 0x08, 0x43, 0xE0, 0x1C, 0x41, 0x04, 0x23, 0x82, 0x08,
  0x20, 0xC0, 0x29, 0x24, 0x92, 0x90, 0x30, 0x41, 0x04, 0x10, 0x72, 0x08,
  0x23, 0x80, 0xED, 0xC0,
};

const GFXglyph JetBrainsMono_Italic11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 3, 8, 7, 2, -8 },
  { 4, 4, 3, 7, 2, -8 },
  { 6, 7, 8, 7, 0, -8 },
  { 13, 6, 12, 7, 0, -10 },
  { 22, 7, 8, 7, 0, -8 },
  { 29, 6, 8, 7, 0, -8 },
  { 35, 2, 3, 7, 3, -8 },
  { 36, 4, 10, 7, 2, -9 },
  { 41, 4, 10, 7, 1, -9 },
  { 46, 5, 6, 7, 1, -7 },
  { 50, 5, 5, 7, 1, -6 },
  { 54, 3, 4, 7, 1, -2 },
  { 56, 3, 1, 7, 2, -4 },
  { 57, 2, 2, 7, 2, -2 },
  { 58, 7, 10, 7, 0, -9 },
  { 67, 5, 8, 7, 1, -8 },
  { 72, 6, 8, 7, 0, -8 },
  { 78, 5, 8, 7, 1, -8 },
  { 83, 5, 8, 7, 1, -8 },
  { 88, 5, 8, 7, 1, -8 },
  { 93, 5, 8, 7, 1, -8 },
  { 98, 5, 8, 7, 1, -8 },
  { 103, 6, 8, 7, 1, -8 },
  { 109, 5, 8, 7, 1, -8 },
  { 114, 5, 8, 7, 1, -8 },
  { 119, 3, 6, 7, 2, -6 },
  { 122, 4, 8, 7, 1, -6 },
  { 126, 5, 6, 7, 1, -7 },
  { 130, 5, 3, 7, 1, -5 },
  { 132, 5, 6, 7, 1, -7 },
  { 136, 4, 8, 7, 2, -8 },
  { 140, 7, 10, 7, 0, -8 },
  { 149, 6, 8, 7, 0, -8 },
  { 155, 5, 8, 7, 1, -8 },
  { 160, 5, 8, 7, 1, -8 },
  { 165, 5, 8, 7, 1, -8 },
  { 170, 6, 8, 7, 1, -8 },
  { 176, 6, 8, 7, 1, -8 },
  { 182, 5, 8, 7, 1, -8 },
  { 187, 5, 8, 7, 1, -8 },
  { 192, 5, 8, 7, 1, -8 },
  { 197, 6, 8, 7, 0, -8 },
  { 203, 6, 8, 7, 1, -8 },
  { 209, 5, 8, 7, 1, -8 },
  { 214, 7, 8, 7, 0, -8 },
  { 221, 6, 8, 7, 0, -8 },
  { 227, 5, 8, 7, 1, -8 },
  { 232, 6, 8, 7, 1, -8 },
  { 238, 5, 10, 7, 1, -8 },
  { 245, 5, 8, 7, 1, -8 },
  { 250, 6, 8, 7, 0, -8 },
  { 256, 6, 8, 7, 1, -8 },
  { 262, 5, 8, 7, 1, -8 },
  { 267, 6, 8, 7, 1, -8 },
  { 273, 6, 8, 7, 1, -8 },
  { 279, 7, 8, 7, 0, -8 },
  { 286, 6, 8, 7, 1, -8 },
  { 292, 6, 8, 7, 0, -8 },
  { 298, 4, 10, 7, 2, -9 },
  { 303, 3, 10, 7, 2, -9 },
  { 307, 4, 10, 7, 1, -9 },
  { 312, 5, 4, 7, 1, -8 },
  { 315, 5, 1, 7, 0, 0 },
  { 316, 2, 2, 7, 3, -9 },
  { 317, 5, 6, 7, 1, -6 },
  { 321, 5, 8, 7, 1, -8 },
  { 326, 5, 6, 7, 1, -6 },
  { 330, 5, 8, 7, 1, -8 },
  { 335, 5, 6, 7, 1, -6 },
  { 339, 8, 10, 7, -1, -8 },
  { 349, 5, 8, 7, 1, -6 },
  { 354, 5, 8, 7, 1, -8 },
  { 359, 6, 9, 7, 0, -9 },
  { 366, 6, 11, 7, 0, -9 },
  { 375, 5, 8, 7, 1, -8 },
  { 380, 5, 8, 7, 1, -8 },
  { 385, 6, 6, 7, 0, -6 },
  { 390, 5, 6, 7, 1, -6 },
  { 394, 5, 6, 7, 1, -6 },
  { 398, 6, 8, 7, 0, -6 },
  { 404, 5, 8, 7, 1, -6 },
  { 409, 5, 6, 7, 1, -6 },
  { 413, 5, 6, 7, 1, -6 },
  { 417, 5, 8, 7, 1, -8 },
  { 422, 5, 6, 7, 1, -6 },
  { 426, 5, 6, 7, 1, -6 },
  { 430, 6, 6, 7, 1, -6 },
  { 435, 6, 6, 7, 0, -6 },
  { 440, 5, 8, 7, 1, -6 },
  { 445, 6, 6, 7, 0, -6 },
  { 450, 6, 10, 7, 1, -9 },
  { 458, 3, 10, 7, 2, -9 },
  { 462, 6, 10, 7, 0, -9 },
  { 470, 5, 2, 7, 1, -5 },
};

const GFXfont JetBrainsMono_Italic11pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Italic11pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Italic11pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _JETBRAINSMONO_ITALIC11PT7B_H_
