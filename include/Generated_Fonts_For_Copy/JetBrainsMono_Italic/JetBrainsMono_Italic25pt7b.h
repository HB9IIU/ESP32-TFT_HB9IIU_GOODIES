#ifndef _JETBRAINSMONO_ITALIC25PT7B_H_
#define _JETBRAINSMONO_ITALIC25PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Italic.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Italic25pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x61, 0x8E, 0x38, 0xE3, 0x0C, 0x30, 0xC3, 0x08, 0x60, 0x00,
  0x38, 0xF3, 0x80, 0xE7, 0xE7, 0xC7, 0xC6, 0xC6, 0xC6, 0xC6, 0x03, 0x0C,
  0x08, 0x60, 0x61, 0x81, 0x84, 0x04, 0x30, 0xFF, 0xF4, 0xC2, 0x02, 0x18,
  0x18, 0x60, 0x61, 0x01, 0x0C, 0x3F, 0xFC, 0xFF, 0xF1, 0x86, 0x06, 0x18,
  0x18, 0x40, 0xC3, 0x03, 0x0C, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x01,
  0x00, 0x7F, 0x07, 0xFC, 0x66, 0xE3, 0x33, 0x39, 0x01, 0xC8, 0x0E, 0x40,
  0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x0B, 0xC0, 0x4E, 0x02, 0x37, 0x31, 0xB9,
  0x9C, 0xCD, 0xC7, 0xFC, 0x1F, 0xC0, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x60,
  0x00, 0x0F, 0x81, 0x8E, 0xE1, 0x86, 0x31, 0x82, 0x19, 0x83, 0x08, 0x81,
  0x8C, 0xC0, 0x7E, 0xC0, 0x3C, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x4F,
  0x80, 0x6F, 0xC0, 0x6C, 0x60, 0x66, 0x30, 0x63, 0x18, 0x61, 0x8C, 0x60,
  0xFC, 0x70, 0x3C, 0x00, 0x01, 0x00, 0x7F, 0x07, 0xBC, 0x30, 0xE1, 0x87,
  0x1C, 0x00, 0x60, 0x03, 0x80, 0x1C, 0x01, 0xF0, 0x19, 0x87, 0xCE, 0x6E,
  0x37, 0x61, 0xF3, 0x07, 0x18, 0x38, 0xC3, 0xE7, 0xFB, 0x1F, 0x1C, 0x6F,
  0xFF, 0xB0, 0x00, 0xC0, 0x70, 0x78, 0x38, 0x1C, 0x06, 0x03, 0x80, 0xC0,
  0x30, 0x1C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x03, 0x80, 0xE0, 0x38,
  0x06, 0x01, 0xC0, 0x70, 0x0F, 0x01, 0xE0, 0x18, 0x0C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x01,
  0xC0, 0x60, 0x18, 0x06, 0x03, 0x80, 0xC0, 0x70, 0x18, 0x0E, 0x0E, 0x07,
  0x03, 0x00, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x10, 0xC2, 0x73, 0x3B, 0xFB,
  0xF0, 0xFC, 0x01, 0xC0, 0x0D, 0x80, 0x67, 0x03, 0x8C, 0x1C, 0x38, 0x20,
  0x80, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x0F, 0xFF, 0xFF, 0xE0,
  0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x1E, 0x38, 0x71, 0xC3, 0x0E,
  0x18, 0x70, 0xFF, 0xFF, 0x33, 0xDE, 0xE0, 0x00, 0x06, 0x00, 0x1C, 0x00,
  0x30, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xE0,
  0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03,
  0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x70, 0x00, 0x00, 0x80, 0x3F, 0x83, 0xFC, 0x30, 0x73, 0x81,
  0x98, 0x0C, 0xC0, 0x66, 0x03, 0x32, 0x3B, 0xB9, 0x99, 0xCC, 0xC0, 0x66,
  0x03, 0x30, 0x19, 0x81, 0xCC, 0x0C, 0x70, 0xE3, 0xFE, 0x0F, 0xE0, 0x03,
  0xC0, 0x7C, 0x1C, 0xC3, 0x9C, 0x21, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x38, 0x03, 0x80, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x70, 0xFF,
  0xFF, 0xFF, 0x00, 0x80, 0x3F, 0x87, 0xFC, 0x30, 0x73, 0x01, 0x98, 0x0C,
  0x00, 0xE0, 0x06, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0xFF, 0x3F, 0xF8, 0x1F, 0xF8, 0xFF,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x00, 0xF8, 0x01, 0xE0,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x70, 0x33, 0x81, 0x8C, 0x1C, 0x7F,
  0xC1, 0xF8, 0x00, 0x00, 0xF0, 0x0C, 0x01, 0x80, 0x30, 0x07, 0x00, 0xE0,
  0x1C, 0x01, 0x86, 0x30, 0x66, 0x0E, 0xE0, 0xEC, 0x0C, 0xFF, 0xCF, 0xFC,
  0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x3F, 0xF3, 0xFF, 0x30, 0x03, 0x00,
  0x30, 0x07, 0x00, 0x67, 0x86, 0xFC, 0x70, 0xE6, 0x06, 0x00, 0x60, 0x06,
  0x00, 0xE0, 0x0C, 0xC0, 0xCC, 0x1C, 0xFF, 0x87, 0xF0, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x30, 0x06, 0x00, 0xE0, 0x1C, 0x01, 0xFE, 0x3F, 0xF7, 0x07,
  0x60, 0x36, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x67, 0x0E, 0x7F, 0xC3, 0xF8,
  0x7F, 0xF7, 0xFF, 0xE0, 0x7C, 0x06, 0xC0, 0xC0, 0x1C, 0x01, 0x80, 0x38,
  0x03, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0C, 0x01, 0x80, 0x38, 0x03, 0x00,
  0x70, 0x06, 0x00, 0x00, 0x80, 0x3F, 0x83, 0xFC, 0x30, 0x71, 0x81, 0x9C,
  0x1C, 0xE0, 0xC3, 0x0E, 0x0F, 0xE0, 0x3C, 0x07, 0xF0, 0x71, 0xC7, 0x07,
  0x30, 0x39, 0x81, 0xCC, 0x0C, 0x60, 0xE3, 0xFE, 0x0F, 0xE0, 0x01, 0x00,
  0xFE, 0x3F, 0xF3, 0x07, 0x60, 0x36, 0x03, 0x60, 0x3E, 0x03, 0x60, 0x77,
  0x0E, 0x7F, 0xE3, 0xFC, 0x01, 0x80, 0x30, 0x07, 0x00, 0xE0, 0x0C, 0x01,
  0x80, 0x30, 0x00, 0x1C, 0x78, 0xF0, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x83, 0xC7, 0x8E, 0x00, 0x0E, 0x1E, 0x1E, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x38, 0x38, 0x70, 0x70, 0x60, 0xC0, 0xC0, 0x00, 0x10,
  0x07, 0x01, 0xF0, 0x78, 0x1E, 0x07, 0x80, 0xE0, 0x0E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1C, 0x00, 0xC0, 0x7F, 0xF7, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xEF, 0xFE, 0x20, 0x03, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xC0, 0x0F, 0x00, 0x30, 0x07, 0x03, 0xE0, 0xF8, 0x3C, 0x07, 0x00,
  0xC0, 0x00, 0x7E, 0x1F, 0xC0, 0x38, 0x06, 0x01, 0x80, 0x60, 0x38, 0x0C,
  0x3F, 0x0F, 0x07, 0x01, 0x80, 0x60, 0x00, 0x00, 0x03, 0x80, 0xE0, 0x38,
  0x00, 0x00, 0x40, 0x07, 0xF0, 0x3C, 0x70, 0xE0, 0x71, 0x80, 0x66, 0x00,
  0xCC, 0x01, 0x98, 0x7B, 0x31, 0xDE, 0x67, 0x19, 0x8C, 0x33, 0x18, 0x66,
  0x30, 0xCC, 0x61, 0x98, 0xC3, 0x31, 0x8C, 0xC3, 0xF9, 0x81, 0x83, 0x00,
  0x07, 0x00, 0x06, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0x80, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x06, 0xC0, 0x36, 0x03, 0xB0, 0x19, 0xC0, 0xCE, 0x0C,
  0x30, 0x61, 0x87, 0x0C, 0x3F, 0xE3, 0xFF, 0x18, 0x18, 0xC0, 0xCE, 0x06,
  0x60, 0x3F, 0x01, 0xC0, 0x1F, 0xE0, 0xFF, 0x86, 0x0E, 0x30, 0x33, 0x81,
  0x98, 0x1C, 0xC0, 0xC6, 0x3C, 0x3F, 0xC1, 0x8F, 0x1C, 0x1C, 0xC0, 0x66,
  0x03, 0x30, 0x19, 0x81, 0xCC, 0x1C, 0xFF, 0xC7, 0xF8, 0x00, 0x01, 0x00,
  0xFE, 0x1F, 0xE3, 0x87, 0x70, 0x37, 0x03, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0xEC, 0x0C, 0xE1, 0xCF,
  0xF8, 0x7F, 0x00, 0x1F, 0xE0, 0xFF, 0x86, 0x0E, 0x70, 0x73, 0x81, 0x98,
  0x1C, 0xC0, 0xE6, 0x06, 0x30, 0x31, 0x81, 0x9C, 0x0C, 0xE0, 0xE6, 0x07,
  0x30, 0x31, 0x81, 0x8C, 0x38, 0xFF, 0x87, 0xF8, 0x00, 0x1F, 0xFC, 0x7F,
  0xF1, 0x80, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x0F, 0xFC, 0x3F,
  0xF0, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x7F, 0xE3, 0xFF, 0x80, 0x1F, 0xFC, 0x7F, 0xF1, 0x80, 0x06, 0x00,
  0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x3F, 0xF0, 0xFF, 0xC7, 0x00,
  0x1C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80,
  0x00, 0x01, 0x00, 0xFE, 0x1F, 0xE3, 0x87, 0x70, 0x37, 0x03, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0xE7, 0xEE, 0x7E, 0xC0, 0x6C, 0x0E, 0xC0, 0xEC,
  0x0C, 0xE1, 0xCF, 0xF8, 0x7F, 0x00, 0x18, 0x18, 0xC0, 0xC6, 0x06, 0x30,
  0x33, 0x83, 0x98, 0x1C, 0xC0, 0xC6, 0x06, 0x3F, 0xF1, 0xFF, 0x9C, 0x1C,
  0xE0, 0xE6, 0x06, 0x30, 0x31, 0x81, 0x8C, 0x0C, 0xE0, 0x67, 0x07, 0x00,
  0x3F, 0xF3, 0xFF, 0x03, 0x00, 0x30, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0xFF, 0xCF, 0xF8, 0x01, 0xFC, 0x07, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x0C,
  0x00, 0x31, 0x80, 0xC6, 0x07, 0x1C, 0x38, 0x7F, 0xC0, 0x7E, 0x00, 0x18,
  0x0E, 0x30, 0x30, 0x60, 0xE1, 0xC3, 0x83, 0x86, 0x06, 0x1C, 0x0C, 0x70,
  0x18, 0xC0, 0x3F, 0x80, 0x7F, 0x01, 0xC6, 0x03, 0x0E, 0x06, 0x0C, 0x0C,
  0x18, 0x18, 0x38, 0x30, 0x30, 0xE0, 0x61, 0xC0, 0xE0, 0x18, 0x07, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x70, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x01, 0xC0, 0x38, 0x06, 0x00, 0xFF, 0xFF, 0xF8, 0x1C, 0x1C,
  0xF0, 0xF3, 0xC3, 0x8F, 0x1A, 0x34, 0x78, 0xDB, 0x63, 0x6D, 0x9D, 0xE6,
  0x67, 0xB9, 0x9C, 0xC6, 0x03, 0x18, 0x0C, 0x60, 0x33, 0x81, 0xCE, 0x07,
  0x30, 0x18, 0xC0, 0x63, 0x01, 0x80, 0x1C, 0x1C, 0x70, 0x61, 0xE1, 0x8D,
  0x86, 0x36, 0x18, 0xD8, 0xE3, 0x63, 0x0C, 0xCC, 0x33, 0x31, 0xCC, 0xC7,
  0x33, 0x18, 0xCC, 0x61, 0xF1, 0x87, 0x86, 0x1E, 0x18, 0x78, 0xE1, 0xE3,
  0x03, 0x80, 0x01, 0x00, 0xFE, 0x1F, 0xE3, 0x87, 0x70, 0x37, 0x03, 0x60,
  0x76, 0x07, 0x60, 0x66, 0x06, 0xE0, 0x6E, 0x06, 0xC0, 0xEC, 0x0E, 0xC0,
  0xCC, 0x0C, 0xE1, 0xCF, 0xF8, 0x7F, 0x00, 0x1F, 0xF0, 0x7F, 0xE1, 0x81,
  0xCE, 0x07, 0x38, 0x1C, 0xC0, 0x73, 0x01, 0x8C, 0x0E, 0x3F, 0xF0, 0xFF,
  0x87, 0xF0, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xE0,
  0x03, 0x80, 0x00, 0x00, 0x80, 0x3F, 0x83, 0xFC, 0x30, 0x73, 0x81, 0x98,
  0x0C, 0xC0, 0x66, 0x07, 0x30, 0x3B, 0x81, 0x9C, 0x0C, 0xC0, 0x66, 0x03,
  0x30, 0x19, 0x81, 0xCC, 0x0C, 0x70, 0xE3, 0xFE, 0x0F, 0xE0, 0x06, 0x00,
  0x38, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x1F, 0xF0, 0x7F, 0xE1, 0x83, 0x8E,
  0x06, 0x38, 0x18, 0xC0, 0x63, 0x03, 0x8C, 0x0C, 0x3F, 0xF0, 0xFF, 0x07,
  0x18, 0x18, 0x60, 0x61, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x38, 0xE0, 0x63,
  0x81, 0xC0, 0x00, 0x80, 0x3F, 0x83, 0xFE, 0x30, 0x71, 0x81, 0x9C, 0x00,
  0xE0, 0x07, 0x00, 0x1E, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0x00,
  0x1B, 0x80, 0xDC, 0x0E, 0x60, 0xE3, 0xFE, 0x0F, 0xE0, 0xFF, 0xFF, 0xFF,
  0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x1C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80,
  0x30, 0x39, 0x81, 0x8C, 0x0C, 0xE0, 0x67, 0x03, 0x30, 0x39, 0x81, 0x8C,
  0x0C, 0x60, 0x67, 0x03, 0x38, 0x19, 0x81, 0xCC, 0x0E, 0x60, 0x63, 0x03,
  0x1C, 0x38, 0xFF, 0x83, 0xF8, 0x00, 0xC0, 0x3E, 0x03, 0xB8, 0x19, 0xC0,
  0xC6, 0x0E, 0x30, 0x61, 0x87, 0x0C, 0x30, 0x61, 0x83, 0x18, 0x18, 0xC0,
  0xCE, 0x06, 0x60, 0x3B, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x00,
  0xE3, 0x8F, 0x0C, 0x3C, 0x71, 0xB1, 0xC6, 0xC5, 0x1B, 0x14, 0x6C, 0xD3,
  0x32, 0x4C, 0xC9, 0x33, 0x64, 0x8D, 0x96, 0x34, 0x58, 0xD1, 0x63, 0xCF,
  0x0E, 0x3C, 0x38, 0xF0, 0xE3, 0xC3, 0x8E, 0x00, 0x1C, 0x0F, 0x0C, 0x0C,
  0x0E, 0x1C, 0x06, 0x38, 0x06, 0x30, 0x07, 0x60, 0x03, 0xE0, 0x03, 0xC0,
  0x01, 0x80, 0x03, 0xC0, 0x07, 0xC0, 0x06, 0xC0, 0x0C, 0xE0, 0x1C, 0x60,
  0x38, 0x70, 0x30, 0x70, 0x70, 0x30, 0xE0, 0x38, 0xC0, 0x3F, 0x03, 0x98,
  0x18, 0xC1, 0xC6, 0x0C, 0x18, 0xC0, 0xCE, 0x06, 0x60, 0x3E, 0x00, 0xF0,
  0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01,
  0xC0, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x60,
  0x07, 0x00, 0x70, 0x03, 0x00, 0x30, 0x03, 0x80, 0x18, 0x01, 0x80, 0x1C,
  0x01, 0xC0, 0x0C, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x1F, 0x8F, 0xC6, 0x03,
  0x01, 0x81, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x07, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x38, 0x1C, 0x0C, 0x06, 0x03, 0xF1, 0xF8, 0xC0,
  0xE0, 0x60, 0x60, 0x60, 0x60, 0x70, 0x30, 0x30, 0x30, 0x38, 0x18, 0x18,
  0x18, 0x1C, 0x1C, 0x0C, 0x0C, 0x0C, 0x0E, 0x06, 0x06, 0x06, 0x07, 0x0F,
  0xC3, 0xF0, 0x1C, 0x07, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0xE0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x1C, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x03, 0x8F, 0xE3, 0xF0, 0x03, 0x80, 0xF0, 0x1E, 0x06, 0x41, 0x8C,
  0x31, 0x8C, 0x33, 0x83, 0x60, 0x78, 0x0C, 0xFF, 0xFF, 0xFF, 0xCE, 0x63,
  0x0F, 0x73, 0xFF, 0x70, 0xE6, 0x06, 0x60, 0x6E, 0x06, 0xE0, 0x6C, 0x0E,
  0xC0, 0xEC, 0x0C, 0xC0, 0xCE, 0x1C, 0xFE, 0xC7, 0xDC, 0x18, 0x01, 0x80,
  0x18, 0x03, 0x80, 0x3B, 0xE3, 0x7F, 0x38, 0x73, 0x03, 0x30, 0x33, 0x03,
  0x70, 0x37, 0x07, 0x60, 0x76, 0x06, 0x60, 0x67, 0x0E, 0xFF, 0xCE, 0xF8,
  0x0F, 0x83, 0xFE, 0x30, 0xE6, 0x06, 0x60, 0x6E, 0x00, 0xE0, 0x0C, 0x00,
  0xC0, 0x0C, 0x0E, 0xC0, 0xCE, 0x1C, 0xFF, 0x87, 0xF0, 0x00, 0x38, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0xF7, 0x1F, 0xF9, 0xC3, 0x8C, 0x0C, 0x60, 0x67,
  0x03, 0x38, 0x19, 0x81, 0xCC, 0x0E, 0x60, 0x63, 0x03, 0x1C, 0x38, 0xFE,
  0xC3, 0xEE, 0x00, 0x0F, 0x87, 0xF8, 0xC3, 0xB0, 0x36, 0x07, 0xC0, 0xFF,
  0xFF, 0xFF, 0xC0, 0x18, 0x03, 0x03, 0x70, 0xEF, 0xF8, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x3F, 0xC0, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00,
  0x7F, 0xF8, 0x3F, 0xFC, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0x80, 0x00,
  0x0F, 0x33, 0xFF, 0x70, 0xE6, 0x06, 0x60, 0x6E, 0x06, 0xE0, 0x6C, 0x0E,
  0xC0, 0xEC, 0x0C, 0xE1, 0xC7, 0xEC, 0x3C, 0xC0, 0x1C, 0x01, 0xC0, 0x18,
  0x7F, 0x8F, 0xF0, 0xF8, 0x00, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80, 0x3B,
  0xE3, 0x7F, 0x38, 0x73, 0x03, 0x30, 0x33, 0x03, 0x70, 0x36, 0x07, 0x60,
  0x76, 0x06, 0x60, 0x66, 0x06, 0xE0, 0x6E, 0x0E, 0x01, 0xC0, 0x1C, 0x00,
  0x80, 0x00, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x18, 0x03, 0x80, 0x38, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00, 0x70, 0x06, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x3F,
  0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x70,
  0x03, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x38, 0x3F,
  0x83, 0xF8, 0x1E, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x38,
  0x1C, 0xE0, 0xE3, 0x07, 0x0C, 0x38, 0x31, 0xC0, 0xC6, 0x07, 0xF0, 0x1F,
  0xC0, 0x63, 0x81, 0x86, 0x06, 0x1C, 0x18, 0x30, 0x60, 0xE3, 0x81, 0xC0,
  0x7E, 0x1F, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x1F, 0xE1,
  0xFC, 0x36, 0x71, 0xFF, 0xDC, 0xC6, 0xC6, 0x36, 0x31, 0xB1, 0x8D, 0x8C,
  0xCC, 0x46, 0xE6, 0x36, 0x31, 0xB1, 0x8D, 0x8C, 0x6C, 0x66, 0x66, 0x30,
  0x3B, 0xE3, 0x7F, 0x38, 0x73, 0x03, 0x30, 0x33, 0x03, 0x70, 0x36, 0x07,
  0x60, 0x76, 0x06, 0x60, 0x66, 0x06, 0xE0, 0x6E, 0x0E, 0x0F, 0x87, 0xF8,
  0xC3, 0xB0, 0x36, 0x07, 0xC0, 0xF8, 0x1E, 0x07, 0xC0, 0xF8, 0x1B, 0x03,
  0x70, 0xEF, 0xF8, 0xFE, 0x00, 0x1D, 0xF0, 0xDF, 0xC7, 0x0E, 0x38, 0x31,
  0x81, 0x8C, 0x0C, 0xE0, 0x67, 0x07, 0x30, 0x39, 0x81, 0x8C, 0x0C, 0x70,
  0xE7, 0xFE, 0x3B, 0xE1, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x38, 0x00,
  0x07, 0xB8, 0xFF, 0xCE, 0x1C, 0x60, 0x63, 0x03, 0x38, 0x19, 0xC0, 0xCC,
  0x0E, 0x60, 0x63, 0x03, 0x18, 0x18, 0xE1, 0xC7, 0xF6, 0x1F, 0x70, 0x03,
  0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x33, 0xC3, 0xFE, 0x78, 0x77,
  0x07, 0x60, 0x76, 0x07, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0x07, 0xE1, 0xFF, 0x38, 0x33, 0x00, 0x30, 0x03,
  0x80, 0x3F, 0x80, 0xFE, 0x00, 0xE0, 0x06, 0x00, 0x66, 0x0E, 0x7F, 0xC3,
  0xF8, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0x0C, 0x00,
  0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x1F, 0xC0, 0xFC, 0x70, 0x36, 0x07, 0x60, 0x66, 0x06, 0x60, 0x6E,
  0x06, 0xE0, 0x6C, 0x0E, 0xC0, 0xEC, 0x0C, 0xC0, 0xCE, 0x1C, 0xFF, 0x87,
  0xE0, 0xC0, 0x7C, 0x06, 0xC0, 0xEC, 0x0C, 0xC1, 0xCE, 0x18, 0x63, 0x86,
  0x30, 0x67, 0x06, 0x60, 0x6E, 0x07, 0xC0, 0x3C, 0x03, 0x80, 0xC7, 0x1E,
  0x38, 0xF1, 0xC5, 0x9E, 0x6C, 0xF3, 0x65, 0x9B, 0x6D, 0x9B, 0x6C, 0xD3,
  0x67, 0x9E, 0x3C, 0xF1, 0xC7, 0x8E, 0x38, 0x71, 0xC0, 0x18, 0x0C, 0x70,
  0x60, 0xC3, 0x83, 0x9C, 0x06, 0xE0, 0x1F, 0x00, 0x38, 0x00, 0xE0, 0x07,
  0xC0, 0x3B, 0x01, 0xCE, 0x0E, 0x18, 0x70, 0x73, 0x80, 0xE0, 0x70, 0x36,
  0x07, 0x60, 0x66, 0x06, 0x60, 0x66, 0x06, 0xE0, 0x6C, 0x0E, 0xC0, 0xEC,
  0x0C, 0xE1, 0xC7, 0xEC, 0x3C, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x7F, 0x8F,
  0xF0, 0xF8, 0x00, 0x3F, 0xF9, 0xFF, 0x80, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0F, 0xFE,
  0x7F, 0xF0, 0x00, 0x18, 0x07, 0xC0, 0x70, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x18, 0x01, 0xC0, 0xFC, 0x0F, 0xE0, 0x03,
  0x00, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xC0,
  0x07, 0x00, 0x1F, 0x00, 0x30, 0x1C, 0x71, 0x86, 0x18, 0x61, 0x8E, 0x38,
  0xC3, 0x0C, 0x31, 0xC7, 0x18, 0x61, 0x86, 0x18, 0xE3, 0x0C, 0x30, 0x1C,
  0x01, 0xF0, 0x07, 0x00, 0x38, 0x03, 0x00, 0x30, 0x03, 0x00, 0x70, 0x07,
  0x00, 0x60, 0x07, 0x00, 0x3F, 0x03, 0xF0, 0x60, 0x0E, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x1C, 0x03, 0x80, 0xF8, 0x0C, 0x00, 0x7C,
  0x3F, 0xE3, 0xC6, 0x6C, 0x7E, 0xC1, 0x80,
};

const GFXglyph JetBrainsMono_Italic25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 6, 18, 15, 5, -18 },
  { 15, 8, 7, 15, 5, -18 },
  { 22, 14, 18, 15, 1, -18 },
  { 54, 13, 26, 15, 1, -22 },
  { 97, 17, 18, 15, -1, -18 },
  { 136, 13, 19, 15, 1, -19 },
  { 167, 3, 7, 15, 7, -18 },
  { 170, 10, 24, 15, 4, -21 },
  { 200, 10, 24, 15, 1, -21 },
  { 230, 14, 13, 15, 1, -15 },
  { 253, 12, 12, 15, 2, -14 },
  { 271, 7, 8, 15, 2, -4 },
  { 278, 8, 2, 15, 4, -9 },
  { 280, 5, 4, 15, 4, -4 },
  { 283, 15, 24, 15, 0, -21 },
  { 328, 13, 19, 15, 1, -19 },
  { 359, 12, 18, 15, 1, -18 },
  { 386, 13, 19, 15, 1, -19 },
  { 417, 13, 18, 15, 1, -18 },
  { 447, 12, 18, 15, 2, -18 },
  { 474, 12, 18, 15, 2, -18 },
  { 501, 12, 18, 15, 1, -18 },
  { 528, 12, 18, 15, 3, -18 },
  { 555, 13, 19, 15, 1, -19 },
  { 586, 12, 19, 15, 2, -19 },
  { 615, 7, 14, 15, 4, -14 },
  { 628, 8, 18, 15, 3, -14 },
  { 646, 12, 13, 15, 2, -15 },
  { 666, 12, 8, 15, 2, -12 },
  { 678, 12, 13, 15, 1, -15 },
  { 698, 10, 18, 15, 4, -18 },
  { 721, 15, 24, 15, 0, -19 },
  { 766, 13, 18, 15, 0, -18 },
  { 796, 13, 18, 15, 1, -18 },
  { 826, 12, 19, 15, 2, -19 },
  { 855, 13, 18, 15, 1, -18 },
  { 885, 14, 18, 15, 1, -18 },
  { 917, 14, 18, 15, 1, -18 },
  { 949, 12, 19, 15, 2, -19 },
  { 978, 13, 18, 15, 1, -18 },
  { 1008, 12, 18, 15, 2, -18 },
  { 1035, 14, 18, 15, 0, -18 },
  { 1067, 15, 18, 15, 1, -18 },
  { 1101, 11, 18, 15, 2, -18 },
  { 1126, 14, 18, 15, 1, -18 },
  { 1158, 14, 18, 15, 1, -18 },
  { 1190, 12, 19, 15, 2, -19 },
  { 1219, 14, 18, 15, 1, -18 },
  { 1251, 13, 24, 15, 1, -19 },
  { 1290, 14, 18, 15, 1, -18 },
  { 1322, 13, 19, 15, 1, -19 },
  { 1353, 12, 18, 15, 3, -18 },
  { 1380, 13, 18, 15, 2, -18 },
  { 1410, 13, 18, 15, 3, -18 },
  { 1440, 14, 18, 15, 2, -18 },
  { 1472, 16, 18, 15, 0, -18 },
  { 1508, 13, 18, 15, 3, -18 },
  { 1538, 13, 18, 15, 1, -18 },
  { 1568, 9, 24, 15, 4, -21 },
  { 1595, 8, 24, 15, 4, -21 },
  { 1619, 10, 24, 15, 2, -21 },
  { 1649, 11, 10, 15, 2, -18 },
  { 1663, 12, 2, 15, 0, 1 },
  { 1666, 4, 4, 15, 7, -20 },
  { 1668, 12, 14, 15, 2, -14 },
  { 1689, 12, 18, 15, 1, -18 },
  { 1716, 12, 14, 15, 2, -14 },
  { 1737, 13, 18, 15, 2, -18 },
  { 1767, 11, 14, 15, 2, -14 },
  { 1787, 17, 23, 15, -1, -18 },
  { 1836, 12, 19, 15, 2, -14 },
  { 1865, 12, 18, 15, 1, -18 },
  { 1892, 12, 19, 15, 1, -19 },
  { 1921, 13, 24, 15, 0, -19 },
  { 1960, 14, 18, 15, 1, -18 },
  { 1992, 11, 18, 15, 2, -18 },
  { 2017, 13, 14, 15, 1, -14 },
  { 2040, 12, 14, 15, 1, -14 },
  { 2061, 11, 14, 15, 2, -14 },
  { 2081, 13, 19, 15, 0, -14 },
  { 2112, 13, 19, 15, 1, -14 },
  { 2143, 12, 14, 15, 2, -14 },
  { 2164, 12, 14, 15, 1, -14 },
  { 2185, 12, 18, 15, 2, -18 },
  { 2212, 12, 14, 15, 2, -14 },
  { 2233, 12, 14, 15, 3, -14 },
  { 2254, 13, 14, 15, 2, -14 },
  { 2277, 14, 14, 15, 0, -14 },
  { 2302, 12, 19, 15, 2, -14 },
  { 2331, 13, 14, 15, 1, -14 },
  { 2354, 13, 24, 15, 2, -21 },
  { 2393, 6, 24, 15, 5, -21 },
  { 2411, 12, 24, 15, 1, -21 },
  { 2447, 12, 5, 15, 2, -11 },
};

const GFXfont JetBrainsMono_Italic25pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Italic25pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Italic25pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _JETBRAINSMONO_ITALIC25PT7B_H_
