#ifndef _JETBRAINSMONO_ITALIC46PT7B_H_
#define _JETBRAINSMONO_ITALIC46PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Italic.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Italic46pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3C,
  0x07, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0E,
  0x01, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x3F, 0x87, 0xF0, 0xFC, 0x1F, 0x00,
  0x7C, 0x1E, 0xF8, 0x7D, 0xE0, 0xFB, 0xC1, 0xF7, 0x83, 0xDF, 0x07, 0xBE,
  0x0F, 0x78, 0x1E, 0xF0, 0x7D, 0xE0, 0xF3, 0xC1, 0xE7, 0x83, 0xCE, 0x07,
  0x9C, 0x0E, 0x00, 0x00, 0x0F, 0x01, 0xC0, 0x01, 0xC0, 0x78, 0x00, 0x38,
  0x0E, 0x00, 0x0F, 0x01, 0xC0, 0x01, 0xC0, 0x78, 0x00, 0x78, 0x0E, 0x00,
  0x0F, 0x01, 0xC0, 0x01, 0xC0, 0x78, 0x00, 0x78, 0x0E, 0x00, 0x0E, 0x01,
  0xC0, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x01,
  0xC0, 0x78, 0x00, 0x78, 0x0E, 0x00, 0x0E, 0x01, 0xC0, 0x01, 0xC0, 0x78,
  0x00, 0x78, 0x0E, 0x00, 0x0E, 0x01, 0xC0, 0x01, 0xC0, 0x78, 0x00, 0x78,
  0x0E, 0x00, 0x0E, 0x01, 0xC0, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFE, 0x01, 0xC0, 0x78, 0x00, 0x78, 0x0E, 0x00, 0x0E, 0x01,
  0xC0, 0x01, 0xC0, 0x78, 0x00, 0x78, 0x0E, 0x00, 0x0E, 0x03, 0xC0, 0x01,
  0xC0, 0x78, 0x00, 0x78, 0x0E, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xFC, 0x01, 0xFF, 0xFE, 0x03, 0xE7, 0x3E, 0x07, 0xC7, 0x1F, 0x07, 0x87,
  0x0F, 0x0F, 0x87, 0x0F, 0x0F, 0x06, 0x0F, 0x0F, 0x0E, 0x00, 0x0F, 0x0E,
  0x00, 0x0F, 0x8E, 0x00, 0x0F, 0x8E, 0x00, 0x07, 0xCE, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1C, 0xF8, 0x00, 0x18, 0x7C, 0x00, 0x38,
  0x7C, 0x00, 0x38, 0x3C, 0x00, 0x38, 0x3C, 0x78, 0x38, 0x7C, 0x78, 0x38,
  0x78, 0x78, 0x30, 0x78, 0x78, 0x70, 0xF8, 0x7C, 0x71, 0xF0, 0x7F, 0x77,
  0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x0E, 0x03, 0xFC, 0x00, 0x38,
  0x0F, 0xFC, 0x00, 0xF0, 0x3E, 0x7C, 0x03, 0xC0, 0x70, 0x78, 0x0F, 0x01,
  0xE0, 0x70, 0x3C, 0x03, 0x81, 0xE0, 0x70, 0x07, 0x03, 0xC1, 0xC0, 0x0E,
  0x07, 0x87, 0x80, 0x1C, 0x0E, 0x1E, 0x00, 0x78, 0x1C, 0x78, 0x00, 0x70,
  0x79, 0xE0, 0x00, 0xFF, 0xE3, 0x80, 0x01, 0xFF, 0x8E, 0x00, 0x01, 0xFE,
  0x38, 0x00, 0x00, 0x60, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x71, 0xFC, 0x00, 0x01, 0xC7,
  0xFC, 0x00, 0x07, 0x9F, 0xFC, 0x00, 0x1E, 0x78, 0x78, 0x00, 0x78, 0xE0,
  0x70, 0x00, 0xE1, 0xC0, 0xE0, 0x03, 0x87, 0x81, 0xC0, 0x0E, 0x0F, 0x03,
  0x80, 0x3C, 0x1E, 0x0F, 0x00, 0xF0, 0x38, 0x1E, 0x03, 0xC0, 0x70, 0x38,
  0x07, 0x00, 0xF0, 0xF0, 0x1C, 0x01, 0xFF, 0xC0, 0x70, 0x01, 0xFF, 0x01,
  0xE0, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x1E, 0x07, 0xC0, 0x1E, 0x01, 0xF0, 0x0F,
  0x00, 0xF8, 0x07, 0x80, 0x7C, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFE, 0x03,
  0xCF, 0x8F, 0x03, 0xE7, 0x87, 0xC1, 0xE3, 0xC1, 0xE1, 0xE3, 0xE0, 0xF9,
  0xF1, 0xE0, 0x3F, 0xF0, 0xF0, 0x1F, 0xF0, 0x78, 0x07, 0xF0, 0x3C, 0x01,
  0xF8, 0x1E, 0x00, 0xF8, 0x0F, 0x00, 0x7C, 0x0F, 0x80, 0x7F, 0x03, 0xC0,
  0x7F, 0x81, 0xF8, 0xFF, 0xE0, 0xFF, 0xFC, 0xF8, 0x3F, 0xF8, 0x3C, 0x0F,
  0xF8, 0x1F, 0x00, 0x3D, 0xF7, 0xDF, 0x79, 0xE7, 0x9E, 0xFB, 0xCF, 0x3C,
  0xF3, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x3C, 0x00, 0x1F, 0x80, 0x07, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF0,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x3C, 0x00, 0x01,
  0x00, 0x01, 0x80, 0x00, 0x3C, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xF0, 0x00, 0x38, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x80, 0x78, 0x04, 0x70, 0x3C,
  0x0E, 0x7F, 0x1C, 0x3F, 0x3F, 0xCE, 0x7F, 0xFF, 0xFB, 0xFF, 0xC1, 0xFF,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xDE, 0x00, 0x03, 0xE7, 0x80, 0x03, 0xE3, 0xC0, 0x03, 0xE1, 0xF0, 0x01,
  0xF0, 0x7C, 0x01, 0xF0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x70, 0x07, 0x00,
  0x10, 0x02, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x3F, 0x07, 0xE0, 0x7C, 0x0F, 0xC0,
  0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x78, 0x0F,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xE0, 0x3E, 0x7F, 0x7F,
  0xFF, 0xFF, 0x7E, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xE0,
  0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x7C, 0x07, 0xC1, 0xF0, 0x07, 0xC7,
  0xC0, 0x0F, 0x8F, 0x00, 0x0F, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0xF0,
  0x00, 0x79, 0xE0, 0x01, 0xE3, 0xC0, 0x03, 0xC7, 0x80, 0x07, 0x8F, 0x0E,
  0x0F, 0x1E, 0x3E, 0x1E, 0x78, 0x7C, 0x3C, 0xF0, 0xF8, 0xF9, 0xE1, 0xF1,
  0xE3, 0xC1, 0xC3, 0xC7, 0x80, 0x07, 0x8F, 0x00, 0x0F, 0x3C, 0x00, 0x1E,
  0x78, 0x00, 0x3C, 0xF0, 0x00, 0xF1, 0xE0, 0x01, 0xE3, 0xC0, 0x03, 0xC7,
  0x80, 0x0F, 0x8F, 0x80, 0x1E, 0x1F, 0x00, 0x7C, 0x1F, 0x83, 0xF0, 0x1F,
  0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xBC, 0x03, 0xF9, 0xE0,
  0x3F, 0x0F, 0x01, 0xF0, 0xF8, 0x0E, 0x07, 0x80, 0x60, 0x3C, 0x04, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xFC, 0x03,
  0xFF, 0xFE, 0x07, 0xE0, 0x3E, 0x07, 0x80, 0x1E, 0x0F, 0x80, 0x1F, 0x0F,
  0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x1E, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x78,
  0x00, 0x78, 0xF8, 0x00, 0xF8, 0x78, 0x00, 0xF0, 0x78, 0x01, 0xF0, 0x7C,
  0x03, 0xE0, 0x7F, 0x0F, 0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x1E, 0x0F, 0x80,
  0x78, 0x7C, 0x03, 0xE3, 0xE0, 0x0F, 0x1F, 0x00, 0x3C, 0x78, 0x00, 0xF1,
  0xE0, 0x03, 0xCF, 0x80, 0x0F, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFE, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0,
  0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE3,
  0xF8, 0x03, 0xDF, 0xFC, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0x01,
  0xF0, 0x7C, 0x01, 0xF0, 0xF0, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC7, 0x80, 0x0F, 0x0F, 0x80, 0x3E, 0x1F,
  0x00, 0xF8, 0x1F, 0x87, 0xF0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF9, 0xF0, 0x01, 0xEF, 0xF8, 0x07, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF8, 0x3F, 0x01, 0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x01, 0xE3,
  0xC0, 0x03, 0xCF, 0x00, 0x07, 0x9E, 0x00, 0x0F, 0x3C, 0x00, 0x1E, 0x78,
  0x00, 0x3C, 0xF0, 0x00, 0xF9, 0xE0, 0x01, 0xE3, 0xC0, 0x07, 0xC7, 0xC0,
  0x0F, 0x0F, 0x80, 0x7E, 0x0F, 0xC3, 0xF8, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xF0, 0x00, 0x7B, 0xC0, 0x03, 0xEF, 0x00, 0x0F, 0x3C,
  0x00, 0x7C, 0xF0, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xFC, 0x01,
  0xFF, 0xFE, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x1E, 0x07, 0x80, 0x1E, 0x07,
  0x80, 0x1E, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x3E, 0x07,
  0x80, 0x3C, 0x07, 0x80, 0x78, 0x07, 0xC0, 0xF8, 0x03, 0xF3, 0xE0, 0x01,
  0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xC0, 0x03, 0xF7, 0xE0, 0x0F,
  0xC3, 0xF0, 0x1F, 0x00, 0xF8, 0x1E, 0x00, 0xF8, 0x3C, 0x00, 0x78, 0x3C,
  0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00, 0x78, 0x78,
  0x00, 0xF8, 0x78, 0x00, 0xF0, 0x7C, 0x01, 0xF0, 0x3F, 0x0F, 0xE0, 0x3F,
  0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x03,
  0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xF8, 0x0F, 0x83, 0xE0,
  0x0F, 0x8F, 0x80, 0x0F, 0x1E, 0x00, 0x1E, 0x7C, 0x00, 0x3C, 0xF0, 0x00,
  0x79, 0xE0, 0x00, 0xF3, 0xC0, 0x01, 0xE7, 0x80, 0x03, 0xCF, 0x00, 0x0F,
  0x1E, 0x00, 0x1E, 0x3E, 0x00, 0x7C, 0x7C, 0x01, 0xF0, 0xFE, 0x0F, 0xE0,
  0xFF, 0xFF, 0x80, 0xFF, 0xDE, 0x00, 0xFF, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0x80,
  0xFC, 0x3F, 0x87, 0xF1, 0xFE, 0x1F, 0x81, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0xFE, 0x1F, 0xC7, 0xF8, 0xFF, 0x0F, 0xC0, 0x00, 0x78,
  0x07, 0xF0, 0x1F, 0xC0, 0xFF, 0x03, 0xFC, 0x07, 0xE0, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x1F,
  0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x3C,
  0x01, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0x10, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x00, 0x0C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0x80, 0x7F, 0xFC, 0x0F, 0xFF, 0xC0,
  0x03, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00,
  0x03, 0xE0, 0x01, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x07,
  0xE0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xE0,
  0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x3E, 0x00, 0x1E, 0x03, 0xC0, 0x01, 0xE0,
  0x78, 0x00, 0x0E, 0x07, 0x80, 0x00, 0xE0, 0xF0, 0x00, 0x0F, 0x0F, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x0E, 0x1E, 0x01, 0xFC, 0xE1, 0xE0, 0x3F, 0xEE,
  0x1E, 0x07, 0xFE, 0xE1, 0xE0, 0xF8, 0x3E, 0x1C, 0x0F, 0x03, 0xE1, 0xC0,
  0xE0, 0x1C, 0x3C, 0x1E, 0x03, 0xC3, 0xC1, 0xE0, 0x3C, 0x3C, 0x1E, 0x03,
  0xC3, 0xC1, 0xE0, 0x3C, 0x3C, 0x1E, 0x03, 0xC3, 0x81, 0xC0, 0x38, 0x38,
  0x3C, 0x03, 0x87, 0x83, 0xC0, 0x78, 0x78, 0x3C, 0x07, 0x87, 0x83, 0xE0,
  0xF8, 0x78, 0x1F, 0xBF, 0x87, 0x01, 0xFF, 0x70, 0x70, 0x0F, 0xE7, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x77, 0x00, 0x01, 0xEE, 0x00, 0x03, 0xDE, 0x00, 0x0F,
  0x3C, 0x00, 0x1E, 0x78, 0x00, 0x3C, 0xF0, 0x00, 0xF1, 0xE0, 0x01, 0xE3,
  0xC0, 0x07, 0x87, 0x80, 0x0F, 0x0F, 0x00, 0x3E, 0x1E, 0x00, 0x78, 0x1C,
  0x00, 0xF0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0xF0, 0x1F, 0x01, 0xE0,
  0x3C, 0x03, 0xC0, 0xF8, 0x07, 0x81, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFC, 0x1E, 0x00, 0x78, 0x7C, 0x00, 0x78, 0xF0, 0x00, 0xF1, 0xE0,
  0x01, 0xE7, 0x80, 0x03, 0xCF, 0x00, 0x07, 0xBE, 0x00, 0x0F, 0x78, 0x00,
  0x1F, 0xF0, 0x00, 0x3C, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x07, 0xFF,
  0xFC, 0x07, 0xFF, 0xFE, 0x07, 0x80, 0x7E, 0x07, 0x80, 0x3E, 0x07, 0x80,
  0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x00, 0x1F, 0x0F, 0x00, 0x1E, 0x0F, 0x00,
  0x1E, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x3C, 0x1F, 0x00, 0x7C, 0x1E, 0x03,
  0xF8, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x1E, 0x03,
  0xF8, 0x1E, 0x00, 0xF8, 0x3C, 0x00, 0x7C, 0x3C, 0x00, 0x3C, 0x3C, 0x00,
  0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x7C, 0x00,
  0x78, 0x78, 0x00, 0x78, 0x78, 0x00, 0xF8, 0x78, 0x03, 0xF0, 0x7F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7C, 0x07,
  0xC1, 0xF0, 0x07, 0xC3, 0xC0, 0x0F, 0x8F, 0x80, 0x0F, 0x1E, 0x00, 0x1E,
  0x3C, 0x00, 0x3C, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x01,
  0xE3, 0xE0, 0x03, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x1E, 0x0F, 0x80, 0x7C,
  0x1F, 0xC7, 0xF0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFC,
  0x07, 0x80, 0xFC, 0x07, 0x80, 0x3E, 0x07, 0x80, 0x1E, 0x0F, 0x80, 0x1E,
  0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x1E,
  0x0F, 0x00, 0x1E, 0x1F, 0x00, 0x1E, 0x1E, 0x00, 0x3E, 0x1E, 0x00, 0x3C,
  0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x3E, 0x00, 0x3C,
  0x3E, 0x00, 0x3C, 0x3C, 0x00, 0x7C, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0x78,
  0x3C, 0x00, 0x78, 0x3C, 0x00, 0x78, 0x7C, 0x00, 0xF0, 0x78, 0x00, 0xF0,
  0x78, 0x01, 0xE0, 0x78, 0x07, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80,
  0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF0, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x03,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7C,
  0x07, 0xC1, 0xF0, 0x07, 0xC3, 0xC0, 0x0F, 0x8F, 0x80, 0x0F, 0x1E, 0x00,
  0x1E, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x04,
  0x78, 0x7F, 0xF1, 0xF0, 0xFF, 0xE3, 0xC1, 0xFF, 0xC7, 0x83, 0xFF, 0x8F,
  0x00, 0x0F, 0x1E, 0x00, 0x3E, 0x3C, 0x00, 0x7C, 0x78, 0x00, 0xF1, 0xF0,
  0x01, 0xE3, 0xE0, 0x03, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x1E, 0x0F, 0x80,
  0x7C, 0x1F, 0xC7, 0xF0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0x81, 0xE0, 0x03, 0xC0, 0xF0,
  0x01, 0xE0, 0x78, 0x00, 0xF0, 0x3C, 0x00, 0x78, 0x1E, 0x00, 0x3C, 0x1F,
  0x00, 0x3E, 0x0F, 0x00, 0x1E, 0x07, 0x80, 0x0F, 0x03, 0xC0, 0x07, 0x81,
  0xE0, 0x03, 0xC0, 0xF0, 0x01, 0xE0, 0xF8, 0x01, 0xF0, 0x78, 0x00, 0xF0,
  0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0x03, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0x81, 0xE0, 0x03, 0xC0, 0xF0, 0x01,
  0xE0, 0x78, 0x00, 0xF0, 0x3C, 0x00, 0x78, 0x1E, 0x00, 0x7C, 0x1F, 0x00,
  0x3E, 0x0F, 0x00, 0x1E, 0x07, 0x80, 0x0F, 0x03, 0xC0, 0x07, 0x81, 0xE0,
  0x03, 0xC0, 0xF0, 0x01, 0xE0, 0xF8, 0x01, 0xF0, 0x78, 0x00, 0xF0, 0x00,
  0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0,
  0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x3E, 0x00, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x78, 0x7C, 0x00, 0x3C, 0x3E,
  0x00, 0x1E, 0x1F, 0x00, 0x1E, 0x07, 0x80, 0x1F, 0x03, 0xE0, 0x1F, 0x01,
  0xFC, 0x3F, 0x80, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x03, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x1E, 0x00, 0x1E, 0x03,
  0xC0, 0x07, 0xC0, 0x78, 0x01, 0xF0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x1F, 0x00, 0x3C,
  0x07, 0xC0, 0x07, 0x80, 0xF0, 0x00, 0xF0, 0x3E, 0x00, 0x3E, 0x0F, 0x80,
  0x07, 0x83, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x78, 0x3C, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE0, 0x78, 0x00,
  0x78, 0x0F, 0x00, 0x0F, 0x01, 0xF0, 0x01, 0xE0, 0x1E, 0x00, 0x3C, 0x03,
  0xC0, 0x07, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x07,
  0x80, 0x1F, 0x00, 0xF0, 0x01, 0xE0, 0x1E, 0x00, 0x3E, 0x03, 0xC0, 0x07,
  0xC0, 0xF8, 0x00, 0x78, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x7F,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xE0, 0x07,
  0xC0, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0xC0, 0x7F, 0x07, 0x70,
  0x1D, 0xC1, 0xDC, 0x07, 0x70, 0x77, 0x03, 0xF8, 0x1D, 0xC0, 0xEE, 0x07,
  0x70, 0x7B, 0x83, 0xDE, 0x1C, 0xE0, 0xF3, 0x8F, 0x78, 0x3C, 0xE3, 0x9E,
  0x0F, 0x39, 0xE7, 0x83, 0x8E, 0x71, 0xC0, 0xE3, 0xBC, 0xF0, 0x78, 0xFE,
  0x3C, 0x1E, 0x1F, 0x8F, 0x07, 0x87, 0xC3, 0xC1, 0xE1, 0xF0, 0xF0, 0x78,
  0x00, 0x78, 0x1E, 0x00, 0x1E, 0x0F, 0x80, 0x07, 0x83, 0xC0, 0x01, 0xE0,
  0xF0, 0x00, 0x78, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x03, 0xC0, 0x03,
  0xC1, 0xF0, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x07, 0x80,
  0x03, 0xC1, 0xE0, 0x01, 0xE0, 0x78, 0x00, 0x78, 0x3E, 0x00, 0x1E, 0x00,
  0x07, 0xE0, 0x07, 0x83, 0xF0, 0x03, 0xC1, 0xF8, 0x03, 0xC0, 0xFE, 0x01,
  0xE0, 0x7F, 0x00, 0xF0, 0x3F, 0x80, 0x78, 0x3D, 0xC0, 0x3C, 0x1E, 0xE0,
  0x1E, 0x0F, 0x78, 0x1E, 0x07, 0xBC, 0x0F, 0x03, 0xDE, 0x07, 0x81, 0xE7,
  0x03, 0xC0, 0xE3, 0x81, 0xE0, 0xF1, 0xE0, 0xF0, 0x78, 0xF0, 0x78, 0x3C,
  0x78, 0x78, 0x1E, 0x1C, 0x3C, 0x0F, 0x0E, 0x1E, 0x07, 0x87, 0x8F, 0x07,
  0x83, 0xC7, 0x83, 0xC1, 0xE3, 0xC1, 0xE0, 0xF3, 0xC0, 0xF0, 0x39, 0xE0,
  0x78, 0x1E, 0xF0, 0x3C, 0x0F, 0x78, 0x3C, 0x07, 0xBC, 0x1E, 0x03, 0xDE,
  0x0F, 0x00, 0xEE, 0x07, 0x80, 0x7F, 0x03, 0xC0, 0x3F, 0x81, 0xE0, 0x1F,
  0xC1, 0xF0, 0x0F, 0xE0, 0xF0, 0x03, 0xF0, 0x78, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7C,
  0x07, 0xC1, 0xF0, 0x07, 0x83, 0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x1E, 0x00,
  0x3E, 0x3C, 0x00, 0x78, 0x78, 0x00, 0xF0, 0xF0, 0x01, 0xE3, 0xE0, 0x03,
  0xC7, 0x80, 0x07, 0x8F, 0x00, 0x1F, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x78,
  0x78, 0x00, 0xF1, 0xF0, 0x01, 0xE3, 0xC0, 0x03, 0xC7, 0x80, 0x07, 0x8F,
  0x00, 0x1F, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x78, 0x00, 0xF1, 0xF0,
  0x01, 0xE3, 0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x0F, 0x80, 0x3E, 0x0F, 0x80,
  0xF8, 0x1F, 0xC7, 0xF0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFC, 0x07, 0x80, 0x3F, 0x01, 0xE0, 0x03, 0xE0, 0x78, 0x00, 0xF8,
  0x3E, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xE0, 0xF0, 0x00,
  0x78, 0x3C, 0x00, 0x3E, 0x0F, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xC1, 0xE0,
  0x01, 0xF0, 0x78, 0x01, 0xF8, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xE0, 0x7C, 0x07, 0xC1, 0xF0, 0x07, 0xC7, 0xC0, 0x0F,
  0x8F, 0x00, 0x0F, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0xF8, 0x00, 0xF9,
  0xE0, 0x01, 0xE3, 0xC0, 0x03, 0xC7, 0x80, 0x07, 0x8F, 0x00, 0x0F, 0x1E,
  0x00, 0x1E, 0x7C, 0x00, 0x3C, 0xF0, 0x00, 0xF9, 0xE0, 0x01, 0xE3, 0xC0,
  0x03, 0xC7, 0x80, 0x07, 0x8F, 0x00, 0x0F, 0x3E, 0x00, 0x1E, 0x78, 0x00,
  0x7C, 0xF0, 0x00, 0xF1, 0xE0, 0x01, 0xE3, 0xC0, 0x03, 0xC7, 0x80, 0x0F,
  0x8F, 0x80, 0x3E, 0x1F, 0x80, 0xFC, 0x1F, 0xC7, 0xF0, 0x1F, 0xFF, 0xC0,
  0x3F, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x78, 0x07, 0xF0, 0x3C, 0x00, 0xF8,
  0x1E, 0x00, 0x3C, 0x1F, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x07,
  0x83, 0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xE0, 0xF0, 0x01, 0xF0, 0xF8, 0x00,
  0xF0, 0x78, 0x00, 0xF8, 0x3C, 0x01, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF8, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x03, 0xC0, 0xF8, 0x01, 0xE0,
  0x3C, 0x00, 0xF0, 0x1E, 0x00, 0x78, 0x0F, 0x80, 0x3C, 0x07, 0xC0, 0x1E,
  0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0x00, 0x7C, 0x07, 0x80, 0x1E, 0x03,
  0xC0, 0x0F, 0x81, 0xE0, 0x07, 0xC0, 0xF0, 0x01, 0xE0, 0xF8, 0x00, 0xF8,
  0x78, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xFC, 0x01, 0xFF, 0xFE, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x1F, 0x07, 0x80,
  0x0F, 0x0F, 0x80, 0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x7C, 0x78, 0x00,
  0x78, 0x78, 0x00, 0x78, 0x78, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0x7F, 0x8F,
  0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x7F, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x80, 0x0F, 0x0F, 0x00, 0x1F, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x1E,
  0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x1F, 0x00, 0x1E, 0x1E, 0x00, 0x3E,
  0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x3C,
  0x1E, 0x00, 0x3C, 0x3E, 0x00, 0x3C, 0x3C, 0x00, 0x7C, 0x3C, 0x00, 0x78,
  0x3C, 0x00, 0x78, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0x78, 0x7C, 0x00, 0x78,
  0x78, 0x00, 0xF8, 0x78, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0x78, 0x00, 0xF0,
  0x78, 0x00, 0xF0, 0xF8, 0x00, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xE0,
  0xF8, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0x7F, 0x1F, 0xC0, 0x3F, 0xFF, 0x80,
  0x3F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7B,
  0xC0, 0x01, 0xF7, 0x80, 0x03, 0xCF, 0x00, 0x07, 0x9E, 0x00, 0x1F, 0x3C,
  0x00, 0x3C, 0x78, 0x00, 0xF8, 0xF8, 0x01, 0xE0, 0xF0, 0x03, 0xC1, 0xE0,
  0x0F, 0x03, 0xC0, 0x1E, 0x07, 0x80, 0x7C, 0x0F, 0x00, 0xF0, 0x1E, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xF0, 0x3C, 0x01, 0xE0, 0x78,
  0x03, 0xE0, 0xF0, 0x03, 0xC3, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x1E, 0x00,
  0x1E, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x79, 0xE0, 0x00, 0xF3, 0xC0, 0x01,
  0xEF, 0x00, 0x03, 0xDE, 0x00, 0x07, 0xB8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x78, 0x0F, 0x01, 0xEF,
  0x01, 0xE0, 0x39, 0xE0, 0x7C, 0x0F, 0x3C, 0x0F, 0x81, 0xE7, 0x81, 0xB0,
  0x3C, 0xF0, 0x36, 0x07, 0x1E, 0x0E, 0xC1, 0xE3, 0xC1, 0xF8, 0x3C, 0x78,
  0x37, 0x07, 0x8F, 0x0E, 0xE0, 0xE1, 0xE1, 0xDC, 0x3C, 0x3C, 0x3B, 0x87,
  0x87, 0x86, 0x70, 0xE0, 0xF1, 0xCE, 0x1C, 0x1E, 0x39, 0xC7, 0x83, 0x86,
  0x38, 0xF0, 0x71, 0xC7, 0x1C, 0x0E, 0x38, 0xE7, 0x81, 0xC7, 0x1C, 0xF0,
  0x38, 0xC3, 0x9E, 0x07, 0x38, 0x63, 0x80, 0xE7, 0x0C, 0xF0, 0x3C, 0xC1,
  0x9E, 0x07, 0xB8, 0x33, 0x80, 0xF7, 0x06, 0x70, 0x1E, 0xE0, 0xDE, 0x03,
  0xD8, 0x1B, 0xC0, 0x7F, 0x03, 0x70, 0x0F, 0xE0, 0xEE, 0x01, 0xF8, 0x1F,
  0xC0, 0x3B, 0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x1F,
  0x01, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x1F, 0x00, 0x0F, 0x80, 0xF8,
  0x00, 0xF8, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0x78, 0x07,
  0xC0, 0x03, 0xC0, 0x3C, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x78, 0x3E, 0x00,
  0x03, 0xE1, 0xE0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x79, 0xF0, 0x00, 0x03,
  0xEF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3D, 0xF0, 0x00, 0x03,
  0xE7, 0x80, 0x00, 0x3E, 0x3E, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1F, 0x07,
  0x80, 0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0xF0, 0x07, 0xC0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x00, 0xF0, 0x07, 0x80, 0x07, 0xC0, 0x7C,
  0x00, 0x1E, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x7C, 0x3C, 0x00,
  0x78, 0x3C, 0x00, 0xF0, 0x3C, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x03,
  0xC0, 0x1E, 0x03, 0xC0, 0x1F, 0x07, 0x80, 0x0F, 0x0F, 0x80, 0x0F, 0x0F,
  0x00, 0x0F, 0x9E, 0x00, 0x07, 0xBE, 0x00, 0x07, 0xBC, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E,
  0x00, 0x0F, 0x00, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE,
  0x00, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xFC,
  0x0F, 0xFF, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x01, 0xFF, 0xC0, 0xFF,
  0xF0, 0x3F, 0xFC, 0x0F, 0xFE, 0x00, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x3F, 0x00, 0x07, 0xF0, 0x00, 0x77, 0x00, 0x0F, 0x78, 0x01, 0xE3, 0x80,
  0x1E, 0x38, 0x03, 0xC3, 0x80, 0x38, 0x3C, 0x07, 0x81, 0xC0, 0xF0, 0x1C,
  0x0F, 0x01, 0xE1, 0xE0, 0x1E, 0x1C, 0x00, 0xE3, 0xC0, 0x0F, 0x78, 0x00,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xE0, 0xF8, 0x3E, 0x0F, 0x03, 0xC1, 0xE0, 0x7C, 0x00, 0x78,
  0x00, 0x07, 0xFC, 0xF0, 0x7F, 0xFB, 0xC3, 0xFF, 0xEF, 0x0F, 0x81, 0xBC,
  0x7C, 0x02, 0xF3, 0xE0, 0x07, 0x8F, 0x00, 0x1E, 0x3C, 0x00, 0x78, 0xF0,
  0x01, 0xE3, 0xC0, 0x07, 0x9F, 0x00, 0x1E, 0x78, 0x00, 0xF9, 0xE0, 0x03,
  0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x3C, 0x78, 0x00, 0xF3, 0xE0, 0x03, 0xCF,
  0x80, 0x1F, 0x3E, 0x00, 0x78, 0xF8, 0x03, 0xE1, 0xF0, 0x1F, 0x87, 0xE1,
  0xDE, 0x1F, 0xFF, 0x78, 0x3F, 0xFB, 0xE0, 0x7F, 0x8F, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x03, 0x80,
  0x1E, 0x3F, 0xE0, 0x3D, 0xFF, 0xE0, 0x7B, 0xFF, 0xC0, 0xFC, 0x0F, 0xC3,
  0xD0, 0x0F, 0x87, 0xC0, 0x0F, 0x0F, 0x80, 0x1E, 0x1E, 0x00, 0x3C, 0x3C,
  0x00, 0x78, 0x78, 0x00, 0xF1, 0xF0, 0x01, 0xE3, 0xC0, 0x03, 0xC7, 0x80,
  0x0F, 0x8F, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x78, 0x00,
  0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x07, 0x87, 0xC0, 0x1F, 0x0F, 0xC0, 0x7E,
  0x1F, 0xC1, 0xF8, 0x3D, 0xFF, 0xE0, 0xFB, 0xFF, 0x81, 0xE3, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F,
  0xC1, 0xF8, 0x7C, 0x01, 0xE1, 0xE0, 0x07, 0xCF, 0x00, 0x1F, 0x3C, 0x00,
  0x7C, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x0F, 0x3E, 0x00, 0x7C, 0xF8, 0x01, 0xE1, 0xF0, 0x0F,
  0x87, 0xF1, 0xFC, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E,
  0x00, 0x78, 0x3C, 0x01, 0xFF, 0x3C, 0x07, 0xFF, 0xBC, 0x0F, 0xFF, 0xBC,
  0x0F, 0x81, 0xBC, 0x1F, 0x00, 0xBC, 0x3E, 0x00, 0x78, 0x3C, 0x00, 0x78,
  0x3C, 0x00, 0x78, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0x78, 0x7C, 0x00, 0x78,
  0x78, 0x00, 0xF8, 0x78, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0x78, 0x00, 0xF0,
  0x78, 0x00, 0xF0, 0xF8, 0x00, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xE0,
  0xF8, 0x03, 0xE0, 0x7C, 0x07, 0xE0, 0x7E, 0x1D, 0xE0, 0x7F, 0xFD, 0xE0,
  0x3F, 0xFB, 0xE0, 0x1F, 0xE3, 0xC0, 0x00, 0x3E, 0x00, 0x07, 0xFF, 0x00,
  0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0x81, 0xF8, 0x7C, 0x03, 0xE1, 0xE0,
  0x07, 0x8F, 0x00, 0x1E, 0x3C, 0x00, 0x78, 0xF0, 0x01, 0xE7, 0xC0, 0x07,
  0x9F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE7, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF8, 0x01, 0xE1, 0xE0, 0x0F, 0x87, 0xE0, 0xFC, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x07, 0xFC, 0xF0, 0x7F, 0xFB, 0xC3, 0xFF, 0xEF,
  0x0F, 0x81, 0xBC, 0x7C, 0x03, 0xF1, 0xE0, 0x07, 0x8F, 0x00, 0x1E, 0x3C,
  0x00, 0x78, 0xF0, 0x01, 0xE3, 0xC0, 0x07, 0x9F, 0x00, 0x1E, 0x78, 0x00,
  0xF9, 0xE0, 0x03, 0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x3C, 0x78, 0x00, 0xF1,
  0xE0, 0x07, 0xC7, 0x80, 0x1F, 0x1F, 0x00, 0xF8, 0x7F, 0x1F, 0xE0, 0xFF,
  0xF7, 0x81, 0xFF, 0x9E, 0x03, 0xFC, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x03, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x07,
  0xC0, 0x1E, 0x7F, 0xE0, 0x3D, 0xFF, 0xE0, 0x7B, 0xFF, 0xE0, 0xFC, 0x0F,
  0xC3, 0xF0, 0x0F, 0x87, 0xC0, 0x0F, 0x0F, 0x80, 0x1E, 0x1E, 0x00, 0x3C,
  0x3C, 0x00, 0x78, 0x78, 0x00, 0xF1, 0xF0, 0x01, 0xE3, 0xC0, 0x07, 0xC7,
  0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x78,
  0x00, 0xF1, 0xF0, 0x03, 0xE3, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x0F, 0x00,
  0x1E, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0xF8, 0x00, 0xF1, 0xE0, 0x03,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x07, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0xFF,
  0xFC, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0x80, 0x0F, 0xC3, 0xC0, 0x07, 0x81, 0xE0, 0x07,
  0xC0, 0xF0, 0x07, 0xC0, 0x78, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x3C, 0x07,
  0xC0, 0x1E, 0x07, 0xC0, 0x0F, 0x03, 0xE0, 0x07, 0x83, 0xE0, 0x03, 0xFF,
  0xE0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x78,
  0x3E, 0x00, 0x3C, 0x0F, 0x00, 0x1E, 0x07, 0xC0, 0x0F, 0x01, 0xE0, 0x0F,
  0x80, 0xF8, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1F, 0x01, 0xE0, 0x07, 0x80,
  0xF0, 0x03, 0xE0, 0x78, 0x00, 0xF0, 0x7C, 0x00, 0x7C, 0x00, 0xFF, 0xF0,
  0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xFF, 0xF8,
  0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x38, 0x1C, 0x07, 0xBF,
  0x3F, 0x83, 0xBF, 0xBF, 0xC1, 0xD7, 0xFB, 0xF1, 0xF0, 0xF0, 0x78, 0xF0,
  0x78, 0x3C, 0x78, 0x3C, 0x1E, 0x3C, 0x1C, 0x0E, 0x1E, 0x0E, 0x0F, 0x0E,
  0x07, 0x07, 0x8F, 0x03, 0x83, 0xC7, 0x83, 0xC1, 0xE3, 0xC1, 0xE0, 0xF1,
  0xE0, 0xE0, 0x78, 0xF0, 0x70, 0x38, 0x78, 0x38, 0x3C, 0x38, 0x1C, 0x1E,
  0x3C, 0x1E, 0x0F, 0x1E, 0x0F, 0x07, 0x8F, 0x07, 0x03, 0xC7, 0x83, 0x81,
  0xC3, 0xC1, 0xC1, 0xE1, 0xC0, 0xE0, 0xF1, 0xE0, 0x70, 0x78, 0xF0, 0x78,
  0x3C, 0x78, 0x3C, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x1E, 0x7F, 0xE0, 0x3D,
  0xFF, 0xE0, 0x7B, 0xFF, 0xE0, 0xFC, 0x0F, 0xC3, 0xF0, 0x0F, 0x87, 0xC0,
  0x0F, 0x0F, 0x80, 0x1E, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x78, 0x00,
  0xF1, 0xF0, 0x01, 0xE3, 0xC0, 0x07, 0xC7, 0x80, 0x0F, 0x0F, 0x00, 0x1E,
  0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x78, 0x00, 0xF1, 0xF0, 0x03, 0xE3,
  0xC0, 0x07, 0x87, 0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x3C,
  0x00, 0x78, 0xF8, 0x00, 0xF1, 0xE0, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x07,
  0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0x81, 0xF8, 0x7C, 0x03,
  0xE1, 0xE0, 0x07, 0x8F, 0x00, 0x1E, 0x3C, 0x00, 0x78, 0xF0, 0x01, 0xE7,
  0xC0, 0x07, 0x9E, 0x00, 0x1E, 0x78, 0x00, 0x79, 0xE0, 0x03, 0xE7, 0x80,
  0x0F, 0x1E, 0x00, 0x3C, 0x78, 0x00, 0xF3, 0xE0, 0x03, 0xCF, 0x80, 0x1F,
  0x3E, 0x00, 0x78, 0xF8, 0x03, 0xE1, 0xF0, 0x1F, 0x07, 0xF1, 0xFC, 0x0F,
  0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x07,
  0x8F, 0xF8, 0x07, 0xBF, 0xFC, 0x07, 0xBF, 0xFC, 0x07, 0xF0, 0x7E, 0x0F,
  0xC0, 0x3E, 0x0F, 0x80, 0x1E, 0x0F, 0x80, 0x1E, 0x0F, 0x00, 0x1E, 0x0F,
  0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x1F, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E,
  0x00, 0x3E, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x1E,
  0x00, 0x3C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x78, 0x3E, 0x00, 0xF8, 0x3F,
  0x01, 0xF0, 0x3F, 0x83, 0xF0, 0x3D, 0xFF, 0xE0, 0x7D, 0xFF, 0xC0, 0x78,
  0xFF, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x07, 0xFC, 0xF0, 0x7F, 0xFB, 0xC3, 0xFF,
  0xEF, 0x1F, 0x81, 0xBC, 0x7C, 0x03, 0xF3, 0xE0, 0x07, 0x8F, 0x00, 0x1E,
  0x3C, 0x00, 0x78, 0xF0, 0x01, 0xE7, 0xC0, 0x07, 0x9E, 0x00, 0x3E, 0x78,
  0x00, 0xF1, 0xE0, 0x03, 0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x3C, 0x78, 0x00,
  0xF3, 0xE0, 0x03, 0xCF, 0x00, 0x1F, 0x3E, 0x00, 0x78, 0xF8, 0x03, 0xE3,
  0xF0, 0x1F, 0x87, 0xE1, 0xDE, 0x1F, 0xFF, 0x78, 0x3F, 0xFB, 0xE0, 0x7F,
  0x8F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x1E, 0x7F, 0xE0, 0x3D, 0xFF, 0xE0, 0x7F, 0xFF, 0xC1,
  0xFC, 0x0F, 0xC3, 0xF0, 0x0F, 0x87, 0xC0, 0x0F, 0x0F, 0x00, 0x1E, 0x1E,
  0x00, 0x3C, 0x3C, 0x00, 0x78, 0x78, 0x00, 0xF1, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x1F, 0xFF, 0x01, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF1, 0xF8, 0x0F, 0x8F, 0x00, 0x3C, 0x78, 0x01, 0xE7, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0xF8, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xEF, 0x00, 0x1E, 0x7C, 0x01,
  0xF3, 0xF0, 0x3F, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0xFF, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xF0, 0x1E, 0x00, 0x3C, 0x78, 0x00, 0xF1, 0xE0, 0x03,
  0xC7, 0x80, 0x0F, 0x3E, 0x00, 0x3C, 0xF0, 0x01, 0xF3, 0xC0, 0x07, 0x8F,
  0x00, 0x1E, 0x3C, 0x00, 0x78, 0xF0, 0x01, 0xE7, 0xC0, 0x07, 0x9E, 0x00,
  0x3E, 0x78, 0x00, 0xF1, 0xE0, 0x03, 0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x3C,
  0xF8, 0x00, 0xF3, 0xE0, 0x07, 0xCF, 0x80, 0x1E, 0x1E, 0x00, 0xF8, 0x7C,
  0x07, 0xC1, 0xF8, 0x7E, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xEF, 0x00, 0x0F, 0x3C, 0x00, 0x3C,
  0x78, 0x01, 0xF1, 0xE0, 0x07, 0x87, 0x80, 0x3E, 0x1E, 0x00, 0xF0, 0x78,
  0x07, 0xC1, 0xE0, 0x1E, 0x03, 0xC0, 0xF8, 0x0F, 0x03, 0xC0, 0x3C, 0x0F,
  0x00, 0xF0, 0x78, 0x03, 0xC1, 0xE0, 0x0F, 0x0F, 0x00, 0x1E, 0x3C, 0x00,
  0x79, 0xE0, 0x01, 0xE7, 0x80, 0x07, 0xBC, 0x00, 0x1E, 0xF0, 0x00, 0x7F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0xE0, 0x7C,
  0x0F, 0xE0, 0x7C, 0x0E, 0xE0, 0x7C, 0x0E, 0xE0, 0xFC, 0x1E, 0xE0, 0xFC,
  0x1C, 0xE0, 0xDC, 0x1C, 0xE0, 0xDC, 0x3C, 0xE1, 0xDC, 0x38, 0xE1, 0x9C,
  0x38, 0xE1, 0x9C, 0x78, 0xE3, 0x9C, 0x70, 0xE3, 0x9C, 0x70, 0xE3, 0x1C,
  0x70, 0xE7, 0x1C, 0xE0, 0xE7, 0x1C, 0xE0, 0xE6, 0x1C, 0xE0, 0xEE, 0x1D,
  0xE0, 0xEE, 0x1D, 0xC0, 0xEC, 0x1D, 0xC0, 0xFC, 0x1F, 0xC0, 0xFC, 0x1F,
  0x80, 0xF8, 0x1F, 0x80, 0xF8, 0x1F, 0x80, 0xF8, 0x1F, 0x00, 0xF0, 0x1F,
  0x00, 0x07, 0xC0, 0x07, 0xE0, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x00,
  0xF8, 0x0F, 0x00, 0x0F, 0x03, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x1E, 0x3E,
  0x00, 0x03, 0xC7, 0x80, 0x00, 0x3D, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xDE, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x3C,
  0x3C, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xE0, 0x78, 0x00, 0xF8, 0x0F, 0x80,
  0x3E, 0x00, 0xF0, 0x07, 0x80, 0x1F, 0x01, 0xF0, 0x01, 0xE0, 0xFC, 0x00,
  0x3E, 0x00, 0x1E, 0x00, 0x3C, 0x78, 0x00, 0xF1, 0xE0, 0x03, 0xC7, 0x80,
  0x0F, 0x3E, 0x00, 0x3C, 0xF0, 0x01, 0xF3, 0xC0, 0x07, 0x8F, 0x00, 0x1E,
  0x3C, 0x00, 0x78, 0xF0, 0x01, 0xE7, 0xC0, 0x07, 0x9E, 0x00, 0x3E, 0x78,
  0x00, 0xF1, 0xE0, 0x03, 0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x3C, 0x78, 0x01,
  0xF1, 0xE0, 0x0F, 0xC7, 0xC0, 0x7E, 0x1F, 0xEF, 0xF8, 0x3F, 0xFD, 0xE0,
  0x7F, 0xE7, 0x80, 0xFE, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0xFE,
  0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0xF0, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0x80, 0x01, 0xE0, 0x7C, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x03, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x81, 0xF0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x1F, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x07,
  0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1F, 0xC1, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x1F, 0xFE, 0x00, 0x3F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xC0, 0x1E, 0x3F, 0xC0, 0x3C, 0xFF, 0xC0, 0x7B,
  0xFF, 0xC1, 0xE7, 0x87, 0xC3, 0xDE, 0x0F, 0x8F, 0xBC, 0x0F, 0xFE, 0x78,
  0x0F, 0xF8, 0xF0, 0x0F, 0xE0, 0x00, 0x02, 0x00,
};

const GFXglyph JetBrainsMono_Italic46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 28, 0, -1 },
  { 1, 11, 34, 28, 9, -34 },
  { 48, 15, 14, 28, 9, -34 },
  { 75, 27, 34, 28, 1, -34 },
  { 190, 24, 46, 28, 2, -40 },
  { 328, 31, 34, 28, -1, -34 },
  { 460, 25, 34, 28, 1, -34 },
  { 567, 6, 14, 28, 13, -34 },
  { 578, 19, 45, 28, 7, -39 },
  { 685, 19, 45, 28, 2, -39 },
  { 792, 25, 24, 28, 2, -28 },
  { 867, 22, 22, 28, 3, -26 },
  { 928, 12, 14, 28, 4, -7 },
  { 949, 15, 4, 28, 7, -17 },
  { 957, 8, 7, 28, 8, -7 },
  { 964, 27, 43, 28, 1, -38 },
  { 1110, 23, 34, 28, 3, -34 },
  { 1208, 21, 34, 28, 2, -34 },
  { 1298, 24, 34, 28, 2, -34 },
  { 1400, 24, 34, 28, 2, -34 },
  { 1502, 22, 34, 28, 3, -34 },
  { 1596, 23, 34, 28, 3, -34 },
  { 1694, 23, 34, 28, 2, -34 },
  { 1792, 22, 34, 28, 6, -34 },
  { 1886, 24, 34, 28, 2, -34 },
  { 1988, 23, 34, 28, 4, -34 },
  { 2086, 11, 26, 28, 8, -26 },
  { 2122, 14, 33, 28, 5, -26 },
  { 2180, 22, 24, 28, 4, -27 },
  { 2246, 22, 15, 28, 3, -23 },
  { 2288, 22, 24, 28, 2, -27 },
  { 2354, 19, 34, 28, 6, -34 },
  { 2435, 28, 42, 28, 0, -34 },
  { 2582, 23, 34, 28, 0, -34 },
  { 2680, 24, 34, 28, 2, -34 },
  { 2782, 23, 34, 28, 3, -34 },
  { 2880, 24, 34, 28, 2, -34 },
  { 2982, 24, 34, 28, 3, -34 },
  { 3084, 25, 34, 28, 2, -34 },
  { 3191, 23, 34, 28, 3, -34 },
  { 3289, 25, 34, 28, 2, -34 },
  { 3396, 23, 34, 28, 3, -34 },
  { 3494, 25, 34, 28, 1, -34 },
  { 3601, 27, 34, 28, 2, -34 },
  { 3716, 20, 34, 28, 3, -34 },
  { 3801, 26, 34, 28, 1, -34 },
  { 3912, 25, 34, 28, 2, -34 },
  { 4019, 23, 34, 28, 3, -34 },
  { 4117, 26, 34, 28, 2, -34 },
  { 4228, 23, 42, 28, 3, -34 },
  { 4349, 25, 34, 28, 2, -34 },
  { 4456, 24, 34, 28, 2, -34 },
  { 4558, 23, 34, 28, 5, -34 },
  { 4656, 24, 34, 28, 3, -34 },
  { 4758, 23, 34, 28, 6, -34 },
  { 4856, 27, 34, 28, 3, -34 },
  { 4971, 29, 34, 28, 0, -34 },
  { 5095, 24, 34, 28, 5, -34 },
  { 5197, 25, 34, 28, 2, -34 },
  { 5304, 18, 43, 28, 7, -38 },
  { 5401, 14, 43, 28, 7, -38 },
  { 5477, 18, 43, 28, 4, -38 },
  { 5574, 20, 18, 28, 4, -34 },
  { 5619, 23, 4, 28, 0, 1 },
  { 5631, 9, 6, 28, 12, -36 },
  { 5638, 22, 26, 28, 3, -26 },
  { 5710, 23, 34, 28, 2, -34 },
  { 5808, 22, 26, 28, 3, -26 },
  { 5880, 24, 34, 28, 3, -34 },
  { 5982, 22, 26, 28, 3, -26 },
  { 6054, 31, 42, 28, -2, -34 },
  { 6217, 22, 34, 28, 3, -26 },
  { 6311, 23, 34, 28, 2, -34 },
  { 6409, 22, 36, 28, 2, -36 },
  { 6508, 23, 44, 28, 1, -36 },
  { 6635, 25, 34, 28, 2, -34 },
  { 6742, 19, 34, 28, 5, -34 },
  { 6823, 25, 26, 28, 1, -26 },
  { 6905, 23, 26, 28, 2, -26 },
  { 6980, 22, 26, 28, 3, -26 },
  { 7052, 24, 34, 28, 1, -26 },
  { 7154, 22, 34, 28, 3, -26 },
  { 7248, 23, 26, 28, 3, -26 },
  { 7323, 21, 26, 28, 3, -26 },
  { 7392, 22, 32, 28, 4, -32 },
  { 7480, 22, 25, 28, 3, -25 },
  { 7549, 22, 25, 28, 5, -25 },
  { 7618, 24, 25, 28, 4, -25 },
  { 7693, 27, 25, 28, 0, -25 },
  { 7778, 22, 33, 28, 3, -25 },
  { 7869, 23, 25, 28, 2, -25 },
  { 7941, 24, 43, 28, 4, -38 },
  { 8070, 11, 43, 28, 9, -38 },
  { 8130, 24, 43, 28, 1, -38 },
  { 8259, 23, 10, 28, 3, -21 },
};

const GFXfont JetBrainsMono_Italic46pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Italic46pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Italic46pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _JETBRAINSMONO_ITALIC46PT7B_H_
