#ifndef _JETBRAINSMONO_ITALIC54PT7B_H_
#define _JETBRAINSMONO_ITALIC54PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Italic.ttf
// Size: 54pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Italic54pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x1F, 0xC1, 0xFE, 0x0F,
  0xF0, 0x7F, 0x81, 0xF8, 0x00, 0x3E, 0x07, 0xCF, 0x81, 0xF7, 0xE0, 0xFD,
  0xF8, 0x3F, 0x7C, 0x0F, 0x9F, 0x03, 0xE7, 0xC0, 0xF9, 0xF0, 0x3E, 0x7C,
  0x0F, 0x9E, 0x03, 0xC7, 0x80, 0xF3, 0xE0, 0x7C, 0xF8, 0x1F, 0x3E, 0x07,
  0x8F, 0x01, 0xE3, 0xC0, 0x78, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x03, 0xC0,
  0x3C, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x07, 0x80,
  0x78, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x1E, 0x01, 0xE0, 0x07, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFE, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x78, 0x07, 0x80, 0x00, 0x78, 0x07,
  0x80, 0x00, 0xF0, 0x07, 0x80, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x0F,
  0x00, 0x01, 0xE0, 0x0F, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x01, 0xE0, 0x1E,
  0x00, 0x03, 0xC0, 0x1E, 0x00, 0x03, 0xC0, 0x3C, 0x10, 0x7F, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0x80, 0x78,
  0x00, 0x0F, 0x00, 0x78, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0xF0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x1E, 0x01, 0xE0,
  0x00, 0x3C, 0x01, 0xE0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x3C, 0x03, 0xC0,
  0x00, 0x78, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xC0, 0x1F, 0x8E, 0x3F, 0x00, 0xF8, 0x70, 0xF8, 0x0F, 0x83, 0x87, 0xC0,
  0x7C, 0x3C, 0x3E, 0x07, 0xC1, 0xE0, 0xF0, 0x3E, 0x0E, 0x0F, 0x81, 0xF0,
  0x70, 0x00, 0x0F, 0x83, 0x80, 0x00, 0x7E, 0x1C, 0x00, 0x03, 0xF0, 0xE0,
  0x00, 0x0F, 0xCF, 0x00, 0x00, 0x7F, 0x70, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1C, 0xFE, 0x00, 0x00, 0xE3,
  0xF0, 0x00, 0x07, 0x0F, 0xC0, 0x00, 0x38, 0x3E, 0x00, 0x03, 0xC1, 0xF0,
  0x00, 0x1E, 0x0F, 0x80, 0x00, 0xE0, 0x7C, 0x3E, 0x07, 0x03, 0xE1, 0xF0,
  0x38, 0x3E, 0x0F, 0x81, 0xC1, 0xF0, 0x7E, 0x1E, 0x1F, 0x83, 0xF0, 0xF1,
  0xF8, 0x0F, 0xE7, 0x3F, 0x80, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x04, 0x00, 0xFF, 0x80, 0x01, 0xE0, 0x0F,
  0xFF, 0x00, 0x0F, 0x00, 0x7F, 0xFC, 0x00, 0x78, 0x01, 0xF0, 0xF8, 0x03,
  0xC0, 0x0F, 0x01, 0xE0, 0x1E, 0x00, 0x3C, 0x07, 0x80, 0xF8, 0x00, 0xF0,
  0x1E, 0x03, 0xC0, 0x07, 0x80, 0xF0, 0x1E, 0x00, 0x1E, 0x03, 0xC0, 0xF0,
  0x00, 0x78, 0x0F, 0x07, 0x80, 0x01, 0xE0, 0x3C, 0x3C, 0x00, 0x07, 0x80,
  0xF1, 0xF0, 0x00, 0x1E, 0x07, 0x87, 0x80, 0x00, 0x7E, 0x3E, 0x3C, 0x00,
  0x00, 0xFF, 0xF1, 0xE0, 0x00, 0x03, 0xFF, 0x8F, 0x00, 0x00, 0x07, 0xFC,
  0x78, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0xFF, 0x80, 0x00, 0x07, 0xCF, 0xFF, 0x00,
  0x00, 0x1E, 0x7F, 0xFC, 0x00, 0x00, 0xF1, 0xE0, 0xF8, 0x00, 0x07, 0x8F,
  0x01, 0xE0, 0x00, 0x3C, 0x3C, 0x07, 0x80, 0x01, 0xE0, 0xF0, 0x1E, 0x00,
  0x0F, 0x03, 0xC0, 0x78, 0x00, 0x7C, 0x1F, 0x01, 0xE0, 0x01, 0xE0, 0x78,
  0x0F, 0x00, 0x0F, 0x01, 0xE0, 0x3C, 0x00, 0x78, 0x07, 0x80, 0xF0, 0x03,
  0xC0, 0x1F, 0x07, 0xC0, 0x1E, 0x00, 0x7F, 0x7E, 0x00, 0xF8, 0x00, 0xFF,
  0xF0, 0x03, 0xC0, 0x01, 0xFF, 0x80, 0x3E, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xE0, 0x1F, 0x00, 0x1F, 0x00,
  0x7E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x04, 0x7E, 0x7E, 0x03, 0xE1, 0xF0, 0xF8,
  0x0F, 0x8F, 0x83, 0xF0, 0x7C, 0x3E, 0x07, 0xC3, 0xE0, 0xF8, 0x0F, 0x9F,
  0x03, 0xE0, 0x3F, 0x7C, 0x0F, 0x00, 0x7F, 0xE0, 0x7C, 0x01, 0xFF, 0x01,
  0xF0, 0x03, 0xFC, 0x07, 0xC0, 0x0F, 0xE0, 0x1F, 0x00, 0x1F, 0x00, 0x7C,
  0x00, 0xFE, 0x01, 0xF0, 0x03, 0xF8, 0x07, 0xC0, 0x3F, 0xF0, 0x1F, 0x81,
  0xFF, 0xE0, 0x7F, 0xFF, 0xCF, 0x80, 0xFF, 0xFE, 0x3F, 0x01, 0xFF, 0xF0,
  0x7C, 0x03, 0xFF, 0x00, 0xF8, 0x01, 0x80, 0x00, 0x00, 0x3E, 0x7C, 0xF9,
  0xF7, 0xEF, 0x9F, 0x3E, 0x7C, 0xF9, 0xE3, 0xCF, 0x9F, 0x3E, 0x78, 0x00,
  0x00, 0x04, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x80,
  0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x3C, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x30, 0x07, 0x80, 0x77, 0xE0,
  0x70, 0x3F, 0x7F, 0x87, 0x0F, 0xFF, 0xFC, 0x73, 0xFF, 0x7F, 0xF6, 0xFF,
  0xE1, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xB8, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x1F, 0x3E,
  0x00, 0x03, 0xE3, 0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0xC1, 0xF8, 0x01,
  0xF8, 0x0F, 0x80, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x07, 0xC0, 0x1C, 0x00,
  0x70, 0x00, 0x40, 0x02, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x80,
  0xFC, 0x07, 0xF0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x01,
  0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0x3F, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x18, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x01, 0xFC,
  0x1F, 0xC0, 0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x3E,
  0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE1, 0xF0,
  0x00, 0x3E, 0x1F, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x03,
  0xE1, 0xF0, 0x00, 0x3E, 0x1E, 0x00, 0x03, 0xC3, 0xE0, 0xF0, 0x3C, 0x3E,
  0x1F, 0x87, 0xC3, 0xE1, 0xF8, 0x7C, 0x3E, 0x1F, 0x87, 0xC3, 0xE1, 0xF8,
  0x7C, 0x3C, 0x0F, 0x07, 0x83, 0xC0, 0x00, 0x78, 0x7C, 0x00, 0x0F, 0x87,
  0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0xF8, 0x78, 0x00,
  0x0F, 0x87, 0x80, 0x00, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0,
  0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0x7E, 0x00, 0x7C, 0x07, 0xF0,
  0x1F, 0xC0, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x0F, 0xE7, 0xC0,
  0x0F, 0xE7, 0xC0, 0x0F, 0xC3, 0xE0, 0x0F, 0xC1, 0xF0, 0x07, 0x80, 0xF8,
  0x03, 0x80, 0x7C, 0x01, 0x00, 0x3E, 0x01, 0x00, 0x1E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x0F, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0,
  0x3F, 0xF7, 0xFC, 0x07, 0xE0, 0x1F, 0x81, 0xF8, 0x01, 0xF8, 0x7E, 0x00,
  0x1F, 0x0F, 0x80, 0x03, 0xE1, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x8F,
  0x80, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x8F,
  0x80, 0x01, 0xF1, 0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x01,
  0xF0, 0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x81, 0xF8, 0x0F, 0xE0, 0x3F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x0F, 0x80,
  0xF8, 0x03, 0xE0, 0x7E, 0x00, 0xF8, 0x3F, 0x00, 0x3E, 0x1F, 0x80, 0x0F,
  0x87, 0xC0, 0x03, 0xC3, 0xE0, 0x01, 0xF1, 0xF0, 0x00, 0x7C, 0x7C, 0x00,
  0x1F, 0x1F, 0x00, 0x07, 0xC7, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x03,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xF0, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x0F, 0xE0, 0x03, 0xE7,
  0xFF, 0x00, 0x7D, 0xFF, 0xF0, 0x0F, 0x7F, 0xFF, 0x03, 0xFF, 0x3F, 0xE0,
  0x7F, 0x00, 0xFE, 0x0F, 0xC0, 0x0F, 0xC1, 0xF0, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x1E, 0x00, 0x07, 0xC3, 0xC0, 0x01, 0xF0, 0x7C,
  0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x81, 0xFC, 0x07, 0xF0, 0x1F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0xBF, 0xE0, 0x07, 0xDF, 0xFE, 0x03, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xF0, 0x7F, 0x00, 0xFE, 0x3F, 0x00, 0x1F, 0x8F, 0x80,
  0x03, 0xE7, 0xE0, 0x00, 0xF9, 0xF0, 0x00, 0x3F, 0x7C, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xEF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x0F,
  0xBE, 0x00, 0x03, 0xEF, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0x7C, 0xFC, 0x00,
  0x3E, 0x1F, 0x80, 0x1F, 0x87, 0xF0, 0x1F, 0xC0, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x80, 0x00,
  0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFE, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xCF, 0x80, 0x01, 0xF3, 0xE0,
  0x00, 0xF8, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xE3, 0xFC,
  0x07, 0xE0, 0x1F, 0x80, 0xF8, 0x01, 0xF8, 0x3E, 0x00, 0x1F, 0x07, 0xC0,
  0x03, 0xE0, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xE0,
  0xF8, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x01, 0xF0, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0xBF, 0x80, 0x03, 0xFF, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x01, 0xFC, 0x7F,
  0x00, 0x7E, 0x03, 0xF0, 0x1F, 0x00, 0x3F, 0x07, 0xC0, 0x03, 0xE0, 0xF8,
  0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x1E,
  0x3E, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x1F, 0x1F, 0x80,
  0x07, 0xC1, 0xF0, 0x01, 0xF8, 0x3F, 0x80, 0xFE, 0x03, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFC, 0x0F, 0xF8, 0xFF, 0x03, 0xF0, 0x0F, 0xE1, 0xF8, 0x00,
  0xF8, 0xFC, 0x00, 0x3F, 0x3E, 0x00, 0x07, 0xDF, 0x00, 0x01, 0xF7, 0xC0,
  0x00, 0x7D, 0xF0, 0x00, 0x1F, 0x7C, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFB, 0xE0, 0x00, 0x3E, 0xFC, 0x00, 0x0F, 0xBF, 0x00, 0x07,
  0xC7, 0xC0, 0x03, 0xF1, 0xF8, 0x01, 0xF8, 0x7F, 0x81, 0xFE, 0x0F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFB, 0xE0, 0x03, 0xF9, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xE0, 0x7F, 0x83, 0xFC, 0x1F, 0xF1, 0xFF, 0x07, 0xF8, 0x3F, 0x80,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x10, 0x07, 0xE0, 0x7F, 0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0xF0, 0x3F,
  0x00, 0x60, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x03, 0xFF,
  0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x00,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x60, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x00, 0x08, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF,
  0xF0, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00,
  0x0F, 0xC0, 0x00, 0xFE, 0x03, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xC0,
  0x07, 0xF8, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x01,
  0xF0, 0x03, 0xE0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x01, 0xE0, 0x78, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x00, 0x78, 0x3C, 0x00,
  0xFE, 0x3C, 0x1E, 0x00, 0xFF, 0x9E, 0x0F, 0x00, 0xFF, 0xEF, 0x07, 0x80,
  0xFC, 0x3F, 0x07, 0xC0, 0xF8, 0x0F, 0x83, 0xE0, 0x7C, 0x07, 0xC1, 0xE0,
  0x3C, 0x03, 0xE0, 0xF0, 0x3E, 0x01, 0xF0, 0x78, 0x1F, 0x00, 0xF8, 0x3C,
  0x0F, 0x80, 0x78, 0x3E, 0x07, 0x80, 0x3C, 0x1F, 0x03, 0xC0, 0x1E, 0x0F,
  0x81, 0xE0, 0x0F, 0x07, 0x80, 0xF0, 0x07, 0x83, 0xC0, 0xF8, 0x07, 0xC1,
  0xE0, 0x7C, 0x03, 0xE0, 0xF0, 0x3E, 0x01, 0xE0, 0xF8, 0x1F, 0x01, 0xF0,
  0x7C, 0x0F, 0x81, 0xF8, 0x3C, 0x03, 0xFB, 0xFC, 0x1E, 0x01, 0xFF, 0xDE,
  0x0F, 0x00, 0x7F, 0xCF, 0x07, 0x80, 0x1F, 0x80, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x17,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1E, 0xF0, 0x00, 0x07, 0xDE, 0x00,
  0x00, 0xFB, 0xC0, 0x00, 0x1E, 0x78, 0x00, 0x07, 0xCF, 0x00, 0x00, 0xF1,
  0xE0, 0x00, 0x3E, 0x3C, 0x00, 0x07, 0xC7, 0xC0, 0x01, 0xF0, 0xF8, 0x00,
  0x3E, 0x1F, 0x00, 0x07, 0x83, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x07,
  0x80, 0x0F, 0x80, 0xF0, 0x01, 0xF0, 0x1E, 0x00, 0x7C, 0x03, 0xC0, 0x0F,
  0x80, 0x78, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E,
  0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x1F, 0x00, 0x07, 0x83, 0xE0, 0x00, 0xF0,
  0xFC, 0x00, 0x1F, 0x1F, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x7C, 0xF8, 0x00,
  0x0F, 0x9F, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x78, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x07, 0xC0, 0x1F, 0xE0, 0x7C, 0x00, 0x7E,
  0x07, 0xC0, 0x03, 0xE0, 0x78, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE0, 0xF8,
  0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x07,
  0xC0, 0xF0, 0x00, 0x7C, 0x0F, 0x00, 0x0F, 0x81, 0xF0, 0x03, 0xF0, 0x1F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFE, 0x03, 0xE0, 0x03, 0xF0, 0x3E, 0x00, 0x1F, 0x83,
  0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0xF8, 0x3C, 0x00,
  0x0F, 0x87, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0xF8,
  0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x78, 0x00, 0x3F, 0x0F, 0x80,
  0x0F, 0xE0, 0xF8, 0x07, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xEF,
  0xF8, 0x0F, 0xC0, 0x1F, 0x81, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x0F,
  0x80, 0x07, 0xC3, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x7C, 0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x1F,
  0x00, 0x0F, 0x83, 0xF0, 0x03, 0xE0, 0x3F, 0x01, 0xFC, 0x07, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7C, 0x01, 0xFC, 0x0F, 0x80, 0x1F, 0x81,
  0xF0, 0x01, 0xF8, 0x3C, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE1, 0xF0, 0x00,
  0x7C, 0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x3C, 0x1F,
  0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x07,
  0xC3, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC1, 0xE0,
  0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0x7C,
  0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x7C, 0x3E, 0x00,
  0x0F, 0x87, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x83,
  0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x1F, 0x00, 0x3F, 0x83, 0xE0, 0x3F,
  0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xF0, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xC0, 0x3F, 0xEF, 0xF8, 0x0F, 0xC0, 0x1F, 0x81, 0xF0, 0x01, 0xF0, 0x7C,
  0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x1F,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0xFF, 0xF8, 0xF8, 0x1F,
  0xFF, 0x1F, 0x03, 0xFF, 0xC3, 0xE0, 0xFF, 0xF8, 0x7C, 0x00, 0x1F, 0x0F,
  0x80, 0x03, 0xE1, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x8F, 0x80, 0x01,
  0xE1, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF0, 0xF8,
  0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x83, 0xF0, 0x03, 0xE0, 0x3F, 0x01, 0xFC,
  0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x01, 0xF0, 0x3C, 0x00,
  0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0,
  0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x0F, 0x80,
  0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x7C,
  0x0F, 0x80, 0x07, 0xC0, 0xF8, 0x00, 0x7C, 0x0F, 0x00, 0x07, 0xC1, 0xF0,
  0x00, 0x7C, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x83, 0xE0, 0x00, 0xF8, 0x3E,
  0x00, 0x0F, 0x83, 0xE0, 0x00, 0xF0, 0x3E, 0x00, 0x1F, 0x03, 0xE0, 0x01,
  0xF0, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x07,
  0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00,
  0x3E, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE0,
  0xF8, 0x00, 0x3C, 0x0F, 0x80, 0x07, 0xC0, 0xF8, 0x00, 0x7C, 0x00, 0x03,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFE, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x7C, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF0,
  0x1F, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x3F, 0x01, 0xF8, 0x01, 0xF8, 0x07,
  0xF0, 0x0F, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x7E, 0x07, 0x80, 0x01, 0xF0, 0x1F, 0x00, 0x07, 0xE0, 0x3E, 0x00,
  0x0F, 0x80, 0x7C, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0xFC, 0x01, 0xF0, 0x03,
  0xF0, 0x03, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x7E,
  0x00, 0x3E, 0x00, 0xF8, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0xF8, 0x0F, 0xC0,
  0x01, 0xF0, 0x1F, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x0F, 0x81, 0xF8, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x0F,
  0x80, 0xF8, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x7C,
  0x03, 0xE0, 0x00, 0xF0, 0x07, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0,
  0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x7C, 0x03, 0xE0, 0x00,
  0xF8, 0x07, 0xC0, 0x01, 0xF8, 0x0F, 0x80, 0x01, 0xF0, 0x1F, 0x00, 0x03,
  0xE0, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03,
  0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x3D, 0xC1, 0xFE,
  0x00, 0xFF, 0x07, 0xF8, 0x07, 0xB8, 0x1F, 0xE0, 0x1E, 0xE0, 0x7B, 0x80,
  0xFF, 0x81, 0xCF, 0x03, 0xDE, 0x07, 0x3C, 0x0F, 0x78, 0x3C, 0xF0, 0x79,
  0xE0, 0xF3, 0xC1, 0xEF, 0x03, 0xCF, 0x0F, 0x3C, 0x0F, 0x1C, 0x3C, 0xF0,
  0x3C, 0x71, 0xE3, 0xC0, 0xF1, 0xE7, 0x9F, 0x07, 0xC7, 0xBC, 0x7C, 0x1F,
  0x1E, 0xF1, 0xF0, 0x7C, 0x7B, 0x87, 0x81, 0xF0, 0xFE, 0x1E, 0x07, 0x83,
  0xF0, 0xF8, 0x1E, 0x0F, 0xC3, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0x00,
  0x3E, 0x0F, 0x80, 0x00, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F,
  0x03, 0xC0, 0x00, 0x7C, 0x0F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xC1,
  0xF0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x78, 0x1F, 0x00, 0x03, 0xE0, 0x7C,
  0x00, 0x0F, 0x81, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xF8, 0x3E, 0x00,
  0x03, 0xC0, 0xF8, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x78, 0x1F, 0xE0, 0x07, 0xC0, 0xFF, 0x00,
  0x3E, 0x07, 0xF8, 0x01, 0xF0, 0x3F, 0xC0, 0x0F, 0x81, 0xFE, 0x00, 0x7C,
  0x0F, 0xF8, 0x03, 0xC0, 0xFF, 0xC0, 0x3E, 0x07, 0xDE, 0x01, 0xF0, 0x3E,
  0xF0, 0x0F, 0x81, 0xF7, 0x80, 0x7C, 0x0F, 0x3E, 0x03, 0xE0, 0x79, 0xF0,
  0x1E, 0x03, 0xC7, 0x80, 0xF0, 0x3E, 0x3C, 0x0F, 0x81, 0xF1, 0xE0, 0x7C,
  0x0F, 0x8F, 0x83, 0xE0, 0x7C, 0x7C, 0x1F, 0x03, 0xC1, 0xE0, 0xF0, 0x1E,
  0x0F, 0x07, 0x81, 0xF0, 0x78, 0x7C, 0x0F, 0x83, 0xE3, 0xE0, 0x7C, 0x1F,
  0x1F, 0x03, 0xE0, 0x78, 0xF8, 0x1F, 0x03, 0xC7, 0x80, 0xF0, 0x1E, 0x3C,
  0x0F, 0x80, 0xF9, 0xE0, 0x7C, 0x07, 0xDF, 0x03, 0xE0, 0x1E, 0xF8, 0x1F,
  0x00, 0xF7, 0xC0, 0xF8, 0x07, 0xBE, 0x07, 0x80, 0x3F, 0xE0, 0x3C, 0x01,
  0xFF, 0x03, 0xE0, 0x07, 0xF8, 0x1F, 0x00, 0x3F, 0xC0, 0xF8, 0x01, 0xFE,
  0x07, 0xC0, 0x0F, 0xF0, 0x3C, 0x00, 0x7F, 0x03, 0xE0, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFC, 0x03, 0xFE, 0xFF, 0x81, 0xF8, 0x07, 0xE0, 0x7C, 0x00, 0xFC, 0x3E,
  0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC7, 0xC0, 0x01, 0xF1, 0xF0, 0x00, 0x7C,
  0x7C, 0x00, 0x1F, 0x1F, 0x00, 0x07, 0xC7, 0x80, 0x01, 0xE3, 0xE0, 0x00,
  0xF8, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xE3, 0xE0,
  0x00, 0xF8, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x1F, 0x00, 0x07, 0xC7,
  0xC0, 0x01, 0xF1, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x1F, 0x00, 0x07,
  0xC7, 0x80, 0x01, 0xE3, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x3E, 0x3E, 0x00,
  0x0F, 0x8F, 0x80, 0x03, 0xE3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x3E,
  0x00, 0x3F, 0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0x7F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7C, 0x00, 0x7F, 0x03, 0xE0, 0x01, 0xF8,
  0x1F, 0x00, 0x07, 0xE0, 0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0xF8, 0x7C,
  0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x00,
  0x1F, 0x07, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C,
  0x1F, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x0F,
  0xFF, 0xFC, 0x01, 0xFF, 0x3F, 0xC0, 0x3F, 0x00, 0xFE, 0x07, 0xE0, 0x07,
  0xE0, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x0F,
  0x80, 0x03, 0xE1, 0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x03, 0xE1, 0xF0, 0x00,
  0x3E, 0x1F, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x03, 0xC3,
  0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x3E, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF8,
  0x7C, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x87, 0xC0,
  0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x87, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F,
  0x0F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0xE0, 0x7E,
  0x00, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x07, 0xC0, 0x0F,
  0xE0, 0x7C, 0x00, 0x3F, 0x07, 0xC0, 0x03, 0xF0, 0x78, 0x00, 0x1F, 0x0F,
  0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00,
  0x1F, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x03, 0xE1,
  0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0xC1, 0xF0, 0x07, 0xF8, 0x1F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00,
  0x3E, 0x07, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x3E, 0x03, 0xE0, 0x03, 0xE0,
  0x3F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF8,
  0x07, 0xC0, 0x0F, 0x80, 0x7C, 0x00, 0xF8, 0x07, 0xC0, 0x0F, 0xC0, 0x7C,
  0x00, 0x7C, 0x0F, 0x80, 0x07, 0xC0, 0xF8, 0x00, 0x7E, 0x0F, 0x80, 0x07,
  0xE0, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xF0, 0xF8, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xC0, 0x0F, 0xF9, 0xFE, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xC0,
  0x07, 0xC0, 0x7C, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0xF0, 0x3E, 0x00, 0x07,
  0x81, 0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE1, 0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x83,
  0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0xC0, 0x7F, 0x01, 0xFC, 0x03, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x1F,
  0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x7C,
  0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x03,
  0xE0, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x0F,
  0x80, 0x07, 0xC0, 0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x7C, 0x1F, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0xF8, 0x3E, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0x03, 0xE0, 0x01, 0xF0,
  0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x07, 0xC0,
  0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x7E,
  0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x02, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x3E, 0x7C,
  0x00, 0x07, 0xCF, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x07,
  0xC7, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x0F, 0x00, 0x07, 0x81, 0xE0,
  0x01, 0xF0, 0x3E, 0x00, 0x3E, 0x07, 0xC0, 0x0F, 0x80, 0xF8, 0x01, 0xF0,
  0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x1E, 0x03, 0xE0, 0x03, 0xC0, 0x7C, 0x00,
  0x78, 0x0F, 0x00, 0x0F, 0x83, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x1F,
  0x00, 0x07, 0xC3, 0xE0, 0x00, 0xF8, 0x78, 0x00, 0x1F, 0x1F, 0x00, 0x03,
  0xE3, 0xE0, 0x00, 0x3C, 0xF8, 0x00, 0x07, 0x9F, 0x00, 0x00, 0xF3, 0xC0,
  0x00, 0x1E, 0xF8, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7C, 0x07, 0xE0, 0x3E, 0xF8, 0x0F, 0xC0, 0x79, 0xF0, 0x1F, 0x80,
  0xF3, 0xE0, 0x7F, 0x03, 0xE7, 0xC0, 0xEE, 0x07, 0xCF, 0x01, 0xF8, 0x0F,
  0x1E, 0x03, 0xF0, 0x1E, 0x3C, 0x0E, 0xE0, 0x7C, 0x78, 0x1D, 0xC0, 0xF0,
  0xF0, 0x3B, 0x81, 0xE1, 0xE0, 0xF7, 0x03, 0xC3, 0xC1, 0xCE, 0x0F, 0x87,
  0x83, 0x9C, 0x1E, 0x0F, 0x07, 0x38, 0x3C, 0x1E, 0x1C, 0x70, 0x78, 0x3C,
  0x38, 0xE1, 0xF0, 0xF8, 0x71, 0xC3, 0xC1, 0xF1, 0xE3, 0x87, 0x83, 0xE3,
  0x87, 0x1F, 0x07, 0xC7, 0x0E, 0x3C, 0x0F, 0x8E, 0x1C, 0x78, 0x1F, 0x3C,
  0x38, 0xF0, 0x3C, 0x70, 0x73, 0xE0, 0x78, 0xE0, 0xE7, 0x80, 0xF3, 0xC1,
  0xCF, 0x01, 0xE7, 0x03, 0x9E, 0x03, 0xCE, 0x0F, 0x7C, 0x07, 0x9C, 0x1E,
  0xF0, 0x0F, 0x78, 0x39, 0xE0, 0x1E, 0xE0, 0x73, 0xC0, 0x3D, 0xC0, 0xEF,
  0x00, 0x7B, 0x81, 0xDE, 0x00, 0xFE, 0x03, 0xBC, 0x01, 0xFC, 0x07, 0x78,
  0x03, 0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x1F, 0xC0, 0x0F, 0xC0, 0x3F, 0x80,
  0x1F, 0x80, 0x7E, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0xC0, 0x7E, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x03, 0xE0, 0x03, 0xE0,
  0x01, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x07,
  0xE0, 0x1F, 0x80, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x3E, 0x03, 0xE0, 0x00,
  0x07, 0xC1, 0xF0, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x00, 0x7C, 0x3E, 0x00,
  0x00, 0x0F, 0x9F, 0x00, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x7D, 0xF0, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x1F, 0x9F, 0x00, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x01, 0xF8, 0x1F, 0x00,
  0x00, 0x7C, 0x07, 0xC0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x3E,
  0x00, 0x0F, 0xC0, 0x0F, 0x80, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0x7C, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x1F, 0x00,
  0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x3E, 0x7C, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x0F,
  0x83, 0xE0, 0x01, 0xF8, 0x3E, 0x00, 0x1F, 0x03, 0xE0, 0x03, 0xE0, 0x1F,
  0x00, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x00, 0xF8, 0x0F,
  0x80, 0x0F, 0x81, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00,
  0x7C, 0x7C, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x3C, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0xFF, 0x80, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x01, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0,
  0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x1F, 0xFF, 0x80,
  0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3D, 0xE0, 0x00,
  0x7D, 0xE0, 0x00, 0x78, 0xE0, 0x00, 0xF0, 0xF0, 0x01, 0xF0, 0xF0, 0x01,
  0xE0, 0xF0, 0x03, 0xE0, 0x78, 0x07, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x0F,
  0x80, 0x7C, 0x0F, 0x00, 0x3C, 0x1F, 0x00, 0x3C, 0x3E, 0x00, 0x3C, 0x3C,
  0x00, 0x1E, 0x7C, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0xF0, 0x00, 0x1F, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xE0, 0xFC, 0x0F, 0x83, 0xE0, 0x7C, 0x0F, 0x03, 0xE0, 0x7C, 0x00, 0x3F,
  0xC3, 0xE0, 0x1F, 0xFC, 0x7C, 0x07, 0xFF, 0xCF, 0x01, 0xFF, 0xFF, 0xE0,
  0x7F, 0x03, 0xFC, 0x1F, 0x80, 0x3F, 0x83, 0xE0, 0x03, 0xF0, 0xF8, 0x00,
  0x7E, 0x1F, 0x00, 0x0F, 0xC3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x1F,
  0x00, 0x07, 0xC3, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x03,
  0xE1, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE1, 0xF0,
  0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x7C,
  0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0xFE, 0x0F, 0xE0,
  0x3F, 0xC0, 0xFF, 0xFE, 0xF8, 0x1F, 0xFF, 0x9F, 0x01, 0xFF, 0xE7, 0xC0,
  0x0F, 0xF8, 0xF8, 0x00, 0x30, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE1, 0xFE, 0x00, 0xF8, 0xFF, 0xE0, 0x3E, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x03, 0xDC, 0x0F, 0xE1, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0x3E, 0x1F,
  0x80, 0x0F, 0x87, 0xC0, 0x03, 0xF1, 0xF0, 0x00, 0x78, 0x7C, 0x00, 0x3E,
  0x1E, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xE3, 0xE0, 0x00, 0xF8, 0xF8, 0x00,
  0x3E, 0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xC3, 0xC0, 0x01, 0xF1, 0xF0,
  0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x1F, 0x00, 0x07, 0xC7, 0xC0, 0x01, 0xF1,
  0xF0, 0x00, 0xF8, 0x7E, 0x00, 0x7E, 0x3F, 0x80, 0x1F, 0x0F, 0xF0, 0x1F,
  0xC3, 0xEF, 0xFF, 0xE0, 0xFB, 0xFF, 0xF0, 0x3E, 0x7F, 0xF8, 0x0F, 0x8F,
  0xF8, 0x00, 0x00, 0x20, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xFC, 0x00,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0xFE, 0x07, 0xF0, 0xFC, 0x00, 0xF8,
  0x7C, 0x00, 0x7E, 0x7E, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0x9F, 0x00, 0x07,
  0xDF, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x03, 0xE7, 0xC0,
  0x01, 0xF3, 0xE0, 0x01, 0xF9, 0xF0, 0x00, 0xF8, 0xFC, 0x00, 0xFC, 0x3F,
  0x01, 0xFC, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00,
  0x3F, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x03, 0xFC, 0x3E, 0x00, 0xFF, 0xE3, 0xE0, 0x1F, 0xFF, 0x3E,
  0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0x03, 0xFC, 0x0F, 0xC0, 0x1F, 0xC0, 0xF8,
  0x00, 0xFC, 0x1F, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0xFC, 0x1F, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0xF8, 0x3E,
  0x00, 0x0F, 0x83, 0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0x03, 0xC0, 0x01,
  0xF0, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x07,
  0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00,
  0x7E, 0x07, 0xE0, 0x0F, 0xE0, 0x7F, 0x01, 0xFE, 0x03, 0xFF, 0xFB, 0xE0,
  0x3F, 0xFF, 0x3E, 0x01, 0xFF, 0xE7, 0xC0, 0x07, 0xFC, 0x7C, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xC0, 0xFC, 0x07, 0xF0, 0xFC, 0x00, 0xF8, 0x7C, 0x00, 0x7C,
  0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x1E, 0x00, 0x07, 0x9F, 0x00, 0x03,
  0xCF, 0x80, 0x03, 0xE7, 0xC0, 0x01, 0xF3, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFE, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x01, 0xF1, 0xF0, 0x00, 0xF8, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x1F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xF8, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x87, 0xC0, 0x7F, 0xF1, 0xF0, 0x3F, 0xFE, 0x78,
  0x1F, 0xFF, 0xFE, 0x0F, 0xE0, 0x7F, 0x87, 0xE0, 0x0F, 0xE1, 0xF0, 0x01,
  0xF8, 0xFC, 0x00, 0x7E, 0x3E, 0x00, 0x1F, 0x8F, 0x80, 0x07, 0xC3, 0xC0,
  0x01, 0xF1, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x1F, 0x00, 0x07, 0xC7,
  0xC0, 0x01, 0xF1, 0xF0, 0x00, 0x78, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x0F,
  0x8F, 0x80, 0x03, 0xE3, 0xE0, 0x00, 0xF8, 0xFC, 0x00, 0x7E, 0x3F, 0x00,
  0x3F, 0x07, 0xE0, 0x1B, 0xC1, 0xFE, 0x1F, 0xF0, 0x3F, 0xFF, 0x7C, 0x0F,
  0xFF, 0xDF, 0x01, 0xFF, 0xC7, 0xC0, 0x1F, 0xC1, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE1, 0xFE, 0x00, 0xF9, 0xFF, 0xE0,
  0x3E, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xDC, 0x0F, 0xE1, 0xFC, 0x01,
  0xF8, 0x7E, 0x00, 0x3E, 0x1F, 0x80, 0x0F, 0xC7, 0xC0, 0x03, 0xF1, 0xF0,
  0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x1E, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xE3,
  0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x0F, 0x80, 0x07,
  0xC3, 0xC0, 0x01, 0xF1, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x1F, 0x00,
  0x07, 0xC7, 0xC0, 0x01, 0xF1, 0xF0, 0x00, 0xF8, 0x78, 0x00, 0x3E, 0x3E,
  0x00, 0x0F, 0x8F, 0x80, 0x03, 0xE3, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x3E,
  0x3E, 0x00, 0x0F, 0x0F, 0x80, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x0F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x0F, 0xC3, 0xE0, 0x00, 0xFC, 0x1F, 0x00, 0x0F, 0xC0, 0xF8, 0x00,
  0xFC, 0x07, 0xC0, 0x0F, 0xC0, 0x3E, 0x00, 0x7C, 0x03, 0xE0, 0x07, 0xC0,
  0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x07, 0xE0, 0x07, 0xC0, 0x7E, 0x00, 0x3E,
  0x07, 0xE0, 0x01, 0xF0, 0x7E, 0x00, 0x0F, 0x07, 0xE0, 0x00, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00,
  0x0F, 0x83, 0xF0, 0x00, 0x78, 0x0F, 0x80, 0x07, 0xC0, 0x7E, 0x00, 0x3E,
  0x01, 0xF0, 0x01, 0xF0, 0x0F, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x01,
  0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x3E, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0xF8,
  0x0F, 0x80, 0x07, 0xE0, 0x7C, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0xFC, 0x00,
  0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x07, 0x8F, 0x83, 0xE0, 0x1E, 0xFF, 0x3F,
  0xC0, 0x7B, 0xFD, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x0F, 0x83, 0xF0, 0xF8,
  0x3E, 0x0F, 0x81, 0xE0, 0xF8, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x1E, 0x0F,
  0x03, 0xC0, 0xF8, 0x7C, 0x0F, 0x03, 0xE1, 0xF0, 0x3C, 0x0F, 0x87, 0xC0,
  0xF0, 0x3C, 0x1E, 0x03, 0xC0, 0xF0, 0x78, 0x1E, 0x03, 0xC1, 0xE0, 0x78,
  0x1F, 0x0F, 0x81, 0xE0, 0x7C, 0x3E, 0x07, 0x81, 0xF0, 0xF8, 0x1E, 0x07,
  0x83, 0xE0, 0x78, 0x1E, 0x0F, 0x01, 0xC0, 0x78, 0x3C, 0x0F, 0x03, 0xE0,
  0xF0, 0x3C, 0x0F, 0x87, 0xC0, 0xF0, 0x3E, 0x1F, 0x03, 0xC0, 0xF0, 0x7C,
  0x0F, 0x03, 0xC1, 0xE0, 0x38, 0x0F, 0x07, 0x81, 0xE0, 0x3C, 0x1E, 0x07,
  0x81, 0xF0, 0xF8, 0x1E, 0x07, 0xC3, 0xE0, 0x78, 0x1F, 0x00, 0x0F, 0x87,
  0xF8, 0x03, 0xE7, 0xFF, 0x80, 0xFB, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x0F,
  0x70, 0x3F, 0x87, 0xF0, 0x07, 0xE1, 0xF8, 0x00, 0xF8, 0x7E, 0x00, 0x3F,
  0x1F, 0x00, 0x0F, 0xC7, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x78, 0x00,
  0x3E, 0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xE3, 0xE0, 0x00, 0xF8, 0xF8,
  0x00, 0x3C, 0x3E, 0x00, 0x1F, 0x0F, 0x00, 0x07, 0xC7, 0xC0, 0x01, 0xF1,
  0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x1F, 0x00, 0x07, 0xC7, 0xC0, 0x03,
  0xE1, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x8F, 0x80,
  0x03, 0xE3, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x3C, 0x3E, 0x00, 0x1F, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xC0, 0xFE, 0x0F, 0xF0, 0xFC, 0x01, 0xF8, 0x7C, 0x00, 0x7C, 0x7C, 0x00,
  0x3E, 0x3E, 0x00, 0x1F, 0x1F, 0x00, 0x07, 0x9F, 0x00, 0x07, 0xCF, 0x80,
  0x03, 0xE7, 0xC0, 0x01, 0xF3, 0xE0, 0x00, 0xF9, 0xF0, 0x00, 0x7C, 0xF8,
  0x00, 0x3E, 0x78, 0x00, 0x1E, 0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0x9F,
  0x00, 0x07, 0xCF, 0x80, 0x03, 0xE7, 0xC0, 0x01, 0xE3, 0xE0, 0x01, 0xF1,
  0xF0, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0x3F, 0x01, 0xF8, 0x1F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0x00,
  0x00, 0x03, 0xE1, 0xFE, 0x00, 0x3E, 0x7F, 0xF8, 0x03, 0xEF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFC, 0x03, 0xDC, 0x0F, 0xE0, 0x7F, 0x00, 0x7E, 0x07, 0xE0,
  0x03, 0xE0, 0x7E, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x1E,
  0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE0, 0xF8,
  0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x03,
  0xC0, 0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x7C, 0x1F,
  0x00, 0x07, 0xC1, 0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x81, 0xF8, 0x01,
  0xF8, 0x3F, 0x80, 0x1F, 0x03, 0xFC, 0x07, 0xF0, 0x3E, 0xFF, 0xFE, 0x03,
  0xEF, 0xFF, 0xC0, 0x3E, 0x7F, 0xF8, 0x03, 0xE3, 0xFE, 0x00, 0x7C, 0x02,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xC3,
  0xE0, 0x1F, 0xFC, 0x7C, 0x07, 0xFF, 0xCF, 0x01, 0xFF, 0xFF, 0xE0, 0x7F,
  0x03, 0xFC, 0x1F, 0x80, 0x3F, 0x83, 0xE0, 0x03, 0xF0, 0xF8, 0x00, 0x7E,
  0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x1F, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE1,
  0xF0, 0x00, 0xF8, 0x3C, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE1, 0xF0, 0x00,
  0x7C, 0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x1F,
  0x00, 0x0F, 0x83, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0xFE, 0x0F, 0xE0, 0x3F,
  0xC0, 0xFF, 0xFE, 0xF8, 0x1F, 0xFF, 0x9E, 0x01, 0xFF, 0xE7, 0xC0, 0x1F,
  0xF8, 0xF8, 0x00, 0x30, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x0F, 0x87, 0xF8, 0x03, 0xE7, 0xFF, 0x80, 0xFB, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFE, 0x0F, 0x70, 0x3F, 0x87, 0xF0, 0x03, 0xE1, 0xF8, 0x00, 0xFC, 0x7E,
  0x00, 0x1F, 0x1F, 0x00, 0x07, 0xC7, 0xC0, 0x01, 0xF1, 0xF0, 0x00, 0x7C,
  0x78, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFE, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x03, 0xF0, 0xF8, 0x00,
  0x7C, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0xF8, 0xFC, 0x00, 0x3E, 0x1F,
  0x80, 0x3F, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0,
  0x03, 0xFF, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00,
  0x1F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0x80, 0x03, 0xE1, 0xF0, 0x00,
  0x7C, 0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xE0, 0xF0, 0x00, 0x7C, 0x3E,
  0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x07,
  0xC3, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0xC3, 0xE0,
  0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0x78,
  0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x3E, 0x00,
  0x0F, 0x87, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x83,
  0xE0, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x08, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x07,
  0xDF, 0x00, 0x03, 0xEF, 0x80, 0x03, 0xE7, 0xC0, 0x01, 0xF1, 0xE0, 0x00,
  0xF8, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x1F, 0x00,
  0x3E, 0x0F, 0x80, 0x3E, 0x03, 0xC0, 0x1F, 0x01, 0xE0, 0x1F, 0x00, 0xF8,
  0x0F, 0x80, 0x7C, 0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x07,
  0x83, 0xE0, 0x03, 0xC3, 0xE0, 0x01, 0xF1, 0xF0, 0x00, 0xF8, 0xF0, 0x00,
  0x7C, 0xF8, 0x00, 0x3E, 0x78, 0x00, 0x0F, 0x7C, 0x00, 0x07, 0xBC, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0xF0, 0x0F, 0x80, 0x7F, 0x80, 0x7C, 0x07, 0xBC, 0x07, 0xE0, 0x3D,
  0xE0, 0x3F, 0x01, 0xEF, 0x01, 0xF8, 0x1E, 0x78, 0x1D, 0xC0, 0xF3, 0xC0,
  0xEE, 0x07, 0x9E, 0x07, 0x70, 0x3C, 0xF0, 0x7B, 0x83, 0xC7, 0x83, 0x9C,
  0x1E, 0x3C, 0x1C, 0xE0, 0xF1, 0xE0, 0xE7, 0x0F, 0x0F, 0x0E, 0x38, 0x78,
  0x78, 0x71, 0xC3, 0xC3, 0xC3, 0x8E, 0x3C, 0x1E, 0x38, 0x71, 0xE0, 0xF1,
  0xC3, 0x8F, 0x07, 0x8E, 0x1C, 0xF0, 0x3C, 0xE0, 0xE7, 0x81, 0xE7, 0x07,
  0x3C, 0x0F, 0x38, 0x39, 0xC0, 0x7B, 0x81, 0xDE, 0x03, 0xDC, 0x0E, 0xF0,
  0x1E, 0xE0, 0x77, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x3F,
  0x80, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x01,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0x80, 0x07, 0xE0, 0x3F, 0x00,
  0x1F, 0x00, 0x7C, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x03, 0xE0, 0x3F,
  0x00, 0x0F, 0x80, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x3F, 0x00,
  0x00, 0xF9, 0xF8, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xDF,
  0x00, 0x00, 0x3F, 0x3E, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x07, 0xC3, 0xF0,
  0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0x3E, 0x00,
  0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x01, 0xF0, 0x0F, 0x80, 0x07, 0xE0, 0x7E,
  0x00, 0x0F, 0x83, 0xF0, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x07, 0xC7, 0xC0,
  0x01, 0xF1, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x8F,
  0x80, 0x03, 0xE3, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x0F,
  0x8F, 0x80, 0x03, 0xC3, 0xE0, 0x01, 0xF1, 0xF0, 0x00, 0x7C, 0x7C, 0x00,
  0x1F, 0x1F, 0x00, 0x07, 0xC7, 0xC0, 0x01, 0xF1, 0xF0, 0x00, 0x78, 0x7C,
  0x00, 0x3E, 0x1E, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xE3, 0xE0, 0x00, 0xF8,
  0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x1F, 0xC1, 0xFE, 0x3F,
  0xF0, 0x3F, 0xFF, 0x7C, 0x0F, 0xFF, 0x9F, 0x00, 0xFF, 0xC7, 0xC0, 0x0F,
  0x81, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F,
  0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF,
  0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF,
  0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0xFF, 0x00, 0x3C, 0x7F, 0xF0, 0x0F, 0x8F, 0xFF, 0x01, 0xF3, 0xF7, 0xF0,
  0x3E, 0xF8, 0x3E, 0x07, 0xDF, 0x07, 0xE1, 0xF3, 0xC0, 0x7F, 0xFE, 0x78,
  0x07, 0xFF, 0x8F, 0x00, 0x7F, 0xE3, 0xE0, 0x07, 0xF8, 0x00, 0x00, 0x10,
  0x00,
};

const GFXglyph JetBrainsMono_Italic54pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 32, 0, -1 },
  { 1, 13, 39, 32, 10, -39 },
  { 65, 18, 16, 32, 10, -39 },
  { 101, 32, 39, 32, 1, -39 },
  { 257, 29, 55, 32, 2, -47 },
  { 457, 38, 40, 32, -2, -40 },
  { 647, 30, 41, 32, 1, -40 },
  { 801, 7, 16, 32, 15, -39 },
  { 815, 22, 53, 32, 9, -46 },
  { 961, 22, 53, 32, 3, -46 },
  { 1107, 28, 28, 32, 3, -33 },
  { 1205, 26, 26, 32, 4, -31 },
  { 1290, 14, 17, 32, 5, -8 },
  { 1320, 18, 4, 32, 8, -20 },
  { 1329, 9, 9, 32, 10, -8 },
  { 1340, 32, 51, 32, 1, -45 },
  { 1544, 28, 41, 32, 3, -40 },
  { 1688, 25, 39, 32, 2, -39 },
  { 1810, 27, 40, 32, 3, -40 },
  { 1945, 27, 40, 32, 3, -39 },
  { 2080, 26, 39, 32, 3, -39 },
  { 2207, 27, 40, 32, 3, -39 },
  { 2342, 26, 40, 32, 3, -39 },
  { 2472, 26, 39, 32, 7, -39 },
  { 2599, 27, 41, 32, 3, -40 },
  { 2738, 26, 40, 32, 5, -40 },
  { 2868, 13, 31, 32, 10, -30 },
  { 2919, 18, 39, 32, 5, -30 },
  { 3007, 26, 28, 32, 5, -32 },
  { 3098, 26, 17, 32, 4, -26 },
  { 3154, 26, 28, 32, 3, -32 },
  { 3245, 21, 39, 32, 8, -39 },
  { 3348, 33, 50, 32, 0, -40 },
  { 3555, 27, 39, 32, 0, -39 },
  { 3687, 28, 39, 32, 3, -39 },
  { 3824, 27, 41, 32, 4, -40 },
  { 3963, 27, 39, 32, 3, -39 },
  { 4095, 29, 39, 32, 3, -39 },
  { 4237, 29, 39, 32, 3, -39 },
  { 4379, 27, 41, 32, 4, -40 },
  { 4518, 28, 39, 32, 3, -39 },
  { 4655, 28, 39, 32, 3, -39 },
  { 4792, 30, 40, 32, 1, -39 },
  { 4942, 31, 39, 32, 3, -39 },
  { 5094, 23, 39, 32, 4, -39 },
  { 5207, 30, 39, 32, 2, -39 },
  { 5354, 29, 39, 32, 2, -39 },
  { 5496, 26, 41, 32, 4, -40 },
  { 5630, 29, 39, 32, 3, -39 },
  { 5772, 28, 50, 32, 3, -40 },
  { 5947, 28, 39, 32, 3, -39 },
  { 6084, 29, 41, 32, 2, -40 },
  { 6233, 27, 39, 32, 6, -39 },
  { 6365, 28, 40, 32, 3, -39 },
  { 6505, 27, 39, 32, 7, -39 },
  { 6637, 31, 39, 32, 4, -39 },
  { 6789, 34, 39, 32, 0, -39 },
  { 6955, 28, 39, 32, 6, -39 },
  { 7092, 29, 39, 32, 2, -39 },
  { 7234, 21, 51, 32, 8, -45 },
  { 7368, 16, 51, 32, 9, -45 },
  { 7470, 21, 51, 32, 5, -45 },
  { 7604, 24, 21, 32, 5, -39 },
  { 7667, 27, 4, 32, 0, 1 },
  { 7681, 10, 7, 32, 14, -42 },
  { 7690, 27, 31, 32, 3, -30 },
  { 7795, 26, 40, 32, 3, -39 },
  { 7925, 25, 31, 32, 4, -30 },
  { 8022, 28, 40, 32, 3, -39 },
  { 8162, 25, 31, 32, 4, -30 },
  { 8259, 37, 49, 32, -3, -39 },
  { 8486, 26, 40, 32, 4, -30 },
  { 8616, 26, 39, 32, 3, -39 },
  { 8743, 26, 42, 32, 2, -42 },
  { 8880, 28, 52, 32, 1, -42 },
  { 9062, 29, 39, 32, 3, -39 },
  { 9204, 23, 39, 32, 5, -39 },
  { 9317, 30, 30, 32, 1, -30 },
  { 9430, 26, 30, 32, 3, -30 },
  { 9528, 25, 31, 32, 4, -30 },
  { 9625, 28, 40, 32, 1, -30 },
  { 9765, 27, 40, 32, 3, -30 },
  { 9900, 26, 30, 32, 4, -30 },
  { 9998, 26, 31, 32, 3, -30 },
  { 10099, 25, 38, 32, 5, -38 },
  { 10218, 27, 31, 32, 3, -30 },
  { 10323, 25, 30, 32, 6, -30 },
  { 10417, 29, 30, 32, 4, -30 },
  { 10526, 30, 30, 32, 1, -30 },
  { 10639, 26, 40, 32, 4, -30 },
  { 10769, 27, 30, 32, 2, -30 },
  { 10871, 28, 51, 32, 5, -45 },
  { 11050, 13, 51, 32, 10, -45 },
  { 11133, 28, 51, 32, 1, -45 },
  { 11312, 27, 12, 32, 3, -25 },
};

const GFXfont JetBrainsMono_Italic54pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Italic54pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Italic54pt7bGlyphs,
  0x20, 0x7E, 71
};

#endif // _JETBRAINSMONO_ITALIC54PT7B_H_
