#ifndef _JETBRAINSMONO_ITALIC49PT7B_H_
#define _JETBRAINSMONO_ITALIC49PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Italic.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Italic49pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x07, 0x80,
  0x78, 0x07, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x07,
  0xE0, 0x7F, 0x0F, 0xF0, 0xFE, 0x07, 0xC0, 0x3E, 0x0F, 0x9E, 0x07, 0x9F,
  0x07, 0xCF, 0x83, 0xE7, 0xC1, 0xF3, 0xE0, 0xF9, 0xF0, 0x78, 0xF0, 0x3C,
  0x78, 0x1E, 0x3C, 0x0F, 0x1E, 0x0F, 0x9E, 0x07, 0x8F, 0x03, 0xC7, 0x81,
  0xE3, 0xC0, 0xF0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x38, 0x07, 0x00, 0x03,
  0xC0, 0x38, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0xE0, 0x1C, 0x00, 0x0F, 0x00,
  0xE0, 0x00, 0x78, 0x0F, 0x00, 0x03, 0x80, 0x70, 0x00, 0x3C, 0x07, 0x80,
  0x01, 0xE0, 0x3C, 0x03, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0x00, 0x38, 0x07, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x1C, 0x03,
  0xC0, 0x00, 0xE0, 0x1C, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x70, 0x0F, 0x00,
  0x03, 0x80, 0x70, 0x00, 0x3C, 0x07, 0x80, 0x01, 0xC0, 0x3C, 0x00, 0x1E,
  0x01, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xF8, 0x03, 0xC0, 0x78, 0x00, 0x1C, 0x03, 0xC0, 0x01, 0xE0, 0x1C, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0x70, 0x0F, 0x00, 0x07, 0x80, 0x70, 0x00, 0x3C,
  0x07, 0x80, 0x01, 0xC0, 0x3C, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0xF0, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF8, 0x0F, 0xCE, 0x7E, 0x03, 0xE3, 0x8F, 0x81, 0xF0, 0xE1, 0xF0,
  0x78, 0x38, 0x7C, 0x1E, 0x0E, 0x1F, 0x07, 0x83, 0x00, 0x03, 0xE1, 0xC0,
  0x00, 0xF8, 0x70, 0x00, 0x1F, 0x1C, 0x00, 0x07, 0xC7, 0x00, 0x01, 0xFD,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0E, 0x7E,
  0x00, 0x07, 0x0F, 0x80, 0x01, 0xC3, 0xE0, 0x00, 0x70, 0x78, 0x00, 0x1C,
  0x1E, 0x00, 0x07, 0x07, 0x87, 0x81, 0xC1, 0xE1, 0xE0, 0xE0, 0xF8, 0x78,
  0x38, 0x3C, 0x1F, 0x0E, 0x1F, 0x07, 0xE3, 0x8F, 0x80, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x07, 0x80, 0xFF, 0xC0, 0x07, 0x80, 0xFF, 0xE0, 0x03, 0x80, 0xF8, 0xF8,
  0x03, 0xC0, 0x78, 0x3C, 0x03, 0xC0, 0x38, 0x1E, 0x03, 0xC0, 0x3C, 0x0F,
  0x03, 0xC0, 0x1E, 0x07, 0x83, 0xC0, 0x0F, 0x03, 0xC1, 0xC0, 0x07, 0x01,
  0xC1, 0xC0, 0x03, 0x80, 0xE1, 0xE0, 0x01, 0xE0, 0xF1, 0xE0, 0x00, 0xF0,
  0xF9, 0xE0, 0x00, 0x7F, 0xF9, 0xE0, 0x00, 0x1F, 0xF8, 0xE0, 0x00, 0x07,
  0xF0, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x70, 0xFC, 0x00,
  0x00, 0x71, 0xFF, 0x80, 0x00, 0x79, 0xFF, 0xE0, 0x00, 0x79, 0xF1, 0xF0,
  0x00, 0x78, 0xF0, 0x78, 0x00, 0x78, 0x70, 0x3C, 0x00, 0x78, 0x78, 0x1E,
  0x00, 0x38, 0x3C, 0x0F, 0x00, 0x3C, 0x1E, 0x07, 0x80, 0x3C, 0x0F, 0x03,
  0xC0, 0x3C, 0x07, 0x01, 0xC0, 0x3C, 0x03, 0xC1, 0xE0, 0x3C, 0x01, 0xE1,
  0xF0, 0x1C, 0x00, 0xFF, 0xF0, 0x1E, 0x00, 0x3F, 0xF0, 0x1E, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0x80, 0x1F, 0x01, 0xF0, 0x03, 0xC0, 0x3E, 0x00, 0xF8,
  0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x0F, 0x8F, 0x9F, 0x01, 0xE3, 0xE1, 0xF0,
  0x7C, 0x78, 0x3E, 0x1F, 0x0F, 0x03, 0xE3, 0xC3, 0xE0, 0x3E, 0xF0, 0x7C,
  0x07, 0xFE, 0x0F, 0x80, 0x7F, 0x81, 0xE0, 0x0F, 0xE0, 0x3C, 0x00, 0xFC,
  0x07, 0x80, 0x1F, 0x00, 0xF0, 0x03, 0xF0, 0x1E, 0x00, 0xFE, 0x03, 0xE0,
  0x7F, 0xE0, 0x7F, 0x7F, 0xBE, 0x0F, 0xFF, 0xC7, 0xC0, 0xFF, 0xF0, 0x7C,
  0x07, 0xF8, 0x0F, 0xC0, 0x3D, 0xF7, 0xDF, 0x7D, 0xE7, 0xBE, 0xFB, 0xEF,
  0x3C, 0xF3, 0xCF, 0x00, 0x00, 0x00, 0x70, 0x00, 0x1F, 0x00, 0x07, 0xF0,
  0x00, 0xFF, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80,
  0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0x18, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0x7E, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x01, 0x80,
  0x78, 0x06, 0x7C, 0x1E, 0x0F, 0xBF, 0xC7, 0x0F, 0xEF, 0xF9, 0xCF, 0xFD,
  0xFF, 0xEF, 0xFC, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xEF, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x7C,
  0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x87, 0xE0, 0x07, 0xC0, 0xF8, 0x07,
  0xE0, 0x3F, 0x00, 0xF0, 0x07, 0x80, 0x18, 0x00, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF8, 0x3F, 0x01, 0xF8,
  0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x1F,
  0x00, 0xF8, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x0C, 0x3F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0x7C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xC0,
  0x7E, 0x03, 0xF0, 0x7E, 0x00, 0xF8, 0x3E, 0x00, 0x3C, 0x1E, 0x00, 0x1F,
  0x1F, 0x00, 0x0F, 0x8F, 0x00, 0x07, 0x87, 0x80, 0x03, 0xC3, 0xC0, 0x01,
  0xE3, 0xE0, 0x00, 0xF1, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x7C, 0x78, 0x38,
  0x3E, 0x3C, 0x3E, 0x1E, 0x1E, 0x3F, 0x0F, 0x0F, 0x1F, 0x87, 0x8F, 0x87,
  0xC3, 0xC7, 0x81, 0xC3, 0xE3, 0xC0, 0x01, 0xF1, 0xE0, 0x00, 0xF0, 0xF0,
  0x00, 0x78, 0x78, 0x00, 0x3C, 0x7C, 0x00, 0x1E, 0x3E, 0x00, 0x1F, 0x1E,
  0x00, 0x0F, 0x8F, 0x80, 0x07, 0x87, 0xC0, 0x07, 0xC3, 0xE0, 0x07, 0xC0,
  0xF8, 0x07, 0xE0, 0x7F, 0x9F, 0xE0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0xC0, 0x03, 0xFF, 0x80, 0x0F, 0xDE, 0x00, 0x7F, 0x3C, 0x01, 0xF8, 0x78,
  0x03, 0xE1, 0xF0, 0x07, 0x03, 0xE0, 0x1C, 0x07, 0xC0, 0x20, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF,
  0xFC, 0x03, 0xF0, 0x1F, 0x81, 0xF0, 0x03, 0xE0, 0x78, 0x00, 0xF8, 0x3E,
  0x00, 0x1E, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xE1, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x07,
  0x87, 0x80, 0x07, 0xC3, 0xC0, 0x03, 0xC1, 0xF0, 0x03, 0xE0, 0xFC, 0x03,
  0xE0, 0x3F, 0xDF, 0xE0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x3E, 0x07, 0xC0, 0x3C, 0x0F, 0x80, 0x3C, 0x1F, 0x00, 0x3C, 0x1F,
  0x00, 0x3C, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x78, 0x00, 0x7C, 0x78,
  0x00, 0x78, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xE0, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x02, 0x00, 0x1F, 0x3F, 0xE0, 0x1F, 0x7F, 0xF0, 0x1E,
  0xFF, 0xF8, 0x1F, 0xF3, 0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0x00, 0x7C, 0x3E,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x78, 0xF8, 0x00, 0x78, 0xF8, 0x00, 0xF8, 0xF8, 0x01, 0xF0, 0x7C,
  0x03, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xEF, 0xF0, 0x07,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x0F, 0xF1, 0xFE, 0x1F, 0x80, 0x7E, 0x1F,
  0x00, 0x3F, 0x3E, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C,
  0x00, 0x1F, 0x78, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0x78, 0x00, 0x1E, 0x78,
  0x00, 0x1E, 0x78, 0x00, 0x3E, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0xFC, 0x3E,
  0x01, 0xF8, 0x3F, 0xCF, 0xF0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x03,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFE, 0x78, 0x00, 0x3E, 0x78, 0x00, 0x3E, 0xF8, 0x00, 0x7C, 0xF8,
  0x00, 0x78, 0xF8, 0x00, 0xF8, 0xF0, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x1E,
  0x0F, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x07, 0xC1, 0xE0, 0x03,
  0xC0, 0xF0, 0x03, 0xE0, 0x7C, 0x01, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0xC3,
  0xF0, 0x03, 0xF7, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0xF8, 0x00, 0x7F, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x7C, 0x03, 0xE0, 0x7C,
  0x00, 0xF0, 0x7C, 0x00, 0x7C, 0x3C, 0x00, 0x3E, 0x1E, 0x00, 0x0F, 0x1F,
  0x00, 0x0F, 0x8F, 0x00, 0x07, 0xC7, 0x80, 0x03, 0xC3, 0xE0, 0x03, 0xE1,
  0xF0, 0x01, 0xF0, 0xFC, 0x03, 0xF0, 0x3F, 0xEF, 0xF0, 0x0F, 0xFF, 0xF0,
  0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x07, 0xFF,
  0xC0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC1, 0xF8, 0x0F, 0xC7, 0xE0, 0x0F,
  0x8F, 0x80, 0x0F, 0xBE, 0x00, 0x1F, 0x78, 0x00, 0x3F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xBE,
  0x00, 0x1F, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0xF9, 0xF8, 0x03, 0xF1, 0xFC,
  0x1F, 0xC3, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x01, 0xFE, 0xF8, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0xFE, 0x1F, 0xE1, 0xFE, 0x1F, 0xE0, 0xFC,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x07, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xE0, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0xFE,
  0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08,
  0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80,
  0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00,
  0x78, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x10,
  0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8,
  0x0C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xE0, 0x1F,
  0xFF, 0x01, 0xFF, 0xF8, 0x20, 0x7F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F,
  0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xC0, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x07,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x1F, 0xC1, 0xFC, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x3E,
  0x00, 0x07, 0x80, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x78, 0x1E, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x1E, 0x0F, 0x00, 0x3C,
  0x78, 0x3C, 0x03, 0xFD, 0xE1, 0xE0, 0x3F, 0xF7, 0x87, 0x80, 0xFC, 0xFE,
  0x1E, 0x07, 0xC0, 0xF0, 0x78, 0x1E, 0x03, 0xC1, 0xE0, 0xF0, 0x0F, 0x07,
  0x83, 0xC0, 0x3C, 0x3C, 0x0F, 0x00, 0xF0, 0xF0, 0x3C, 0x03, 0xC3, 0xC0,
  0xF0, 0x1E, 0x0F, 0x03, 0xC0, 0x78, 0x3C, 0x1E, 0x01, 0xE0, 0xF0, 0x78,
  0x07, 0x83, 0x81, 0xE0, 0x1E, 0x1E, 0x07, 0x80, 0xF8, 0x78, 0x1E, 0x03,
  0xC1, 0xE0, 0x7C, 0x1F, 0x07, 0x80, 0xFF, 0xDC, 0x1E, 0x03, 0xFE, 0xF0,
  0x78, 0x07, 0xF3, 0xC1, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3D, 0xE0, 0x00, 0x1E, 0xF0, 0x00,
  0x1E, 0x78, 0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x9E, 0x00, 0x07, 0x8F, 0x00,
  0x03, 0xC7, 0x80, 0x03, 0xC3, 0xC0, 0x01, 0xE1, 0xF0, 0x01, 0xF0, 0x78,
  0x00, 0xF0, 0x3C, 0x00, 0xF8, 0x1E, 0x00, 0x78, 0x0F, 0x00, 0x3C, 0x07,
  0x80, 0x3E, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x00,
  0x78, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xC1, 0xE0, 0x01, 0xE1, 0xF0, 0x00, 0xF0, 0xF8, 0x00, 0x78, 0x78,
  0x00, 0x3C, 0x7C, 0x00, 0x1E, 0x3C, 0x00, 0x0F, 0x3E, 0x00, 0x07, 0xDF,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xC0, 0x7F, 0x81, 0xF0,
  0x03, 0xE0, 0x78, 0x00, 0xF8, 0x1E, 0x00, 0x1E, 0x07, 0x80, 0x07, 0x81,
  0xE0, 0x01, 0xE0, 0xF8, 0x00, 0x78, 0x3E, 0x00, 0x3E, 0x0F, 0x00, 0x0F,
  0x03, 0xC0, 0x07, 0xC0, 0xF0, 0x03, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x78, 0x07, 0xF0, 0x1E,
  0x00, 0x7E, 0x07, 0x80, 0x0F, 0x81, 0xE0, 0x01, 0xE0, 0xF8, 0x00, 0x7C,
  0x3E, 0x00, 0x1F, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xE0, 0xF0, 0x00,
  0x78, 0x3C, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x0F, 0xC1, 0xE0,
  0x07, 0xE0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF,
  0x80, 0x7F, 0xFF, 0xC0, 0x7E, 0x03, 0xF0, 0x3E, 0x00, 0xF8, 0x3E, 0x00,
  0x3C, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x0F, 0x80, 0x07, 0x87, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x1F, 0x0F, 0x00, 0x0F, 0x87, 0x80, 0x07, 0x83, 0xC0, 0x07,
  0xC1, 0xF0, 0x07, 0xC0, 0xFC, 0x07, 0xE0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xE0, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x01,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x7C, 0x07, 0xF0,
  0x3E, 0x00, 0xFC, 0x1E, 0x00, 0x3E, 0x0F, 0x00, 0x1F, 0x07, 0x80, 0x07,
  0x83, 0xC0, 0x03, 0xC3, 0xE0, 0x01, 0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0x00,
  0xF8, 0x78, 0x00, 0x7C, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x1F, 0x00,
  0x0F, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0xC3, 0xC0, 0x03, 0xE1, 0xE0,
  0x01, 0xE0, 0xF0, 0x00, 0xF0, 0xF8, 0x00, 0x78, 0x7C, 0x00, 0x7C, 0x3E,
  0x00, 0x3E, 0x1E, 0x00, 0x1F, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x83,
  0xC0, 0x07, 0xC3, 0xE0, 0x07, 0xC1, 0xF0, 0x07, 0xE0, 0xF8, 0x07, 0xE0,
  0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x80, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF,
  0xC0, 0x7E, 0x03, 0xF0, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0x3C, 0x1E, 0x00,
  0x1E, 0x0F, 0x00, 0x0F, 0x0F, 0x80, 0x07, 0x87, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x07, 0xFF, 0x87,
  0x83, 0xFF, 0xC3, 0xC1, 0xFF, 0xE3, 0xE0, 0xFF, 0xF1, 0xF0, 0x00, 0xF0,
  0xF8, 0x00, 0x78, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x3E, 0x1E, 0x00, 0x1F,
  0x0F, 0x00, 0x0F, 0x87, 0x80, 0x07, 0x83, 0xC0, 0x07, 0xC1, 0xF0, 0x07,
  0xC0, 0xFC, 0x07, 0xE0, 0x7F, 0xDF, 0xE0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF,
  0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xE0, 0x03, 0xC0, 0xF0, 0x00, 0xF0,
  0x3C, 0x00, 0x3C, 0x0F, 0x00, 0x1F, 0x07, 0xC0, 0x07, 0xC1, 0xF0, 0x01,
  0xF0, 0x7C, 0x00, 0x78, 0x1E, 0x00, 0x1E, 0x07, 0x80, 0x07, 0x81, 0xE0,
  0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x03,
  0xC0, 0x03, 0xC0, 0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x3C, 0x1F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1E, 0x00,
  0x1E, 0x07, 0x80, 0x07, 0x81, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x3E,
  0x00, 0x3E, 0x0F, 0x00, 0x0F, 0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x00, 0xF0,
  0x3C, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x07, 0xC1, 0xF0, 0x01,
  0xE0, 0x78, 0x00, 0x78, 0x1E, 0x00, 0x1E, 0x07, 0x80, 0x07, 0x83, 0xE0,
  0x03, 0xE0, 0x03, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC1, 0xE0,
  0x00, 0xF8, 0x7C, 0x00, 0x1E, 0x0F, 0x80, 0x07, 0xC0, 0xF0, 0x00, 0xF8,
  0x1F, 0x00, 0x3E, 0x03, 0xF0, 0x0F, 0x80, 0x3F, 0xDF, 0xF0, 0x07, 0xFF,
  0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xC0, 0x01,
  0xF0, 0x3C, 0x00, 0x1F, 0x03, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x07,
  0xC0, 0x07, 0xC0, 0x7C, 0x00, 0xF8, 0x07, 0x80, 0x1F, 0x00, 0x78, 0x01,
  0xF0, 0x07, 0x80, 0x3E, 0x00, 0x78, 0x07, 0xC0, 0x0F, 0x80, 0x7C, 0x00,
  0xF8, 0x0F, 0x80, 0x0F, 0x81, 0xF0, 0x00, 0xF0, 0x1F, 0x00, 0x0F, 0x03,
  0xE0, 0x00, 0xF0, 0x7C, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0x80, 0x01, 0xE0, 0x7C, 0x00, 0x1E, 0x07, 0xC0, 0x01, 0xE0,
  0x7C, 0x00, 0x3E, 0x03, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x3E, 0x03, 0xE0,
  0x03, 0xC0, 0x1F, 0x00, 0x3C, 0x01, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x3C,
  0x00, 0xF8, 0x07, 0xC0, 0x0F, 0x80, 0x7C, 0x00, 0xF8, 0x07, 0x80, 0x07,
  0xC0, 0x78, 0x00, 0x7C, 0x07, 0x80, 0x03, 0xC0, 0x78, 0x00, 0x3E, 0x0F,
  0x80, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x00,
  0xFC, 0x1F, 0x80, 0x3F, 0x83, 0xF0, 0x07, 0xF0, 0x7F, 0x01, 0xFE, 0x1F,
  0xE0, 0x3F, 0x83, 0xFC, 0x0F, 0x70, 0x73, 0x81, 0xEE, 0x0E, 0x70, 0x7B,
  0xC1, 0xCE, 0x0F, 0x78, 0x39, 0xE3, 0xCF, 0x0F, 0x3C, 0x79, 0xC1, 0xE7,
  0x8E, 0x78, 0x3C, 0x73, 0xCF, 0x07, 0x8E, 0x71, 0xE0, 0xF1, 0xDE, 0x3C,
  0x1E, 0x3B, 0x87, 0x87, 0xC7, 0xF1, 0xE0, 0xF8, 0xFC, 0x3C, 0x1E, 0x0F,
  0x87, 0x83, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x3E, 0x0F, 0x00, 0x07, 0xC1,
  0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x1E, 0x0F, 0x80, 0x03, 0xC1, 0xE0, 0x00,
  0x78, 0x3C, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xE0, 0xF0, 0x00, 0x7C, 0x3E,
  0x00, 0x0F, 0x07, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x07,
  0x83, 0xC0, 0x01, 0xF0, 0x78, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x03, 0xE0,
  0x7E, 0x00, 0x78, 0x0F, 0xC0, 0x0F, 0x03, 0xF8, 0x01, 0xE0, 0x7F, 0x80,
  0x3C, 0x0F, 0xF0, 0x0F, 0x81, 0xFE, 0x01, 0xF0, 0x3F, 0xC0, 0x3C, 0x07,
  0xB8, 0x07, 0x81, 0xF7, 0x80, 0xF0, 0x3C, 0xF0, 0x1E, 0x07, 0x9E, 0x07,
  0xC0, 0xF3, 0xC0, 0xF8, 0x1E, 0x38, 0x1E, 0x03, 0xC7, 0x83, 0xC0, 0xF8,
  0xF0, 0x78, 0x1F, 0x1E, 0x0F, 0x03, 0xC3, 0xC3, 0xE0, 0x78, 0x38, 0x7C,
  0x0F, 0x07, 0x8F, 0x01, 0xE0, 0xF1, 0xE0, 0x3C, 0x1E, 0x3C, 0x0F, 0x83,
  0xC7, 0x81, 0xF0, 0x38, 0xF0, 0x3C, 0x07, 0xBE, 0x07, 0x80, 0xF7, 0xC0,
  0xF0, 0x1E, 0xF0, 0x1E, 0x03, 0xDE, 0x07, 0xC0, 0x3B, 0xC0, 0xF8, 0x07,
  0xF8, 0x1E, 0x00, 0xFF, 0x03, 0xC0, 0x1F, 0xE0, 0x78, 0x03, 0xF8, 0x0F,
  0x00, 0x3F, 0x03, 0xE0, 0x07, 0xE0, 0x7C, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x7E,
  0x03, 0xF0, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x1E, 0x00, 0x1E, 0x0F,
  0x00, 0x0F, 0x0F, 0x80, 0x07, 0x87, 0xC0, 0x03, 0xC3, 0xC0, 0x03, 0xE1,
  0xE0, 0x01, 0xF0, 0xF0, 0x00, 0xF8, 0x78, 0x00, 0x78, 0x7C, 0x00, 0x3C,
  0x3E, 0x00, 0x1E, 0x1F, 0x00, 0x1F, 0x0F, 0x00, 0x0F, 0x87, 0x80, 0x07,
  0xC3, 0xC0, 0x03, 0xC3, 0xE0, 0x01, 0xE1, 0xF0, 0x00, 0xF0, 0xF8, 0x00,
  0x78, 0x78, 0x00, 0x7C, 0x3C, 0x00, 0x3E, 0x1E, 0x00, 0x1E, 0x0F, 0x00,
  0x0F, 0x07, 0x80, 0x0F, 0x83, 0xC0, 0x07, 0xC1, 0xF0, 0x07, 0xC0, 0xFC,
  0x07, 0xE0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7C, 0x01, 0xFC, 0x0F, 0x80, 0x0F, 0x81,
  0xE0, 0x00, 0xF8, 0x3C, 0x00, 0x1F, 0x07, 0x80, 0x03, 0xE0, 0xF0, 0x00,
  0x7C, 0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF0, 0xF0, 0x00, 0x3C, 0x1E,
  0x00, 0x0F, 0x83, 0xC0, 0x01, 0xF0, 0x78, 0x00, 0x7C, 0x1F, 0x00, 0x3F,
  0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFE, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x7E, 0x03, 0xF0, 0x7E, 0x00, 0xF8,
  0x3E, 0x00, 0x3C, 0x1E, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x8F, 0x00, 0x07,
  0x87, 0x80, 0x03, 0xC3, 0xC0, 0x01, 0xE3, 0xE0, 0x00, 0xF1, 0xF0, 0x00,
  0xF8, 0xF8, 0x00, 0x7C, 0x78, 0x00, 0x3E, 0x3C, 0x00, 0x1E, 0x1E, 0x00,
  0x0F, 0x0F, 0x00, 0x07, 0x8F, 0x80, 0x03, 0xC7, 0xC0, 0x03, 0xE3, 0xC0,
  0x01, 0xF1, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x3C, 0x7C,
  0x00, 0x1E, 0x3E, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0x87,
  0xC0, 0x07, 0xC3, 0xF0, 0x07, 0xC0, 0xF8, 0x07, 0xE0, 0x7F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3E, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xC0, 0x7C, 0x03, 0xF8, 0x0F, 0x80, 0x1F, 0x81, 0xE0,
  0x01, 0xF0, 0x3C, 0x00, 0x3E, 0x07, 0x80, 0x03, 0xC0, 0xF0, 0x00, 0x78,
  0x3E, 0x00, 0x0F, 0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x1E, 0x00,
  0x1F, 0x03, 0xC0, 0x03, 0xE0, 0x78, 0x00, 0xF8, 0x1F, 0x00, 0x7E, 0x03,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xF8,
  0x00, 0x3C, 0x0F, 0x80, 0x0F, 0x81, 0xF0, 0x01, 0xF0, 0x1E, 0x00, 0x3E,
  0x03, 0xE0, 0x07, 0x80, 0x7C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF8,
  0x03, 0xC0, 0x1F, 0x00, 0xF8, 0x01, 0xE0, 0x1F, 0x00, 0x3E, 0x03, 0xC0,
  0x07, 0xC0, 0x78, 0x00, 0xF8, 0x0F, 0x00, 0x0F, 0x81, 0xE0, 0x01, 0xF0,
  0x7C, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x0F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x03, 0xE0,
  0x7C, 0x00, 0x7C, 0x1E, 0x00, 0x1F, 0x07, 0x80, 0x07, 0xC1, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x78, 0x78,
  0x00, 0x3E, 0x1E, 0x00, 0x0F, 0x07, 0xC0, 0x07, 0xC1, 0xF8, 0x03, 0xE0,
  0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0x80, 0x07, 0xC1, 0xE0, 0x01, 0xE0, 0x78, 0x00, 0x78, 0x3E,
  0x00, 0x1E, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x03, 0xE0, 0xF0, 0x00, 0xF8,
  0x3C, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x07, 0xC0, 0x03, 0xC1, 0xF0, 0x01,
  0xF0, 0x7C, 0x00, 0x7C, 0x1E, 0x00, 0x1F, 0x07, 0x80, 0x07, 0x81, 0xE0,
  0x01, 0xE0, 0x78, 0x00, 0x78, 0x3E, 0x00, 0x1E, 0x0F, 0x80, 0x0F, 0x83,
  0xC0, 0x03, 0xE0, 0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x3C, 0x0F, 0x00, 0x0F,
  0x07, 0xC0, 0x03, 0xC1, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x1E, 0x00,
  0x1F, 0x07, 0x80, 0x07, 0x81, 0xE0, 0x01, 0xE0, 0x78, 0x00, 0xF8, 0x1E,
  0x00, 0x3E, 0x07, 0xC0, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0x7F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1E, 0xF8, 0x00,
  0x3E, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x7C, 0x78, 0x00, 0x78, 0x78, 0x00,
  0x78, 0x78, 0x00, 0xF8, 0x78, 0x00, 0xF0, 0x78, 0x01, 0xF0, 0x7C, 0x01,
  0xE0, 0x7C, 0x01, 0xE0, 0x7C, 0x03, 0xE0, 0x7C, 0x03, 0xC0, 0x3C, 0x07,
  0xC0, 0x3C, 0x07, 0x80, 0x3C, 0x0F, 0x80, 0x3C, 0x0F, 0x00, 0x3C, 0x0F,
  0x00, 0x3C, 0x1F, 0x00, 0x3C, 0x1E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3C,
  0x00, 0x3E, 0x3C, 0x00, 0x1E, 0x7C, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0xF8,
  0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3C, 0x07,
  0xC0, 0x79, 0xE0, 0x3E, 0x07, 0x8F, 0x03, 0xF0, 0x3C, 0x78, 0x1F, 0x01,
  0xE3, 0xC0, 0xF8, 0x0F, 0x3E, 0x0E, 0xC0, 0xF1, 0xF0, 0x76, 0x07, 0x8F,
  0x03, 0xB0, 0x3C, 0x78, 0x19, 0x83, 0xC3, 0xC1, 0xDC, 0x1E, 0x1E, 0x0E,
  0xE0, 0xF0, 0xF0, 0x77, 0x07, 0x87, 0x87, 0x38, 0x78, 0x3C, 0x39, 0xC3,
  0xC1, 0xE1, 0xCE, 0x1E, 0x0F, 0x0C, 0x70, 0xE0, 0x78, 0xE3, 0x8F, 0x03,
  0xC7, 0x1C, 0x78, 0x1E, 0x38, 0xE3, 0xC0, 0xF3, 0x87, 0x1C, 0x07, 0x9C,
  0x39, 0xE0, 0x3C, 0xE1, 0xCF, 0x01, 0xE7, 0x0E, 0x78, 0x0F, 0x70, 0x77,
  0x80, 0x73, 0x83, 0xBC, 0x03, 0x9C, 0x1D, 0xE0, 0x1D, 0xC0, 0xCE, 0x00,
  0xEE, 0x06, 0xF0, 0x0F, 0x70, 0x37, 0x80, 0x7B, 0x81, 0xBC, 0x03, 0xF8,
  0x1D, 0xC0, 0x1F, 0xC0, 0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0xE0, 0x3F,
  0x80, 0x3F, 0x01, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x07, 0x80, 0x03, 0xF0, 0x1F, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x7C,
  0x00, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x0F, 0x80, 0x0F, 0x80, 0x7C, 0x00,
  0x1F, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0xF0, 0x7C, 0x00, 0x03,
  0xE3, 0xE0, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xDF, 0x00, 0x00,
  0x1F, 0x3C, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1F,
  0x07, 0xC0, 0x00, 0xF8, 0x1F, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x3E, 0x00,
  0xF8, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0x3E, 0x00, 0x1F,
  0x00, 0xF8, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xE0,
  0xF8, 0x00, 0x07, 0xDE, 0x00, 0x01, 0xE7, 0x80, 0x00, 0xF9, 0xF0, 0x00,
  0x7C, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x83, 0xE0, 0x03, 0xC0, 0x78,
  0x01, 0xF0, 0x1E, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x00, 0xF0, 0x1F, 0x00,
  0x3C, 0x0F, 0x80, 0x0F, 0x83, 0xC0, 0x01, 0xE1, 0xF0, 0x00, 0x78, 0x78,
  0x00, 0x1F, 0x3C, 0x00, 0x07, 0xDF, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07,
  0xFF, 0x80, 0xFF, 0xF0, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xFF, 0xE0,
  0x3F, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x00, 0xF0, 0x01, 0xF0, 0x03,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0xC0,
  0x0F, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xF0, 0x03, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x00,
  0xFF, 0xF0, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x01, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x7F, 0xF8, 0x07, 0xFF,
  0x80, 0x7F, 0xF8, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3B, 0xC0, 0x01, 0xEF, 0x00, 0x0F,
  0x1C, 0x00, 0x3C, 0x70, 0x01, 0xE1, 0xE0, 0x0F, 0x07, 0x80, 0x3C, 0x0E,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x3C, 0x01, 0xC1, 0xE0, 0x07, 0x87,
  0x80, 0x1E, 0x3C, 0x00, 0x78, 0xF0, 0x00, 0xEF, 0x80, 0x03, 0xC0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x3E, 0x0F, 0x03, 0xC1, 0xF0, 0x7C, 0x00, 0xFF, 0x0F, 0x03, 0xFF, 0xDF,
  0x07, 0xFF, 0xDF, 0x0F, 0xF3, 0xFF, 0x0F, 0x80, 0x7E, 0x1F, 0x00, 0x3E,
  0x1E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3C, 0x00, 0x3E,
  0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x7C, 0x00, 0x3C, 0x7C, 0x00, 0x7C,
  0x7C, 0x00, 0x7C, 0x78, 0x00, 0x7C, 0x78, 0x00, 0x78, 0x78, 0x00, 0x78,
  0x78, 0x00, 0x78, 0x78, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0x7C, 0x01, 0xF8,
  0x7C, 0x03, 0xF8, 0x7F, 0x9E, 0xF0, 0x3F, 0xFE, 0xF0, 0x1F, 0xFC, 0xF0,
  0x0F, 0xF1, 0xF0, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x8F, 0xF0, 0x0F, 0x9F, 0xFC,
  0x0F, 0xBF, 0xFE, 0x0F, 0x7D, 0xFE, 0x0F, 0xE0, 0x3F, 0x0F, 0x80, 0x1F,
  0x0F, 0x80, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1F,
  0x1E, 0x00, 0x1F, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x3E, 0x00, 0x1E,
  0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3C, 0x00, 0x3E, 0x3C, 0x00, 0x3C,
  0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7E, 0x00, 0xF8,
  0x7B, 0x01, 0xF8, 0x7B, 0xCF, 0xF0, 0x7B, 0xFF, 0xE0, 0x79, 0xFF, 0xC0,
  0xF8, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC,
  0x07, 0xFF, 0xFC, 0x0F, 0xC0, 0x7E, 0x1F, 0x00, 0x3E, 0x1E, 0x00, 0x1E,
  0x3E, 0x00, 0x1E, 0x3E, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x7C,
  0x78, 0x00, 0x78, 0x78, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7E, 0x03, 0xF0,
  0x7F, 0xDF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x7F, 0x87, 0x80, 0xFF, 0xF7, 0xC0, 0xFF,
  0xFB, 0xE0, 0xFF, 0x3F, 0xF0, 0x7C, 0x03, 0xF0, 0x7C, 0x00, 0xF8, 0x3C,
  0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x0F, 0x00, 0x0F, 0x87,
  0x80, 0x07, 0x83, 0xC0, 0x03, 0xC3, 0xE0, 0x01, 0xE1, 0xF0, 0x01, 0xF0,
  0xF8, 0x00, 0xF8, 0x78, 0x00, 0x7C, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x1E,
  0x0F, 0x00, 0x0F, 0x07, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0xC1, 0xF0, 0x07,
  0xE0, 0xF8, 0x07, 0xF0, 0x7F, 0x9E, 0xF0, 0x1F, 0xFF, 0x78, 0x07, 0xFF,
  0x3C, 0x01, 0xFE, 0x3E, 0x00, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xE0, 0x0F,
  0xFF, 0xE0, 0x3F, 0x8F, 0xE0, 0xF8, 0x07, 0xC3, 0xE0, 0x07, 0xC7, 0x80,
  0x0F, 0x9F, 0x00, 0x1F, 0x3C, 0x00, 0x3E, 0x78, 0x00, 0x7C, 0xF0, 0x00,
  0xF9, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x0F, 0x8F, 0x00, 0x1E, 0x1F, 0x00, 0x7C, 0x1F,
  0x87, 0xF0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x8F, 0x03, 0xFF, 0xDF, 0x07,
  0xFF, 0xDF, 0x0F, 0xF3, 0xFF, 0x0F, 0x80, 0x7E, 0x1F, 0x00, 0x3E, 0x1F,
  0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3C, 0x00, 0x3E, 0x3C,
  0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x7C, 0x00, 0x3C, 0x7C,
  0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x78, 0x00, 0x78, 0x78, 0x00, 0x78, 0x7C,
  0x00, 0xF8, 0x7C, 0x01, 0xF8, 0x7E, 0x03, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F,
  0xFE, 0xF8, 0x1F, 0xFC, 0xF0, 0x07, 0xF8, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x3F,
  0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x8F, 0xF8, 0x0F,
  0x9F, 0xFC, 0x0F, 0xBF, 0xFE, 0x0F, 0x78, 0xFE, 0x0F, 0xE0, 0x3F, 0x0F,
  0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x1F,
  0x00, 0x1F, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x3E,
  0x00, 0x1E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3C, 0x00, 0x3E, 0x3C,
  0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x7C, 0x00, 0x7C, 0x7C,
  0x00, 0x7C, 0x78, 0x00, 0x7C, 0x78, 0x00, 0x78, 0x78, 0x00, 0x78, 0x78,
  0x00, 0x78, 0xF8, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xC0, 0x1F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0xFC, 0x1E, 0x00, 0x3F, 0x07,
  0xC0, 0x0F, 0xC0, 0xF8, 0x01, 0xF0, 0x1E, 0x00, 0x7C, 0x03, 0xC0, 0x1F,
  0x00, 0x78, 0x07, 0xC0, 0x0F, 0x01, 0xF0, 0x03, 0xE0, 0x7E, 0x00, 0x7C,
  0x1F, 0x80, 0x0F, 0x83, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00,
  0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC1,
  0xF0, 0x00, 0xF0, 0x1F, 0x00, 0x1E, 0x03, 0xE0, 0x03, 0xC0, 0x3E, 0x00,
  0x78, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x78, 0x00,
  0xF8, 0x0F, 0x00, 0x1F, 0x01, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x3F, 0x00,
  0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x7F,
  0xFF, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x0F, 0x3F, 0x1F, 0x81, 0xEF, 0xE7,
  0xF8, 0x3F, 0xFF, 0xFF, 0x07, 0xC7, 0xE1, 0xE0, 0xF0, 0x78, 0x3C, 0x3E,
  0x0F, 0x07, 0x87, 0x81, 0xE0, 0xF0, 0xF0, 0x38, 0x1E, 0x1E, 0x07, 0x03,
  0xC3, 0xC0, 0xE0, 0x78, 0x78, 0x3C, 0x0F, 0x0F, 0x07, 0x83, 0xC3, 0xC0,
  0xF0, 0x78, 0x78, 0x1C, 0x0F, 0x0F, 0x03, 0x81, 0xE1, 0xE0, 0x70, 0x3C,
  0x3C, 0x1E, 0x07, 0x87, 0x83, 0xC1, 0xF1, 0xF0, 0x78, 0x3C, 0x3C, 0x0F,
  0x07, 0x87, 0x81, 0xC0, 0xF0, 0xF0, 0x38, 0x1E, 0x1E, 0x0F, 0x03, 0xC3,
  0xC1, 0xE0, 0xF8, 0xF8, 0x3C, 0x1E, 0x1E, 0x07, 0x83, 0xC3, 0xC0, 0xE0,
  0x78, 0x00, 0x07, 0x8F, 0xF8, 0x0F, 0x9F, 0xFC, 0x0F, 0xBF, 0xFE, 0x0F,
  0x78, 0xFE, 0x0F, 0xE0, 0x3F, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x1F,
  0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x1E, 0x00, 0x1E, 0x1E,
  0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x3E, 0x00, 0x1E, 0x3E, 0x00, 0x3E, 0x3E,
  0x00, 0x3E, 0x3C, 0x00, 0x3E, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C,
  0x00, 0x3C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x78, 0x00, 0x7C, 0x78,
  0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00, 0x78, 0xF8, 0x00, 0xF8, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0xF8,
  0x07, 0xC3, 0xE0, 0x07, 0xC7, 0x80, 0x0F, 0x9F, 0x00, 0x1F, 0x3E, 0x00,
  0x3E, 0x78, 0x00, 0x7C, 0xF0, 0x00, 0xF9, 0xE0, 0x01, 0xE7, 0xC0, 0x03,
  0xCF, 0x80, 0x07, 0x9F, 0x00, 0x1F, 0x3C, 0x00, 0x3E, 0x78, 0x00, 0x7C,
  0xF0, 0x00, 0xF1, 0xE0, 0x01, 0xE3, 0xC0, 0x07, 0xC7, 0x80, 0x0F, 0x8F,
  0x80, 0x3E, 0x1F, 0x00, 0xFC, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x3F,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xC7, 0xFC, 0x03, 0xE7, 0xFF, 0x01,
  0xF7, 0xFF, 0xC0, 0xF7, 0xDF, 0xE0, 0x7F, 0x01, 0xF8, 0x3E, 0x00, 0x7C,
  0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x07,
  0xC3, 0xC0, 0x03, 0xE1, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0xF8, 0x00,
  0x78, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x1E, 0x00, 0x1F, 0x0F, 0x00,
  0x0F, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE1, 0xF8,
  0x03, 0xE0, 0xF6, 0x03, 0xF0, 0x7B, 0xCF, 0xF0, 0x3D, 0xFF, 0xF0, 0x1E,
  0x7F, 0xF0, 0x1F, 0x1F, 0xF0, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x0F, 0x03, 0xFF, 0xDF, 0x07, 0xFF, 0xDF, 0x0F, 0xF3, 0xFE, 0x0F, 0x80,
  0x7E, 0x1F, 0x00, 0x7E, 0x1E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00,
  0x3E, 0x3C, 0x00, 0x3E, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x7C, 0x00,
  0x3C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x78, 0x00, 0x7C, 0x78, 0x00,
  0x78, 0x78, 0x00, 0x78, 0x78, 0x00, 0x78, 0xF8, 0x00, 0xF8, 0xF8, 0x00,
  0xF8, 0x7C, 0x01, 0xF8, 0x7C, 0x03, 0xF0, 0x7F, 0x9E, 0xF0, 0x3F, 0xFE,
  0xF0, 0x3F, 0xFC, 0xF0, 0x0F, 0xF1, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x0F, 0x8F,
  0xF0, 0x0F, 0xBF, 0xFC, 0x0F, 0x7F, 0xFE, 0x0F, 0x78, 0xFE, 0x0F, 0xC0,
  0x3F, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00,
  0x1F, 0x1E, 0x00, 0x1F, 0x1E, 0x00, 0x1F, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF0, 0x7F, 0x9F, 0xF0, 0xF8, 0x03, 0xE3, 0xE0, 0x07,
  0xC7, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xCF, 0x00, 0x07, 0x9F, 0x00, 0x1F, 0x3E, 0x00,
  0x7C, 0x3F, 0x87, 0xF8, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0x7F, 0xFC,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF,
  0xE0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x1F, 0x00, 0x0F, 0x1F, 0x00,
  0x1F, 0x1F, 0x00, 0x1F, 0x1E, 0x00, 0x1F, 0x1E, 0x00, 0x1E, 0x1E, 0x00,
  0x1E, 0x3E, 0x00, 0x1E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3C, 0x00,
  0x3E, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x7C, 0x00,
  0x3C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x78, 0x00, 0x7C, 0x78, 0x00,
  0x78, 0x78, 0x00, 0x78, 0x78, 0x00, 0xF8, 0x78, 0x00, 0xF0, 0x7C, 0x01,
  0xF0, 0x7E, 0x03, 0xE0, 0x3F, 0x9F, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x3E, 0xF8, 0x00,
  0x3C, 0x78, 0x00, 0x7C, 0x78, 0x00, 0x78, 0x78, 0x00, 0xF8, 0x78, 0x00,
  0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xE0, 0x3C, 0x01, 0xE0, 0x3C, 0x03,
  0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x3E, 0x07, 0x80, 0x3E, 0x0F,
  0x80, 0x1E, 0x0F, 0x00, 0x1E, 0x1F, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x3E,
  0x00, 0x1E, 0x3C, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0xF0, 0x3E, 0x03, 0xFC, 0x0F, 0x80, 0xEF, 0x03, 0xE0, 0x7B, 0xC1,
  0xF8, 0x1E, 0xF0, 0x7E, 0x07, 0x3C, 0x1F, 0x83, 0xCE, 0x06, 0xE0, 0xF3,
  0x83, 0xB8, 0x38, 0xE0, 0xEE, 0x1E, 0x38, 0x33, 0x87, 0x8E, 0x1C, 0xE1,
  0xC3, 0x87, 0x38, 0x70, 0xE1, 0x8E, 0x3C, 0x38, 0xE3, 0x8E, 0x0E, 0x38,
  0xE3, 0x83, 0x8C, 0x39, 0xE0, 0xE7, 0x0E, 0x70, 0x39, 0xC3, 0x9C, 0x0E,
  0x60, 0xEF, 0x03, 0xB8, 0x3B, 0x80, 0xEE, 0x0E, 0xE0, 0x3B, 0x03, 0xF8,
  0x0F, 0xC0, 0xFE, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x3E, 0x03,
  0xF0, 0x0F, 0x80, 0xF8, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0xF8,
  0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x1F, 0x01, 0xF0, 0x03, 0xE0,
  0x7C, 0x00, 0x3C, 0x1F, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x78, 0xF0, 0x00,
  0x0F, 0xBE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFB, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF0, 0xF8,
  0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x01, 0xF8,
  0x03, 0xE0, 0x3E, 0x00, 0x7C, 0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x00, 0xFC,
  0x00, 0x0F, 0x00, 0x0F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x1E, 0x00,
  0x1F, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x3E, 0x00,
  0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3C, 0x00, 0x3C, 0x3C, 0x00,
  0x3C, 0x3C, 0x00, 0x3C, 0x7C, 0x00, 0x3C, 0x7C, 0x00, 0x7C, 0x7C, 0x00,
  0x7C, 0x78, 0x00, 0x78, 0x7C, 0x00, 0x78, 0x7C, 0x00, 0xF8, 0x7C, 0x01,
  0xF8, 0x7E, 0x03, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xFE, 0xF8, 0x1F, 0xFC,
  0xF0, 0x07, 0xF0, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x7F, 0xF8,
  0x00, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x07, 0xFF, 0xC0, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x01,
  0xE0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x0F, 0x8F, 0xF8, 0x07, 0x8F, 0xFE, 0x03, 0xCF, 0xDF, 0x81, 0xE7,
  0x83, 0xE0, 0xF3, 0xC1, 0xF8, 0xF3, 0xE0, 0x7F, 0xF9, 0xE0, 0x1F, 0xF8,
  0xF0, 0x07, 0xF8, 0x78, 0x00, 0xE0, 0x00,
};

const GFXglyph JetBrainsMono_Italic49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 29, 0, -1 },
  { 1, 12, 36, 29, 9, -36 },
  { 55, 17, 15, 29, 9, -36 },
  { 87, 29, 36, 29, 1, -36 },
  { 218, 26, 50, 29, 2, -43 },
  { 381, 33, 36, 29, -1, -36 },
  { 530, 27, 36, 29, 1, -36 },
  { 652, 6, 15, 29, 14, -36 },
  { 664, 20, 47, 29, 8, -41 },
  { 782, 20, 47, 29, 2, -41 },
  { 900, 26, 25, 29, 3, -30 },
  { 982, 24, 23, 29, 3, -28 },
  { 1051, 13, 15, 29, 5, -7 },
  { 1076, 16, 4, 29, 7, -18 },
  { 1084, 8, 8, 29, 9, -8 },
  { 1092, 29, 46, 29, 1, -41 },
  { 1259, 25, 36, 29, 3, -36 },
  { 1372, 23, 36, 29, 2, -36 },
  { 1476, 26, 36, 29, 2, -36 },
  { 1593, 25, 36, 29, 2, -36 },
  { 1706, 24, 36, 29, 3, -36 },
  { 1814, 24, 36, 29, 3, -36 },
  { 1922, 24, 36, 29, 2, -36 },
  { 2030, 24, 36, 29, 6, -36 },
  { 2138, 25, 36, 29, 2, -36 },
  { 2251, 23, 36, 29, 5, -36 },
  { 2355, 12, 27, 29, 9, -27 },
  { 2396, 16, 35, 29, 5, -27 },
  { 2466, 24, 26, 29, 4, -29 },
  { 2544, 24, 16, 29, 3, -24 },
  { 2592, 24, 26, 29, 2, -29 },
  { 2670, 20, 36, 29, 7, -36 },
  { 2760, 30, 45, 29, 0, -36 },
  { 2929, 25, 36, 29, 0, -36 },
  { 3042, 26, 36, 29, 2, -36 },
  { 3159, 25, 36, 29, 3, -36 },
  { 3272, 25, 36, 29, 2, -36 },
  { 3385, 26, 36, 29, 3, -36 },
  { 3502, 27, 36, 29, 2, -36 },
  { 3624, 25, 36, 29, 3, -36 },
  { 3737, 26, 36, 29, 2, -36 },
  { 3854, 25, 36, 29, 3, -36 },
  { 3967, 27, 36, 29, 1, -36 },
  { 4089, 28, 36, 29, 2, -36 },
  { 4215, 22, 36, 29, 3, -36 },
  { 4314, 27, 36, 29, 2, -36 },
  { 4436, 27, 36, 29, 2, -36 },
  { 4558, 25, 36, 29, 3, -36 },
  { 4671, 27, 36, 29, 2, -36 },
  { 4793, 25, 45, 29, 3, -36 },
  { 4934, 27, 36, 29, 2, -36 },
  { 5056, 26, 36, 29, 2, -36 },
  { 5173, 24, 36, 29, 6, -36 },
  { 5281, 26, 36, 29, 3, -36 },
  { 5398, 24, 36, 29, 6, -36 },
  { 5506, 29, 36, 29, 3, -36 },
  { 5637, 30, 36, 29, 0, -36 },
  { 5772, 26, 36, 29, 5, -36 },
  { 5889, 26, 36, 29, 2, -36 },
  { 6006, 19, 46, 29, 7, -41 },
  { 6116, 15, 46, 29, 8, -41 },
  { 6203, 20, 46, 29, 4, -41 },
  { 6318, 22, 19, 29, 4, -36 },
  { 6371, 24, 4, 29, 0, 1 },
  { 6383, 9, 6, 29, 13, -38 },
  { 6390, 24, 27, 29, 3, -27 },
  { 6471, 24, 36, 29, 2, -36 },
  { 6579, 24, 27, 29, 3, -27 },
  { 6660, 25, 36, 29, 3, -36 },
  { 6773, 23, 27, 29, 3, -27 },
  { 6851, 33, 45, 29, -2, -36 },
  { 7037, 24, 36, 29, 3, -27 },
  { 7145, 24, 36, 29, 2, -36 },
  { 7253, 23, 38, 29, 2, -38 },
  { 7363, 25, 47, 29, 1, -38 },
  { 7510, 27, 36, 29, 2, -36 },
  { 7632, 20, 36, 29, 5, -36 },
  { 7722, 27, 27, 29, 1, -27 },
  { 7814, 24, 27, 29, 2, -27 },
  { 7895, 23, 27, 29, 3, -27 },
  { 7973, 25, 36, 29, 1, -27 },
  { 8086, 24, 36, 29, 3, -27 },
  { 8194, 24, 27, 29, 3, -27 },
  { 8275, 23, 27, 29, 3, -27 },
  { 8353, 24, 34, 29, 4, -34 },
  { 8455, 24, 27, 29, 3, -27 },
  { 8536, 24, 27, 29, 5, -27 },
  { 8617, 26, 27, 29, 4, -27 },
  { 8705, 27, 27, 29, 1, -27 },
  { 8797, 24, 36, 29, 3, -27 },
  { 8905, 25, 27, 29, 2, -27 },
  { 8990, 25, 46, 29, 5, -41 },
  { 9134, 12, 46, 29, 9, -41 },
  { 9203, 25, 46, 29, 1, -41 },
  { 9347, 25, 10, 29, 3, -22 },
};

const GFXfont JetBrainsMono_Italic49pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Italic49pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Italic49pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _JETBRAINSMONO_ITALIC49PT7B_H_
