#ifndef _JETBRAINSMONO_ITALIC69PT7B_H_
#define _JETBRAINSMONO_ITALIC69PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Italic.ttf
// Size: 69pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Italic69pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x01,
  0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x01,
  0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF,
  0xC0, 0xFF, 0x80, 0x7F, 0x00, 0x3F, 0x80, 0xFE, 0x7F, 0x01, 0xFC, 0xFE,
  0x03, 0xF9, 0xF8, 0x07, 0xE7, 0xF0, 0x0F, 0xCF, 0xE0, 0x3F, 0x9F, 0xC0,
  0x7F, 0x3F, 0x80, 0xFE, 0x7E, 0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0x07,
  0xE3, 0xF0, 0x0F, 0xC7, 0xE0, 0x1F, 0x9F, 0x80, 0x3E, 0x3F, 0x00, 0xFC,
  0x7E, 0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0x07, 0xE3, 0xE0, 0x0F, 0x87,
  0xC0, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x01, 0xF8,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x01, 0xF0,
  0x00, 0x03, 0xF0, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0xF1, 0xE3, 0xFC, 0x00, 0xFF, 0x0F, 0x0F, 0xE0, 0x07, 0xF0, 0x78, 0x3F,
  0x80, 0x7F, 0x07, 0xC1, 0xFC, 0x03, 0xF0, 0x3C, 0x07, 0xE0, 0x1F, 0x81,
  0xE0, 0x3F, 0x01, 0xFC, 0x0F, 0x01, 0xF8, 0x0F, 0xE0, 0x78, 0x10, 0x00,
  0x7E, 0x03, 0xC0, 0x00, 0x03, 0xF8, 0x1E, 0x00, 0x00, 0x1F, 0xC1, 0xF0,
  0x00, 0x00, 0xFE, 0x0F, 0x00, 0x00, 0x07, 0xF8, 0x78, 0x00, 0x00, 0x1F,
  0xC3, 0xC0, 0x00, 0x00, 0xFF, 0x9E, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x1E, 0x3F, 0xE0, 0x00, 0x00, 0xF0, 0xFF, 0x00, 0x00,
  0x07, 0x83, 0xF8, 0x00, 0x00, 0x3C, 0x0F, 0xE0, 0x00, 0x01, 0xE0, 0x7F,
  0x00, 0x00, 0x1F, 0x03, 0xF8, 0x00, 0x00, 0xF0, 0x1F, 0xC0, 0x00, 0x07,
  0x80, 0xFE, 0x0F, 0xC0, 0x3C, 0x07, 0xE0, 0x7E, 0x01, 0xE0, 0x3F, 0x03,
  0xF0, 0x0F, 0x01, 0xF8, 0x1F, 0x80, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0x81,
  0xFC, 0x07, 0xF8, 0x3C, 0x1F, 0xC0, 0x1F, 0xE1, 0xE1, 0xFE, 0x00, 0xFF,
  0xCF, 0x3F, 0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x07,
  0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xE0,
  0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0x0F, 0xC0, 0x1F, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x7E, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x7C, 0x01, 0xF0, 0x3F, 0x00, 0x00,
  0xF8, 0x03, 0xE0, 0x7C, 0x00, 0x01, 0xF0, 0x07, 0xC1, 0xF0, 0x00, 0x03,
  0xE0, 0x1F, 0x87, 0xC0, 0x00, 0x07, 0xE0, 0x7E, 0x1F, 0x00, 0x00, 0x0F,
  0xE3, 0xFC, 0x7C, 0x00, 0x00, 0x1F, 0xFF, 0xF1, 0xF8, 0x00, 0x00, 0x1F,
  0xFF, 0xC7, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0xF8, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC1, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7E, 0x3F, 0xFF, 0x80, 0x00, 0x01, 0xF8,
  0xFF, 0xFF, 0x80, 0x00, 0x03, 0xE1, 0xF8, 0x3F, 0x00, 0x00, 0x0F, 0x87,
  0xE0, 0x3E, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x7E, 0x00, 0x00, 0xF8, 0x3F,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x7C, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0xF8,
  0x03, 0xE0, 0x00, 0x1F, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x7C, 0x03, 0xE0,
  0x0F, 0x80, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x07, 0xC0, 0x1F, 0x80,
  0x3E, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x7E, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x07, 0xE0, 0x03, 0xE0, 0x00, 0xFF, 0x7F,
  0x80, 0x0F, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x03, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0x87, 0xFE, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x1F,
  0xC0, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x1F, 0xC7, 0xF0, 0xFE,
  0x00, 0xFE, 0x1F, 0x83, 0xF8, 0x07, 0xF0, 0xFE, 0x07, 0xF0, 0x1F, 0x83,
  0xF0, 0x0F, 0xC0, 0xFE, 0x0F, 0xC0, 0x3F, 0x87, 0xF0, 0x3F, 0x00, 0x7F,
  0x1F, 0x80, 0xFC, 0x01, 0xFC, 0xFC, 0x07, 0xF0, 0x03, 0xFF, 0xF0, 0x1F,
  0x80, 0x0F, 0xFF, 0x80, 0x7E, 0x00, 0x1F, 0xFC, 0x01, 0xF8, 0x00, 0x3F,
  0xE0, 0x07, 0xE0, 0x00, 0xFF, 0x80, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x3F, 0xE0, 0x0F, 0xE0, 0x01, 0xFF,
  0x80, 0x3F, 0x80, 0x0F, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFE,
  0x07, 0xFB, 0xF8, 0x07, 0xFF, 0xFF, 0xC7, 0xE0, 0x1F, 0xFF, 0xFE, 0x1F,
  0xC0, 0x3F, 0xFF, 0xF0, 0x3F, 0x80, 0x7F, 0xFF, 0x00, 0xFE, 0x00, 0x7F,
  0xF0, 0x01, 0xFC, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0xC7, 0xE3, 0xF8,
  0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFC, 0x3F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7E,
  0x1F, 0x87, 0xE1, 0xF8, 0x7C, 0x1F, 0x07, 0xC3, 0xF0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x38, 0x00, 0xF8, 0x00, 0xE3, 0xF0, 0x0F, 0x80,
  0x7E, 0x7F, 0xC0, 0xF8, 0x1F, 0xF7, 0xFF, 0x0F, 0x07, 0xFF, 0xFF, 0xF8,
  0xF1, 0xFF, 0xFF, 0xFF, 0xEE, 0x7F, 0xFF, 0x1F, 0xFF, 0xEF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0x7C, 0x00, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00,
  0x0F, 0xC3, 0xF8, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x3F, 0x81, 0xFC,
  0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x1F, 0xE0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x1F,
  0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x80, 0x03, 0x80, 0xFF,
  0x0F, 0xFC, 0x7F, 0xE7, 0xFF, 0x3F, 0xF9, 0xFF, 0xCF, 0xFE, 0x7F, 0xE3,
  0xFF, 0x0F, 0xF0, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x0F, 0xE0,
  0x00, 0xFE, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x01, 0xFC, 0x1F,
  0xC0, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x7E,
  0x1F, 0x80, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00,
  0x7E, 0x0F, 0xC0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x01, 0xF8, 0x3F, 0x00,
  0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x00, 0xFC, 0x3F,
  0x00, 0x80, 0x3F, 0x87, 0xE0, 0x7E, 0x07, 0xE0, 0xFC, 0x1F, 0xC0, 0xFC,
  0x1F, 0x83, 0xFC, 0x1F, 0x87, 0xF0, 0x7F, 0x83, 0xF0, 0xFC, 0x0F, 0xF0,
  0x7E, 0x1F, 0x81, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x83, 0xF0, 0x7E, 0x01,
  0xE0, 0x7E, 0x0F, 0xC0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x01, 0xF8, 0x7E,
  0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x01, 0xF8,
  0x3F, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00,
  0xFC, 0x3F, 0x80, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x07, 0xE0, 0xFE, 0x00,
  0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x07, 0xE0, 0x3F,
  0x80, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0x40, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x1F, 0xF7, 0xE0, 0x00, 0x7F, 0xC7, 0xE0, 0x00, 0xFF, 0x87, 0xE0, 0x01,
  0xFE, 0x0F, 0xE0, 0x01, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x03,
  0xE0, 0x0F, 0xC0, 0x03, 0x80, 0x0F, 0xC0, 0x03, 0x00, 0x0F, 0xC0, 0x02,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xBF, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xE0, 0x01, 0xFE, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x3F, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x7E, 0x00,
  0x00, 0x7E, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x0F,
  0xE0, 0x7E, 0x00, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x7F, 0x00,
  0x03, 0xF8, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x01, 0xF8, 0x07, 0xF0,
  0x00, 0xFC, 0x03, 0xF8, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x7F, 0x03, 0xF8,
  0x00, 0x3F, 0x03, 0xF8, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x0F, 0xC3, 0xFC,
  0x00, 0x07, 0xE1, 0xFC, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x03, 0xF8, 0xFE,
  0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0xFC, 0x3F, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x1F, 0xF0,
  0x00, 0x1F, 0x8F, 0xFF, 0x80, 0x03, 0xF3, 0xFF, 0xFC, 0x00, 0x7E, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xE3, 0xFF, 0x80, 0x7F,
  0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x3F, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x7E, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x7F, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x3F, 0xC0, 0x07, 0xF8, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0xFF, 0x80, 0x01, 0xFD, 0xFF, 0xF8, 0x00, 0x7E, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFE, 0x01, 0xFF,
  0x03, 0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00,
  0xFE, 0x1F, 0xC0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x07, 0xE3, 0xF8, 0x00,
  0x01, 0xF8, 0xFC, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x1F, 0x9F, 0xC0,
  0x00, 0x07, 0xE7, 0xE0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x7E, 0x7E,
  0x00, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x03, 0xF1,
  0xF8, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x3F,
  0x83, 0xF8, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x1F, 0xE0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF,
  0x8F, 0xC0, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x01,
  0xFC, 0x7E, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x3F, 0x87, 0xE0, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xE7, 0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF0, 0x00, 0xFE, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x3F,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00,
  0x1F, 0x81, 0xFC, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x00, 0xFC, 0x03, 0xF0,
  0x00, 0x3F, 0x80, 0x7E, 0x00, 0x07, 0xE0, 0x0F, 0xE0, 0x01, 0xF8, 0x00,
  0xFE, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x01, 0xFE, 0x1F, 0xE0,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x03,
  0xF8, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x00, 0xFE,
  0x07, 0xE0, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0xFC, 0x3F, 0x80,
  0x00, 0x1F, 0x87, 0xE0, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0xFC, 0x1F,
  0xC0, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x01, 0xFC,
  0x07, 0xF8, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xF7,
  0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xF0, 0x1F, 0xC0, 0x01, 0xFC, 0x0F, 0xE0,
  0x00, 0x3F, 0x87, 0xF0, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x01, 0xF8, 0xFE,
  0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x07, 0xE7,
  0xF0, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x1F,
  0x9F, 0x80, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x00,
  0xFC, 0x7E, 0x00, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x1F, 0xC7, 0xF0, 0x00,
  0x0F, 0xE1, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x03, 0xFC, 0x0F, 0xF8,
  0x01, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFD, 0xF8, 0x00, 0x3F, 0xFC, 0xFE, 0x00,
  0x01, 0xF8, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x7F, 0x00, 0x7F, 0xC0, 0x7F, 0xF0, 0x7F, 0xF8,
  0x3F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFE, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x7F, 0x80, 0x7F, 0xE0, 0x7F, 0xF0, 0x3F,
  0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x03, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x01, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xC0,
  0x04, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x00,
  0x3E, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x3F, 0x00, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x1F,
  0xF1, 0xF8, 0x1F, 0x80, 0x0F, 0xFE, 0x7E, 0x07, 0xC0, 0x07, 0xFF, 0xDF,
  0x01, 0xF0, 0x03, 0xFF, 0xF7, 0xC0, 0x7C, 0x01, 0xFC, 0x0F, 0xF0, 0x3F,
  0x00, 0xFE, 0x01, 0xFC, 0x0F, 0xC0, 0x3F, 0x00, 0x3F, 0x03, 0xF0, 0x0F,
  0x80, 0x0F, 0xC0, 0xF8, 0x07, 0xE0, 0x03, 0xE0, 0x3E, 0x01, 0xF8, 0x00,
  0xF8, 0x0F, 0x80, 0x7E, 0x00, 0x3E, 0x07, 0xE0, 0x1F, 0x00, 0x1F, 0x81,
  0xF8, 0x07, 0xC0, 0x07, 0xE0, 0x7E, 0x01, 0xF0, 0x01, 0xF8, 0x1F, 0x80,
  0xFC, 0x00, 0x7E, 0x07, 0xC0, 0x3F, 0x00, 0x1F, 0x01, 0xF0, 0x0F, 0xC0,
  0x07, 0xC0, 0xFC, 0x03, 0xE0, 0x01, 0xF0, 0x3F, 0x00, 0xF8, 0x00, 0xFC,
  0x0F, 0xC0, 0x3E, 0x00, 0x3F, 0x03, 0xF0, 0x0F, 0x80, 0x0F, 0xC0, 0xF8,
  0x03, 0xE0, 0x07, 0xE0, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x0F, 0x80, 0x3F,
  0x00, 0xFE, 0x07, 0xE0, 0x0F, 0xF0, 0xFF, 0x81, 0xF8, 0x03, 0xFF, 0xFB,
  0xE0, 0x7E, 0x00, 0x7F, 0xFC, 0xF8, 0x1F, 0x80, 0x0F, 0xFE, 0x3C, 0x07,
  0xC0, 0x01, 0xFE, 0x1F, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xDF, 0x80,
  0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x0F, 0xCF,
  0xC0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x0F,
  0xC7, 0xE0, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x00, 0x7E, 0x0F, 0x80, 0x00,
  0x0F, 0xC1, 0xF0, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x00, 0x7E, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x7E, 0x03,
  0xF0, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0xFE,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0x03, 0xF0, 0x03, 0xE0, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07,
  0xE0, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x7E,
  0x0F, 0xE0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00,
  0x3F, 0x0F, 0xE0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x00, 0xFC, 0x7F, 0x00,
  0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x00, 0x3F, 0x7F,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xC0, 0x0F, 0xFE, 0x01,
  0xF8, 0x00, 0x1F, 0xE0, 0x1F, 0x80, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x0F,
  0xE0, 0x1F, 0x80, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x3F, 0x80,
  0x00, 0x7E, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x7E, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x3F, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x7E, 0x00,
  0x07, 0xF0, 0x07, 0xE0, 0x01, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xC0, 0x1F, 0xFE, 0x00, 0xFC, 0x00,
  0x1F, 0xF0, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x1F,
  0xC0, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x00, 0x1F,
  0x81, 0xF8, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x01, 0xF8, 0x1F, 0x80, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x03, 0xF0, 0x3F,
  0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x00, 0x7E,
  0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00,
  0x7F, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xE0, 0x0F, 0xF8, 0x0F,
  0xF0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x07, 0xF0,
  0x7E, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x1F,
  0xC3, 0xF0, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x0F, 0xC0,
  0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x3F,
  0x80, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x7F, 0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF0, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xC0, 0x1F,
  0xFC, 0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x1F, 0x80, 0x01, 0xFC, 0x01, 0xF8,
  0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x3F, 0x80, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00,
  0x7E, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x7E, 0x03, 0xF0,
  0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x0F, 0xC0,
  0x7E, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00,
  0xFC, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x01, 0xFC, 0x0F, 0xE0,
  0x00, 0x1F, 0x80, 0xFC, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x03,
  0xF8, 0x1F, 0xC0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x1F, 0x80,
  0x00, 0x3F, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x3F, 0x01,
  0xF8, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x07,
  0xE0, 0x3F, 0x00, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x3F, 0x00,
  0x01, 0xFC, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x07, 0xF8, 0x07,
  0xF0, 0x01, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xE0, 0x0F, 0xF8, 0x0F, 0xF0, 0x00,
  0xFE, 0x03, 0xF8, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x07, 0xF0, 0x7E, 0x00,
  0x01, 0xFC, 0x3F, 0x80, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x1F, 0xC3, 0xF0,
  0x00, 0x07, 0xF0, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x7F, 0xFF, 0xC3, 0xF0, 0x1F, 0xFF, 0xF0, 0xFC, 0x07,
  0xFF, 0xF8, 0x3F, 0x01, 0xFF, 0xFE, 0x1F, 0xC0, 0x7F, 0xFF, 0x87, 0xF0,
  0x3F, 0xFF, 0xE1, 0xF8, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0xFE, 0x1F,
  0x80, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xF0,
  0xFE, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x1F,
  0xC3, 0xF0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00,
  0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x7F, 0x00,
  0x0F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xF8, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x00, 0xFE, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x01, 0xF8,
  0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0xFE, 0x01, 0xF8, 0x00,
  0x07, 0xF0, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x07,
  0xF0, 0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x01, 0xF8, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x03, 0xF0,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x01, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x7F, 0x00, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0x07, 0xE0,
  0x1F, 0x80, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x3F, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x1F,
  0xC0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x1F,
  0xC0, 0x3F, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x3F, 0x00, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x40, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x3F, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x1F,
  0x80, 0x7F, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xE0, 0x1F, 0xF8,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0xF4, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x01, 0xF8,
  0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x03,
  0xF0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x03,
  0xF8, 0x00, 0x03, 0xF0, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x0F, 0xE0, 0x00, 0x07, 0xE0,
  0x1F, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x3F,
  0x80, 0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00,
  0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x1F, 0x80,
  0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x0F, 0xE0,
  0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03,
  0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x7E, 0x00,
  0x00, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0xFE,
  0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x03, 0xFE,
  0x00, 0x1F, 0xF8, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x7F,
  0xC0, 0x3F, 0xF0, 0x01, 0xF7, 0x80, 0x7F, 0xE0, 0x03, 0xEF, 0x00, 0xFB,
  0xC0, 0x0F, 0xBE, 0x01, 0xE7, 0xC0, 0x1F, 0x7C, 0x03, 0xCF, 0x80, 0x7C,
  0xF8, 0x0F, 0x9F, 0x00, 0xF9, 0xE0, 0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0x3E,
  0x7C, 0x07, 0xCF, 0x80, 0x7C, 0x78, 0x1F, 0x9F, 0x00, 0xF8, 0xF8, 0x3E,
  0x3E, 0x01, 0xF1, 0xF0, 0xFC, 0xFC, 0x03, 0xE3, 0xE1, 0xF1, 0xF0, 0x0F,
  0xC7, 0xC7, 0xE3, 0xE0, 0x1F, 0x8F, 0x8F, 0x87, 0xC0, 0x3F, 0x0F, 0x1F,
  0x1F, 0x80, 0x7E, 0x1F, 0x7C, 0x3F, 0x00, 0xF8, 0x3E, 0xF8, 0x7E, 0x01,
  0xF0, 0x7F, 0xE0, 0xFC, 0x07, 0xE0, 0xFF, 0xC3, 0xF0, 0x0F, 0xC1, 0xFF,
  0x07, 0xE0, 0x1F, 0x81, 0xFE, 0x0F, 0xC0, 0x3F, 0x03, 0xF8, 0x1F, 0x80,
  0x7E, 0x07, 0xF0, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00,
  0x01, 0xF8, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x7E, 0x00,
  0x00, 0x7F, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x7E,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0x7E, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xF8, 0x07, 0xFC, 0x00,
  0x0F, 0xC0, 0x3F, 0xE0, 0x00, 0x7E, 0x01, 0xFF, 0x00, 0x03, 0xF0, 0x1F,
  0xF8, 0x00, 0x3F, 0x00, 0xFF, 0xE0, 0x01, 0xF8, 0x07, 0xFF, 0x00, 0x0F,
  0xC0, 0x3E, 0xF8, 0x00, 0x7E, 0x01, 0xF7, 0xC0, 0x03, 0xF0, 0x0F, 0xBE,
  0x00, 0x1F, 0x80, 0xFD, 0xF8, 0x01, 0xF8, 0x07, 0xEF, 0xC0, 0x0F, 0xC0,
  0x3F, 0x3E, 0x00, 0x7E, 0x01, 0xF9, 0xF0, 0x03, 0xF0, 0x0F, 0xCF, 0x80,
  0x1F, 0x80, 0x7E, 0x7E, 0x00, 0xFC, 0x07, 0xE3, 0xF0, 0x0F, 0xC0, 0x3F,
  0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x7C, 0x03, 0xF0, 0x0F, 0xC3, 0xE0, 0x1F,
  0x80, 0x7E, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0xFC, 0x07, 0xE0, 0x1F, 0x87,
  0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0x03, 0xF0, 0x0F, 0xC0, 0xF8, 0x1F, 0x80,
  0x7E, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x3F, 0x07, 0xE0, 0x1F, 0x81, 0xF8,
  0x3F, 0x00, 0xFC, 0x07, 0xC1, 0xF8, 0x0F, 0xC0, 0x3E, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0xFC, 0x03, 0xF0, 0x0F, 0xC7, 0xE0, 0x1F, 0x80, 0x7E, 0x3F,
  0x00, 0xFC, 0x01, 0xF1, 0xF8, 0x07, 0xE0, 0x0F, 0x8F, 0xC0, 0x7E, 0x00,
  0x7E, 0x7C, 0x03, 0xF0, 0x03, 0xF3, 0xE0, 0x1F, 0x80, 0x1F, 0xBF, 0x00,
  0xFC, 0x00, 0x7D, 0xF8, 0x07, 0xE0, 0x03, 0xEF, 0xC0, 0x3F, 0x00, 0x1F,
  0xFE, 0x01, 0xF8, 0x00, 0xFF, 0xF0, 0x1F, 0x80, 0x07, 0xFF, 0x00, 0xFC,
  0x00, 0x1F, 0xF8, 0x07, 0xE0, 0x00, 0xFF, 0xC0, 0x3F, 0x00, 0x07, 0xFE,
  0x01, 0xF8, 0x00, 0x3F, 0xF0, 0x0F, 0xC0, 0x01, 0xFF, 0x80, 0xFC, 0x00,
  0x07, 0xF8, 0x07, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xE0,
  0x0F, 0xF8, 0x0F, 0xF0, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0x81, 0xFC,
  0x00, 0x07, 0xE0, 0x7E, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00, 0x7E, 0x0F,
  0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x01, 0xF8,
  0x3F, 0x00, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x0F,
  0xE1, 0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xF0, 0xFE, 0x00,
  0x01, 0xFC, 0x3F, 0x00, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x7E, 0x1F,
  0xC0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x03, 0xF0,
  0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x00,
  0x7E, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x07, 0xE0, 0xFC, 0x00,
  0x03, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x7F, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x7F, 0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF0, 0x07,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0x70, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0xF0, 0x00, 0xFF, 0xC0, 0x1F, 0x80, 0x00, 0xFF, 0x80, 0x7E,
  0x00, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x07, 0xE0, 0x00, 0x07,
  0xF0, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x7F, 0x03, 0xF0,
  0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x00, 0x1F,
  0xC0, 0xFC, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x01, 0xFC,
  0x07, 0xE0, 0x00, 0x0F, 0xF0, 0x1F, 0x80, 0x00, 0x7F, 0x80, 0x7E, 0x00,
  0x03, 0xFC, 0x01, 0xF8, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xEF,
  0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF0, 0x00, 0xFE, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0x83,
  0xF0, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x1F,
  0xC3, 0xF0, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x3F, 0x0F, 0xE0,
  0x00, 0x07, 0xE1, 0xFC, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x00, 0x3F, 0x87,
  0xE0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x1F,
  0x87, 0xF0, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x00, 0xFE, 0x1F, 0x80, 0x00,
  0x1F, 0xC3, 0xF0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x7E, 0x0F, 0xC0,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x00, 0x3F, 0x0F,
  0xC0, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x3F,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0xFC, 0x3F, 0x80, 0x00,
  0x3F, 0x87, 0xF0, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x00, 0xFC, 0x0F, 0xC0,
  0x00, 0x3F, 0x81, 0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x03, 0xFC, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFE,
  0x00, 0x3F, 0xF0, 0x07, 0xE0, 0x00, 0x3F, 0xC0, 0x3F, 0x00, 0x00, 0xFE,
  0x01, 0xF8, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x7E, 0x00,
  0x00, 0xFE, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x00, 0x3F, 0x81,
  0xF8, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00,
  0x7E, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x3F, 0x81, 0xFC,
  0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x01, 0xFC,
  0x03, 0xF0, 0x00, 0x1F, 0xE0, 0x1F, 0x80, 0x07, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x07, 0xE0, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0xFE, 0x00,
  0x07, 0xE0, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x07,
  0xE0, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x1F,
  0xC0, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x07, 0xE0,
  0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x07, 0xF0,
  0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0xFF, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0x1F, 0xE0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x7E, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x3F,
  0x80, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x02, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC1, 0xF8,
  0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0xFE, 0x00,
  0x03, 0xFC, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x1F, 0xF8, 0x07, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x1F, 0x80, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00,
  0x7F, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x7E, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x3F, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x00,
  0xFC, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0xFC, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x1F, 0x80,
  0xFE, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x01,
  0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x03, 0xF8, 0x0F, 0xC0,
  0x00, 0x3F, 0x81, 0xFC, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x3F, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x1F, 0x80, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x3F, 0x80,
  0x00, 0x7E, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x7E, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x0F,
  0xC0, 0x7F, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x7E, 0x00,
  0x00, 0xFC, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x01, 0xF8, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFF,
  0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xEF, 0xC0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x7F, 0x3F, 0x00,
  0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x00, 0x7E, 0x1F,
  0x80, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0x7E,
  0x0F, 0xE0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00,
  0x7E, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x03, 0xF0, 0x0F, 0xC0,
  0x00, 0xFE, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x03, 0xF0, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x07, 0xF0,
  0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x03, 0xF0,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x01,
  0xF8, 0x07, 0xE0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x3F, 0x00,
  0x00, 0x7E, 0x07, 0xE0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x01, 0xF8, 0x3F,
  0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x00, 0xFC,
  0x7F, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x00,
  0x7E, 0x7E, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x00, 0xF9, 0xF0, 0x00,
  0x00, 0x1F, 0x7E, 0x00, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x00, 0x7D, 0xF0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x3F, 0x80, 0x1F, 0x8F, 0x80, 0x1F, 0xC0, 0x1F, 0x87, 0xC0,
  0x0F, 0xE0, 0x0F, 0xC7, 0xE0, 0x0F, 0xF0, 0x07, 0xE3, 0xF0, 0x07, 0xF8,
  0x03, 0xE1, 0xF8, 0x03, 0xFC, 0x03, 0xF0, 0xFC, 0x01, 0xDE, 0x01, 0xF8,
  0x7E, 0x01, 0xEF, 0x00, 0xF8, 0x3F, 0x00, 0xF7, 0x80, 0x7C, 0x1F, 0x80,
  0x7B, 0xC0, 0x7E, 0x0F, 0xC0, 0x79, 0xE0, 0x3F, 0x07, 0xE0, 0x3C, 0xF0,
  0x1F, 0x03, 0xF0, 0x1E, 0x70, 0x0F, 0x81, 0xF8, 0x0F, 0x38, 0x0F, 0xC0,
  0xFC, 0x0F, 0x1C, 0x07, 0xE0, 0x7E, 0x07, 0x9E, 0x03, 0xE0, 0x3F, 0x03,
  0xCF, 0x01, 0xF0, 0x1F, 0x03, 0xC7, 0x81, 0xF8, 0x0F, 0x81, 0xE3, 0xC0,
  0xF8, 0x07, 0xC0, 0xF1, 0xE0, 0x7C, 0x03, 0xE0, 0x78, 0xF0, 0x7E, 0x01,
  0xF0, 0x78, 0x78, 0x3F, 0x00, 0xF8, 0x3C, 0x3C, 0x1F, 0x00, 0x7C, 0x1E,
  0x1E, 0x0F, 0x80, 0x3E, 0x1E, 0x0F, 0x0F, 0xC0, 0x1F, 0x0F, 0x07, 0x87,
  0xE0, 0x1F, 0x87, 0x83, 0xC3, 0xE0, 0x0F, 0xC3, 0xC1, 0xE1, 0xF0, 0x07,
  0xE3, 0xC0, 0xF1, 0xF8, 0x03, 0xF1, 0xE0, 0x78, 0xF8, 0x01, 0xF8, 0xF0,
  0x3C, 0x7C, 0x00, 0xFC, 0xF0, 0x1E, 0x3E, 0x00, 0x7E, 0x78, 0x0F, 0x3F,
  0x00, 0x3F, 0x3C, 0x07, 0x9F, 0x00, 0x1F, 0x9E, 0x03, 0xCF, 0x80, 0x0F,
  0x9E, 0x01, 0xCF, 0xC0, 0x07, 0xCF, 0x00, 0xE7, 0xC0, 0x03, 0xE7, 0x80,
  0xF3, 0xE0, 0x01, 0xF7, 0xC0, 0x79, 0xF0, 0x00, 0xFB, 0xC0, 0x3D, 0xF8,
  0x00, 0x7D, 0xE0, 0x1E, 0xF8, 0x00, 0x3E, 0xF0, 0x0F, 0x7C, 0x00, 0x1F,
  0xF0, 0x07, 0xBE, 0x00, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x0F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0x80, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0xFD, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x00, 0x0F, 0xE3,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00,
  0x00, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xFB, 0xF0, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x01, 0xF8,
  0x7E, 0x00, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00,
  0x0F, 0xC0, 0x7E, 0x00, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x1F,
  0xC0, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x03, 0xF0, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0xFE, 0x01, 0xFC, 0x00,
  0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x00, 0xFE, 0x0F,
  0xE0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x00,
  0xFE, 0x3F, 0x00, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0x1F, 0xBF, 0x80,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0xFF, 0xE0, 0x07,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFD, 0xE0, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x07, 0xE7, 0xC0,
  0x00, 0x1F, 0x8F, 0x80, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x00,
  0x03, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x1F, 0x80, 0x7C, 0x00,
  0x3E, 0x00, 0xF8, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07,
  0xC0, 0x03, 0xE0, 0x1F, 0x80, 0x07, 0xC0, 0x3E, 0x00, 0x0F, 0x80, 0xFC,
  0x00, 0x0F, 0x83, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3E, 0x1F, 0x80,
  0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x00, 0xFB, 0xF0, 0x00,
  0x01, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0x80,
  0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0x83, 0xF0, 0x03, 0xFF, 0xF0, 0xFC, 0x01, 0xFF, 0xFE, 0x3F, 0x00, 0xFF,
  0xFF, 0xDF, 0xC0, 0x7F, 0xFF, 0xF7, 0xE0, 0x3F, 0xE0, 0x3F, 0xF8, 0x1F,
  0xE0, 0x03, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x1F, 0xE0,
  0xFE, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x3F,
  0x07, 0xE0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00,
  0xFC, 0x1F, 0x80, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x1F, 0x83, 0xF8, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x7E, 0x0F, 0xC0,
  0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x03, 0xF8, 0x7F,
  0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x7F,
  0x07, 0xF0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x0F,
  0xF8, 0x0F, 0xF8, 0x0F, 0x7E, 0x03, 0xFF, 0xFF, 0xDF, 0x80, 0x7F, 0xFF,
  0xEF, 0xE0, 0x1F, 0xFF, 0xF3, 0xF0, 0x03, 0xFF, 0xF8, 0xFC, 0x00, 0x3F,
  0xF8, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x1E, 0x00, 0x03, 0xF0,
  0x7F, 0xF0, 0x00, 0xFC, 0x3F, 0xFF, 0x00, 0x3F, 0x3F, 0xFF, 0xE0, 0x0F,
  0xDF, 0xFF, 0xFC, 0x03, 0xF7, 0xFF, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xE0,
  0x7E, 0xC0, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x1F,
  0x81, 0xFC, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00,
  0x7E, 0x0F, 0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x07, 0xE0, 0xFC, 0x00,
  0x01, 0xF8, 0x3F, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3F, 0x83, 0xF0,
  0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x1F,
  0x80, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xF0,
  0x7E, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x1F,
  0x83, 0xF8, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00,
  0xFC, 0x0F, 0xE0, 0x00, 0x7F, 0x07, 0xFC, 0x00, 0x3F, 0xC1, 0xFF, 0x00,
  0x1F, 0xE0, 0x7E, 0xF0, 0x0F, 0xF0, 0x1F, 0xBF, 0xFF, 0xFC, 0x07, 0xEF,
  0xFF, 0xFE, 0x01, 0xF9, 0xFF, 0xFF, 0x00, 0x7E, 0x3F, 0xFF, 0x00, 0x3F,
  0x87, 0xFF, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x0F, 0xE0, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0xFF, 0x0F, 0xE0, 0x00,
  0x3F, 0x87, 0xF0, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x07, 0xE3, 0xF8, 0x00,
  0x03, 0xF1, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x1F, 0xC3,
  0xF8, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x0F, 0xE0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x00, 0xFC, 0x00,
  0x0F, 0xFE, 0x0F, 0xC0, 0x03, 0xFF, 0xF0, 0xFC, 0x00, 0x7F, 0xFF, 0x8F,
  0xC0, 0x0F, 0xFF, 0xFD, 0xFC, 0x01, 0xFF, 0xFF, 0xDF, 0x80, 0x3F, 0xE0,
  0x3F, 0xF8, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x7F, 0x00, 0x07, 0xF8, 0x0F,
  0xE0, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x3F,
  0x01, 0xFC, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x3F, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x1F, 0x80, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x3F,
  0x80, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x7E,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00,
  0x0F, 0xE0, 0x3F, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x7E,
  0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x01, 0xFC,
  0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x7F, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x3D, 0xF8, 0x03, 0xFF, 0xFF, 0xDF, 0x80, 0x1F, 0xFF, 0xFB, 0xF8,
  0x01, 0xFF, 0xFF, 0x3F, 0x00, 0x0F, 0xFF, 0xE3, 0xF0, 0x00, 0x3F, 0xF8,
  0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xF8, 0x03, 0xFC, 0x07,
  0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x7E, 0x1F,
  0x80, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x7E, 0x3F,
  0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x7E, 0x3F,
  0x00, 0x00, 0x7E, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFC, 0x7E,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x03, 0xF0, 0xFE,
  0x00, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x1F, 0xE0, 0x3F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x0F,
  0xC0, 0x1F, 0xFF, 0xC7, 0xE0, 0x1F, 0xFF, 0xF3, 0xF0, 0x1F, 0xFF, 0xFB,
  0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xF0, 0x0F, 0xFC, 0x1F, 0xE0, 0x03,
  0xFE, 0x0F, 0xE0, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x7F, 0x87, 0xF0, 0x00,
  0x1F, 0xC3, 0xF0, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x07, 0xE1, 0xF8, 0x00,
  0x03, 0xF0, 0xFC, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0xFC, 0x3F, 0x00,
  0x00, 0xFE, 0x1F, 0x80, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x3F, 0x0F, 0xC0,
  0x00, 0x1F, 0x87, 0xE0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x07, 0xE1, 0xF8,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x01, 0xF8, 0x7F,
  0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0xFF, 0x07,
  0xF0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0xEF, 0xC1, 0xFF, 0x00, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF7, 0xE0, 0x3F, 0xFF, 0xFB, 0xF0, 0x0F, 0xFF, 0xF9, 0xF8,
  0x03, 0xFF, 0xF0, 0xFC, 0x00, 0x7F, 0xF0, 0xFE, 0x00, 0x03, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0,
  0x1E, 0x00, 0x03, 0xF0, 0x7F, 0xF0, 0x00, 0xFC, 0x7F, 0xFF, 0x00, 0x3F,
  0x3F, 0xFF, 0xE0, 0x0F, 0xDF, 0xFF, 0xFC, 0x03, 0xF7, 0xFF, 0xFF, 0x01,
  0xFF, 0xC0, 0x3F, 0xE0, 0x7E, 0xC0, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0xFE,
  0x07, 0xF0, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x01,
  0xF8, 0x1F, 0x80, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFE, 0x0F, 0xC0,
  0x00, 0x3F, 0x83, 0xF0, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x03, 0xF0, 0x7E,
  0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x01,
  0xF8, 0x3F, 0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x3F, 0x87, 0xF0, 0x00,
  0x0F, 0xC1, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x80,
  0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x07, 0xF0, 0x7E,
  0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x07, 0xF0,
  0x1F, 0x80, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x07, 0xF8, 0x07, 0xE0, 0x00,
  0x7F, 0x80, 0x3F, 0x00, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x03, 0xF8,
  0x00, 0x3F, 0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x03, 0xFC, 0x00, 0x0F, 0xC0,
  0x3F, 0xC0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x1F, 0xC0, 0x00,
  0x3F, 0x01, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x3F, 0x80,
  0x00, 0x7E, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x00,
  0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03,
  0xF8, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x7E,
  0x00, 0x03, 0xF8, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x00, 0x7F,
  0x00, 0xFC, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x60, 0x03, 0x00, 0x3F, 0x1F, 0xC1, 0xFE, 0x01, 0xF9,
  0xFF, 0x1F, 0xF8, 0x0F, 0xDF, 0xFD, 0xFF, 0xE0, 0x7D, 0xFF, 0xEF, 0xFF,
  0x03, 0xEC, 0x7F, 0xE3, 0xF8, 0x1F, 0x81, 0xFC, 0x0F, 0xE1, 0xFC, 0x07,
  0xE0, 0x3F, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x7E, 0x01, 0xF0, 0x0F, 0x83,
  0xF0, 0x0F, 0x80, 0x7C, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0xF8, 0x07, 0xC0,
  0x3F, 0x07, 0xC0, 0x3E, 0x01, 0xF8, 0x7E, 0x01, 0xF0, 0x0F, 0xC3, 0xF0,
  0x0F, 0x80, 0x7E, 0x1F, 0x80, 0x7C, 0x03, 0xE0, 0xFC, 0x03, 0xE0, 0x3F,
  0x07, 0xE0, 0x3E, 0x01, 0xF8, 0x3E, 0x01, 0xF0, 0x0F, 0xC3, 0xF0, 0x0F,
  0x80, 0x7E, 0x1F, 0x80, 0x7C, 0x03, 0xF0, 0xFC, 0x03, 0xE0, 0x1F, 0x07,
  0xE0, 0x1F, 0x00, 0xF8, 0x3F, 0x01, 0xF0, 0x0F, 0xC1, 0xF0, 0x0F, 0x80,
  0x7E, 0x1F, 0x80, 0x7C, 0x03, 0xF0, 0xFC, 0x03, 0xE0, 0x1F, 0x87, 0xE0,
  0x1F, 0x00, 0xF8, 0x3F, 0x00, 0xF8, 0x07, 0xC1, 0xF8, 0x07, 0xC0, 0x7E,
  0x0F, 0x80, 0x7C, 0x03, 0xF0, 0x7C, 0x03, 0xE0, 0x1F, 0x87, 0xE0, 0x1F,
  0x00, 0xFC, 0x3F, 0x00, 0xF8, 0x07, 0xE1, 0xF8, 0x07, 0xC0, 0x3E, 0x0F,
  0xC0, 0x3E, 0x03, 0xF0, 0x7E, 0x03, 0xE0, 0x1F, 0x83, 0xE0, 0x1F, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0xFE, 0x1F, 0xFC, 0x00, 0x3F,
  0x1F, 0xFF, 0xC0, 0x0F, 0xCF, 0xFF, 0xF8, 0x03, 0xF7, 0xFF, 0xFF, 0x00,
  0xFD, 0xFF, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xF8, 0x1F, 0xB0, 0x01, 0xFE,
  0x07, 0xF8, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x01,
  0xF8, 0x1F, 0x80, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x1F, 0x83, 0xF8, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x7E, 0x0F, 0xC0,
  0x00, 0x3F, 0x83, 0xF0, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0x7F,
  0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0x7E,
  0x0F, 0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x01,
  0xF8, 0x3F, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3F, 0x83, 0xF0, 0x00,
  0x0F, 0xE1, 0xFC, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x00, 0xFC, 0x1F, 0x80,
  0x00, 0x3F, 0x07, 0xE0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xF0, 0x7E,
  0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC,
  0x07, 0xFC, 0x07, 0xFC, 0x07, 0xF0, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0xFE,
  0x1F, 0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x7E,
  0x3F, 0x80, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x7E,
  0x3F, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0xFE,
  0x7F, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0xFC,
  0x7E, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x00, 0xFC,
  0xFE, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x01, 0xF8,
  0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x03, 0xF0,
  0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0xE0,
  0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x5C, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xE1, 0xFF,
  0xC0, 0x00, 0xFC, 0x3F, 0xFF, 0x00, 0x0F, 0xCF, 0xFF, 0xF8, 0x00, 0xFD,
  0xFF, 0xFF, 0xC0, 0x0F, 0xDF, 0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xE0,
  0x1F, 0xB0, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00,
  0x7E, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x7E, 0x03, 0xF8,
  0x00, 0x07, 0xE0, 0x3F, 0x80, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x3F, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00,
  0xFE, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0xFC, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x7E, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x01,
  0xF8, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x01, 0xF8, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0xFE, 0x00, 0x03, 0xF0, 0x0F, 0xE0, 0x00, 0x7F, 0x01,
  0xFF, 0x00, 0x07, 0xF0, 0x1F, 0xB0, 0x01, 0xFE, 0x01, 0xFB, 0xC0, 0x3F,
  0xC0, 0x1F, 0xBF, 0xFF, 0xFC, 0x01, 0xFB, 0xFF, 0xFF, 0x80, 0x1F, 0x9F,
  0xFF, 0xF0, 0x01, 0xF8, 0xFF, 0xFC, 0x00, 0x3F, 0x87, 0xFF, 0x80, 0x03,
  0xF0, 0x0F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0x83, 0xF0, 0x03, 0xFF, 0xF0, 0xFC, 0x01, 0xFF, 0xFE, 0x7F, 0x00,
  0xFF, 0xFF, 0xDF, 0x80, 0x7F, 0xFF, 0xF7, 0xE0, 0x3F, 0xE0, 0x3D, 0xF8,
  0x1F, 0xE0, 0x03, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x1F,
  0xE0, 0xFC, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x00,
  0x01, 0xFC, 0x1F, 0x80, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x1F, 0x83, 0xF8,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x7E, 0x0F,
  0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x03, 0xF0,
  0x7F, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00,
  0x7F, 0x07, 0xF0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x80,
  0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0x7E, 0x03, 0xFF, 0xFF, 0xDF, 0x80, 0x7F,
  0xFF, 0xEF, 0xE0, 0x1F, 0xFF, 0xF3, 0xF0, 0x03, 0xFF, 0xF8, 0xFC, 0x00,
  0x3F, 0xF8, 0x3F, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0xFC, 0x3F, 0xFC, 0x00, 0x7E, 0x1F, 0xFF, 0x80, 0x1F, 0x9F, 0xFF, 0xF0,
  0x07, 0xE7, 0xFF, 0xFE, 0x01, 0xFB, 0xFF, 0xFF, 0xC0, 0x7F, 0xE0, 0x0F,
  0xF0, 0x1F, 0xF0, 0x01, 0xFC, 0x0F, 0xF8, 0x00, 0x3F, 0x83, 0xFC, 0x00,
  0x0F, 0xE0, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x7E, 0x0F, 0xC0,
  0x00, 0x1F, 0x83, 0xF0, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x03, 0xF8, 0x7F,
  0x00, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xF0, 0x03, 0xFC, 0x0F, 0xE0,
  0x00, 0xFE, 0x07, 0xE0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x1F, 0xC3, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x07,
  0xF1, 0xFC, 0x00, 0x03, 0xF0, 0xFF, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x07,
  0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xE0, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00,
  0x7F, 0x0F, 0xE0, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x00,
  0x01, 0xF8, 0x3F, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0xFC, 0x1F,
  0x80, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xF0,
  0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x1F,
  0x83, 0xF0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00,
  0x7E, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xE1, 0xFC, 0x00,
  0x03, 0xF0, 0x7F, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x01, 0xF8, 0x1F,
  0xC0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x3F, 0xC0,
  0x3F, 0xE0, 0x3F, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x1F, 0xDF, 0x80, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x0F, 0xE7, 0xE0,
  0x00, 0x07, 0xE3, 0xF0, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x03, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xFC, 0x0F,
  0xC0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x7E, 0x01,
  0xF8, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x0F, 0xC0,
  0x03, 0xF0, 0x07, 0xE0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x7E, 0x03, 0xF0,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x00, 0xFC, 0x7E,
  0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x1F, 0x9F,
  0x80, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0xFF,
  0xE0, 0x0F, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0x00, 0x7D, 0xF8, 0x07, 0xF8,
  0x03, 0xEF, 0xC0, 0x3F, 0xC0, 0x3F, 0x7E, 0x01, 0xFE, 0x01, 0xF3, 0xF0,
  0x1E, 0xF0, 0x0F, 0x9F, 0x80, 0xF7, 0x80, 0xFC, 0xFC, 0x07, 0xBC, 0x07,
  0xC7, 0xE0, 0x39, 0xE0, 0x3E, 0x3F, 0x03, 0xCF, 0x01, 0xF1, 0xF0, 0x1E,
  0x78, 0x1F, 0x0F, 0x80, 0xE3, 0xC0, 0xF8, 0x7C, 0x0F, 0x1E, 0x07, 0xC3,
  0xE0, 0x78, 0xF0, 0x7C, 0x1F, 0x03, 0xC7, 0x83, 0xE0, 0xF8, 0x3C, 0x3C,
  0x1F, 0x07, 0xC1, 0xE1, 0xE1, 0xF0, 0x3E, 0x0F, 0x0F, 0x0F, 0x81, 0xF0,
  0xF0, 0x78, 0x7C, 0x0F, 0x87, 0x83, 0xC7, 0xC0, 0x7C, 0x3C, 0x1E, 0x3E,
  0x03, 0xE3, 0xC0, 0xF1, 0xF0, 0x1F, 0x1E, 0x07, 0x8F, 0x00, 0xF8, 0xF0,
  0x3C, 0xF8, 0x07, 0xCF, 0x01, 0xE7, 0xC0, 0x3E, 0x78, 0x0F, 0x3C, 0x01,
  0xF3, 0xC0, 0x7B, 0xE0, 0x0F, 0xBC, 0x03, 0xDF, 0x00, 0x7D, 0xE0, 0x1E,
  0xF0, 0x03, 0xEF, 0x00, 0xFF, 0x80, 0x1F, 0x70, 0x07, 0xFC, 0x00, 0xFF,
  0x80, 0x3F, 0xC0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x07,
  0xF8, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x0F,
  0xF0, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00,
  0x3F, 0x81, 0xFC, 0x00, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x00, 0x7F, 0x0F,
  0xE0, 0x00, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00,
  0x00, 0xFD, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00,
  0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0x87, 0xE0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x07, 0xE1, 0xF8, 0x00,
  0x07, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x01, 0xF8, 0x7F, 0x00,
  0x00, 0xFC, 0x3F, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x3F, 0x0F, 0xC0,
  0x00, 0x3F, 0x87, 0xE0, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x0F, 0xC3, 0xF8,
  0x00, 0x07, 0xE1, 0xF8, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x01, 0xF8, 0x7E,
  0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0x7E, 0x1F,
  0xC0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x03, 0xF0,
  0x7E, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFE,
  0x0F, 0xE0, 0x01, 0xFF, 0x07, 0xF8, 0x01, 0xFF, 0x83, 0xFF, 0x03, 0xFF,
  0x80, 0xFF, 0xFF, 0xEF, 0xC0, 0x3F, 0xFF, 0xE7, 0xE0, 0x1F, 0xFF, 0xE3,
  0xF0, 0x03, 0xFF, 0xE1, 0xF8, 0x00, 0x7F, 0xC1, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xE0, 0xFF, 0xF0, 0x00, 0xFC,
  0x3F, 0xFF, 0x00, 0x3F, 0x0F, 0xFF, 0xF0, 0x07, 0xE3, 0xFF, 0xFF, 0x00,
  0xFC, 0x7E, 0x0F, 0xE0, 0x1F, 0x9F, 0xC0, 0xFE, 0x03, 0xF3, 0xF0, 0x0F,
  0xE0, 0xFC, 0x7E, 0x01, 0xFF, 0x7F, 0x8F, 0xC0, 0x1F, 0xFF, 0xE1, 0xF8,
  0x01, 0xFF, 0xF8, 0x7E, 0x00, 0x1F, 0xFE, 0x0F, 0xC0, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0x80, 0x00,
};

const GFXglyph JetBrainsMono_Italic69pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 41, 0, -1 },
  { 1, 16, 50, 41, 13, -50 },
  { 101, 23, 20, 41, 13, -50 },
  { 159, 40, 50, 41, 2, -50 },
  { 409, 37, 70, 41, 3, -60 },
  { 733, 47, 51, 41, -2, -51 },
  { 1033, 38, 52, 41, 2, -51 },
  { 1280, 10, 20, 41, 19, -50 },
  { 1305, 29, 67, 41, 11, -58 },
  { 1548, 28, 67, 41, 4, -58 },
  { 1783, 36, 36, 41, 4, -42 },
  { 1945, 33, 32, 41, 5, -39 },
  { 2077, 19, 21, 41, 6, -10 },
  { 2127, 23, 6, 41, 10, -26 },
  { 2145, 13, 12, 41, 12, -11 },
  { 2165, 41, 65, 41, 1, -57 },
  { 2499, 35, 52, 41, 4, -51 },
  { 2727, 32, 50, 41, 3, -50 },
  { 2927, 36, 51, 41, 3, -51 },
  { 3157, 36, 51, 41, 3, -50 },
  { 3387, 33, 50, 41, 4, -50 },
  { 3594, 35, 51, 41, 4, -50 },
  { 3818, 34, 51, 41, 3, -50 },
  { 4035, 34, 50, 41, 8, -50 },
  { 4248, 35, 52, 41, 4, -51 },
  { 4476, 34, 51, 41, 6, -51 },
  { 4693, 17, 40, 41, 12, -39 },
  { 4778, 22, 50, 41, 7, -39 },
  { 4916, 33, 37, 41, 6, -41 },
  { 5069, 33, 22, 41, 5, -34 },
  { 5160, 33, 37, 41, 4, -41 },
  { 5313, 27, 50, 41, 10, -50 },
  { 5482, 42, 63, 41, 0, -51 },
  { 5813, 35, 50, 41, 0, -50 },
  { 6032, 36, 50, 41, 3, -50 },
  { 6257, 34, 52, 41, 5, -51 },
  { 6478, 36, 50, 41, 3, -50 },
  { 6703, 37, 50, 41, 4, -50 },
  { 6935, 37, 50, 41, 4, -50 },
  { 7167, 34, 52, 41, 5, -51 },
  { 7388, 37, 50, 41, 3, -50 },
  { 7620, 35, 50, 41, 4, -50 },
  { 7839, 38, 51, 41, 1, -50 },
  { 8082, 40, 50, 41, 3, -50 },
  { 8332, 30, 50, 41, 5, -50 },
  { 8520, 39, 50, 41, 2, -50 },
  { 8764, 37, 50, 41, 3, -50 },
  { 8996, 34, 52, 41, 5, -51 },
  { 9217, 38, 50, 41, 3, -50 },
  { 9455, 35, 63, 41, 4, -51 },
  { 9731, 37, 50, 41, 3, -50 },
  { 9963, 37, 52, 41, 3, -51 },
  { 10204, 35, 50, 41, 8, -50 },
  { 10423, 36, 51, 41, 4, -50 },
  { 10653, 35, 50, 41, 8, -50 },
  { 10872, 41, 50, 41, 4, -50 },
  { 11129, 43, 50, 41, 0, -50 },
  { 11398, 37, 50, 41, 7, -50 },
  { 11630, 37, 50, 41, 3, -50 },
  { 11862, 27, 65, 41, 10, -57 },
  { 12082, 21, 65, 41, 11, -57 },
  { 12253, 27, 65, 41, 6, -57 },
  { 12473, 31, 27, 41, 6, -50 },
  { 12578, 34, 5, 41, 0, 2 },
  { 12600, 13, 10, 41, 18, -54 },
  { 12617, 34, 40, 41, 4, -39 },
  { 12787, 34, 51, 41, 3, -50 },
  { 13004, 33, 40, 41, 5, -39 },
  { 13169, 36, 51, 41, 4, -50 },
  { 13399, 32, 40, 41, 5, -39 },
  { 13559, 47, 62, 41, -3, -50 },
  { 13924, 33, 51, 41, 5, -39 },
  { 14135, 34, 50, 41, 3, -50 },
  { 14348, 34, 54, 41, 2, -54 },
  { 14578, 36, 66, 41, 1, -54 },
  { 14875, 37, 50, 41, 4, -50 },
  { 15107, 29, 50, 41, 7, -50 },
  { 15289, 37, 39, 41, 2, -39 },
  { 15470, 34, 39, 41, 3, -39 },
  { 15636, 32, 40, 41, 5, -39 },
  { 15796, 36, 51, 41, 1, -39 },
  { 16026, 34, 51, 41, 4, -39 },
  { 16243, 34, 39, 41, 5, -39 },
  { 16409, 33, 40, 41, 4, -39 },
  { 16574, 33, 48, 41, 6, -48 },
  { 16772, 34, 39, 41, 4, -38 },
  { 16938, 33, 38, 41, 7, -38 },
  { 17095, 37, 38, 41, 5, -38 },
  { 17271, 39, 38, 41, 1, -38 },
  { 17457, 33, 50, 41, 5, -38 },
  { 17664, 34, 38, 41, 3, -38 },
  { 17826, 36, 65, 41, 6, -57 },
  { 18119, 17, 65, 41, 13, -57 },
  { 18258, 35, 65, 41, 2, -57 },
  { 18543, 35, 14, 41, 4, -31 },
};

const GFXfont JetBrainsMono_Italic69pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Italic69pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Italic69pt7bGlyphs,
  0x20, 0x7E, 91
};

#endif // _JETBRAINSMONO_ITALIC69PT7B_H_
