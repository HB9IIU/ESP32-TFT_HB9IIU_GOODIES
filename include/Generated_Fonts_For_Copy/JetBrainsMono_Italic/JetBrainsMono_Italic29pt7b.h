#ifndef _JETBRAINSMONO_ITALIC29PT7B_H_
#define _JETBRAINSMONO_ITALIC29PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Italic.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Italic29pt7bBitmaps[] PROGMEM = {
  0x00, 0x0E, 0x1C, 0x38, 0x70, 0xE3, 0x87, 0x0E, 0x1C, 0x30, 0x60, 0xC1,
  0x83, 0x0C, 0x00, 0x00, 0x01, 0xE7, 0xC7, 0x00, 0x71, 0xDC, 0x77, 0x1D,
  0xC6, 0x61, 0x98, 0x66, 0x3B, 0x8E, 0xE3, 0x00, 0x01, 0x83, 0x00, 0xC3,
  0x80, 0xE1, 0x80, 0x60, 0xC0, 0x30, 0xE0, 0x38, 0x64, 0xFF, 0xFC, 0x7F,
  0xFE, 0x0E, 0x18, 0x06, 0x0C, 0x03, 0x0C, 0x03, 0x06, 0x01, 0x83, 0x07,
  0xFF, 0xE3, 0xFF, 0xF0, 0x60, 0xC0, 0x30, 0xC0, 0x30, 0x60, 0x18, 0x30,
  0x0C, 0x30, 0x0C, 0x18, 0x00, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x03, 0xFC, 0x07, 0xFE, 0x0E, 0x4E, 0x1C, 0xC6, 0x1C, 0xC6, 0x1C,
  0xC0, 0x1C, 0xC0, 0x1C, 0xC0, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01,
  0xF8, 0x01, 0xBC, 0x01, 0x9C, 0x01, 0x1C, 0x61, 0x1C, 0x63, 0x1C, 0x73,
  0x38, 0x7B, 0x78, 0x3F, 0xF0, 0x1F, 0xC0, 0x02, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x07, 0xC0, 0x70, 0xFE, 0x0E, 0x18, 0x60, 0xC1, 0x86,
  0x18, 0x18, 0x63, 0x01, 0x86, 0x60, 0x18, 0xCE, 0x01, 0xFD, 0xC0, 0x1F,
  0x98, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x60, 0x01, 0x9F, 0x80,
  0x3B, 0xF8, 0x03, 0x31, 0xC0, 0x67, 0x1C, 0x0C, 0x61, 0x81, 0x86, 0x18,
  0x30, 0x61, 0x87, 0x07, 0xF0, 0xE0, 0x3E, 0x00, 0x03, 0xF0, 0x0F, 0xF8,
  0x0E, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x00, 0x1C, 0x00, 0x0C, 0x00,
  0x0E, 0x00, 0x1F, 0x00, 0x3F, 0x01, 0x73, 0x8E, 0x63, 0x8C, 0xE1, 0xDC,
  0xE0, 0xF8, 0xE0, 0xF0, 0xE0, 0x70, 0xE0, 0xF0, 0xE3, 0xF8, 0xFF, 0xB8,
  0x7E, 0x1C, 0x77, 0x76, 0xEE, 0xEE, 0xC0, 0x00, 0x10, 0x07, 0x01, 0xE0,
  0x3C, 0x07, 0x00, 0xE0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0x00,
  0xE0, 0x02, 0x00, 0x08, 0x00, 0x60, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0E,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x1C,
  0x03, 0x80, 0x70, 0x0F, 0x01, 0xE0, 0x78, 0x07, 0x00, 0x80, 0x00, 0x01,
  0xC0, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x08, 0x38, 0x3E, 0x63, 0xFE, 0xDF,
  0xBF, 0xFC, 0x03, 0x00, 0x0F, 0x00, 0x77, 0x00, 0xCE, 0x03, 0x8E, 0x0E,
  0x1E, 0x18, 0x18, 0x00, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0x80, 0x06, 0x00, 0x1E, 0x38, 0xF1, 0xC7, 0x8E, 0x18, 0x70, 0xC0, 0xFF,
  0xFF, 0xFF, 0xF8, 0x13, 0xFF, 0xF7, 0x00, 0x00, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x30, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xF0, 0x1F, 0xF0,
  0x70, 0x71, 0xC0, 0xE3, 0x00, 0xCE, 0x01, 0x9C, 0x03, 0x38, 0x0E, 0x70,
  0x1C, 0xC7, 0x39, 0x9E, 0x63, 0x18, 0xCE, 0x01, 0x9C, 0x07, 0x38, 0x0E,
  0x60, 0x1C, 0xC0, 0x31, 0xC0, 0xE3, 0xC3, 0x83, 0xFE, 0x03, 0xF8, 0x00,
  0x01, 0xF0, 0x0F, 0xC0, 0xF7, 0x07, 0x98, 0x18, 0x60, 0x41, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x38, 0x1F, 0xFF, 0xFF,
  0xF8, 0x03, 0xF8, 0x1F, 0xF8, 0x38, 0x38, 0xE0, 0x71, 0x80, 0x67, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x03, 0xFF, 0xCF, 0xFF, 0x80, 0x0F, 0xFE, 0x1F, 0xFC, 0x00, 0x38, 0x00,
  0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x03, 0xF0, 0x07, 0xF0,
  0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x30, 0x0C, 0x60,
  0x38, 0xE0, 0x71, 0xC1, 0xC1, 0xFF, 0x01, 0xFC, 0x00, 0x00, 0x3C, 0x01,
  0xC0, 0x06, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x0E,
  0x00, 0x70, 0xE3, 0x83, 0x9C, 0x0E, 0xE0, 0x3B, 0x80, 0xCF, 0xFF, 0x3F,
  0xFC, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x1F, 0xFC,
  0x7F, 0xF1, 0x80, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0xF8,
  0x37, 0xF1, 0xF3, 0xE7, 0x83, 0x9C, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0xE0, 0x33, 0x81, 0xCF, 0x0E, 0x1F, 0xF0, 0x3F, 0x80, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1D, 0xF0, 0x3F, 0xF0, 0xF0, 0xF1, 0xC0, 0xE7, 0x00, 0xCE,
  0x01, 0x98, 0x03, 0x30, 0x0E, 0x60, 0x1C, 0xE0, 0x71, 0xE1, 0xC1, 0xFF,
  0x01, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xEE, 0x03, 0xB0, 0x0E, 0xC0, 0x70,
  0x01, 0xC0, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x01, 0xC0,
  0x07, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x07, 0x00,
  0x1C, 0x00, 0xE0, 0x00, 0x03, 0xF8, 0x0F, 0xF8, 0x38, 0x38, 0xE0, 0x71,
  0xC0, 0xE3, 0x81, 0xC7, 0x03, 0x0E, 0x0E, 0x0E, 0x78, 0x0F, 0xC0, 0x1F,
  0x80, 0xF3, 0x83, 0x83, 0x86, 0x03, 0x9C, 0x07, 0x30, 0x0E, 0x60, 0x18,
  0xE0, 0x71, 0xE1, 0xE1, 0xFF, 0x81, 0xFC, 0x00, 0x0F, 0xE0, 0x7F, 0xC3,
  0x83, 0x9C, 0x0E, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xB8, 0x06, 0xE0, 0x3B,
  0x81, 0xEF, 0x0F, 0x1F, 0xD8, 0x3E, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x00, 0x1E, 0x7C, 0xF8,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x9F, 0x3E, 0x38, 0x07,
  0x87, 0xC3, 0xE0, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0xE0, 0xF0, 0x70, 0x38, 0x38, 0x1C, 0x1C, 0x0C, 0x00, 0x00,
  0x04, 0x00, 0x70, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x07, 0x80, 0x18,
  0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xC0,
  0x01, 0x00, 0x7F, 0xFD, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFE, 0xFF, 0xF8, 0x10, 0x00, 0x70, 0x01, 0xF0, 0x01,
  0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xC0, 0x03, 0x00, 0x3C, 0x07, 0xE0,
  0x7C, 0x07, 0xC0, 0x7C, 0x01, 0xC0, 0x0C, 0x00, 0x00, 0x3F, 0x83, 0xFC,
  0x03, 0xE0, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x01, 0xC0, 0x3C,
  0x3F, 0x83, 0xE0, 0x38, 0x03, 0x80, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x0F, 0x80, 0xF0, 0x00, 0x01, 0xFE, 0x01, 0xFF, 0xC0, 0xF0, 0x38,
  0x30, 0x06, 0x1C, 0x01, 0x86, 0x00, 0x63, 0x80, 0x18, 0xC0, 0xF6, 0x30,
  0xFD, 0x8C, 0x30, 0xE3, 0x1C, 0x38, 0xC7, 0x0C, 0x71, 0x83, 0x1C, 0x60,
  0xC6, 0x18, 0x31, 0x86, 0x1C, 0x61, 0x87, 0x18, 0x77, 0xCE, 0x1F, 0x63,
  0x80, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3F,
  0xC0, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x01, 0xF0, 0x03, 0x60, 0x0E, 0xC0,
  0x1D, 0x80, 0x33, 0x00, 0xE6, 0x01, 0x8C, 0x07, 0x18, 0x0E, 0x38, 0x18,
  0x70, 0x70, 0xE0, 0xC1, 0xC3, 0xFF, 0x87, 0xFF, 0x1C, 0x06, 0x38, 0x0C,
  0x60, 0x19, 0xC0, 0x33, 0x80, 0x7E, 0x00, 0xE0, 0x0F, 0xF8, 0x1F, 0xFC,
  0x1C, 0x1E, 0x1C, 0x0E, 0x1C, 0x06, 0x18, 0x0E, 0x18, 0x0E, 0x18, 0x0C,
  0x38, 0x3C, 0x3F, 0xF0, 0x3F, 0xF8, 0x30, 0x38, 0x30, 0x1C, 0x30, 0x1C,
  0x70, 0x1C, 0x70, 0x1C, 0x70, 0x1C, 0x70, 0x38, 0x60, 0xF8, 0x7F, 0xF0,
  0xFF, 0xC0, 0x07, 0xF0, 0x3F, 0xE1, 0xC1, 0xCE, 0x07, 0x38, 0x0C, 0xC0,
  0x33, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x0E, 0xE0, 0x33, 0x81, 0xCF, 0x0E, 0x1F,
  0xF0, 0x3F, 0x80, 0x0F, 0xF0, 0x3F, 0xF8, 0x70, 0x70, 0xE0, 0x71, 0xC0,
  0xE3, 0x01, 0xC6, 0x03, 0x8C, 0x07, 0x38, 0x0E, 0x70, 0x18, 0xE0, 0x31,
  0xC0, 0xE3, 0x01, 0xC6, 0x03, 0x9C, 0x07, 0x38, 0x0C, 0x70, 0x38, 0xE0,
  0x71, 0x87, 0xC3, 0xFF, 0x0F, 0xF8, 0x00, 0x1F, 0xFE, 0x3F, 0xFC, 0x60,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00,
  0xFF, 0xF1, 0xFF, 0xC3, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0xFF, 0x8F, 0xFF, 0x00, 0x0F,
  0xFF, 0x0F, 0xFF, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x38, 0x00, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x30,
  0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60,
  0x00, 0x60, 0x00, 0xE0, 0x00, 0x07, 0xF0, 0x3F, 0xE1, 0xC1, 0xCE, 0x07,
  0x38, 0x0C, 0xC0, 0x33, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x1F,
  0x98, 0xFE, 0x63, 0xFB, 0x80, 0xEE, 0x03, 0xB8, 0x0E, 0xE0, 0x33, 0x81,
  0xCF, 0x0E, 0x1F, 0xF0, 0x3F, 0x80, 0x0C, 0x07, 0x1C, 0x07, 0x1C, 0x06,
  0x1C, 0x06, 0x1C, 0x0E, 0x18, 0x0E, 0x18, 0x0E, 0x18, 0x0E, 0x38, 0x0C,
  0x3F, 0xFC, 0x3F, 0xFC, 0x38, 0x1C, 0x30, 0x1C, 0x30, 0x1C, 0x70, 0x18,
  0x70, 0x18, 0x70, 0x18, 0x70, 0x38, 0x60, 0x38, 0x60, 0x38, 0xE0, 0x38,
  0x1F, 0xFC, 0x7F, 0xF0, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x3F, 0xF8, 0xFF,
  0xE0, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0x80, 0x03, 0x00, 0x0E, 0x70, 0x1C, 0xE0, 0x39, 0xC0, 0xE3, 0xC3,
  0xC3, 0xFF, 0x03, 0xF8, 0x00, 0x0C, 0x03, 0x8E, 0x03, 0x87, 0x03, 0x83,
  0x81, 0xC1, 0xC1, 0xC0, 0xC1, 0xC0, 0x60, 0xE0, 0x30, 0xE0, 0x38, 0xE0,
  0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0x1C, 0x03, 0x0E, 0x01, 0x87, 0x01, 0xC1,
  0xC0, 0xE0, 0xE0, 0x70, 0x30, 0x38, 0x1C, 0x18, 0x0E, 0x0C, 0x03, 0x0E,
  0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x38, 0x03, 0xFF, 0xEF, 0xFF,
  0x00, 0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x1B, 0x1E, 0x1F, 0x3B,
  0x36, 0x33, 0x36, 0x33, 0x66, 0x33, 0x66, 0x33, 0xCE, 0x33, 0xCE, 0x71,
  0x8C, 0x70, 0x0C, 0x70, 0x0C, 0x70, 0x1C, 0x60, 0x1C, 0x60, 0x1C, 0xE0,
  0x18, 0xE0, 0x18, 0xE0, 0x18, 0xE0, 0x38, 0x0E, 0x07, 0x1E, 0x07, 0x1F,
  0x06, 0x1B, 0x06, 0x1B, 0x06, 0x1B, 0x0E, 0x1B, 0x0E, 0x3B, 0x8E, 0x39,
  0x8E, 0x39, 0x8C, 0x39, 0x8C, 0x31, 0x9C, 0x31, 0xDC, 0x30, 0xDC, 0x70,
  0xDC, 0x70, 0xD8, 0x70, 0xD8, 0x60, 0xF8, 0x60, 0x78, 0x60, 0x78, 0xE0,
  0x78, 0x07, 0xF0, 0x3F, 0xE1, 0xC1, 0xCE, 0x07, 0x38, 0x1C, 0xC0, 0x73,
  0x01, 0xDC, 0x07, 0x70, 0x1D, 0xC0, 0x67, 0x01, 0x98, 0x0E, 0x60, 0x3B,
  0x80, 0xEE, 0x03, 0xB8, 0x0C, 0xE0, 0x33, 0x81, 0xCF, 0x0E, 0x1F, 0xF0,
  0x3F, 0x80, 0x0F, 0xFC, 0x1F, 0xFE, 0x1C, 0x0F, 0x1C, 0x07, 0x1C, 0x07,
  0x18, 0x07, 0x18, 0x07, 0x18, 0x07, 0x38, 0x0E, 0x38, 0x1E, 0x3F, 0xFC,
  0x3F, 0xF0, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0x07, 0xF0, 0x1F, 0xF0,
  0x70, 0x71, 0xC0, 0xE3, 0x00, 0xCE, 0x01, 0x9C, 0x07, 0x38, 0x0E, 0x70,
  0x1C, 0xC0, 0x39, 0x80, 0x63, 0x00, 0xCE, 0x01, 0x9C, 0x07, 0x38, 0x0E,
  0x70, 0x1C, 0xE0, 0x31, 0xC0, 0xE3, 0xC3, 0x83, 0xFE, 0x03, 0xF8, 0x00,
  0x70, 0x00, 0x60, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x0F, 0xF8, 0x1F,
  0xFE, 0x1C, 0x1E, 0x1C, 0x07, 0x1C, 0x07, 0x18, 0x07, 0x18, 0x07, 0x18,
  0x0E, 0x38, 0x0E, 0x38, 0x3C, 0x3F, 0xF8, 0x3F, 0xE0, 0x30, 0xE0, 0x30,
  0xE0, 0x70, 0x60, 0x70, 0x70, 0x70, 0x70, 0x70, 0x70, 0x60, 0x38, 0x60,
  0x38, 0xE0, 0x3C, 0x03, 0xFC, 0x07, 0xFE, 0x0E, 0x0E, 0x1C, 0x06, 0x1C,
  0x06, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0xC0, 0x07,
  0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1C, 0x60, 0x1C, 0x60,
  0x1C, 0x70, 0x38, 0x78, 0x78, 0x3F, 0xF0, 0x1F, 0xC0, 0x7F, 0xFF, 0xFF,
  0xFC, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0,
  0x00, 0x18, 0x0E, 0x70, 0x1C, 0xE0, 0x31, 0xC0, 0x63, 0x80, 0xC6, 0x03,
  0x8C, 0x07, 0x38, 0x0E, 0x70, 0x1C, 0xE0, 0x31, 0xC0, 0x63, 0x01, 0xC6,
  0x03, 0x8C, 0x07, 0x38, 0x0E, 0x70, 0x18, 0xE0, 0x71, 0xC0, 0xE3, 0xC3,
  0x83, 0xFE, 0x03, 0xF8, 0x00, 0xC0, 0x1F, 0x00, 0x6C, 0x03, 0xB8, 0x0E,
  0xE0, 0x73, 0x81, 0xCE, 0x06, 0x38, 0x38, 0xE0, 0xC3, 0x87, 0x06, 0x1C,
  0x18, 0x60, 0x63, 0x81, 0x8C, 0x06, 0x70, 0x1D, 0x80, 0x76, 0x01, 0xF8,
  0x07, 0xC0, 0x1F, 0x00, 0x38, 0x00, 0x61, 0xC3, 0xB0, 0xE1, 0x98, 0x70,
  0xCC, 0x78, 0xE6, 0x3C, 0x63, 0x1E, 0x31, 0x8B, 0x19, 0xCD, 0x9C, 0xE6,
  0xCC, 0x72, 0x66, 0x3B, 0x33, 0x1D, 0x9B, 0x8E, 0xCD, 0x86, 0x46, 0xC3,
  0x63, 0xE1, 0xB1, 0xE0, 0xD0, 0xB0, 0x78, 0x58, 0x3C, 0x3C, 0x1E, 0x1C,
  0x0E, 0x0E, 0x00, 0x0E, 0x01, 0xC3, 0x80, 0xE0, 0x60, 0x70, 0x1C, 0x38,
  0x07, 0x0E, 0x00, 0xE7, 0x00, 0x3B, 0x80, 0x06, 0xE0, 0x01, 0xF0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xF0, 0x01, 0xDC, 0x00, 0x63,
  0x00, 0x38, 0xE0, 0x1C, 0x38, 0x0E, 0x07, 0x03, 0x81, 0xC1, 0xC0, 0x30,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0xC0, 0x19, 0xC0, 0x73, 0x81, 0xC3, 0x03,
  0x07, 0x0E, 0x0E, 0x38, 0x0C, 0x70, 0x1D, 0xC0, 0x3B, 0x00, 0x3E, 0x00,
  0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x0F, 0xFF, 0x1F, 0xFE, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x60, 0x00, 0xFF, 0xF8, 0xFF,
  0xF8, 0x0F, 0xF0, 0xFE, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06,
  0x00, 0x60, 0x0F, 0xF0, 0xFE, 0x00, 0xC0, 0xE0, 0xE0, 0x60, 0x60, 0x70,
  0x70, 0x70, 0x30, 0x30, 0x38, 0x38, 0x18, 0x18, 0x1C, 0x1C, 0x1C, 0x0C,
  0x0C, 0x0E, 0x0E, 0x06, 0x06, 0x07, 0x07, 0x07, 0x03, 0x0F, 0xE1, 0xFC,
  0x03, 0x80, 0x60, 0x0C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x06,
  0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0x60, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0x80, 0x30, 0x0E, 0x1F, 0xC3, 0xF8, 0x00, 0x03,
  0x80, 0x3C, 0x06, 0xC0, 0xEC, 0x0C, 0xC1, 0x86, 0x38, 0x63, 0x06, 0x70,
  0x76, 0x03, 0xC0, 0x30, 0xFF, 0xFF, 0xFF, 0xF0, 0xE3, 0x1C, 0x70, 0x0F,
  0xDC, 0x7F, 0xF3, 0xC7, 0xCC, 0x0E, 0x70, 0x19, 0xC0, 0xE6, 0x03, 0x98,
  0x0E, 0xE0, 0x3B, 0x80, 0xEE, 0x03, 0x38, 0x1C, 0xE0, 0x73, 0xC3, 0xC7,
  0xFF, 0x0F, 0x9C, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x3F, 0x06, 0xFF, 0x0F, 0x0E, 0x3C, 0x1C, 0x70, 0x18, 0xE0, 0x31,
  0xC0, 0xE3, 0x01, 0xC6, 0x03, 0x9C, 0x07, 0x38, 0x0C, 0x70, 0x18, 0xE0,
  0x71, 0xA1, 0xC3, 0x7F, 0x8E, 0x7C, 0x00, 0x07, 0xE0, 0x7F, 0xE3, 0xC3,
  0x8E, 0x06, 0x70, 0x1D, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0xB8, 0x0C, 0xE0, 0x73, 0xC3, 0x87, 0xFE, 0x0F, 0xE0, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC1, 0xFB, 0x87, 0xFF,
  0x1E, 0x3E, 0x30, 0x38, 0xE0, 0x31, 0xC0, 0xE3, 0x01, 0xC6, 0x03, 0x9C,
  0x07, 0x38, 0x0E, 0x70, 0x18, 0xE0, 0x71, 0xC0, 0xE3, 0xC3, 0xC3, 0xFF,
  0x83, 0xE7, 0x00, 0x07, 0xE0, 0xFF, 0x8E, 0x0E, 0x60, 0x77, 0x01, 0xB0,
  0x0D, 0x80, 0x6F, 0xFF, 0xFF, 0xFF, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x07,
  0x78, 0x71, 0xFF, 0x87, 0xF0, 0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x78,
  0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x40, 0xFF,
  0xF8, 0x1F, 0xFF, 0x80, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x00, 0x00, 0x70, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xDC,
  0x7F, 0xF3, 0xC7, 0xCE, 0x0E, 0x70, 0x19, 0xC0, 0x66, 0x03, 0x98, 0x0E,
  0x60, 0x3B, 0x80, 0xEE, 0x03, 0x38, 0x1C, 0x79, 0xF1, 0xFF, 0xC3, 0xE7,
  0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x1F, 0xF0, 0x7F, 0x80, 0x0C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x3F, 0x06, 0xFF,
  0x0F, 0x0E, 0x3C, 0x1C, 0x70, 0x18, 0xE0, 0x31, 0x80, 0xE3, 0x01, 0xC6,
  0x03, 0x9C, 0x07, 0x38, 0x0C, 0x70, 0x18, 0xE0, 0x71, 0x80, 0xE3, 0x01,
  0xCE, 0x03, 0x80, 0x00, 0x20, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x83, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x04, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x0F,
  0xFC, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x07, 0x81, 0xFE, 0x07, 0xF8,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C,
  0x07, 0x18, 0x0E, 0x18, 0x1C, 0x38, 0x38, 0x38, 0x70, 0x38, 0xE0, 0x39,
  0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x71, 0xC0, 0x70, 0xE0, 0x70, 0xE0, 0x70,
  0x70, 0x70, 0x70, 0x60, 0x38, 0xE0, 0x3C, 0xFF, 0x0F, 0xE0, 0x06, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x38, 0x03, 0x80, 0x3C, 0x01,
  0xFF, 0x0F, 0xF0, 0x37, 0x9C, 0x6F, 0x7C, 0xE7, 0x19, 0x8C, 0x37, 0x18,
  0x6E, 0x31, 0xDC, 0x63, 0xB0, 0xC7, 0x61, 0x8C, 0xC7, 0x1B, 0x8C, 0x37,
  0x18, 0xEE, 0x31, 0xD8, 0x63, 0xB0, 0xC6, 0x63, 0x8C, 0x1D, 0xF8, 0x37,
  0xF8, 0x78, 0x71, 0xE0, 0xE3, 0x80, 0xC7, 0x01, 0x8C, 0x07, 0x18, 0x0E,
  0x30, 0x1C, 0xE0, 0x39, 0xC0, 0x63, 0x80, 0xC7, 0x03, 0x8C, 0x07, 0x18,
  0x0E, 0x70, 0x1C, 0x07, 0xE0, 0xFF, 0x8F, 0x1E, 0x60, 0x77, 0x01, 0xB8,
  0x0D, 0x80, 0xEC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0D, 0xC0, 0x6E, 0x07,
  0x78, 0x71, 0xFF, 0x07, 0xF0, 0x1D, 0xF8, 0x37, 0xF8, 0x78, 0x71, 0xE0,
  0xE3, 0x80, 0xC7, 0x01, 0x8E, 0x07, 0x18, 0x0E, 0x30, 0x1C, 0xE0, 0x39,
  0xC0, 0x63, 0x80, 0xC7, 0x03, 0x8D, 0x0E, 0x1B, 0xFC, 0x73, 0xE0, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x00, 0x0F, 0xDC, 0x7F,
  0xF3, 0xC7, 0xDC, 0x0E, 0x70, 0x19, 0xC0, 0xE6, 0x03, 0x98, 0x0E, 0xE0,
  0x3B, 0x80, 0xCE, 0x03, 0x38, 0x1C, 0xE0, 0x73, 0xC3, 0xC7, 0xF7, 0x0F,
  0x9C, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x3B, 0xF0,
  0xFF, 0xE3, 0xC3, 0xCE, 0x07, 0x38, 0x1C, 0xC0, 0x77, 0x01, 0xDC, 0x00,
  0x70, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0x0F, 0xF0, 0xFF, 0xCE, 0x0E, 0x60, 0x37, 0x00, 0x38, 0x00,
  0xF0, 0x07, 0xF8, 0x0F, 0xF0, 0x03, 0x80, 0x0C, 0x00, 0x6C, 0x07, 0x70,
  0x7B, 0xFF, 0x8F, 0xF8, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x7F,
  0xFD, 0xFF, 0xF8, 0x70, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x78, 0x00,
  0xFF, 0x01, 0xFC, 0x30, 0x1C, 0xC0, 0x77, 0x01, 0xDC, 0x06, 0x70, 0x19,
  0xC0, 0x66, 0x03, 0x98, 0x0E, 0x60, 0x3B, 0x80, 0xEE, 0x03, 0x38, 0x1C,
  0xE0, 0x73, 0xC3, 0x87, 0xFC, 0x0F, 0xE0, 0xE0, 0x1F, 0x80, 0xEE, 0x03,
  0x98, 0x0C, 0x60, 0x71, 0x81, 0x87, 0x0E, 0x1C, 0x30, 0x71, 0xC0, 0xC6,
  0x03, 0x38, 0x0C, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0x00, 0xE3,
  0x87, 0xC3, 0x86, 0xC2, 0x86, 0xC2, 0x8E, 0xC6, 0x8C, 0xC6, 0x8C, 0xC4,
  0x9C, 0xCC, 0x98, 0xCC, 0x98, 0xC8, 0x98, 0xD8, 0xB0, 0xD8, 0xB0, 0xD0,
  0xB0, 0xF0, 0xE0, 0xF0, 0xE0, 0xE0, 0xE0, 0x1C, 0x07, 0x87, 0x07, 0x83,
  0x83, 0x80, 0xE3, 0x80, 0x73, 0x80, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xC0,
  0x03, 0xE0, 0x01, 0xB0, 0x01, 0xDC, 0x01, 0xCE, 0x01, 0xC3, 0x81, 0xC1,
  0xC0, 0xE0, 0x71, 0xE0, 0x3C, 0x38, 0x1C, 0xC0, 0x73, 0x01, 0xDC, 0x06,
  0x70, 0x19, 0xC0, 0x67, 0x03, 0x98, 0x0E, 0x60, 0x3B, 0x80, 0xEE, 0x07,
  0x38, 0x1C, 0x79, 0xF1, 0xFD, 0xC1, 0xE7, 0x00, 0x1C, 0x00, 0x60, 0x01,
  0x80, 0x0E, 0x1F, 0xF0, 0x7F, 0x80, 0x1F, 0xFE, 0x3F, 0xFC, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x1F, 0xFE, 0x7F, 0xFC,
  0x00, 0x3C, 0x01, 0xF0, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xE0, 0xFF, 0x03, 0xF0,
  0x0F, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x20, 0x1F, 0x00, 0x3C, 0x00,
  0x0E, 0x18, 0x30, 0xE1, 0xC3, 0x87, 0x0C, 0x18, 0x70, 0xE1, 0xC3, 0x86,
  0x0C, 0x38, 0x70, 0xE1, 0xC3, 0x06, 0x0C, 0x38, 0x70, 0xE1, 0xC3, 0x00,
  0x0F, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xFC, 0x01,
  0xF0, 0x3F, 0xC0, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x03, 0xF0, 0x0F, 0x00, 0x00,
  0x3E, 0x0D, 0xFC, 0x3E, 0x71, 0xF8, 0xFF, 0xC1, 0xFB, 0x03, 0x80,
};

const GFXglyph JetBrainsMono_Italic29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 7, 21, 17, 5, -21 },
  { 20, 10, 9, 17, 5, -21 },
  { 32, 17, 21, 17, 1, -21 },
  { 77, 16, 29, 17, 1, -25 },
  { 135, 20, 21, 17, -1, -21 },
  { 188, 16, 21, 17, 1, -21 },
  { 230, 4, 9, 17, 8, -21 },
  { 235, 12, 29, 17, 5, -25 },
  { 279, 12, 29, 17, 1, -25 },
  { 323, 15, 15, 17, 2, -18 },
  { 352, 14, 13, 17, 2, -16 },
  { 375, 7, 9, 17, 3, -4 },
  { 383, 10, 3, 17, 4, -11 },
  { 387, 5, 5, 17, 5, -5 },
  { 391, 18, 27, 17, 0, -24 },
  { 452, 15, 21, 17, 2, -21 },
  { 492, 14, 21, 17, 1, -21 },
  { 529, 15, 21, 17, 1, -21 },
  { 569, 15, 21, 17, 1, -21 },
  { 609, 14, 21, 17, 2, -21 },
  { 646, 14, 21, 17, 2, -21 },
  { 683, 15, 21, 17, 1, -21 },
  { 723, 14, 21, 17, 4, -21 },
  { 760, 15, 21, 17, 1, -21 },
  { 800, 14, 21, 17, 3, -21 },
  { 837, 7, 16, 17, 5, -16 },
  { 851, 9, 21, 17, 3, -16 },
  { 875, 14, 15, 17, 2, -17 },
  { 902, 14, 9, 17, 2, -14 },
  { 918, 14, 15, 17, 1, -17 },
  { 945, 12, 21, 17, 4, -21 },
  { 977, 18, 26, 17, 0, -21 },
  { 1036, 15, 21, 17, 0, -21 },
  { 1076, 16, 21, 17, 1, -21 },
  { 1118, 14, 21, 17, 2, -21 },
  { 1155, 15, 21, 17, 1, -21 },
  { 1195, 15, 21, 17, 2, -21 },
  { 1235, 16, 21, 17, 1, -21 },
  { 1277, 14, 21, 17, 2, -21 },
  { 1314, 16, 21, 17, 1, -21 },
  { 1356, 14, 21, 17, 2, -21 },
  { 1393, 15, 21, 17, 1, -21 },
  { 1433, 17, 21, 17, 1, -21 },
  { 1478, 13, 21, 17, 2, -21 },
  { 1513, 16, 21, 17, 1, -21 },
  { 1555, 16, 21, 17, 1, -21 },
  { 1597, 14, 21, 17, 2, -21 },
  { 1634, 16, 21, 17, 1, -21 },
  { 1676, 15, 26, 17, 2, -21 },
  { 1725, 16, 21, 17, 1, -21 },
  { 1767, 16, 21, 17, 1, -21 },
  { 1809, 15, 21, 17, 3, -21 },
  { 1849, 15, 21, 17, 2, -21 },
  { 1889, 14, 21, 17, 4, -21 },
  { 1926, 17, 21, 17, 2, -21 },
  { 1971, 18, 21, 17, 0, -21 },
  { 2019, 15, 21, 17, 3, -21 },
  { 2059, 16, 21, 17, 1, -21 },
  { 2101, 12, 27, 17, 4, -24 },
  { 2142, 8, 27, 17, 5, -24 },
  { 2169, 11, 27, 17, 3, -24 },
  { 2207, 12, 11, 17, 3, -21 },
  { 2224, 14, 2, 17, 0, 1 },
  { 2228, 5, 4, 17, 8, -23 },
  { 2231, 14, 16, 17, 2, -16 },
  { 2259, 15, 21, 17, 1, -21 },
  { 2299, 14, 16, 17, 2, -16 },
  { 2327, 15, 21, 17, 2, -21 },
  { 2367, 13, 16, 17, 2, -16 },
  { 2393, 20, 26, 17, -1, -21 },
  { 2458, 14, 21, 17, 2, -16 },
  { 2495, 15, 21, 17, 1, -21 },
  { 2535, 14, 23, 17, 1, -23 },
  { 2576, 15, 28, 17, 0, -23 },
  { 2629, 16, 21, 17, 1, -21 },
  { 2671, 12, 21, 17, 3, -21 },
  { 2703, 15, 16, 17, 1, -16 },
  { 2733, 15, 16, 17, 1, -16 },
  { 2763, 13, 16, 17, 2, -16 },
  { 2789, 15, 21, 17, 1, -16 },
  { 2829, 14, 21, 17, 2, -16 },
  { 2866, 14, 16, 17, 2, -16 },
  { 2894, 13, 16, 17, 2, -16 },
  { 2920, 14, 20, 17, 2, -20 },
  { 2955, 14, 16, 17, 2, -16 },
  { 2983, 14, 16, 17, 3, -16 },
  { 3011, 16, 16, 17, 2, -16 },
  { 3043, 17, 16, 17, 0, -16 },
  { 3077, 14, 21, 17, 2, -16 },
  { 3114, 15, 16, 17, 1, -16 },
  { 3144, 14, 27, 17, 3, -24 },
  { 3192, 7, 27, 17, 6, -24 },
  { 3216, 14, 27, 17, 1, -24 },
  { 3264, 14, 6, 17, 2, -13 },
};

const GFXfont JetBrainsMono_Italic29pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Italic29pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Italic29pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _JETBRAINSMONO_ITALIC29PT7B_H_
