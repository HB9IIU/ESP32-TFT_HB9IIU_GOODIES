#ifndef _JETBRAINSMONO_ITALIC7PT7B_H_
#define _JETBRAINSMONO_ITALIC7PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Italic.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Italic7pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x80, 0xB4, 0x37, 0x6F, 0xA0, 0x27, 0x62, 0x3E, 0x40, 0xFF,
  0x08, 0xEB, 0x00, 0x74, 0x5A, 0xF0, 0xC0, 0x2A, 0x49, 0x10, 0x44, 0x92,
  0x70, 0x2F, 0x60, 0x2F, 0x20, 0xE0, 0xC0, 0x80, 0x11, 0x22, 0x44, 0x80,
  0x75, 0xB9, 0x60, 0x62, 0x22, 0xF0, 0x71, 0x24, 0xE0, 0x72, 0x11, 0xE0,
  0x32, 0x5E, 0x20, 0x76, 0x51, 0xE0, 0x24, 0x79, 0x60, 0xE5, 0x28, 0x75,
  0x69, 0x60, 0xF7, 0xA8, 0x42, 0x46, 0x80, 0x73, 0x10, 0x7F, 0x43, 0x68,
  0xE5, 0x48, 0x79, 0xBD, 0xBC, 0x26, 0x66, 0x90, 0x75, 0x69, 0xE0, 0x74,
  0x49, 0x60, 0x75, 0x59, 0xE0, 0x74, 0x78, 0xE0, 0x74, 0x78, 0x80, 0x74,
  0x79, 0x60, 0x55, 0x79, 0xA0, 0x72, 0x22, 0xE0, 0x31, 0x11, 0xE0, 0x56,
  0x6A, 0x90, 0x44, 0x44, 0xF0, 0x55, 0xB9, 0x90, 0x55, 0x5B, 0xA0, 0x75,
  0x59, 0x60, 0x75, 0x78, 0x80, 0x75, 0x99, 0x62, 0x75, 0x6A, 0xB0, 0x74,
  0x21, 0xE0, 0xE9, 0x28, 0x55, 0x59, 0x60, 0xB7, 0x68, 0xAD, 0xAC, 0xEA,
  0x00, 0x56, 0x26, 0x90, 0xB5, 0x28, 0x72, 0x24, 0xE0, 0x6A, 0x49, 0x30,
  0xA9, 0x54, 0x55, 0x58, 0x56, 0x80, 0xE0, 0x80, 0x75, 0x96, 0x47, 0x59,
  0xE0, 0x74, 0x96, 0x17, 0x59, 0x60, 0x67, 0x86, 0x33, 0x44, 0x4C, 0x75,
  0x97, 0x60, 0x47, 0x59, 0x90, 0x26, 0x22, 0xF0, 0x16, 0x22, 0x2E, 0x45,
  0x6A, 0xB0, 0xD2, 0x4E, 0x7B, 0xBD, 0x75, 0x99, 0x65, 0x96, 0x75, 0x9E,
  0x80, 0x75, 0x96, 0x20, 0x75, 0x48, 0x74, 0x3E, 0x5E, 0x4C, 0x55, 0x96,
  0xB7, 0x40, 0xFF, 0x60, 0x56, 0x6B, 0x55, 0x97, 0x60, 0x72, 0x4E, 0x29,
  0x44, 0x90, 0x55, 0x68, 0x42, 0x23, 0x44, 0x80, 0xF0,
};

const GFXglyph JetBrainsMono_Italic7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 2, 5, 4, 1, -5 },
  { 3, 3, 2, 4, 1, -5 },
  { 4, 4, 5, 4, 0, -5 },
  { 7, 4, 7, 4, 0, -6 },
  { 11, 5, 5, 4, 0, -5 },
  { 15, 4, 5, 4, 0, -5 },
  { 18, 1, 2, 4, 2, -5 },
  { 19, 3, 7, 4, 1, -6 },
  { 22, 3, 7, 4, 0, -6 },
  { 25, 4, 3, 4, 0, -4 },
  { 27, 4, 3, 4, 0, -4 },
  { 29, 2, 2, 4, 1, -1 },
  { 30, 2, 1, 4, 1, -3 },
  { 31, 1, 1, 4, 1, -1 },
  { 32, 4, 7, 4, 0, -6 },
  { 36, 4, 5, 4, 0, -5 },
  { 39, 4, 5, 4, 0, -5 },
  { 42, 4, 5, 4, 0, -5 },
  { 45, 4, 5, 4, 0, -5 },
  { 48, 4, 5, 4, 0, -5 },
  { 51, 4, 5, 4, 0, -5 },
  { 54, 4, 5, 4, 0, -5 },
  { 57, 3, 5, 4, 1, -5 },
  { 59, 4, 5, 4, 0, -5 },
  { 62, 3, 5, 4, 1, -5 },
  { 64, 2, 4, 4, 1, -4 },
  { 65, 2, 5, 4, 1, -4 },
  { 67, 3, 4, 4, 1, -4 },
  { 69, 4, 2, 4, 0, -3 },
  { 70, 4, 4, 4, 0, -4 },
  { 72, 3, 5, 4, 1, -5 },
  { 74, 4, 6, 4, 0, -5 },
  { 77, 4, 5, 4, 0, -5 },
  { 80, 4, 5, 4, 0, -5 },
  { 83, 4, 5, 4, 0, -5 },
  { 86, 4, 5, 4, 0, -5 },
  { 89, 4, 5, 4, 0, -5 },
  { 92, 4, 5, 4, 0, -5 },
  { 95, 4, 5, 4, 0, -5 },
  { 98, 4, 5, 4, 0, -5 },
  { 101, 4, 5, 4, 0, -5 },
  { 104, 4, 5, 4, 0, -5 },
  { 107, 4, 5, 4, 0, -5 },
  { 110, 4, 5, 4, 0, -5 },
  { 113, 4, 5, 4, 0, -5 },
  { 116, 4, 5, 4, 0, -5 },
  { 119, 4, 5, 4, 0, -5 },
  { 122, 4, 5, 4, 0, -5 },
  { 125, 4, 6, 4, 0, -5 },
  { 128, 4, 5, 4, 0, -5 },
  { 131, 4, 5, 4, 0, -5 },
  { 134, 3, 5, 4, 1, -5 },
  { 136, 4, 5, 4, 0, -5 },
  { 139, 3, 5, 4, 1, -5 },
  { 141, 5, 5, 4, 0, -5 },
  { 145, 4, 5, 4, 0, -5 },
  { 148, 3, 5, 4, 1, -5 },
  { 150, 4, 5, 4, 0, -5 },
  { 153, 3, 7, 4, 1, -6 },
  { 156, 2, 7, 4, 1, -6 },
  { 158, 2, 7, 4, 1, -6 },
  { 160, 3, 3, 4, 1, -5 },
  { 162, 3, 1, 4, 0, 0 },
  { 163, 1, 1, 4, 2, -6 },
  { 164, 4, 4, 4, 0, -4 },
  { 166, 4, 5, 4, 0, -5 },
  { 169, 4, 4, 4, 0, -4 },
  { 171, 4, 5, 4, 0, -5 },
  { 174, 4, 4, 4, 0, -4 },
  { 176, 4, 6, 4, 0, -5 },
  { 179, 4, 5, 4, 0, -4 },
  { 182, 4, 5, 4, 0, -5 },
  { 185, 4, 5, 4, 0, -5 },
  { 188, 4, 6, 4, 0, -5 },
  { 191, 4, 5, 4, 0, -5 },
  { 194, 3, 5, 4, 1, -5 },
  { 196, 4, 4, 4, 0, -4 },
  { 198, 4, 4, 4, 0, -4 },
  { 200, 4, 4, 4, 0, -4 },
  { 202, 4, 5, 4, 0, -4 },
  { 205, 4, 5, 4, 0, -4 },
  { 208, 4, 4, 4, 0, -4 },
  { 210, 4, 4, 4, 0, -4 },
  { 212, 3, 5, 4, 1, -5 },
  { 214, 4, 4, 4, 0, -4 },
  { 216, 3, 4, 4, 1, -4 },
  { 218, 3, 4, 4, 1, -4 },
  { 220, 4, 4, 4, 0, -4 },
  { 222, 4, 5, 4, 0, -4 },
  { 225, 4, 4, 4, 0, -4 },
  { 227, 3, 7, 4, 1, -6 },
  { 230, 2, 7, 4, 1, -6 },
  { 232, 4, 7, 4, 0, -6 },
  { 236, 4, 1, 4, 0, -3 },
};

const GFXfont JetBrainsMono_Italic7pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Italic7pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Italic7pt7bGlyphs,
  0x20, 0x7E, 9
};

#endif // _JETBRAINSMONO_ITALIC7PT7B_H_
