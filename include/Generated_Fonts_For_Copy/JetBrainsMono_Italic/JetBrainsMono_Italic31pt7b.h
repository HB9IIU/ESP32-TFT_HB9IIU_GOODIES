#ifndef _JETBRAINSMONO_ITALIC31PT7B_H_
#define _JETBRAINSMONO_ITALIC31PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Italic.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Italic31pt7bBitmaps[] PROGMEM = {
  0x00, 0x0E, 0x1C, 0x38, 0xF1, 0xE3, 0x87, 0x0E, 0x1C, 0x30, 0x60, 0xC3,
  0x87, 0x0C, 0x18, 0x00, 0x00, 0x01, 0x0F, 0x9F, 0x3C, 0x00, 0x71, 0xDC,
  0x77, 0x1F, 0x87, 0xE1, 0xB8, 0xEE, 0x3B, 0x8E, 0xC3, 0xB0, 0xC0, 0x00,
  0xC1, 0x80, 0x30, 0x60, 0x18, 0x38, 0x06, 0x0C, 0x03, 0x83, 0x00, 0xC1,
  0xC0, 0x30, 0x60, 0xFF, 0xFF, 0x3F, 0xFF, 0x81, 0x83, 0x00, 0xE0, 0xC0,
  0x30, 0x60, 0x0C, 0x18, 0x07, 0x06, 0x01, 0x83, 0x03, 0xFF, 0xF8, 0xFF,
  0xFE, 0x0C, 0x18, 0x03, 0x06, 0x01, 0xC3, 0x80, 0x60, 0xC0, 0x18, 0x30,
  0x0E, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x0F, 0x80, 0x1F, 0xF0, 0x1F, 0xFC, 0x1C, 0xCE, 0x0C, 0x63, 0x0E, 0x31,
  0x87, 0x18, 0x03, 0x88, 0x01, 0xEC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x63, 0x80, 0x31, 0xC0, 0x18, 0xE3,
  0x8C, 0x71, 0xC6, 0x38, 0xE3, 0x38, 0x7D, 0x78, 0x1F, 0xF8, 0x07, 0xF8,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x18,
  0x3F, 0x01, 0x83, 0x9C, 0x1C, 0x38, 0xE1, 0xC1, 0x87, 0x0C, 0x0C, 0x38,
  0xC0, 0x61, 0x8C, 0x03, 0x0C, 0xC0, 0x1F, 0xEE, 0x00, 0xFE, 0xE0, 0x00,
  0x86, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x67, 0xE0, 0x07, 0x7F,
  0x00, 0x77, 0x1C, 0x03, 0x30, 0xE0, 0x31, 0x87, 0x03, 0x0C, 0x30, 0x30,
  0x61, 0x83, 0x83, 0x1C, 0x38, 0x1F, 0xC3, 0x80, 0x7C, 0x00, 0x01, 0xF0,
  0x03, 0xFE, 0x03, 0xFF, 0x81, 0xC1, 0xC0, 0xC0, 0xE0, 0xE0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x07, 0xF0, 0x07,
  0x38, 0x7B, 0x8E, 0x39, 0x87, 0x38, 0xC1, 0xF8, 0xE0, 0xF8, 0x70, 0x3C,
  0x38, 0x1E, 0x1C, 0x1F, 0x0F, 0x1D, 0xC3, 0xFC, 0xE0, 0xFC, 0x38, 0x77,
  0xFE, 0xEE, 0xEE, 0xCC, 0x00, 0x18, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0x70,
  0x07, 0x00, 0x38, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x18, 0x01, 0xC0,
  0x0E, 0x00, 0x30, 0x01, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x80,
  0x3E, 0x00, 0x70, 0x00, 0x80, 0x0C, 0x00, 0xF0, 0x0F, 0x80, 0x3C, 0x01,
  0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x01,
  0xC0, 0x1C, 0x03, 0x80, 0x38, 0x07, 0x00, 0xE0, 0x3C, 0x0F, 0x80, 0xE0,
  0x08, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x81, 0x81,
  0xF1, 0x8F, 0xFD, 0xBF, 0x7F, 0x7E, 0x0F, 0xE0, 0x03, 0x80, 0x0E, 0xC0,
  0x1C, 0xE0, 0x3C, 0xE0, 0x38, 0x70, 0x70, 0x78, 0x20, 0x20, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x7F,
  0xFF, 0xFF, 0xFE, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x00, 0x0F, 0x1E, 0x1E, 0x1C, 0x3C, 0x38, 0x78, 0x70, 0xE0,
  0xE0, 0x7F, 0xFF, 0xF8, 0x77, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x07, 0xFC, 0x0F, 0xFE, 0x1C,
  0x0E, 0x38, 0x0E, 0x38, 0x06, 0x30, 0x06, 0x30, 0x0E, 0x70, 0x0E, 0x70,
  0x0E, 0x73, 0x8E, 0x73, 0xCE, 0x63, 0x8C, 0x61, 0x0C, 0xE0, 0x1C, 0xE0,
  0x1C, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x38, 0xE0, 0x38, 0x70, 0xF0, 0x7F,
  0xE0, 0x3F, 0xC0, 0x00, 0x78, 0x03, 0xF0, 0x0F, 0xE0, 0x7D, 0x81, 0xE7,
  0x03, 0x8E, 0x04, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x07, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0xF8, 0x03, 0xFE, 0x07, 0xFF, 0x0E, 0x07, 0x1C, 0x07, 0x1C, 0x07, 0x38,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x7F, 0xFC, 0x7F, 0xFC, 0xFF, 0xFC, 0x0F, 0xFF, 0x0F,
  0xFF, 0x0F, 0xFF, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0xF0, 0x03, 0xFC, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x70, 0x1C, 0x70, 0x1C, 0x70,
  0x3C, 0x78, 0x78, 0x3F, 0xF0, 0x1F, 0xC0, 0x00, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x71, 0xE0, 0xE3, 0x81, 0xCE, 0x03, 0xB8, 0x07, 0x7F,
  0xFC, 0xFF, 0xF9, 0xFF, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x06,
  0x00, 0x1C, 0x00, 0x1F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF8, 0xE0, 0x01, 0xC0,
  0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x39, 0xE0, 0x7F, 0xF0, 0xFF, 0xF1,
  0xC0, 0xE7, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x33, 0x80, 0xE7, 0x01, 0xCF, 0x0F, 0x0F, 0xFC, 0x0F, 0xF0, 0x00, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x0E, 0x00, 0x3B, 0xE0, 0xFF, 0xE3, 0xE3, 0xE7, 0x01, 0xCE,
  0x03, 0xB8, 0x07, 0x70, 0x0E, 0xE0, 0x1D, 0xC0, 0x3B, 0x80, 0x77, 0x01,
  0xCF, 0x8F, 0x0F, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xEE, 0x01, 0xDC, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xF0, 0x0F, 0xF8, 0x3F, 0xF8, 0xE0, 0x71, 0x80,
  0xE7, 0x01, 0xCE, 0x03, 0x9C, 0x06, 0x1C, 0x1C, 0x3C, 0xF0, 0x3F, 0xC0,
  0x3F, 0x01, 0xEF, 0x07, 0x0F, 0x1C, 0x0E, 0x30, 0x0E, 0xE0, 0x1D, 0xC0,
  0x3B, 0x80, 0x67, 0x01, 0xCF, 0x0F, 0x0F, 0xFC, 0x0F, 0xF0, 0x00, 0x03,
  0xE0, 0x1F, 0xF0, 0x7F, 0xF1, 0xC0, 0xE7, 0x00, 0xEE, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0D, 0xC0, 0x3B, 0x80, 0xF3, 0x83, 0xC7, 0xFF, 0x87,
  0xEE, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x03, 0x80, 0x1E, 0x00, 0x00, 0x3E, 0x7C, 0xF9, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x3E, 0x7C, 0xF0, 0x07, 0xC1,
  0xF0, 0x7C, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x03, 0x81, 0xE0, 0x70, 0x3C, 0x0E, 0x03, 0x81, 0xC0, 0x60,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x78, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xC0, 0x3E, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1C, 0x00, 0x08, 0x3F, 0xFE, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0xFF,
  0xFD, 0xFF, 0xF0, 0x30, 0x00, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xC0, 0x03, 0x00, 0x3C, 0x03, 0xF0, 0x3E, 0x03, 0xE0,
  0x7E, 0x03, 0xE0, 0x0E, 0x00, 0x20, 0x00, 0x3E, 0x01, 0xFE, 0x0F, 0xF8,
  0x01, 0xE0, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x80,
  0x78, 0x3F, 0x81, 0xF8, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x07, 0x80, 0x7C, 0x01, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x3F, 0xF0, 0x1F, 0x1F, 0x03, 0x80, 0xE0, 0xE0, 0x0C, 0x38, 0x01, 0xC6,
  0x00, 0x38, 0xC0, 0x06, 0x38, 0x3E, 0xC7, 0x0F, 0xD8, 0xC3, 0x87, 0x18,
  0x70, 0xE3, 0x0C, 0x1C, 0x61, 0x83, 0x9C, 0x70, 0x63, 0x8E, 0x0C, 0x71,
  0xC1, 0x8C, 0x38, 0x71, 0x87, 0x0E, 0x30, 0xFF, 0xCE, 0x0F, 0xB1, 0xC0,
  0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xFF,
  0x00, 0x0F, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xDC, 0x01, 0xDC, 0x01, 0x8C, 0x03, 0x8C,
  0x03, 0x8C, 0x07, 0x0C, 0x07, 0x0E, 0x06, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E,
  0x1F, 0xFE, 0x1F, 0xFE, 0x38, 0x0E, 0x38, 0x06, 0x38, 0x06, 0x70, 0x06,
  0x70, 0x07, 0xE0, 0x07, 0x1F, 0xC0, 0x1F, 0xFC, 0x1F, 0xFE, 0x18, 0x1E,
  0x38, 0x0E, 0x38, 0x0E, 0x38, 0x0E, 0x38, 0x0E, 0x38, 0x1C, 0x30, 0x3C,
  0x7F, 0xF0, 0x7F, 0xF0, 0x70, 0xF8, 0x70, 0x1C, 0x70, 0x1C, 0x60, 0x1C,
  0x60, 0x1C, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x38, 0xFF, 0xF0, 0xFF, 0xE0,
  0xFF, 0xC0, 0x01, 0xF0, 0x07, 0xFC, 0x0F, 0xFE, 0x1C, 0x0E, 0x18, 0x0E,
  0x38, 0x06, 0x38, 0x06, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00,
  0xE0, 0x1C, 0xE0, 0x38, 0xF0, 0x38, 0x78, 0xF0, 0x7F, 0xE0, 0x3F, 0xC0,
  0x0F, 0xF0, 0x0F, 0xFC, 0x0F, 0xFE, 0x0C, 0x0F, 0x1C, 0x07, 0x1C, 0x07,
  0x1C, 0x07, 0x1C, 0x07, 0x1C, 0x07, 0x18, 0x07, 0x38, 0x07, 0x38, 0x06,
  0x38, 0x0E, 0x38, 0x0E, 0x38, 0x0E, 0x30, 0x0E, 0x70, 0x0E, 0x70, 0x1C,
  0x70, 0x1C, 0x70, 0x38, 0x71, 0xF8, 0x7F, 0xE0, 0xFF, 0xC0, 0x1F, 0xFF,
  0x1F, 0xFF, 0x1F, 0xFF, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x3F, 0xFC, 0x3F, 0xFC, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0x1F, 0xFF, 0x8F, 0xFF,
  0x87, 0xFF, 0xC3, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x18, 0x00, 0x0F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0xC3,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x00, 0x01, 0xF0, 0x07,
  0xFC, 0x0F, 0xFE, 0x1C, 0x0E, 0x18, 0x0E, 0x38, 0x06, 0x38, 0x06, 0x38,
  0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x71, 0xFE, 0x71, 0xFC, 0x71,
  0xFC, 0x70, 0x1C, 0x60, 0x1C, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x38, 0xF0,
  0x38, 0x78, 0xF0, 0x7F, 0xE0, 0x3F, 0xC0, 0x1C, 0x07, 0x1C, 0x07, 0x1C,
  0x07, 0x18, 0x06, 0x38, 0x0E, 0x38, 0x0E, 0x38, 0x0E, 0x38, 0x0E, 0x38,
  0x0E, 0x30, 0x0E, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0x70, 0x1C, 0x70,
  0x1C, 0x70, 0x1C, 0x60, 0x18, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x38, 0xE0,
  0x38, 0xE0, 0x38, 0xC0, 0x30, 0x1F, 0xFF, 0x1F, 0xFE, 0x1F, 0xFE, 0x00,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0xFF, 0xF0, 0xFF,
  0xF0, 0xFF, 0xF0, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x38, 0xE0, 0x1C, 0x70, 0x0E, 0x38, 0x06, 0x1C, 0x07, 0x0F, 0x8F, 0x03,
  0xFF, 0x00, 0xFF, 0x00, 0x0E, 0x01, 0xC3, 0x80, 0xF0, 0xE0, 0x38, 0x30,
  0x1C, 0x1C, 0x0F, 0x07, 0x03, 0x81, 0xC1, 0xC0, 0x70, 0xF0, 0x1C, 0x38,
  0x06, 0x1C, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0E, 0x1C, 0x03,
  0x87, 0x00, 0xC1, 0xC0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0x70, 0x70, 0x1C, 0x1C, 0x07, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x30, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF,
  0x80, 0x0E, 0x03, 0x8F, 0x03, 0xC7, 0xC1, 0xE3, 0xE1, 0xF1, 0xB0, 0xD8,
  0xD8, 0xFC, 0x6C, 0x6E, 0x76, 0x76, 0x3B, 0x33, 0x1D, 0xDB, 0x8E, 0x79,
  0xC6, 0x3C, 0xE3, 0x1C, 0x73, 0x80, 0x31, 0xC0, 0x38, 0xE0, 0x1C, 0x70,
  0x0E, 0x38, 0x07, 0x18, 0x03, 0x8C, 0x01, 0x8E, 0x00, 0xC7, 0x00, 0xE3,
  0x80, 0x70, 0x0F, 0x03, 0x87, 0x81, 0xC3, 0xC0, 0xE1, 0xE0, 0x71, 0xF8,
  0x30, 0xFC, 0x18, 0x7E, 0x1C, 0x3B, 0x0E, 0x19, 0x87, 0x0C, 0xE3, 0x8E,
  0x71, 0x87, 0x38, 0xC3, 0x8C, 0xE1, 0xC6, 0x70, 0xC3, 0xB8, 0x61, 0xDC,
  0x70, 0xEE, 0x38, 0x36, 0x1C, 0x1B, 0x0E, 0x0F, 0x87, 0x07, 0xC3, 0x03,
  0xE3, 0x80, 0xF0, 0x01, 0xF0, 0x0F, 0xF8, 0x3F, 0xF8, 0xE0, 0x71, 0x80,
  0xE7, 0x01, 0xCE, 0x03, 0x9C, 0x07, 0x30, 0x0E, 0xE0, 0x1D, 0xC0, 0x33,
  0x80, 0x67, 0x01, 0xCE, 0x03, 0x9C, 0x07, 0x30, 0x0E, 0xE0, 0x1D, 0xC0,
  0x33, 0x80, 0xE7, 0x81, 0xC7, 0x8F, 0x0F, 0xFC, 0x0F, 0xF0, 0x00, 0x0F,
  0xF8, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x30, 0x1E, 0x1C, 0x03, 0x87, 0x00,
  0xE1, 0xC0, 0x38, 0x70, 0x0E, 0x1C, 0x03, 0x86, 0x01, 0xC3, 0x80, 0xF0,
  0xFF, 0xF8, 0x3F, 0xFC, 0x0F, 0xF8, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xF0, 0x07, 0xFC, 0x0F, 0xFE, 0x1C, 0x0E, 0x38,
  0x0E, 0x38, 0x06, 0x38, 0x06, 0x30, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70,
  0x0E, 0x70, 0x0E, 0x70, 0x0C, 0x60, 0x1C, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0,
  0x1C, 0xE0, 0x1C, 0xE0, 0x38, 0xE0, 0x38, 0x78, 0xF0, 0x7F, 0xE0, 0x3F,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0x70, 0x0F, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0xC1, 0x80, 0xE1, 0xC0, 0x38,
  0xE0, 0x1C, 0x70, 0x0E, 0x38, 0x07, 0x1C, 0x07, 0x0C, 0x03, 0x8E, 0x07,
  0x87, 0xFF, 0x83, 0xFF, 0x81, 0xC7, 0x00, 0xE1, 0xC0, 0x60, 0xE0, 0x70,
  0x70, 0x38, 0x1C, 0x1C, 0x0E, 0x0E, 0x07, 0x07, 0x01, 0xC3, 0x80, 0xE3,
  0x80, 0x78, 0x00, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0xC1, 0xC0, 0xE0, 0xC0,
  0x30, 0xE0, 0x18, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x03,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x38, 0x07, 0x1C, 0x03, 0x8E, 0x03, 0x87, 0x87, 0x81, 0xFF,
  0x80, 0x7F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x18, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x00, 0x1C,
  0x07, 0x1C, 0x07, 0x18, 0x07, 0x18, 0x07, 0x38, 0x06, 0x38, 0x0E, 0x38,
  0x0E, 0x38, 0x0E, 0x38, 0x0E, 0x30, 0x0E, 0x70, 0x0C, 0x70, 0x1C, 0x70,
  0x1C, 0x70, 0x1C, 0x70, 0x1C, 0x60, 0x1C, 0xE0, 0x1C, 0xE0, 0x38, 0xE0,
  0x38, 0xE0, 0x78, 0x78, 0xF0, 0x7F, 0xE0, 0x3F, 0xC0, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x37, 0x00, 0xEE, 0x01, 0xDC, 0x07, 0x38, 0x0E, 0x70, 0x38,
  0x60, 0x70, 0xC0, 0xC1, 0xC3, 0x83, 0x87, 0x07, 0x1C, 0x0E, 0x38, 0x1C,
  0x60, 0x39, 0xC0, 0x73, 0x80, 0xEE, 0x00, 0xDC, 0x01, 0xB0, 0x03, 0xE0,
  0x07, 0x80, 0x0F, 0x00, 0x00, 0x70, 0xE1, 0xDC, 0x38, 0x77, 0x1E, 0x19,
  0x87, 0x86, 0x61, 0xE3, 0x98, 0x58, 0xE6, 0x36, 0x31, 0x8D, 0x8C, 0x63,
  0x67, 0x19, 0x99, 0xC6, 0x66, 0x63, 0x99, 0x98, 0xE4, 0x6E, 0x3B, 0x13,
  0x0E, 0xC4, 0xC3, 0xB1, 0x70, 0xF8, 0x5C, 0x3E, 0x16, 0x0F, 0x8D, 0x83,
  0x63, 0xE0, 0xF0, 0xF8, 0x3C, 0x3C, 0x0F, 0x0F, 0x00, 0x0E, 0x00, 0xE1,
  0xC0, 0x38, 0x1C, 0x07, 0x03, 0x81, 0xC0, 0x70, 0x70, 0x07, 0x0E, 0x00,
  0xE3, 0x80, 0x0E, 0xE0, 0x01, 0xD8, 0x00, 0x3F, 0x00, 0x03, 0xC0, 0x00,
  0x70, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xEE, 0x00, 0x39, 0xC0, 0x07,
  0x38, 0x01, 0xC3, 0x80, 0x70, 0x70, 0x1E, 0x07, 0x03, 0x80, 0xE0, 0xE0,
  0x1C, 0x38, 0x01, 0xC0, 0xE0, 0x03, 0xB8, 0x03, 0x9C, 0x03, 0x8E, 0x01,
  0xC3, 0x01, 0xC1, 0xC0, 0xC0, 0xE0, 0xE0, 0x30, 0xE0, 0x1C, 0x70, 0x0E,
  0x70, 0x03, 0x70, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x30, 0x00, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07,
  0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xF0, 0x07, 0xF8, 0x3F, 0x81, 0xFC, 0x0C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0xE0, 0x70, 0x18, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0x60, 0x38, 0x1C, 0x0E, 0x03, 0x01, 0xC0, 0xE0, 0x70, 0x38,
  0x0C, 0x07, 0x03, 0x81, 0xC0, 0x60, 0x38, 0x1C, 0x0E, 0x07, 0x01, 0xC0,
  0xE0, 0x70, 0x38, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0x06, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38,
  0x03, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x0F, 0xF0, 0xFF, 0x00, 0x01,
  0xC0, 0x0E, 0x00, 0xF0, 0x0E, 0xC0, 0x66, 0x07, 0x30, 0x71, 0xC3, 0x06,
  0x38, 0x31, 0x81, 0xDC, 0x0F, 0xC0, 0x30, 0xFF, 0xFF, 0xFF, 0xFC, 0xF1,
  0xC3, 0x87, 0x07, 0xEE, 0x3F, 0xDC, 0xF0, 0xF9, 0xC0, 0xF7, 0x01, 0xCE,
  0x03, 0x9C, 0x07, 0x38, 0x0E, 0x70, 0x1C, 0xC0, 0x3B, 0x80, 0x67, 0x01,
  0xCE, 0x03, 0x9C, 0x0F, 0x1C, 0x3E, 0x3F, 0xDC, 0x3F, 0x38, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0xFC,
  0x1F, 0xFE, 0x1E, 0x1E, 0x1C, 0x0E, 0x3C, 0x0E, 0x38, 0x0E, 0x38, 0x0E,
  0x38, 0x0E, 0x38, 0x0E, 0x30, 0x0E, 0x70, 0x0E, 0x70, 0x0C, 0x70, 0x1C,
  0x78, 0x1C, 0x7C, 0x78, 0x7F, 0xF0, 0xE7, 0xE0, 0x07, 0xF0, 0x3F, 0xF8,
  0x70, 0xF1, 0xC0, 0xE7, 0x00, 0xEE, 0x01, 0xDC, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0xEE, 0x03, 0x9E, 0x07, 0x1E, 0x3C,
  0x3F, 0xF0, 0x3F, 0xC0, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x06, 0x00, 0x0E, 0x07, 0xEE, 0x1F, 0xEE, 0x3C, 0x3E, 0x38, 0x1E,
  0x70, 0x1C, 0x70, 0x1C, 0x70, 0x1C, 0x70, 0x1C, 0x70, 0x1C, 0x60, 0x1C,
  0xE0, 0x18, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x78, 0x70, 0xF8, 0x7F, 0xB8,
  0x3F, 0x38, 0x07, 0xF0, 0x1F, 0xF0, 0x70, 0xF1, 0xC0, 0xE7, 0x00, 0xCE,
  0x01, 0x9C, 0x07, 0x3F, 0xFE, 0x7F, 0xFC, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x07, 0x1C, 0x1C, 0x3F, 0xF0, 0x3F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x07, 0xEE, 0x3F, 0xFC, 0xF0, 0xF9, 0xC0, 0xF7, 0x01,
  0xCE, 0x03, 0x9C, 0x07, 0x38, 0x0E, 0x70, 0x1C, 0xC0, 0x3B, 0x80, 0x67,
  0x01, 0xC7, 0x07, 0x8F, 0xFF, 0x0F, 0xEE, 0x0F, 0x9C, 0x00, 0x38, 0x00,
  0x60, 0x01, 0xC0, 0x03, 0x87, 0xFE, 0x0F, 0xF8, 0x1F, 0x80, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1D,
  0xFC, 0x1F, 0xFE, 0x1E, 0x1E, 0x1C, 0x0E, 0x38, 0x0E, 0x38, 0x0E, 0x38,
  0x0E, 0x38, 0x0E, 0x38, 0x0E, 0x30, 0x0E, 0x70, 0x0E, 0x70, 0x0C, 0x70,
  0x1C, 0x70, 0x1C, 0x70, 0x1C, 0x70, 0x1C, 0xE0, 0x1C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x1F, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x07, 0xFE,
  0x08, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xE0,
  0x7F, 0xC0, 0x7F, 0x80, 0xF8, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x0F, 0x38, 0x0E, 0x38, 0x1C,
  0x38, 0x38, 0x30, 0x70, 0x70, 0xE0, 0x71, 0xE0, 0x7F, 0xC0, 0x7F, 0x80,
  0x71, 0xC0, 0x61, 0xC0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x70, 0xE0, 0x70,
  0xE0, 0x38, 0xC0, 0x3C, 0xFF, 0x07, 0xF8, 0x3F, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xFF, 0x8F, 0xFC, 0x1F, 0xE0, 0x3B, 0xDF, 0x1F, 0xEF, 0x8E, 0x38,
  0xC6, 0x18, 0x63, 0x0C, 0x33, 0x86, 0x39, 0xC7, 0x1C, 0xE3, 0x8E, 0x71,
  0x87, 0x30, 0xC3, 0x18, 0x61, 0x8C, 0x31, 0xCE, 0x18, 0xE7, 0x1C, 0x73,
  0x8C, 0x39, 0xC6, 0x18, 0xC3, 0x0C, 0x00, 0x1D, 0xFC, 0x1F, 0xFE, 0x1E,
  0x1E, 0x1C, 0x0E, 0x38, 0x0E, 0x38, 0x0E, 0x38, 0x0E, 0x38, 0x0E, 0x38,
  0x0E, 0x30, 0x0E, 0x70, 0x0E, 0x70, 0x0C, 0x70, 0x1C, 0x70, 0x1C, 0x70,
  0x1C, 0x70, 0x1C, 0xE0, 0x1C, 0x07, 0xF0, 0x3F, 0xF0, 0x70, 0xF1, 0xC0,
  0xE7, 0x01, 0xCE, 0x03, 0x9C, 0x07, 0x38, 0x0E, 0x70, 0x1C, 0xC0, 0x3B,
  0x80, 0x77, 0x00, 0xCE, 0x03, 0x9C, 0x07, 0x1E, 0x3C, 0x3F, 0xF0, 0x3F,
  0xC0, 0x1C, 0xFC, 0x1F, 0xFE, 0x1E, 0x1E, 0x1C, 0x0E, 0x3C, 0x0E, 0x38,
  0x0E, 0x38, 0x0E, 0x38, 0x0E, 0x38, 0x0E, 0x30, 0x0E, 0x70, 0x0E, 0x70,
  0x0C, 0x70, 0x1C, 0x78, 0x1C, 0x7C, 0x78, 0x7F, 0xF0, 0x67, 0xE0, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0x0F,
  0xEE, 0x3F, 0xDC, 0xF0, 0xF9, 0xC0, 0xF7, 0x01, 0xCE, 0x03, 0x9C, 0x07,
  0x38, 0x0E, 0x70, 0x1C, 0xC0, 0x3B, 0x80, 0x67, 0x01, 0xCE, 0x03, 0x9C,
  0x0F, 0x3C, 0x3E, 0x3F, 0xDC, 0x3F, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1D, 0xF8, 0x37, 0xF8, 0xF8,
  0x79, 0xE0, 0x73, 0x80, 0xE7, 0x01, 0xCE, 0x03, 0x98, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x00, 0x0F, 0xF8, 0x7F, 0xF3, 0xC1, 0xCE, 0x03, 0x30, 0x00,
  0xC0, 0x03, 0x80, 0x0F, 0xF0, 0x1F, 0xF0, 0x07, 0xE0, 0x03, 0x80, 0x06,
  0x00, 0x1B, 0x80, 0xEF, 0x07, 0x9F, 0xFC, 0x3F, 0xC0, 0x03, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x03, 0xFF, 0xFF, 0xFF, 0xC3, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0xFC, 0x1F, 0xF0, 0x3F, 0xC0,
  0x38, 0x0E, 0x70, 0x1C, 0xE0, 0x39, 0x80, 0x77, 0x00, 0xCE, 0x03, 0x9C,
  0x07, 0x38, 0x0E, 0x70, 0x1C, 0xC0, 0x3B, 0x80, 0x77, 0x01, 0xCE, 0x03,
  0x9E, 0x0F, 0x1E, 0x3C, 0x3F, 0xF0, 0x3F, 0x80, 0xE0, 0x0F, 0xC0, 0x39,
  0x80, 0x73, 0x81, 0xC7, 0x03, 0x8E, 0x06, 0x1C, 0x1C, 0x38, 0x30, 0x30,
  0xE0, 0x61, 0x80, 0xE7, 0x01, 0xCE, 0x03, 0xB8, 0x07, 0x70, 0x07, 0xC0,
  0x0F, 0x80, 0x1E, 0x00, 0xE1, 0xC3, 0xF0, 0xE1, 0xB8, 0xF0, 0xDC, 0x78,
  0xEE, 0x3C, 0x67, 0x36, 0x33, 0x9B, 0x39, 0xCD, 0x98, 0xE4, 0xCC, 0x76,
  0x66, 0x3B, 0x36, 0x1D, 0x1B, 0x0F, 0x8D, 0x87, 0xC7, 0x83, 0xC3, 0xC1,
  0xE1, 0xE0, 0xF0, 0xE0, 0x00, 0x1E, 0x03, 0xC3, 0x81, 0xE0, 0x70, 0x70,
  0x1C, 0x38, 0x03, 0x9C, 0x00, 0xEE, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01,
  0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1C, 0xE0, 0x0E, 0x38, 0x07, 0x07,
  0x03, 0xC1, 0xC0, 0xE0, 0x38, 0xF0, 0x0F, 0x00, 0x38, 0x0E, 0x70, 0x1C,
  0xE0, 0x39, 0x80, 0x77, 0x00, 0xCE, 0x03, 0x9C, 0x07, 0x38, 0x0E, 0x70,
  0x1C, 0xC0, 0x39, 0x80, 0x67, 0x81, 0xC7, 0x07, 0x8F, 0xFF, 0x0F, 0xEE,
  0x07, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x87, 0xFE, 0x0F,
  0xF8, 0x1F, 0x80, 0x00, 0x1F, 0xFF, 0x1F, 0xFF, 0x00, 0x0E, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x7F, 0xFC, 0x7F, 0xFC,
  0xFF, 0xFC, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0x80, 0x07, 0x80, 0xFE, 0x00, 0xFF, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0xE0, 0x03, 0xE0,
  0x06, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0x83,
  0x0E, 0x1C, 0x38, 0x70, 0xE1, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xC3, 0x87,
  0x0E, 0x00, 0x0F, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0x80, 0x01, 0x80, 0x01, 0xE1, 0x00, 0xFE, 0x01, 0xFE, 0x03, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x1E, 0x00, 0xFC, 0x00, 0xF8, 0x00,
  0x1E, 0x06, 0xFE, 0x0D, 0xDE, 0x3F, 0x1E, 0x7E, 0x1F, 0xDC, 0x1F, 0x00,
};

const GFXglyph JetBrainsMono_Italic31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 7, 23, 19, 6, -23 },
  { 22, 10, 10, 19, 6, -23 },
  { 35, 18, 23, 19, 1, -23 },
  { 87, 17, 31, 19, 1, -27 },
  { 153, 21, 23, 19, -1, -23 },
  { 214, 17, 23, 19, 1, -23 },
  { 263, 4, 10, 19, 9, -23 },
  { 268, 13, 30, 19, 5, -26 },
  { 317, 12, 30, 19, 2, -26 },
  { 362, 16, 16, 19, 2, -19 },
  { 394, 15, 15, 19, 2, -18 },
  { 423, 8, 10, 19, 3, -5 },
  { 433, 11, 2, 19, 4, -11 },
  { 436, 5, 5, 19, 6, -5 },
  { 440, 19, 29, 19, 0, -26 },
  { 509, 16, 23, 19, 2, -23 },
  { 555, 15, 23, 19, 1, -23 },
  { 599, 16, 23, 19, 1, -23 },
  { 645, 16, 23, 19, 1, -23 },
  { 691, 15, 23, 19, 2, -23 },
  { 735, 15, 23, 19, 2, -23 },
  { 779, 15, 23, 19, 2, -23 },
  { 823, 15, 23, 19, 4, -23 },
  { 867, 15, 23, 19, 2, -23 },
  { 911, 15, 23, 19, 3, -23 },
  { 955, 7, 17, 19, 6, -17 },
  { 970, 10, 22, 19, 3, -17 },
  { 998, 15, 16, 19, 3, -18 },
  { 1028, 15, 10, 19, 2, -15 },
  { 1047, 14, 16, 19, 2, -18 },
  { 1075, 13, 23, 19, 4, -23 },
  { 1113, 19, 29, 19, 0, -23 },
  { 1182, 16, 23, 19, 0, -23 },
  { 1228, 16, 23, 19, 2, -23 },
  { 1274, 16, 23, 19, 2, -23 },
  { 1320, 16, 23, 19, 1, -23 },
  { 1366, 16, 23, 19, 2, -23 },
  { 1412, 17, 23, 19, 2, -23 },
  { 1461, 16, 23, 19, 2, -23 },
  { 1507, 16, 23, 19, 2, -23 },
  { 1553, 16, 23, 19, 2, -23 },
  { 1599, 17, 23, 19, 1, -23 },
  { 1648, 18, 23, 19, 1, -23 },
  { 1700, 14, 23, 19, 2, -23 },
  { 1741, 17, 23, 19, 1, -23 },
  { 1790, 17, 23, 19, 1, -23 },
  { 1839, 15, 23, 19, 2, -23 },
  { 1883, 18, 23, 19, 1, -23 },
  { 1935, 16, 29, 19, 2, -23 },
  { 1993, 17, 23, 19, 1, -23 },
  { 2042, 17, 23, 19, 1, -23 },
  { 2091, 15, 23, 19, 4, -23 },
  { 2135, 16, 23, 19, 2, -23 },
  { 2181, 15, 23, 19, 4, -23 },
  { 2225, 18, 23, 19, 2, -23 },
  { 2277, 19, 23, 19, 0, -23 },
  { 2332, 17, 23, 19, 3, -23 },
  { 2381, 17, 23, 19, 1, -23 },
  { 2430, 13, 29, 19, 4, -26 },
  { 2478, 9, 29, 19, 5, -26 },
  { 2511, 12, 29, 19, 3, -26 },
  { 2555, 13, 12, 19, 3, -23 },
  { 2575, 15, 2, 19, 0, 1 },
  { 2579, 6, 4, 19, 8, -24 },
  { 2582, 15, 17, 19, 2, -17 },
  { 2614, 16, 23, 19, 1, -23 },
  { 2660, 15, 17, 19, 2, -17 },
  { 2692, 16, 23, 19, 2, -23 },
  { 2738, 15, 17, 19, 2, -17 },
  { 2770, 21, 29, 19, -1, -23 },
  { 2847, 15, 23, 19, 2, -17 },
  { 2891, 16, 23, 19, 1, -23 },
  { 2937, 15, 24, 19, 1, -24 },
  { 2982, 16, 30, 19, 0, -24 },
  { 3042, 16, 23, 19, 2, -23 },
  { 3088, 13, 23, 19, 3, -23 },
  { 3126, 17, 17, 19, 1, -17 },
  { 3163, 16, 17, 19, 1, -17 },
  { 3197, 15, 17, 19, 2, -17 },
  { 3229, 16, 23, 19, 1, -17 },
  { 3275, 15, 23, 19, 2, -17 },
  { 3319, 15, 17, 19, 2, -17 },
  { 3351, 14, 17, 19, 2, -17 },
  { 3381, 14, 22, 19, 3, -22 },
  { 3420, 15, 17, 19, 2, -17 },
  { 3452, 15, 17, 19, 3, -17 },
  { 3484, 17, 17, 19, 2, -17 },
  { 3521, 18, 17, 19, 0, -17 },
  { 3560, 15, 23, 19, 2, -17 },
  { 3604, 16, 17, 19, 1, -17 },
  { 3638, 16, 29, 19, 3, -26 },
  { 3696, 7, 29, 19, 6, -26 },
  { 3722, 16, 29, 19, 1, -26 },
  { 3780, 15, 6, 19, 2, -14 },
};

const GFXfont JetBrainsMono_Italic31pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Italic31pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Italic31pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _JETBRAINSMONO_ITALIC31PT7B_H_
