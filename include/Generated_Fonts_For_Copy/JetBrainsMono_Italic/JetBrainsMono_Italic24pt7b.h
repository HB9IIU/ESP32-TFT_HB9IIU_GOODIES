#ifndef _JETBRAINSMONO_ITALIC24PT7B_H_
#define _JETBRAINSMONO_ITALIC24PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Italic.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Italic24pt7bBitmaps[] PROGMEM = {
  0x00, 0x0C, 0x71, 0xC7, 0x1C, 0x61, 0x86, 0x18, 0x43, 0x0C, 0x30, 0x00,
  0x0C, 0x71, 0xC0, 0x73, 0xB9, 0x98, 0xCC, 0x66, 0x33, 0x19, 0x19, 0x8C,
  0x03, 0x18, 0x08, 0x60, 0x61, 0x01, 0x8C, 0x04, 0x30, 0xFF, 0xF7, 0xFF,
  0x86, 0x18, 0x18, 0x40, 0x63, 0x03, 0x0C, 0x0C, 0x20, 0xFF, 0xF1, 0x86,
  0x06, 0x10, 0x18, 0xC0, 0xC3, 0x03, 0x18, 0x00, 0x00, 0x80, 0x04, 0x00,
  0x60, 0x07, 0x80, 0xFF, 0x0E, 0xB8, 0x64, 0xC6, 0x27, 0x31, 0x01, 0xD8,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x01, 0xF0, 0x09, 0x80, 0xCC, 0xE6, 0x67,
  0x33, 0x39, 0x38, 0xFF, 0x83, 0xF0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x02,
  0x01, 0x87, 0xC1, 0x86, 0x61, 0x82, 0x31, 0x83, 0x18, 0x81, 0x8C, 0xC0,
  0xEE, 0xC0, 0x3E, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x4F, 0x00, 0x6F,
  0xC0, 0x6C, 0x60, 0x66, 0x30, 0x63, 0x18, 0x61, 0x98, 0x20, 0xFC, 0x70,
  0x3C, 0x00, 0x03, 0x80, 0x7F, 0x07, 0x38, 0x30, 0xC3, 0x80, 0x1C, 0x00,
  0x60, 0x03, 0x80, 0x3C, 0x03, 0xF1, 0xF9, 0x8D, 0x8E, 0xCC, 0x3E, 0x60,
  0xE3, 0x07, 0x18, 0x78, 0xFE, 0xE3, 0xE3, 0x80, 0x7F, 0xED, 0xB6, 0x00,
  0xC0, 0xF0, 0x70, 0x30, 0x18, 0x0E, 0x03, 0x01, 0xC0, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x38, 0x0C, 0x03, 0x00, 0xE0, 0x38, 0x06, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0x40, 0x0C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x70,
  0x0C, 0x03, 0x00, 0xC0, 0x70, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0C,
  0x03, 0x01, 0xC0, 0x60, 0x70, 0x38, 0x3C, 0x0C, 0x00, 0x03, 0x80, 0x18,
  0x00, 0xC0, 0x06, 0x06, 0x33, 0xFD, 0x7C, 0xFF, 0x80, 0xC0, 0x0F, 0x00,
  0xCC, 0x0E, 0x70, 0xE1, 0x82, 0x08, 0x00, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x61, 0xFF, 0xFF, 0xF8, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0E, 0x00,
  0x1E, 0x38, 0xE1, 0xC3, 0x0E, 0x18, 0x60, 0x7F, 0xFF, 0x33, 0xBC, 0xE0,
  0x00, 0x0E, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x0E, 0x00,
  0x18, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x30,
  0x00, 0xE0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x01,
  0x80, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x7F, 0x07,
  0x1C, 0x70, 0x63, 0x03, 0x98, 0x18, 0xC0, 0xC6, 0x06, 0x67, 0x33, 0x39,
  0x98, 0x8C, 0xC0, 0xC6, 0x06, 0x30, 0x31, 0x81, 0x8C, 0x18, 0x7F, 0xC1,
  0xF8, 0x00, 0x01, 0xC0, 0xF8, 0x3E, 0x1E, 0xC3, 0x18, 0x43, 0x00, 0x60,
  0x0C, 0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0xC0, 0x30,
  0xFF, 0xFF, 0xFC, 0x03, 0xC0, 0x7F, 0x07, 0x1C, 0x70, 0x63, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x1F, 0xF1, 0xFF,
  0x00, 0x30, 0x06, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x78, 0x07, 0xC0, 0x0E,
  0x00, 0x60, 0x06, 0x00, 0x6E, 0x06, 0xE0, 0xEE, 0x0C, 0x7F, 0x83, 0xF0,
  0x00, 0x30, 0x06, 0x00, 0xC0, 0x1C, 0x03, 0x80, 0x70, 0x06, 0x00, 0xC0,
  0x18, 0x73, 0x86, 0x70, 0x66, 0x06, 0x7F, 0xE7, 0xFE, 0x80, 0xE0, 0x0C,
  0x00, 0xC0, 0x0C, 0x3F, 0xE7, 0xFC, 0xC0, 0x18, 0x03, 0x00, 0xE0, 0x18,
  0x83, 0x7C, 0x7B, 0xCC, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0xB0, 0x76,
  0x0C, 0xFF, 0x8F, 0xC0, 0x00, 0xE0, 0x1C, 0x01, 0x80, 0x30, 0x07, 0x00,
  0xE0, 0x0C, 0x01, 0xBC, 0x3F, 0xE7, 0x0E, 0x60, 0x76, 0x07, 0xE0, 0x7E,
  0x06, 0xE0, 0x66, 0x0C, 0x7F, 0xC3, 0xF0, 0x7F, 0xFF, 0xFE, 0xE0, 0x6C,
  0x0E, 0xC0, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x00, 0x60, 0x06, 0x00,
  0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x00, 0x70, 0x0E, 0x00, 0x03, 0xC0,
  0xFE, 0x1C, 0x71, 0x83, 0x30, 0x33, 0x03, 0x38, 0x61, 0xCE, 0x0F, 0x80,
  0xF8, 0x38, 0xC7, 0x06, 0x60, 0x66, 0x06, 0xE0, 0x66, 0x0C, 0x7F, 0xC3,
  0xF0, 0x07, 0x81, 0xFC, 0x38, 0xE7, 0x07, 0x60, 0x76, 0x07, 0xE0, 0x7E,
  0x06, 0x60, 0xE7, 0xBC, 0x3F, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0E, 0x01,
  0xC0, 0x18, 0x07, 0x00, 0x3C, 0xF3, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x3C, 0x70, 0x0F, 0x0F, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E,
  0x1C, 0x18, 0x38, 0x30, 0x70, 0x60, 0xE0, 0x00, 0x30, 0x0E, 0x03, 0xC1,
  0xF0, 0x7C, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0C, 0x7F, 0xEF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF7, 0xFE,
  0x30, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x70, 0x1E,
  0x0F, 0x83, 0xE0, 0x70, 0x0C, 0x00, 0x3C, 0x0F, 0xC3, 0xF8, 0x07, 0x01,
  0xC0, 0x30, 0x18, 0x06, 0x07, 0x0F, 0x83, 0x80, 0xC0, 0x30, 0x00, 0x00,
  0x01, 0xC0, 0xF0, 0x1C, 0x00, 0x01, 0xE0, 0x0F, 0xF0, 0x38, 0x70, 0xC0,
  0x61, 0x80, 0xC6, 0x01, 0x8C, 0x1B, 0x18, 0xFE, 0x23, 0x8C, 0xC6, 0x19,
  0x8C, 0x33, 0x18, 0xC6, 0x31, 0x8C, 0xC3, 0x19, 0xC6, 0x61, 0xFC, 0xC1,
  0x81, 0x80, 0x03, 0x80, 0x03, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0x01,
  0xC0, 0x1C, 0x01, 0xE0, 0x36, 0x03, 0x60, 0x66, 0x06, 0x60, 0x66, 0x0C,
  0x60, 0xC6, 0x18, 0x61, 0x86, 0x3F, 0xF3, 0x03, 0x30, 0x36, 0x03, 0x60,
  0x3E, 0x03, 0x1F, 0x00, 0xFF, 0x06, 0x3C, 0x70, 0x63, 0x03, 0x18, 0x18,
  0xC0, 0xC6, 0x0C, 0x3F, 0xC1, 0xFE, 0x18, 0x18, 0xC0, 0xC6, 0x07, 0x30,
  0x31, 0x81, 0x8C, 0x1C, 0xFF, 0xC7, 0xF8, 0x00, 0x07, 0x81, 0xFC, 0x38,
  0xE3, 0x06, 0x60, 0x66, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x0C, 0xC0, 0xCC, 0x18, 0xFF, 0x87, 0xE0, 0x1F,
  0x01, 0xFE, 0x18, 0xF3, 0x83, 0x30, 0x33, 0x03, 0x30, 0x33, 0x03, 0x30,
  0x37, 0x07, 0x70, 0x66, 0x06, 0x60, 0x66, 0x06, 0x60, 0xE6, 0x1C, 0xFF,
  0x8F, 0xE0, 0x1F, 0xF8, 0xFF, 0xC6, 0x00, 0x30, 0x03, 0x80, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x3F, 0xE1, 0xFF, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x7F, 0xE7, 0xFF, 0x00, 0x1F, 0xF8, 0xFF, 0xC6,
  0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x3F, 0xE1, 0xFF,
  0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x06,
  0x00, 0x00, 0x07, 0x81, 0xFC, 0x38, 0xE3, 0x06, 0x60, 0x66, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x0E, 0x7E, 0xC7, 0xEC, 0x0C, 0xC0, 0xCC, 0x0C, 0xC0,
  0xCC, 0x18, 0xFF, 0x87, 0xE0, 0x18, 0x18, 0xC0, 0xC6, 0x0E, 0x70, 0x63,
  0x03, 0x18, 0x18, 0xC0, 0xC6, 0x06, 0x3F, 0xF1, 0xFF, 0x1C, 0x18, 0xC0,
  0xC6, 0x06, 0x30, 0x31, 0x83, 0x8C, 0x1C, 0xE0, 0xC6, 0x06, 0x00, 0x1F,
  0xF8, 0xFF, 0x80, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01,
  0xC0, 0x7F, 0xC7, 0xFE, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x31, 0x81, 0xC6, 0x06, 0x1C, 0x38, 0x7F, 0xC0, 0xFE,
  0x00, 0x18, 0x0C, 0x60, 0x61, 0x83, 0x8E, 0x1C, 0x30, 0x60, 0xC3, 0x83,
  0x1C, 0x0C, 0x60, 0x3F, 0x81, 0xFC, 0x07, 0x38, 0x18, 0x60, 0x61, 0x81,
  0x87, 0x06, 0x0C, 0x18, 0x38, 0xE0, 0xE3, 0x01, 0x80, 0x38, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x38, 0x0C, 0x03, 0x00, 0xFF, 0xFF, 0xF0, 0x18, 0x39, 0xE1, 0xCF,
  0x1E, 0x78, 0xF3, 0xC5, 0x9E, 0x6C, 0x92, 0xCC, 0xB6, 0x67, 0x33, 0x39,
  0x98, 0x0C, 0xC0, 0xE6, 0x06, 0x70, 0x33, 0x01, 0x98, 0x0C, 0xC0, 0x66,
  0x07, 0x00, 0x1C, 0x18, 0xE0, 0xC7, 0x06, 0x78, 0x73, 0x63, 0x1B, 0x18,
  0xD8, 0xC6, 0xC6, 0x36, 0x33, 0x9B, 0x98, 0xD8, 0xC6, 0xC6, 0x36, 0x31,
  0xB1, 0x87, 0x9C, 0x3C, 0xC1, 0xC6, 0x0E, 0x00, 0x07, 0x81, 0xFC, 0x38,
  0xE3, 0x06, 0x60, 0x66, 0x06, 0x60, 0x66, 0x06, 0x60, 0x6E, 0x0E, 0xC0,
  0xCC, 0x0C, 0xC0, 0xCC, 0x0C, 0xC1, 0xCC, 0x18, 0xFF, 0x07, 0xE0, 0x1F,
  0x80, 0xFF, 0x86, 0x1E, 0x70, 0x73, 0x01, 0x98, 0x0C, 0xC0, 0x66, 0x07,
  0x30, 0x73, 0xFF, 0x1F, 0xE0, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0xE0, 0x06, 0x00, 0x00, 0x03, 0xC0, 0x7F, 0x07, 0x1C, 0x70, 0x63,
  0x03, 0x98, 0x18, 0xC0, 0xC6, 0x06, 0x70, 0x33, 0x01, 0x98, 0x1C, 0xC0,
  0xC6, 0x06, 0x30, 0x31, 0x81, 0x8C, 0x18, 0x7F, 0xC1, 0xF8, 0x00, 0xC0,
  0x07, 0x00, 0x18, 0x00, 0xE0, 0x1F, 0x80, 0xFF, 0x86, 0x3C, 0x70, 0x73,
  0x01, 0x98, 0x0C, 0xC0, 0xE6, 0x06, 0x30, 0xE3, 0xFE, 0x1F, 0xE0, 0xC3,
  0x06, 0x18, 0x30, 0xE1, 0x87, 0x0C, 0x18, 0xE0, 0xE6, 0x07, 0x00, 0x03,
  0xC0, 0x7F, 0x87, 0x1C, 0x30, 0x63, 0x03, 0x98, 0x00, 0xE0, 0x03, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x38, 0x00, 0xC0, 0x06, 0x70, 0x33, 0x81, 0x9C,
  0x1C, 0x7F, 0xC1, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x06, 0x00, 0xE0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x03, 0x80, 0x30, 0x03, 0x00, 0x18, 0x18, 0xC0, 0xC6,
  0x0E, 0x70, 0x73, 0x03, 0x18, 0x18, 0xC0, 0xC6, 0x06, 0x30, 0x33, 0x83,
  0x98, 0x18, 0xC0, 0xC6, 0x06, 0x30, 0x31, 0x83, 0x8C, 0x18, 0x7F, 0x81,
  0xF8, 0x00, 0xC0, 0x3C, 0x07, 0xC0, 0x6C, 0x0E, 0xC0, 0xCE, 0x0C, 0x61,
  0x86, 0x18, 0x63, 0x86, 0x30, 0x63, 0x06, 0x60, 0x66, 0x06, 0xE0, 0x6C,
  0x06, 0xC0, 0x38, 0x03, 0x80, 0xC3, 0x0F, 0x0C, 0x6C, 0x71, 0xB1, 0x46,
  0xC5, 0x33, 0x34, 0xCC, 0xF3, 0x32, 0xCC, 0xCB, 0x63, 0x6D, 0x8D, 0x36,
  0x34, 0xD8, 0xF3, 0xC3, 0xCF, 0x0E, 0x2C, 0x28, 0xA0, 0xE3, 0x83, 0x0E,
  0x00, 0x18, 0x0E, 0x38, 0x18, 0x30, 0x60, 0x61, 0xC0, 0x63, 0x00, 0xCC,
  0x01, 0xF8, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x36, 0x00,
  0xCC, 0x03, 0x9C, 0x0E, 0x18, 0x18, 0x30, 0x60, 0x71, 0xC0, 0x60, 0xC0,
  0x3C, 0x07, 0xC0, 0x66, 0x0C, 0x61, 0xC6, 0x18, 0x73, 0x03, 0x30, 0x36,
  0x03, 0xE0, 0x1C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80, 0x30,
  0x03, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x60,
  0x07, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0xC0, 0x0C, 0x00, 0xFF, 0xE7, 0xFE, 0x00, 0x0F, 0xC3, 0xF0, 0xC0,
  0x70, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x03, 0x80, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x70, 0x18, 0x06, 0x01, 0x80, 0x60, 0x1F, 0x8F,
  0xC0, 0xC1, 0x83, 0x83, 0x06, 0x0C, 0x1C, 0x18, 0x30, 0x60, 0xC1, 0xC1,
  0x83, 0x06, 0x0E, 0x0C, 0x18, 0x30, 0x60, 0xE0, 0xC1, 0x80, 0x0F, 0xC7,
  0xE0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x38, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x07, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x38, 0x0C,
  0x3F, 0x0F, 0xC0, 0x03, 0x00, 0xE0, 0x1E, 0x06, 0xC1, 0x98, 0x31, 0x0C,
  0x31, 0x86, 0x60, 0xD8, 0x0C, 0xFF, 0xF0, 0xE3, 0x0C, 0x30, 0x0F, 0xB1,
  0xFF, 0x30, 0x73, 0x07, 0x70, 0x76, 0x06, 0x60, 0x66, 0x06, 0x60, 0x66,
  0x0E, 0x60, 0xE7, 0xFC, 0x3E, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80,
  0x30, 0x03, 0x7E, 0x3F, 0xE3, 0x87, 0x30, 0x77, 0x07, 0x60, 0x66, 0x06,
  0x60, 0x66, 0x06, 0x60, 0xE6, 0x0C, 0xFF, 0xCC, 0xF8, 0x1F, 0xC7, 0xF9,
  0xC3, 0xB0, 0x3E, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x1B, 0x06,
  0x7F, 0xC7, 0xE0, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x07,
  0xD8, 0x7F, 0xC6, 0x0E, 0x30, 0x73, 0x83, 0x98, 0x18, 0xC0, 0xC6, 0x06,
  0x30, 0x31, 0x83, 0x8C, 0x1C, 0x7F, 0xC1, 0xF6, 0x00, 0x1F, 0x87, 0x39,
  0x83, 0xB0, 0x7E, 0x0F, 0xFF, 0xBF, 0xF6, 0x00, 0xC0, 0x18, 0x0B, 0x06,
  0x7F, 0xC7, 0xE0, 0x00, 0x0F, 0x00, 0x7F, 0x00, 0xF0, 0x00, 0xC0, 0x01,
  0xC0, 0x01, 0x80, 0x1F, 0xFE, 0x1F, 0xFC, 0x01, 0x80, 0x01, 0x80, 0x03,
  0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0xFE, 0x00, 0xF8, 0x00, 0x1F,
  0x67, 0xFD, 0xC3, 0xB0, 0x7E, 0x0F, 0x81, 0xB0, 0x36, 0x06, 0xC0, 0xDC,
  0x3B, 0xFF, 0x3E, 0xC0, 0x18, 0x03, 0x00, 0x67, 0xF8, 0xFE, 0x00, 0x18,
  0x01, 0x80, 0x18, 0x03, 0x80, 0x30, 0x03, 0x7E, 0x3C, 0xE3, 0x87, 0x30,
  0x77, 0x07, 0x60, 0x66, 0x06, 0x60, 0x66, 0x06, 0x60, 0x66, 0x0E, 0xE0,
  0xCC, 0x0C, 0x00, 0x80, 0x38, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE1,
  0xFC, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0E, 0x01, 0x80, 0x30,
  0x06, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x10, 0x03, 0xC0, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01,
  0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x60,
  0x03, 0x00, 0x38, 0x3F, 0x83, 0xF8, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x03, 0x80, 0x18, 0x1C, 0xC1, 0xC6, 0x1C, 0x31, 0xC1, 0x9C, 0x1F,
  0xC0, 0xFE, 0x06, 0x30, 0x31, 0xC1, 0x86, 0x0C, 0x38, 0xE0, 0xC6, 0x07,
  0x00, 0x7E, 0x1F, 0x88, 0xE0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x1C,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x03, 0x80, 0xE0, 0x1F, 0xC3, 0xF0,
  0x7E, 0xF3, 0xBD, 0x98, 0xCC, 0xC6, 0x66, 0x23, 0x33, 0x19, 0x98, 0xD8,
  0xC6, 0xC6, 0x66, 0x33, 0x31, 0x19, 0x88, 0xCC, 0xC6, 0x00, 0x37, 0xE3,
  0xCE, 0x38, 0x73, 0x07, 0x70, 0x76, 0x06, 0x60, 0x66, 0x06, 0x60, 0x66,
  0x06, 0x60, 0xEE, 0x0C, 0xC0, 0xC0, 0x1F, 0x87, 0xF9, 0x83, 0xB0, 0x7E,
  0x0F, 0x81, 0xB0, 0x36, 0x06, 0xC0, 0xD8, 0x3B, 0x06, 0x7F, 0x87, 0xE0,
  0x1B, 0xF0, 0xFF, 0x87, 0x0E, 0x30, 0x73, 0x83, 0x98, 0x18, 0xC0, 0xC6,
  0x06, 0x30, 0x31, 0x83, 0x8C, 0x18, 0xFF, 0xC6, 0x7C, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0xE0, 0x00, 0x0F, 0xB1, 0xFF, 0x30, 0x73, 0x07, 0x70, 0x66,
  0x06, 0x60, 0x66, 0x06, 0x60, 0x66, 0x0E, 0x60, 0xE7, 0xFC, 0x3E, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x37, 0xCF, 0xBD, 0xC1, 0xB0, 0x36,
  0x06, 0xC0, 0x18, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x00,
  0x1F, 0xE3, 0xEE, 0x30, 0x73, 0x00, 0x30, 0x03, 0xF0, 0x1F, 0xC0, 0x1E,
  0x00, 0x60, 0x06, 0xE0, 0xE7, 0xFC, 0x3F, 0x80, 0x06, 0x00, 0xE0, 0x0C,
  0x00, 0xC1, 0xFF, 0xEF, 0xFE, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x38, 0x01, 0xFC, 0x0F, 0x80, 0x30, 0x33,
  0x03, 0x30, 0x33, 0x03, 0x70, 0x76, 0x06, 0x60, 0x66, 0x06, 0x60, 0x66,
  0x0E, 0x60, 0xC7, 0xF8, 0x3F, 0x00, 0xE0, 0x76, 0x06, 0x60, 0xE6, 0x0C,
  0x60, 0xC7, 0x18, 0x31, 0x83, 0x30, 0x33, 0x03, 0x60, 0x36, 0x03, 0xC0,
  0x1C, 0x00, 0xC6, 0x1E, 0x31, 0xB3, 0x8D, 0x94, 0x4C, 0xA6, 0x6D, 0x33,
  0x49, 0x1A, 0x58, 0xF2, 0xC7, 0x14, 0x38, 0xE1, 0xC7, 0x0C, 0x30, 0x00,
  0x18, 0x1C, 0x30, 0xC0, 0xC7, 0x01, 0xB8, 0x06, 0xC0, 0x0E, 0x00, 0x38,
  0x01, 0xE0, 0x0D, 0xC0, 0x73, 0x03, 0x8E, 0x1C, 0x18, 0xE0, 0x70, 0x60,
  0x6C, 0x0D, 0x81, 0xB0, 0x3E, 0x0F, 0xC1, 0xB0, 0x36, 0x06, 0xC1, 0xDC,
  0x3B, 0xFF, 0x3E, 0xC0, 0x18, 0x03, 0x00, 0x67, 0xF8, 0xFE, 0x00, 0x3F,
  0xF3, 0xFF, 0x00, 0xE0, 0x1C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0F, 0xFE, 0xFF, 0xC0, 0x00, 0x70, 0x1F, 0x01, 0x80,
  0x38, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x70, 0xFE, 0x0F,
  0xC0, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0E, 0x00, 0x78, 0x01, 0x80, 0x18, 0xC6, 0x33, 0x9C, 0xC6, 0x31,
  0x8C, 0xE6, 0x31, 0x8C, 0x67, 0x31, 0x8C, 0x63, 0x00, 0x1C, 0x01, 0xF0,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x07, 0xF0, 0x3F, 0x07, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x01, 0xC0, 0x38, 0x0F, 0x00, 0x80, 0x00, 0x1C, 0x37, 0xE3, 0x67,
  0x36, 0x3F, 0xE1, 0xE0,
};

const GFXglyph JetBrainsMono_Italic24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 6, 18, 14, 4, -18 },
  { 15, 9, 8, 14, 4, -18 },
  { 24, 14, 18, 14, 1, -18 },
  { 56, 13, 24, 14, 1, -21 },
  { 95, 17, 18, 14, -1, -18 },
  { 134, 13, 18, 14, 1, -18 },
  { 164, 3, 8, 14, 7, -18 },
  { 167, 10, 23, 14, 4, -20 },
  { 196, 10, 23, 14, 1, -20 },
  { 225, 13, 13, 14, 1, -15 },
  { 247, 11, 12, 14, 2, -14 },
  { 264, 7, 8, 14, 2, -4 },
  { 271, 8, 2, 14, 3, -9 },
  { 273, 5, 4, 14, 4, -4 },
  { 276, 15, 23, 14, 0, -20 },
  { 320, 13, 18, 14, 1, -18 },
  { 350, 11, 18, 14, 1, -18 },
  { 375, 13, 18, 14, 1, -18 },
  { 405, 12, 18, 14, 1, -18 },
  { 432, 12, 18, 14, 1, -18 },
  { 459, 11, 18, 14, 2, -18 },
  { 484, 12, 18, 14, 1, -18 },
  { 511, 12, 18, 14, 3, -18 },
  { 538, 12, 18, 14, 1, -18 },
  { 565, 12, 18, 14, 2, -18 },
  { 592, 6, 13, 14, 4, -13 },
  { 602, 8, 17, 14, 2, -13 },
  { 619, 12, 12, 14, 2, -14 },
  { 637, 11, 8, 14, 2, -12 },
  { 648, 12, 12, 14, 1, -14 },
  { 666, 10, 18, 14, 3, -18 },
  { 689, 15, 22, 14, 0, -18 },
  { 731, 12, 18, 14, 0, -18 },
  { 758, 13, 18, 14, 1, -18 },
  { 788, 12, 18, 14, 2, -18 },
  { 815, 12, 18, 14, 1, -18 },
  { 842, 13, 18, 14, 1, -18 },
  { 872, 13, 18, 14, 1, -18 },
  { 902, 12, 18, 14, 2, -18 },
  { 929, 13, 18, 14, 1, -18 },
  { 959, 13, 18, 14, 1, -18 },
  { 989, 14, 18, 14, 0, -18 },
  { 1021, 14, 18, 14, 1, -18 },
  { 1053, 10, 18, 14, 2, -18 },
  { 1076, 13, 18, 14, 1, -18 },
  { 1106, 13, 18, 14, 1, -18 },
  { 1136, 12, 18, 14, 2, -18 },
  { 1163, 13, 18, 14, 1, -18 },
  { 1193, 13, 22, 14, 1, -18 },
  { 1229, 13, 18, 14, 1, -18 },
  { 1259, 13, 18, 14, 1, -18 },
  { 1289, 12, 18, 14, 3, -18 },
  { 1316, 13, 18, 14, 1, -18 },
  { 1346, 12, 18, 14, 3, -18 },
  { 1373, 14, 18, 14, 2, -18 },
  { 1405, 15, 18, 14, 0, -18 },
  { 1439, 12, 18, 14, 3, -18 },
  { 1466, 13, 18, 14, 1, -18 },
  { 1496, 10, 23, 14, 3, -20 },
  { 1525, 7, 23, 14, 4, -20 },
  { 1546, 10, 23, 14, 2, -20 },
  { 1575, 11, 10, 14, 2, -18 },
  { 1589, 12, 1, 14, 0, 1 },
  { 1591, 5, 4, 14, 6, -19 },
  { 1594, 12, 13, 14, 1, -13 },
  { 1614, 12, 18, 14, 1, -18 },
  { 1641, 11, 13, 14, 2, -13 },
  { 1659, 13, 18, 14, 1, -18 },
  { 1689, 11, 13, 14, 2, -13 },
  { 1707, 16, 22, 14, -1, -18 },
  { 1751, 11, 17, 14, 2, -13 },
  { 1775, 12, 18, 14, 1, -18 },
  { 1802, 11, 19, 14, 1, -19 },
  { 1829, 13, 23, 14, 0, -19 },
  { 1867, 13, 18, 14, 1, -18 },
  { 1897, 10, 18, 14, 2, -18 },
  { 1920, 13, 13, 14, 1, -13 },
  { 1942, 12, 13, 14, 1, -13 },
  { 1962, 11, 13, 14, 2, -13 },
  { 1980, 13, 17, 14, 0, -13 },
  { 2008, 12, 17, 14, 1, -13 },
  { 2034, 11, 13, 14, 2, -13 },
  { 2052, 12, 13, 14, 1, -13 },
  { 2072, 12, 17, 14, 2, -17 },
  { 2098, 12, 13, 14, 1, -13 },
  { 2118, 12, 13, 14, 2, -13 },
  { 2138, 13, 13, 14, 2, -13 },
  { 2160, 14, 13, 14, 0, -13 },
  { 2183, 11, 17, 14, 2, -13 },
  { 2207, 12, 13, 14, 1, -13 },
  { 2227, 12, 23, 14, 2, -20 },
  { 2262, 5, 23, 14, 5, -20 },
  { 2277, 12, 23, 14, 1, -20 },
  { 2312, 12, 5, 14, 1, -11 },
};

const GFXfont JetBrainsMono_Italic24pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Italic24pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Italic24pt7bGlyphs,
  0x20, 0x7E, 32
};

#endif // _JETBRAINSMONO_ITALIC24PT7B_H_
