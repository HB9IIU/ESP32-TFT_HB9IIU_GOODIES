#ifndef _JETBRAINSMONO_ITALIC28PT7B_H_
#define _JETBRAINSMONO_ITALIC28PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Italic.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Italic28pt7bBitmaps[] PROGMEM = {
  0x00, 0x0E, 0x1C, 0x70, 0xE1, 0xC3, 0x87, 0x0C, 0x18, 0x30, 0x61, 0xC3,
  0x06, 0x00, 0x00, 0x00, 0xE3, 0xE7, 0x80, 0x71, 0xDC, 0x66, 0x39, 0x8E,
  0x63, 0xB8, 0xCE, 0x33, 0x0C, 0x01, 0x87, 0x03, 0x06, 0x03, 0x0E, 0x03,
  0x0C, 0x06, 0x0C, 0x3F, 0xFF, 0x3F, 0xFF, 0x0C, 0x18, 0x0C, 0x30, 0x0C,
  0x30, 0x18, 0x30, 0x18, 0x60, 0x18, 0x60, 0xFF, 0xFC, 0x30, 0xC0, 0x30,
  0xC0, 0x60, 0xC0, 0x61, 0x80, 0x61, 0x80, 0xC3, 0x80, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x07, 0x80, 0x7F, 0x81, 0xFF, 0x83, 0x33, 0x8E, 0x67,
  0x18, 0xCE, 0x31, 0x00, 0x72, 0x00, 0xEC, 0x01, 0xF8, 0x01, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x01, 0x38, 0x06, 0x30, 0x0C, 0x63, 0x18, 0xC6, 0x33,
  0x8E, 0x6E, 0x1F, 0xF8, 0x0F, 0xE0, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x01, 0xF8, 0x1C, 0x7B, 0x83, 0x0C, 0x30, 0xC1,
  0x86, 0x30, 0x31, 0x8C, 0x06, 0x33, 0x00, 0xCE, 0xE0, 0x1F, 0x98, 0x01,
  0xC6, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x19, 0xF0, 0x07, 0x7F, 0x00,
  0xDC, 0x60, 0x33, 0x0C, 0x0C, 0x61, 0x83, 0x0C, 0x30, 0xC1, 0x8C, 0x38,
  0x3F, 0x8E, 0x03, 0xE0, 0x01, 0xC0, 0x0F, 0xE0, 0x3D, 0xE0, 0xE0, 0xC1,
  0xC1, 0x83, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0xFC,
  0x03, 0xB8, 0x76, 0x39, 0xDC, 0x33, 0x38, 0x7E, 0x70, 0x78, 0xE0, 0xE1,
  0xC1, 0xE3, 0x8F, 0xC7, 0xF9, 0xC7, 0xE1, 0xC0, 0x76, 0xEE, 0xEE, 0xCC,
  0x00, 0x10, 0x07, 0x01, 0xF0, 0x3C, 0x07, 0x00, 0xE0, 0x0C, 0x01, 0xC0,
  0x18, 0x03, 0x80, 0x38, 0x03, 0x00, 0x30, 0x03, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x60, 0x07, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0x80,
  0x1E, 0x00, 0xF0, 0x07, 0x00, 0x10, 0x08, 0x00, 0x70, 0x0F, 0x80, 0x3C,
  0x01, 0xC0, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06,
  0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x1C,
  0x01, 0x80, 0x38, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0x60, 0x08, 0x00,
  0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x06, 0x18, 0x6F, 0x37, 0xFF,
  0xDF, 0x03, 0xF0, 0x03, 0x80, 0x0D, 0x80, 0x33, 0x80, 0xE7, 0x07, 0x87,
  0x06, 0x0C, 0x00, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01,
  0x83, 0xFF, 0xFF, 0xFF, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0,
  0x00, 0x1E, 0x38, 0xE1, 0xC7, 0x0E, 0x38, 0x70, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xE0, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00,
  0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0,
  0x3F, 0xC1, 0xFF, 0x8E, 0x07, 0x30, 0x1D, 0xC0, 0x77, 0x01, 0xDC, 0x06,
  0x60, 0x19, 0x8C, 0x66, 0x71, 0xB9, 0xCE, 0xE0, 0x3B, 0x80, 0xEC, 0x03,
  0x30, 0x0C, 0xC0, 0x73, 0x81, 0xCE, 0x0E, 0x1F, 0xF0, 0x3F, 0x80, 0x01,
  0xF0, 0x3F, 0x03, 0x98, 0x39, 0xC1, 0x0E, 0x10, 0x70, 0x03, 0x80, 0x18,
  0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x03, 0x80, 0x1C, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xE0, 0x0F, 0xF0,
  0x3F, 0xF0, 0xE0, 0xE1, 0x80, 0xE7, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x03, 0xFF, 0xCF, 0xFF, 0x80,
  0x0F, 0xFE, 0x3F, 0xF8, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00,
  0xE0, 0x01, 0xF0, 0x03, 0xF0, 0x08, 0xF0, 0x00, 0xE0, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x18, 0x0E, 0x30, 0x1C, 0x60, 0x30, 0xE1, 0xE1, 0xFF, 0x80,
  0xFC, 0x00, 0x00, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x18, 0x01, 0xC0, 0x1C, 0x39, 0xC1, 0x9C, 0x0D, 0xC0, 0x6E, 0x07, 0x7F,
  0xFB, 0xFF, 0xDF, 0xFC, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x1F,
  0xFC, 0x7F, 0xE3, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x0D,
  0xF8, 0x7F, 0xF1, 0xE1, 0xC7, 0x03, 0x00, 0x0E, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x1C, 0xE0, 0x63, 0x83, 0x87, 0xFC, 0x0F, 0xE0, 0x00, 0x78,
  0x03, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0x38,
  0x1F, 0xF0, 0xF9, 0xE3, 0x83, 0xDC, 0x07, 0x70, 0x1D, 0x80, 0x76, 0x01,
  0xD8, 0x06, 0x70, 0x39, 0xC1, 0xC3, 0xFE, 0x07, 0xF0, 0x7F, 0xFD, 0xFF,
  0xF6, 0x01, 0x98, 0x0E, 0xE0, 0x30, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01,
  0xC0, 0x07, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x07,
  0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x01, 0xE0, 0x0F, 0xF0,
  0x3F, 0xF0, 0xE0, 0x61, 0xC0, 0xC3, 0x01, 0x86, 0x03, 0x0E, 0x0E, 0x0E,
  0x38, 0x1F, 0xE0, 0x0F, 0x00, 0x7F, 0x81, 0xC7, 0x86, 0x07, 0x1C, 0x06,
  0x30, 0x0C, 0x60, 0x38, 0xC0, 0x71, 0xC1, 0xC1, 0xFF, 0x01, 0xFC, 0x00,
  0x03, 0x80, 0xFF, 0x0F, 0xFC, 0xE0, 0x76, 0x03, 0xF0, 0x1F, 0x80, 0xF8,
  0x07, 0xC0, 0x3F, 0x03, 0xB8, 0x3C, 0xFF, 0xC3, 0xEC, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x06, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x00, 0x0C,
  0x7C, 0xF9, 0xE1, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x1F, 0x3E,
  0x78, 0x07, 0x07, 0xC3, 0xE1, 0xE0, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0xE0, 0xF0, 0x70, 0x70, 0x38, 0x18, 0x1C, 0x00,
  0x00, 0x04, 0x00, 0x70, 0x07, 0x80, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0x18, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03,
  0xC0, 0x03, 0x00, 0x7F, 0xFB, 0xFF, 0xDF, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFE, 0xFF, 0xF0, 0x20, 0x00, 0x60, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x00, 0x3C, 0x03, 0xE0,
  0x7E, 0x07, 0xC0, 0x7C, 0x01, 0xC0, 0x0C, 0x00, 0x00, 0x3F, 0x8F, 0xF8,
  0x07, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0E, 0x03, 0xC7, 0xF0, 0xF8,
  0x1C, 0x03, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x78,
  0x00, 0x00, 0x78, 0x01, 0xFF, 0x01, 0xE3, 0xC1, 0xC0, 0x61, 0xC0, 0x38,
  0xC0, 0x1C, 0xE0, 0x0E, 0x60, 0x27, 0x30, 0xFF, 0x18, 0x73, 0x8C, 0x70,
  0xC6, 0x30, 0x67, 0x18, 0x33, 0x0C, 0x39, 0x8E, 0x18, 0xC7, 0x0C, 0x63,
  0x86, 0x31, 0xC7, 0x38, 0x7D, 0x9C, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01,
  0xC0, 0x00, 0xF0, 0x00, 0x3F, 0x80, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x03,
  0xC0, 0x1F, 0x00, 0x6E, 0x01, 0xB8, 0x0E, 0xE0, 0x33, 0x81, 0xC6, 0x06,
  0x18, 0x18, 0x60, 0xE1, 0x83, 0x06, 0x1F, 0xF8, 0x7F, 0xF3, 0xFF, 0xCE,
  0x07, 0x30, 0x1D, 0xC0, 0x76, 0x00, 0xF8, 0x03, 0x1F, 0xF8, 0x3F, 0xF8,
  0x70, 0x70, 0xC0, 0x71, 0x80, 0xE3, 0x01, 0x86, 0x07, 0x1C, 0x0C, 0x3F,
  0xF0, 0x7F, 0xC0, 0xC3, 0xE1, 0x81, 0xC3, 0x01, 0xCE, 0x03, 0x9C, 0x06,
  0x38, 0x0C, 0x60, 0x38, 0xC1, 0xE1, 0xFF, 0x87, 0xFE, 0x00, 0x01, 0xC0,
  0x3F, 0xC1, 0xFF, 0x8E, 0x07, 0x38, 0x1C, 0xC0, 0x73, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x0C, 0xE0, 0x73, 0x81, 0xCF, 0x0E, 0x1F, 0xF0, 0x3F, 0x80, 0x1F,
  0xF0, 0x3F, 0xF8, 0x70, 0x70, 0xC0, 0x61, 0x80, 0xC3, 0x01, 0x8E, 0x03,
  0x1C, 0x06, 0x38, 0x1C, 0x70, 0x38, 0xC0, 0x71, 0x80, 0xC3, 0x01, 0x8E,
  0x03, 0x1C, 0x0E, 0x38, 0x1C, 0x60, 0x70, 0xC1, 0xC1, 0xFF, 0x07, 0xFC,
  0x00, 0x1F, 0xFE, 0x7F, 0xF8, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x7F, 0xF0, 0xFF, 0xE1, 0xC0, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x03, 0xFF,
  0xC7, 0xFF, 0x00, 0x0F, 0xFF, 0x1F, 0xFE, 0x1C, 0x00, 0x1C, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x04, 0x3F, 0xF8, 0x3F,
  0xF8, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x3F, 0xC1, 0xFF,
  0x8E, 0x07, 0x38, 0x1C, 0xC0, 0x73, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x06, 0x00, 0x18, 0xFE, 0x63, 0xFB, 0x80, 0xCE, 0x03, 0x38, 0x0C, 0xE0,
  0x73, 0x81, 0xCF, 0x0E, 0x1F, 0xF0, 0x3F, 0x80, 0x1C, 0x06, 0x38, 0x1C,
  0x70, 0x38, 0xE0, 0x71, 0x80, 0xC3, 0x01, 0x86, 0x03, 0x1C, 0x0E, 0x3F,
  0xFC, 0x7F, 0xF8, 0xFF, 0xE1, 0x80, 0xC3, 0x01, 0x8E, 0x07, 0x1C, 0x0E,
  0x38, 0x1C, 0x60, 0x38, 0xC0, 0x61, 0x80, 0xC7, 0x03, 0x80, 0x1F, 0xFC,
  0x7F, 0xF0, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x0E, 0x00, 0x38, 0x0F, 0xFE, 0x3F, 0xF8, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x1C, 0x60, 0x18, 0x60, 0x18, 0x70, 0x38, 0x78, 0x70, 0x3F, 0xE0, 0x1F,
  0xC0, 0x1C, 0x07, 0x1C, 0x0E, 0x1C, 0x0C, 0x18, 0x1C, 0x18, 0x38, 0x18,
  0x30, 0x38, 0x70, 0x38, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x30,
  0xC0, 0x30, 0xE0, 0x70, 0xE0, 0x70, 0x70, 0x70, 0x70, 0x60, 0x70, 0x60,
  0x38, 0x60, 0x38, 0xE0, 0x38, 0x1C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x38,
  0x03, 0x80, 0x38, 0x03, 0x00, 0x30, 0x03, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0x1E,
  0x0F, 0x1E, 0x1E, 0x16, 0x1E, 0x36, 0x3E, 0x36, 0x36, 0x36, 0x36, 0x33,
  0x6E, 0x33, 0x6C, 0x33, 0xCC, 0x33, 0xCC, 0x73, 0x8C, 0x70, 0x1C, 0x70,
  0x1C, 0x60, 0x18, 0x60, 0x18, 0x60, 0x18, 0xE0, 0x18, 0xE0, 0x38, 0xE0,
  0x38, 0xC0, 0x38, 0x1E, 0x06, 0x3C, 0x0C, 0x78, 0x38, 0xF8, 0x71, 0xB0,
  0xE3, 0x61, 0x8E, 0xC3, 0x1D, 0x86, 0x3B, 0x9C, 0x63, 0x38, 0xC6, 0x71,
  0x8C, 0xC7, 0x19, 0x8E, 0x3B, 0x1C, 0x36, 0x30, 0x7C, 0x60, 0xF8, 0xC1,
  0xE1, 0x83, 0xC7, 0x03, 0x80, 0x01, 0xC0, 0x3F, 0xC1, 0xFF, 0x8E, 0x0E,
  0x38, 0x1C, 0xC0, 0x73, 0x01, 0x9C, 0x06, 0x70, 0x19, 0xC0, 0xE6, 0x03,
  0x98, 0x0E, 0x60, 0x33, 0x80, 0xCE, 0x03, 0x38, 0x1C, 0xE0, 0x73, 0x81,
  0x8F, 0x0E, 0x1F, 0xF0, 0x3F, 0x80, 0x1F, 0xFC, 0x1F, 0xFE, 0x1C, 0x0E,
  0x18, 0x06, 0x18, 0x07, 0x18, 0x06, 0x38, 0x06, 0x38, 0x0E, 0x38, 0x1C,
  0x3F, 0xFC, 0x3F, 0xF0, 0x3F, 0x80, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x3F, 0xC1, 0xFF, 0x8E, 0x07, 0x30, 0x1D, 0xC0, 0x77, 0x01, 0xDC, 0x06,
  0x70, 0x19, 0x80, 0x66, 0x03, 0xB8, 0x0E, 0xE0, 0x3B, 0x80, 0xEE, 0x03,
  0x30, 0x0C, 0xC0, 0x73, 0x81, 0xCF, 0x0E, 0x1F, 0xF0, 0x3F, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x1F, 0xF8, 0x3F, 0xF8,
  0x70, 0x38, 0xC0, 0x71, 0x80, 0xE3, 0x01, 0xCE, 0x03, 0x9C, 0x06, 0x38,
  0x3C, 0x7F, 0xF0, 0xFF, 0x81, 0x86, 0x03, 0x0E, 0x0E, 0x1C, 0x1C, 0x38,
  0x38, 0x38, 0x60, 0x70, 0xC0, 0xE1, 0x80, 0xE7, 0x01, 0xC0, 0x00, 0xE0,
  0x0F, 0xF0, 0x3F, 0xF0, 0xE0, 0x71, 0xC0, 0xE3, 0x01, 0xC6, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x03, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x60, 0x18, 0xC0, 0x71, 0xC1, 0xC3, 0xFF, 0x01,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x38, 0x0C, 0xE0, 0x73, 0x81, 0xCC, 0x07, 0x30, 0x1C, 0xC0, 0x67,
  0x01, 0x9C, 0x06, 0x70, 0x39, 0x80, 0xE6, 0x03, 0x98, 0x0C, 0xE0, 0x33,
  0x80, 0xCE, 0x07, 0x38, 0x1C, 0xE0, 0x63, 0xC3, 0x87, 0xFC, 0x0F, 0xE0,
  0xE0, 0x1D, 0x80, 0x76, 0x01, 0x98, 0x0E, 0x60, 0x31, 0x81, 0xC7, 0x07,
  0x1C, 0x18, 0x70, 0xE1, 0xC3, 0x07, 0x1C, 0x0C, 0x60, 0x31, 0x80, 0xCE,
  0x03, 0x30, 0x0D, 0xC0, 0x36, 0x00, 0xD8, 0x03, 0xE0, 0x0F, 0x00, 0x61,
  0xC3, 0x61, 0xC7, 0x63, 0xC6, 0x63, 0xC6, 0xE2, 0xCE, 0xE6, 0xCC, 0xE6,
  0x8C, 0xE6, 0x8C, 0xE4, 0x9C, 0xEC, 0x98, 0xCC, 0x98, 0xC8, 0x98, 0xD8,
  0xB8, 0xD8, 0xB0, 0xD8, 0xB0, 0xD1, 0xB0, 0xF1, 0xE0, 0xF1, 0xE0, 0xE1,
  0xE0, 0xE1, 0xE0, 0x1E, 0x03, 0x87, 0x03, 0x81, 0x83, 0x80, 0xE1, 0xC0,
  0x71, 0xC0, 0x19, 0xC0, 0x0E, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xE0,
  0x00, 0x78, 0x00, 0x7C, 0x00, 0x76, 0x00, 0x33, 0x80, 0x38, 0xC0, 0x38,
  0x70, 0x38, 0x38, 0x1C, 0x0C, 0x1C, 0x07, 0x1C, 0x03, 0x80, 0xE0, 0x0E,
  0xC0, 0x39, 0xC0, 0xE3, 0x81, 0x83, 0x07, 0x06, 0x1C, 0x0E, 0x30, 0x0C,
  0xE0, 0x19, 0x80, 0x3E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00,
  0x1F, 0xFE, 0x3F, 0xFC, 0x00, 0x30, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x18, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xC0, 0x13, 0xFF, 0xC7,
  0xFF, 0x80, 0x0F, 0xE1, 0xFC, 0x30, 0x06, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x18, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x01, 0x80,
  0x30, 0x0E, 0x01, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xFE,
  0x1F, 0xC0, 0xC0, 0xC0, 0xE0, 0xE0, 0x60, 0x60, 0x70, 0x70, 0x70, 0x30,
  0x30, 0x38, 0x38, 0x18, 0x18, 0x1C, 0x1C, 0x0C, 0x0C, 0x0E, 0x0E, 0x0E,
  0x06, 0x06, 0x07, 0x07, 0x07, 0xF0, 0xFE, 0x00, 0x60, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x18, 0x01, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x30, 0x03, 0x00,
  0x30, 0x07, 0x00, 0x70, 0x7F, 0x0F, 0xE0, 0x03, 0x80, 0x78, 0x0F, 0x80,
  0xCC, 0x18, 0xC1, 0x8C, 0x30, 0x67, 0x06, 0x60, 0x6C, 0x07, 0xFF, 0xFF,
  0xFF, 0xF0, 0xE1, 0xC3, 0x87, 0x07, 0x00, 0xFE, 0xCF, 0xF6, 0x70, 0x77,
  0x03, 0xB0, 0x1D, 0x80, 0xEC, 0x06, 0xE0, 0x37, 0x01, 0xB8, 0x1D, 0xC0,
  0xEE, 0x07, 0x70, 0x71, 0xFD, 0x87, 0xDC, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x06, 0x00, 0x18, 0xE0, 0x6F, 0xE3, 0xFF, 0x8F, 0x07, 0x38, 0x1C, 0xE0,
  0x73, 0x01, 0xCC, 0x06, 0x30, 0x19, 0xC0, 0x67, 0x03, 0x9C, 0x0E, 0x70,
  0x31, 0xE1, 0xC6, 0xFE, 0x3B, 0xF0, 0x03, 0xC0, 0x7F, 0x8F, 0xFC, 0x70,
  0x77, 0x03, 0xB0, 0x1D, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0xEE, 0x07, 0x78, 0x71, 0xFF, 0x07, 0xF0, 0x00, 0x0C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x07, 0x18, 0x7F, 0x63, 0xFD, 0x8E, 0x0E, 0x70, 0x39,
  0x80, 0xE6, 0x03, 0x98, 0x0C, 0xE0, 0x33, 0x80, 0xCE, 0x07, 0x38, 0x1C,
  0xE0, 0x73, 0x83, 0x87, 0xF6, 0x0F, 0xB8, 0x03, 0x80, 0x7F, 0x0F, 0xBC,
  0x60, 0x77, 0x03, 0xB0, 0x1D, 0x80, 0xEF, 0xFE, 0xFF, 0xF7, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x07, 0x70, 0x71, 0xFF, 0x07, 0xF0, 0x00, 0x1F, 0xE0,
  0x07, 0xFC, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x03,
  0xFF, 0xE0, 0xFF, 0xFC, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x03, 0xC0, 0x07, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x00, 0xFE,
  0xCF, 0xF6, 0x70, 0x77, 0x03, 0xB8, 0x1D, 0x80, 0xEC, 0x06, 0xE0, 0x37,
  0x01, 0xB8, 0x1D, 0xC0, 0xE7, 0x1F, 0x3F, 0xB0, 0xF9, 0x80, 0x0C, 0x00,
  0xE0, 0x07, 0x00, 0x70, 0xFF, 0x87, 0xF0, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x06, 0x00, 0x18, 0xE0, 0x6F, 0xE3, 0xF7, 0x8F, 0x07, 0x38, 0x1C,
  0xE0, 0x73, 0x01, 0xCC, 0x06, 0x30, 0x19, 0xC0, 0x67, 0x03, 0x9C, 0x0E,
  0x60, 0x39, 0x80, 0xC6, 0x03, 0x38, 0x0C, 0x00, 0x60, 0x03, 0xC0, 0x0F,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xC1, 0xFF, 0xFB, 0xFF, 0xE0, 0x00, 0x0C,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x0F, 0xF8, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00,
  0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0, 0xFF, 0x03, 0xF8,
  0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x01,
  0xC6, 0x07, 0x1C, 0x1C, 0x38, 0x70, 0x71, 0xC0, 0xC7, 0x01, 0xFE, 0x03,
  0xF8, 0x0E, 0x38, 0x1C, 0x70, 0x38, 0x70, 0x70, 0xE0, 0xC0, 0xE1, 0x81,
  0xC7, 0x01, 0xC0, 0xFE, 0x0F, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0,
  0x0C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x38, 0x03, 0x80, 0x38, 0x03, 0x81, 0x1F, 0xE0, 0xFE, 0x03, 0x18, 0x6F,
  0x78, 0xEF, 0x39, 0x8C, 0x77, 0x18, 0xEE, 0x31, 0x98, 0x63, 0x31, 0xC6,
  0x63, 0x0C, 0xC6, 0x3B, 0x8C, 0x77, 0x18, 0xCE, 0x31, 0x98, 0x63, 0x31,
  0x86, 0x63, 0x1C, 0x00, 0xE0, 0x6F, 0xE3, 0xF7, 0x8F, 0x07, 0x38, 0x1C,
  0xE0, 0x73, 0x01, 0xCC, 0x06, 0x30, 0x19, 0xC0, 0x67, 0x03, 0x9C, 0x0E,
  0x60, 0x39, 0x80, 0xC6, 0x03, 0x38, 0x0C, 0x03, 0x80, 0x7F, 0x0F, 0xFC,
  0x70, 0x77, 0x03, 0xB0, 0x1D, 0x80, 0xEC, 0x06, 0xE0, 0x37, 0x01, 0xB8,
  0x1D, 0xC0, 0xEE, 0x06, 0x78, 0x71, 0xFF, 0x07, 0xF0, 0x00, 0xE0, 0x6F,
  0xE3, 0xFF, 0x8F, 0x07, 0x38, 0x1C, 0xE0, 0x73, 0x01, 0xCC, 0x06, 0x30,
  0x19, 0xC0, 0x67, 0x03, 0x9C, 0x0E, 0x70, 0x31, 0xE1, 0xC6, 0xFE, 0x3B,
  0xF0, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x07, 0x00,
  0xFE, 0xCF, 0xF6, 0x70, 0x77, 0x03, 0xB0, 0x1D, 0x80, 0xEC, 0x06, 0xE0,
  0x37, 0x01, 0xB8, 0x1D, 0xC0, 0xEE, 0x07, 0x70, 0x71, 0xFD, 0x87, 0xCC,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x01, 0xC0, 0xEF,
  0xC3, 0x7F, 0x8E, 0x0E, 0x38, 0x18, 0xC0, 0x67, 0x01, 0x9C, 0x00, 0x70,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30,
  0x00, 0x03, 0xC0, 0xFF, 0x8F, 0xFE, 0x60, 0x77, 0x00, 0x38, 0x01, 0xE0,
  0x07, 0xF0, 0x1F, 0xE0, 0x0F, 0x80, 0x1C, 0x00, 0xEC, 0x07, 0x70, 0x73,
  0xFF, 0x8F, 0xF0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x01,
  0xFF, 0xFF, 0xFF, 0x81, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xFE,
  0x01, 0xF8, 0x30, 0x1B, 0x80, 0xDC, 0x0E, 0xE0, 0x76, 0x03, 0xB0, 0x1D,
  0x80, 0xDC, 0x06, 0xE0, 0x37, 0x03, 0xB8, 0x1D, 0xC0, 0xCF, 0x0E, 0x3F,
  0xE0, 0xFC, 0x00, 0xE0, 0x3F, 0x01, 0xB8, 0x1C, 0xC0, 0xC6, 0x0E, 0x30,
  0x61, 0x87, 0x0E, 0x38, 0x71, 0x81, 0x9C, 0x0C, 0xC0, 0x6E, 0x03, 0x60,
  0x1F, 0x00, 0xF0, 0x00, 0xC3, 0x87, 0x87, 0x1B, 0x1E, 0x36, 0x3C, 0x6C,
  0x59, 0x99, 0xB3, 0x33, 0x66, 0x64, 0xD8, 0xD9, 0xB1, 0xB3, 0x63, 0x46,
  0x86, 0x8F, 0x0F, 0x1E, 0x1C, 0x3C, 0x38, 0x70, 0x00, 0x1C, 0x0F, 0x0E,
  0x0E, 0x06, 0x1C, 0x07, 0x38, 0x03, 0x70, 0x03, 0xE0, 0x01, 0xE0, 0x03,
  0xC0, 0x03, 0xE0, 0x07, 0x60, 0x0E, 0x70, 0x1C, 0x70, 0x38, 0x38, 0x30,
  0x38, 0xF0, 0x1C, 0x30, 0x1B, 0x80, 0xDC, 0x0E, 0xE0, 0x77, 0x03, 0xB0,
  0x1D, 0x80, 0xCC, 0x06, 0xE0, 0x37, 0x03, 0xB8, 0x1C, 0xE3, 0xE7, 0xF6,
  0x0F, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x1F, 0xF0, 0xFE, 0x00,
  0x1F, 0xFC, 0x7F, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x3C,
  0x01, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x01, 0xFF,
  0xCF, 0xFF, 0x00, 0x00, 0x7C, 0x03, 0xF0, 0x1C, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0,
  0xFE, 0x03, 0xF8, 0x00, 0x60, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x80, 0x0F, 0xC0, 0x0F,
  0x00, 0x0E, 0x1C, 0x38, 0x70, 0xC1, 0x83, 0x0E, 0x1C, 0x38, 0x60, 0xC1,
  0x87, 0x0E, 0x1C, 0x30, 0x60, 0xC3, 0x87, 0x0E, 0x1C, 0x30, 0x61, 0xC0,
  0x0F, 0x00, 0x7E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x18,
  0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xFC, 0x07,
  0xF0, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0x18, 0x1D,
  0xF8, 0x7F, 0xF1, 0xB0, 0xE6, 0xC3, 0xF3, 0x07, 0x80,
};

const GFXglyph JetBrainsMono_Italic28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 7, 20, 17, 5, -20 },
  { 19, 10, 8, 17, 5, -20 },
  { 29, 16, 20, 17, 1, -20 },
  { 69, 15, 28, 17, 1, -24 },
  { 122, 19, 21, 17, -1, -21 },
  { 172, 15, 21, 17, 1, -21 },
  { 212, 4, 8, 17, 8, -20 },
  { 216, 12, 28, 17, 4, -24 },
  { 258, 12, 28, 17, 1, -24 },
  { 300, 15, 14, 17, 1, -17 },
  { 327, 13, 13, 17, 2, -16 },
  { 349, 7, 8, 17, 3, -4 },
  { 356, 9, 2, 17, 4, -10 },
  { 359, 5, 4, 17, 5, -4 },
  { 362, 17, 26, 17, 0, -23 },
  { 418, 14, 21, 17, 2, -21 },
  { 455, 13, 20, 17, 1, -20 },
  { 488, 15, 21, 17, 1, -21 },
  { 528, 15, 20, 17, 1, -20 },
  { 566, 13, 20, 17, 2, -20 },
  { 599, 14, 20, 17, 2, -20 },
  { 634, 14, 20, 17, 1, -20 },
  { 669, 14, 20, 17, 3, -20 },
  { 704, 15, 21, 17, 1, -21 },
  { 744, 13, 21, 17, 3, -21 },
  { 779, 7, 16, 17, 5, -16 },
  { 793, 9, 20, 17, 3, -16 },
  { 816, 14, 15, 17, 2, -17 },
  { 843, 13, 9, 17, 2, -14 },
  { 858, 14, 15, 17, 1, -17 },
  { 885, 11, 20, 17, 4, -20 },
  { 913, 17, 26, 17, 0, -21 },
  { 969, 14, 20, 17, 0, -20 },
  { 1004, 15, 20, 17, 1, -20 },
  { 1042, 14, 21, 17, 2, -21 },
  { 1079, 15, 20, 17, 1, -20 },
  { 1117, 15, 20, 17, 2, -20 },
  { 1155, 16, 20, 17, 1, -20 },
  { 1195, 14, 21, 17, 2, -21 },
  { 1232, 15, 20, 17, 1, -20 },
  { 1270, 14, 20, 17, 2, -20 },
  { 1305, 16, 20, 17, 0, -20 },
  { 1345, 16, 20, 17, 1, -20 },
  { 1385, 12, 20, 17, 2, -20 },
  { 1415, 16, 20, 17, 1, -20 },
  { 1455, 15, 20, 17, 1, -20 },
  { 1493, 14, 21, 17, 2, -21 },
  { 1530, 16, 20, 17, 1, -20 },
  { 1570, 14, 26, 17, 2, -21 },
  { 1616, 15, 20, 17, 1, -20 },
  { 1654, 15, 21, 17, 1, -21 },
  { 1694, 14, 20, 17, 3, -20 },
  { 1729, 14, 20, 17, 2, -20 },
  { 1764, 14, 20, 17, 3, -20 },
  { 1799, 16, 20, 17, 2, -20 },
  { 1839, 17, 20, 17, 0, -20 },
  { 1882, 15, 20, 17, 3, -20 },
  { 1920, 15, 20, 17, 1, -20 },
  { 1958, 11, 26, 17, 4, -23 },
  { 1994, 8, 26, 17, 5, -23 },
  { 2020, 12, 26, 17, 2, -23 },
  { 2059, 12, 10, 17, 3, -20 },
  { 2074, 14, 2, 17, 0, 1 },
  { 2078, 6, 4, 17, 7, -22 },
  { 2081, 13, 16, 17, 2, -16 },
  { 2107, 14, 20, 17, 1, -20 },
  { 2142, 13, 16, 17, 2, -16 },
  { 2168, 14, 20, 17, 2, -20 },
  { 2203, 13, 16, 17, 2, -16 },
  { 2229, 19, 25, 17, -1, -20 },
  { 2289, 13, 21, 17, 2, -16 },
  { 2324, 14, 20, 17, 1, -20 },
  { 2359, 14, 22, 17, 1, -22 },
  { 2398, 15, 27, 17, 0, -22 },
  { 2449, 15, 20, 17, 1, -20 },
  { 2487, 12, 20, 17, 3, -20 },
  { 2517, 15, 16, 17, 1, -16 },
  { 2547, 14, 16, 17, 1, -16 },
  { 2575, 13, 16, 17, 2, -16 },
  { 2601, 14, 21, 17, 1, -16 },
  { 2638, 13, 21, 17, 2, -16 },
  { 2673, 14, 16, 17, 2, -16 },
  { 2701, 13, 16, 17, 2, -16 },
  { 2727, 14, 20, 17, 2, -20 },
  { 2762, 13, 15, 17, 2, -15 },
  { 2787, 13, 15, 17, 3, -15 },
  { 2812, 15, 15, 17, 2, -15 },
  { 2841, 16, 15, 17, 0, -15 },
  { 2871, 13, 20, 17, 2, -15 },
  { 2904, 14, 15, 17, 1, -15 },
  { 2931, 14, 26, 17, 3, -23 },
  { 2977, 7, 26, 17, 5, -23 },
  { 3000, 14, 26, 17, 1, -23 },
  { 3046, 14, 6, 17, 2, -13 },
};

const GFXfont JetBrainsMono_Italic28pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Italic28pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Italic28pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _JETBRAINSMONO_ITALIC28PT7B_H_
