#ifndef _JETBRAINSMONO_ITALIC35PT7B_H_
#define _JETBRAINSMONO_ITALIC35PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Italic.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Italic35pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x0F, 0x0F, 0x0E, 0x0E, 0x1E, 0x1E, 0x1E, 0x1C, 0x1C, 0x1C,
  0x1C, 0x1C, 0x18, 0x38, 0x38, 0x38, 0x30, 0x00, 0x00, 0x00, 0x00, 0x78,
  0xF8, 0xF8, 0xF0, 0x70, 0xEE, 0x1F, 0xC3, 0xF8, 0xFE, 0x1F, 0xC3, 0xB8,
  0x77, 0x0E, 0xE1, 0xD8, 0x3B, 0x06, 0x00, 0x00, 0x70, 0x70, 0x06, 0x06,
  0x00, 0xE0, 0xE0, 0x0E, 0x0E, 0x00, 0xC0, 0xC0, 0x1C, 0x1C, 0x01, 0xC1,
  0xC1, 0xFF, 0xFF, 0x1F, 0xFF, 0xF3, 0xFF, 0xFF, 0x03, 0x03, 0x00, 0x70,
  0x70, 0x07, 0x07, 0x00, 0x60, 0x60, 0x0E, 0x0E, 0x00, 0xC0, 0xE0, 0x0C,
  0x0C, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0x81, 0x81, 0x80, 0x38, 0x38, 0x03,
  0x03, 0x00, 0x30, 0x30, 0x07, 0x07, 0x00, 0x60, 0x60, 0x0E, 0x0E, 0x00,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0xFC, 0x00,
  0xFF, 0xC0, 0x7F, 0xF8, 0x3C, 0xDE, 0x1E, 0x73, 0xC7, 0x18, 0x71, 0xC6,
  0x3C, 0x71, 0x80, 0x1C, 0x60, 0x07, 0x18, 0x01, 0xE6, 0x00, 0x3F, 0x00,
  0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x03, 0x7C, 0x00, 0xCF, 0x00,
  0x71, 0xC0, 0x18, 0x73, 0x86, 0x1C, 0xE1, 0x87, 0x38, 0x63, 0x8F, 0x19,
  0xE1, 0xFF, 0xF0, 0x7F, 0xF8, 0x07, 0xF8, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x07, 0x07, 0xF0,
  0x0E, 0x0F, 0xF8, 0x0C, 0x0E, 0x38, 0x18, 0x1C, 0x38, 0x38, 0x1C, 0x38,
  0x70, 0x1C, 0x38, 0xE0, 0x1C, 0x39, 0xC0, 0x1C, 0x31, 0x80, 0x1E, 0xF3,
  0x00, 0x0F, 0xE7, 0x00, 0x07, 0xCE, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x67, 0xF0, 0x00, 0xEF, 0xF8, 0x01, 0xCE,
  0x38, 0x03, 0x9C, 0x38, 0x07, 0x1C, 0x38, 0x06, 0x1C, 0x38, 0x0C, 0x1C,
  0x38, 0x1C, 0x18, 0x30, 0x38, 0x1C, 0x70, 0x70, 0x1F, 0xE0, 0xE0, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x3F, 0xE0, 0x1F, 0xFC, 0x03, 0xC3, 0xC0, 0xF0,
  0x38, 0x1C, 0x07, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0xC0, 0x01, 0xFC, 0x00, 0x7F, 0x81, 0xDE, 0x78,
  0x73, 0x87, 0x1E, 0x70, 0xF3, 0x8E, 0x0E, 0xE1, 0xC0, 0xF8, 0x78, 0x1F,
  0x0E, 0x01, 0xC1, 0xC0, 0x7C, 0x3C, 0x1F, 0x87, 0xFF, 0xF8, 0x7F, 0xC7,
  0x07, 0xF0, 0x70, 0x7B, 0x9C, 0xEF, 0x7B, 0xDC, 0xE7, 0x38, 0x00, 0x04,
  0x00, 0x70, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1E, 0x00, 0x70, 0x03, 0x80,
  0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x78,
  0x00, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0x04, 0x00,
  0x1C, 0x00, 0x7C, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x3F, 0x00, 0xF8, 0x03, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x1C, 0x38, 0x7F,
  0xCC, 0x7F, 0xFB, 0x7F, 0x3F, 0xFE, 0x00, 0x70, 0x00, 0x3E, 0x00, 0x1D,
  0xC0, 0x0E, 0x70, 0x07, 0x9E, 0x03, 0xC3, 0xC1, 0xE0, 0xF0, 0x30, 0x1C,
  0x04, 0x04, 0x00, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x00, 0x0F, 0xC3, 0xC0, 0xF0, 0x78, 0x1E, 0x0F, 0x03,
  0xC0, 0xE0, 0x70, 0x1C, 0x0E, 0x00, 0xFF, 0xFF, 0xFE, 0xFF, 0xE0, 0x7D,
  0xFF, 0xFF, 0x78, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00,
  0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x7F,
  0xF8, 0x3C, 0x1E, 0x1E, 0x03, 0xC7, 0x00, 0xF3, 0x80, 0x1C, 0xE0, 0x07,
  0x38, 0x03, 0x8E, 0x00, 0xE3, 0x80, 0x38, 0xE3, 0x0E, 0x71, 0xE3, 0x9C,
  0x78, 0xE7, 0x1E, 0x71, 0xC0, 0x1C, 0x70, 0x07, 0x1C, 0x01, 0xCE, 0x00,
  0x73, 0x80, 0x1C, 0xE0, 0x0E, 0x3C, 0x03, 0x87, 0x01, 0xC1, 0xFB, 0xF0,
  0x3F, 0xF8, 0x07, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0xFC, 0x03, 0xF8, 0x07,
  0xF8, 0x1F, 0x38, 0x1E, 0x38, 0x18, 0x38, 0x30, 0x78, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01,
  0xC0, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFC, 0x00,
  0xFF, 0xC0, 0x7F, 0xF8, 0x3C, 0x1E, 0x1E, 0x03, 0x87, 0x00, 0xE3, 0x80,
  0x38, 0xE0, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00,
  0x03, 0xFF, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xC3, 0xFF,
  0xE0, 0xFF, 0xF8, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x03,
  0xFE, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03,
  0xC0, 0x00, 0xF3, 0x80, 0x38, 0xE0, 0x0E, 0x38, 0x07, 0x8F, 0x03, 0xC1,
  0xFF, 0xE0, 0x7F, 0xF0, 0x07, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0xE1, 0xE0, 0x70, 0xE0,
  0x38, 0xE0, 0x1C, 0xF0, 0x1E, 0x70, 0x0E, 0x38, 0x07, 0x3F, 0xFF, 0x9F,
  0xFF, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x0F, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xF8, 0x38, 0x00,
  0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x3E, 0x03, 0xFF, 0xE0, 0xEF, 0xF8, 0x3E, 0x1F, 0x0F, 0x03, 0xC3, 0x80,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C,
  0xE0, 0x0E, 0x3C, 0x03, 0x87, 0x01, 0xC1, 0xFB, 0xF0, 0x3F, 0xF8, 0x07,
  0xF8, 0x00, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03,
  0x9E, 0x03, 0xBF, 0xC3, 0xFF, 0xF1, 0xE0, 0x79, 0xE0, 0x1C, 0xE0, 0x0E,
  0xF0, 0x07, 0x70, 0x03, 0xB8, 0x01, 0xDC, 0x00, 0xEE, 0x00, 0xF7, 0x80,
  0x73, 0xC0, 0x78, 0xFD, 0xF8, 0x3F, 0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0xFF,
  0xBF, 0xFF, 0xDF, 0xFF, 0xEE, 0x00, 0xF7, 0x00, 0x73, 0x80, 0x7B, 0xC0,
  0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0,
  0x01, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78,
  0x00, 0x38, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x7F,
  0xF8, 0x3C, 0x1E, 0x1E, 0x03, 0x87, 0x00, 0xE1, 0xC0, 0x38, 0x70, 0x0E,
  0x1C, 0x07, 0x87, 0x81, 0xC0, 0xF1, 0xE0, 0x1F, 0xF0, 0x03, 0xF0, 0x01,
  0xFE, 0x01, 0xF3, 0xC0, 0xF0, 0x78, 0x78, 0x0E, 0x1C, 0x03, 0xC7, 0x00,
  0x73, 0x80, 0x1C, 0xE0, 0x0E, 0x3C, 0x03, 0x8F, 0x01, 0xE1, 0xFB, 0xF0,
  0x3F, 0xF8, 0x07, 0xF8, 0x00, 0x01, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0xC3,
  0xC1, 0xE3, 0xC0, 0x7B, 0xC0, 0x1D, 0xC0, 0x0E, 0xE0, 0x07, 0x70, 0x03,
  0xF8, 0x03, 0xFC, 0x01, 0xCE, 0x01, 0xE7, 0x81, 0xF3, 0xF3, 0xF0, 0xFF,
  0xF0, 0x3F, 0xF8, 0x00, 0x78, 0x00, 0x38, 0x00, 0x38, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x00, 0x06, 0x0F, 0x87, 0xE3, 0xE1, 0xF0, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x7C, 0x7E, 0x3F, 0x0F, 0x00,
  0x01, 0x80, 0xF8, 0x1F, 0x83, 0xF0, 0x7C, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x78, 0x1F, 0x03,
  0xC0, 0xF0, 0x1E, 0x03, 0x80, 0xF0, 0x1C, 0x07, 0x80, 0xE0, 0x18, 0x00,
  0x00, 0x00, 0x80, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3C,
  0x00, 0x06, 0x00, 0x01, 0x00, 0x3F, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0x3F, 0xFF, 0xBF, 0xFF, 0xC0, 0x20, 0x00, 0x1C, 0x00, 0x0F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F,
  0x00, 0x01, 0x80, 0x07, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x01, 0xFC, 0x00, 0xF8, 0x00, 0x60, 0x00, 0x20, 0x00, 0x00, 0x3F, 0x00,
  0xFF, 0x83, 0xFF, 0x00, 0x7E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x3C, 0x07, 0xE0, 0x7F, 0x01, 0xF8,
  0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x07,
  0xFF, 0x00, 0x7F, 0xFC, 0x07, 0x00, 0xE0, 0x70, 0x07, 0x87, 0x00, 0x1C,
  0x38, 0x00, 0xE3, 0x80, 0x07, 0x1C, 0x00, 0x38, 0xC0, 0x79, 0xCE, 0x0F,
  0xEE, 0x70, 0x71, 0xE3, 0x87, 0x07, 0x1C, 0x38, 0x38, 0xE1, 0x81, 0xC6,
  0x0C, 0x0E, 0x30, 0xE0, 0x73, 0x87, 0x03, 0x1C, 0x38, 0x38, 0xE1, 0xC1,
  0xC7, 0x0E, 0x0E, 0x38, 0x78, 0xF1, 0x83, 0xFB, 0x9C, 0x0F, 0x98, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x1E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x77, 0x00, 0x1D, 0xC0, 0x0E, 0x70,
  0x03, 0x9C, 0x00, 0xE7, 0x00, 0x71, 0xC0, 0x1C, 0x70, 0x0E, 0x1C, 0x03,
  0x87, 0x01, 0xE0, 0xC0, 0x70, 0x38, 0x1C, 0x0E, 0x0E, 0x03, 0x83, 0xFF,
  0xE1, 0xFF, 0xF8, 0x70, 0x0E, 0x3C, 0x03, 0x8E, 0x00, 0xE3, 0x80, 0x39,
  0xE0, 0x0E, 0x70, 0x03, 0xFC, 0x00, 0x70, 0x0F, 0xE0, 0x03, 0xFF, 0x81,
  0xFF, 0xF0, 0x70, 0x3E, 0x1C, 0x03, 0x87, 0x00, 0xF1, 0xC0, 0x38, 0x70,
  0x0E, 0x3C, 0x03, 0x8E, 0x01, 0xE3, 0x80, 0xF0, 0xFF, 0xF8, 0x3F, 0xF8,
  0x0F, 0xFF, 0x83, 0x81, 0xE1, 0xC0, 0x3C, 0x70, 0x07, 0x1C, 0x01, 0xC7,
  0x00, 0x71, 0xC0, 0x1C, 0x70, 0x0F, 0x3C, 0x03, 0x8E, 0x01, 0xE3, 0xFF,
  0xF0, 0xFF, 0xF8, 0x3F, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x7F,
  0xF8, 0x3C, 0x1E, 0x1E, 0x03, 0x87, 0x00, 0xF1, 0xC0, 0x3C, 0xF0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x3C, 0x70, 0x0E, 0x1C, 0x03, 0x87, 0x81, 0xC1, 0xFB, 0xF0,
  0x3F, 0xF8, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0x81, 0xFF, 0xF0,
  0x70, 0x7E, 0x1C, 0x07, 0x87, 0x00, 0xE1, 0xC0, 0x38, 0x70, 0x0E, 0x3C,
  0x03, 0x8E, 0x00, 0xE3, 0x80, 0x38, 0xE0, 0x0E, 0x38, 0x07, 0x8E, 0x01,
  0xC7, 0x80, 0x71, 0xE0, 0x1C, 0x70, 0x07, 0x1C, 0x01, 0xC7, 0x00, 0xF1,
  0xC0, 0x38, 0x70, 0x0E, 0x3C, 0x07, 0x8E, 0x03, 0xC3, 0xFF, 0xE0, 0xFF,
  0xF0, 0x3F, 0xF0, 0x00, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x07,
  0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F,
  0xFC, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xFF,
  0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x7F,
  0xFF, 0x8E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xFF,
  0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC3, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0xFF,
  0xC0, 0x7F, 0xF8, 0x3C, 0x1E, 0x1E, 0x03, 0x87, 0x00, 0xF1, 0xC0, 0x3C,
  0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x3F, 0xE7, 0x8F, 0xF1, 0xC3, 0xFC, 0x70, 0x07, 0x1C, 0x01,
  0xC7, 0x00, 0x71, 0xC0, 0x3C, 0x70, 0x0E, 0x1C, 0x03, 0x87, 0x81, 0xC1,
  0xFB, 0xF0, 0x3F, 0xF8, 0x07, 0xF8, 0x00, 0x0E, 0x01, 0xC3, 0x80, 0x71,
  0xE0, 0x1C, 0x70, 0x07, 0x1C, 0x03, 0xC7, 0x00, 0xE1, 0xC0, 0x38, 0x70,
  0x0E, 0x3C, 0x03, 0x8E, 0x00, 0xE3, 0x80, 0x78, 0xFF, 0xFE, 0x3F, 0xFF,
  0x0F, 0xFF, 0xC3, 0x80, 0x71, 0xE0, 0x1C, 0x70, 0x07, 0x1C, 0x03, 0xC7,
  0x00, 0xE1, 0xC0, 0x38, 0x70, 0x0E, 0x3C, 0x03, 0x8E, 0x00, 0xE3, 0x80,
  0x78, 0xE0, 0x1C, 0x38, 0x07, 0x00, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF,
  0xFC, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x01, 0xFF, 0xF0,
  0xFF, 0xFC, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x70, 0x03, 0x8E, 0x00, 0xF1, 0xE0, 0x1C, 0x3C, 0x07, 0x83,
  0xF7, 0xE0, 0x3F, 0xF8, 0x03, 0xFC, 0x00, 0x0E, 0x00, 0xF0, 0xE0, 0x0E,
  0x1E, 0x01, 0xC1, 0xC0, 0x3C, 0x1C, 0x03, 0x81, 0xC0, 0x70, 0x1C, 0x0F,
  0x01, 0xC1, 0xE0, 0x3C, 0x1C, 0x03, 0x83, 0xC0, 0x38, 0x78, 0x03, 0xFF,
  0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x78, 0x70, 0x07, 0x87, 0x00, 0x70,
  0x78, 0x07, 0x03, 0x80, 0x70, 0x38, 0x07, 0x03, 0xC0, 0x70, 0x1C, 0x0F,
  0x01, 0xC0, 0xE0, 0x1E, 0x0E, 0x00, 0xE0, 0xE0, 0x0F, 0x0E, 0x00, 0xF0,
  0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x7F, 0xFF,
  0x7F, 0xFE, 0xFF, 0xFE, 0x0F, 0x00, 0xF0, 0xF0, 0x1F, 0x0F, 0x81, 0xF0,
  0xF8, 0x3E, 0x0F, 0x83, 0x61, 0xD8, 0x76, 0x1D, 0x86, 0xE1, 0xD8, 0xEE,
  0x1D, 0xCC, 0xE1, 0xDD, 0xCC, 0x19, 0xDD, 0xC3, 0x8D, 0x9C, 0x38, 0xF9,
  0xC3, 0x8F, 0x1C, 0x38, 0xF1, 0xC3, 0x80, 0x38, 0x38, 0x03, 0x87, 0x80,
  0x38, 0x70, 0x03, 0x87, 0x00, 0x38, 0x70, 0x03, 0x87, 0x00, 0x78, 0x70,
  0x07, 0x07, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0x70, 0x0F, 0x01, 0xC7,
  0xC0, 0x71, 0xF0, 0x1C, 0x7C, 0x07, 0x1F, 0x81, 0xC7, 0xE0, 0x71, 0xF8,
  0x38, 0x6E, 0x0E, 0x39, 0x83, 0x8E, 0x70, 0xE3, 0x9C, 0x38, 0xE7, 0x0E,
  0x39, 0xC7, 0x0E, 0x31, 0xC7, 0x0E, 0x71, 0xC3, 0x9C, 0x70, 0xE7, 0x1C,
  0x39, 0xC7, 0x06, 0x71, 0xC1, 0xF8, 0xF0, 0x7E, 0x38, 0x1F, 0x8E, 0x07,
  0xE3, 0x80, 0xF8, 0xE0, 0x3E, 0x38, 0x0F, 0x00, 0x00, 0xFC, 0x00, 0xFF,
  0xC0, 0x7F, 0xF8, 0x3C, 0x1E, 0x1E, 0x03, 0x87, 0x00, 0xE1, 0xC0, 0x38,
  0xF0, 0x0E, 0x38, 0x03, 0x8E, 0x00, 0xE3, 0x80, 0x38, 0xE0, 0x0E, 0x38,
  0x07, 0x8E, 0x01, 0xC7, 0x80, 0x71, 0xC0, 0x1C, 0x70, 0x07, 0x1C, 0x01,
  0xC7, 0x00, 0xF1, 0xC0, 0x38, 0x70, 0x0E, 0x1C, 0x07, 0x87, 0x83, 0xC1,
  0xFF, 0xF0, 0x3F, 0xF8, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0xE0,
  0x7F, 0xFE, 0x0E, 0x03, 0xE1, 0xC0, 0x1C, 0x38, 0x03, 0xC7, 0x00, 0x78,
  0xE0, 0x0F, 0x3C, 0x01, 0xC7, 0x00, 0x38, 0xE0, 0x0F, 0x1C, 0x03, 0xC3,
  0x81, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x03, 0xFE, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0xFF, 0xC0, 0x7F, 0xF8, 0x3C, 0x1E, 0x1E, 0x03, 0xC7, 0x00, 0xF3, 0xC0,
  0x3C, 0xE0, 0x0F, 0x38, 0x03, 0x8E, 0x00, 0xE3, 0x80, 0x38, 0xE0, 0x0E,
  0x78, 0x03, 0x9C, 0x01, 0xE7, 0x00, 0x71, 0xC0, 0x1C, 0x70, 0x07, 0x1C,
  0x01, 0xCF, 0x00, 0x73, 0x80, 0x3C, 0xE0, 0x0E, 0x3C, 0x03, 0x87, 0x01,
  0xC1, 0xFB, 0xF0, 0x3F, 0xF8, 0x07, 0xF8, 0x00, 0x0E, 0x00, 0x03, 0xC0,
  0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x0F, 0xF8, 0x03,
  0xFF, 0xC1, 0xFF, 0xF8, 0x70, 0x3F, 0x1C, 0x03, 0xC7, 0x00, 0x71, 0xC0,
  0x1C, 0x70, 0x07, 0x3C, 0x01, 0xCE, 0x00, 0xF3, 0x80, 0x38, 0xE0, 0x1E,
  0x3F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0x81, 0xE1, 0xC0, 0x70, 0x70, 0x1C,
  0x1E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x3C, 0x3C, 0x07, 0x0E, 0x01,
  0xC3, 0x80, 0x78, 0xE0, 0x0E, 0x38, 0x03, 0xC0, 0x00, 0xFC, 0x00, 0xFF,
  0xC0, 0x7F, 0xF8, 0x3C, 0x1E, 0x1E, 0x03, 0xC7, 0x00, 0xF1, 0xC0, 0x3C,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0x00, 0x07,
  0xF0, 0x00, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01,
  0xC0, 0x00, 0x73, 0x80, 0x1C, 0xE0, 0x07, 0x38, 0x03, 0x8F, 0x01, 0xE1,
  0xFB, 0xF0, 0x7F, 0xF8, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xF8, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x01, 0xC7, 0x80, 0x71, 0xE0,
  0x1C, 0x70, 0x07, 0x1C, 0x01, 0xC7, 0x00, 0xF1, 0xC0, 0x38, 0x70, 0x0E,
  0x3C, 0x03, 0x8E, 0x00, 0xE3, 0x80, 0x38, 0xE0, 0x1E, 0x38, 0x07, 0x0E,
  0x01, 0xC7, 0x80, 0x71, 0xC0, 0x1C, 0x70, 0x07, 0x1C, 0x01, 0xC7, 0x00,
  0xF1, 0xC0, 0x38, 0x70, 0x0E, 0x1C, 0x07, 0x87, 0x03, 0xC1, 0xFB, 0xF0,
  0x3F, 0xF8, 0x07, 0xF8, 0x00, 0xE0, 0x03, 0xFC, 0x00, 0xEF, 0x00, 0x39,
  0xC0, 0x1E, 0x70, 0x07, 0x1C, 0x03, 0xC7, 0x00, 0xE1, 0xC0, 0x38, 0x70,
  0x1C, 0x1C, 0x07, 0x07, 0x03, 0xC1, 0xC0, 0xE0, 0x78, 0x38, 0x0E, 0x1C,
  0x03, 0x87, 0x00, 0xE3, 0x80, 0x38, 0xE0, 0x0E, 0x38, 0x03, 0x9C, 0x00,
  0xE7, 0x00, 0x3B, 0x80, 0x0E, 0xE0, 0x03, 0xB8, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0x80, 0x00, 0x70, 0x78, 0x3B, 0x83, 0xC3, 0x9C, 0x1E, 0x1C,
  0xE0, 0xF0, 0xE7, 0x0D, 0x87, 0x38, 0x6C, 0x71, 0xC3, 0xC3, 0x8E, 0x36,
  0x1C, 0x71, 0xB0, 0xC3, 0x8D, 0x8E, 0x1C, 0x6C, 0x70, 0xE6, 0x63, 0x87,
  0x33, 0x18, 0x39, 0x99, 0xC1, 0xD8, 0xCE, 0x0C, 0xC6, 0x60, 0x66, 0x37,
  0x03, 0x31, 0xB8, 0x1B, 0x0D, 0xC0, 0xD8, 0x6C, 0x0E, 0xC3, 0xE0, 0x7E,
  0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x07, 0x80, 0xF8, 0x3C, 0x07, 0x81, 0xE0,
  0x00, 0x0F, 0x00, 0x3C, 0x1C, 0x01, 0xE0, 0x78, 0x07, 0x00, 0xE0, 0x3C,
  0x03, 0x81, 0xE0, 0x0F, 0x07, 0x00, 0x1C, 0x38, 0x00, 0x71, 0xE0, 0x01,
  0xE7, 0x00, 0x03, 0xB8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xDC, 0x00,
  0x0E, 0x78, 0x00, 0x78, 0xE0, 0x01, 0xC3, 0x80, 0x0E, 0x0F, 0x00, 0x78,
  0x1C, 0x03, 0xC0, 0x78, 0x0E, 0x00, 0xE0, 0x78, 0x03, 0x83, 0xC0, 0x0F,
  0x00, 0xE0, 0x01, 0xF8, 0x00, 0xFF, 0x00, 0x39, 0xC0, 0x1C, 0x70, 0x0F,
  0x1E, 0x03, 0x83, 0x81, 0xC0, 0xE0, 0xF0, 0x3C, 0x38, 0x07, 0x1E, 0x01,
  0xC7, 0x00, 0x73, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x1E,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x00,
  0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x80, 0x00, 0xF0, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xFF, 0xF8, 0x7F, 0xFF, 0x1F,
  0xFF, 0xE0, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0x81, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x3C, 0x07, 0x01, 0xC0, 0x70, 0x1E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x1C, 0x07, 0x01, 0xC0, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x0F, 0xF8,
  0x3F, 0xE0, 0xFF, 0x80, 0x00, 0x70, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xB0,
  0x03, 0xB8, 0x07, 0x38, 0x07, 0x18, 0x0E, 0x1C, 0x0C, 0x1C, 0x1C, 0x0C,
  0x38, 0x0C, 0x38, 0x0E, 0x70, 0x0E, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0xF0, 0x70, 0xE0, 0xF0, 0x00, 0xC0, 0x03, 0xF9, 0xC3,
  0xFE, 0xE3, 0xE3, 0x73, 0xC0, 0x79, 0xC0, 0x3C, 0xE0, 0x1C, 0x70, 0x0E,
  0x78, 0x07, 0x38, 0x03, 0x9C, 0x01, 0xCE, 0x01, 0xE7, 0x00, 0xE3, 0x80,
  0x73, 0xC0, 0x38, 0xE0, 0x3C, 0x70, 0x3E, 0x3F, 0x77, 0x0F, 0xF7, 0x83,
  0xF3, 0x80, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x40, 0x3B, 0xFC, 0x3F, 0xFF, 0x1D, 0x87, 0x8F,
  0x01, 0xC7, 0x80, 0xE3, 0x80, 0x71, 0xC0, 0x39, 0xE0, 0x1C, 0xF0, 0x0E,
  0x70, 0x07, 0x38, 0x03, 0x9C, 0x03, 0xCE, 0x01, 0xC7, 0x00, 0xE7, 0x80,
  0xF3, 0xE0, 0x71, 0xDD, 0xF8, 0xEF, 0xF8, 0x73, 0xF0, 0x00, 0x00, 0x60,
  0x01, 0xFE, 0x03, 0xFF, 0xC3, 0xE1, 0xE1, 0xC0, 0x79, 0xC0, 0x3C, 0xE0,
  0x0E, 0xF0, 0x08, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x09, 0xC0, 0x38, 0xE0, 0x1C, 0x78, 0x1E, 0x3F, 0x7E,
  0x0F, 0xFE, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x0C, 0x38, 0x1F, 0xCE, 0x0F,
  0xFB, 0x87, 0xC6, 0xE3, 0xC0, 0x78, 0xE0, 0x1E, 0x38, 0x07, 0x0E, 0x01,
  0xC7, 0x80, 0x71, 0xC0, 0x1C, 0x70, 0x07, 0x1C, 0x03, 0xC7, 0x00, 0xE1,
  0xC0, 0x38, 0xF0, 0x0E, 0x1C, 0x07, 0x87, 0x03, 0xE1, 0xFB, 0xB8, 0x3F,
  0xDE, 0x07, 0xE7, 0x00, 0x00, 0x60, 0x01, 0xFE, 0x03, 0xFF, 0x83, 0xC1,
  0xE1, 0xC0, 0x71, 0xC0, 0x38, 0xE0, 0x1C, 0xF0, 0x0E, 0x70, 0x07, 0x3F,
  0xFF, 0x9F, 0xFF, 0xCE, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x1C, 0x70, 0x1C, 0x3E, 0x3E, 0x0F, 0xFE, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xC0, 0x03, 0xFD, 0xC3, 0xFE, 0xE3, 0xE3, 0xF1, 0xC0, 0x79, 0xC0, 0x3C,
  0xE0, 0x1C, 0x70, 0x0E, 0x78, 0x07, 0x38, 0x03, 0x9C, 0x01, 0xCE, 0x01,
  0xE7, 0x00, 0xE3, 0x80, 0x71, 0xC0, 0x78, 0xF0, 0x7C, 0x3F, 0xEE, 0x1F,
  0xE7, 0x01, 0xC7, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0,
  0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07,
  0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0xC0, 0x3B, 0xFC,
  0x3F, 0xFF, 0x1D, 0x87, 0x8F, 0x01, 0xC7, 0x80, 0xE3, 0x80, 0x71, 0xC0,
  0x39, 0xE0, 0x1C, 0xE0, 0x0E, 0x70, 0x07, 0x38, 0x07, 0x9C, 0x03, 0xCE,
  0x01, 0xC7, 0x00, 0xE7, 0x80, 0x73, 0x80, 0x39, 0xC0, 0x1C, 0xE0, 0x1E,
  0x70, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x07, 0xFC,
  0x03, 0xFE, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0xFF,
  0xE0, 0x1F, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0,
  0x1F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x08, 0xE0, 0x1E, 0x1C, 0x07, 0x87, 0x81, 0xE0, 0xE0, 0x38, 0x1C, 0x0F,
  0x03, 0x83, 0xC0, 0x70, 0xF0, 0x0E, 0x3C, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x0E, 0x1C, 0x01, 0xC3, 0xC0, 0x38, 0x38, 0x07, 0x07, 0x81, 0xE0, 0x70,
  0x3C, 0x0F, 0x07, 0x00, 0xE0, 0xE0, 0x1E, 0x1C, 0x01, 0xE0, 0x7F, 0xC0,
  0xFF, 0x81, 0xFF, 0x04, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0xFF, 0x0F, 0xFE, 0x07, 0xFC, 0x00,
  0x81, 0x03, 0xFC, 0xF8, 0x6F, 0xFF, 0x1E, 0x38, 0xF3, 0x87, 0x0E, 0x70,
  0xE1, 0x8E, 0x18, 0x71, 0xC3, 0x0E, 0x38, 0xE1, 0xCE, 0x1C, 0x39, 0xC3,
  0x87, 0x38, 0x70, 0xE7, 0x0C, 0x38, 0xE1, 0x87, 0x1C, 0x30, 0xE7, 0x0E,
  0x1C, 0xE1, 0xC3, 0x9C, 0x38, 0x73, 0x86, 0x1C, 0x70, 0xC3, 0x80, 0x00,
  0x30, 0x0E, 0xFF, 0x0F, 0xFF, 0xC7, 0x61, 0xE3, 0xC0, 0x71, 0xE0, 0x38,
  0xE0, 0x1C, 0x70, 0x0E, 0x78, 0x07, 0x38, 0x03, 0x9C, 0x01, 0xCE, 0x01,
  0xE7, 0x00, 0xF3, 0x80, 0x71, 0xC0, 0x39, 0xE0, 0x1C, 0xE0, 0x0E, 0x70,
  0x07, 0x38, 0x07, 0x9C, 0x03, 0x80, 0x00, 0x70, 0x01, 0xFE, 0x03, 0xFF,
  0x83, 0xE3, 0xE1, 0xC0, 0x71, 0xC0, 0x38, 0xE0, 0x1C, 0xF0, 0x0E, 0x78,
  0x07, 0x38, 0x03, 0x9C, 0x01, 0xCE, 0x00, 0xE7, 0x00, 0xF3, 0x80, 0x71,
  0xC0, 0x38, 0xE0, 0x3C, 0x70, 0x1C, 0x3F, 0x7E, 0x0F, 0xFE, 0x03, 0xFC,
  0x00, 0x00, 0x08, 0x03, 0xBF, 0xC1, 0xFF, 0xF8, 0x76, 0x1E, 0x1E, 0x03,
  0x87, 0x80, 0xE1, 0xC0, 0x38, 0x70, 0x0E, 0x3C, 0x03, 0x8F, 0x00, 0xE3,
  0x80, 0x38, 0xE0, 0x0E, 0x38, 0x07, 0x8E, 0x01, 0xC3, 0x80, 0x71, 0xE0,
  0x3C, 0x7C, 0x0E, 0x1D, 0xDF, 0x87, 0x7F, 0xC1, 0xCF, 0xC0, 0x70, 0x00,
  0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xC0, 0x03, 0xF9, 0xC3, 0xFE, 0xE3, 0xE3, 0x73, 0xC0, 0x79, 0xC0,
  0x3C, 0xE0, 0x1C, 0xF0, 0x0E, 0x78, 0x07, 0x38, 0x03, 0x9C, 0x01, 0xCE,
  0x01, 0xE7, 0x00, 0xE3, 0x80, 0x73, 0xC0, 0x39, 0xE0, 0x3C, 0x70, 0x3E,
  0x3F, 0x77, 0x0F, 0xF7, 0x03, 0xF3, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x07, 0x3F,
  0x81, 0xDF, 0xF0, 0x7C, 0x3E, 0x1E, 0x03, 0x87, 0x00, 0xE3, 0xC0, 0x38,
  0xE0, 0x0E, 0x38, 0x03, 0x8E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x03, 0xFF, 0x03, 0xFF, 0xC3,
  0xC1, 0xE3, 0xC0, 0x79, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x3F, 0x00,
  0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x1F, 0xC0, 0x01, 0xE0, 0x00, 0x70, 0x00,
  0x39, 0xC0, 0x1C, 0xF0, 0x1E, 0x3E, 0x7E, 0x1F, 0xFE, 0x07, 0xFE, 0x00,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3F,
  0xF0, 0x1F, 0xF8, 0x03, 0xF8, 0x00, 0x1C, 0x03, 0x9E, 0x01, 0xCE, 0x00,
  0xE7, 0x00, 0x73, 0x80, 0x79, 0xC0, 0x38, 0xE0, 0x1C, 0xF0, 0x0E, 0x70,
  0x07, 0x38, 0x03, 0x9C, 0x01, 0xCE, 0x01, 0xE7, 0x00, 0xE3, 0x80, 0x71,
  0xC0, 0x78, 0xF0, 0x78, 0x7E, 0xF8, 0x1F, 0xF8, 0x07, 0xF8, 0x00, 0xE0,
  0x07, 0xE0, 0x0F, 0xE0, 0x0E, 0xE0, 0x1E, 0xE0, 0x1C, 0x70, 0x3C, 0x70,
  0x38, 0x70, 0x78, 0x70, 0x70, 0x70, 0x70, 0x70, 0xE0, 0x38, 0xE0, 0x39,
  0xC0, 0x39, 0xC0, 0x3B, 0x80, 0x3B, 0x80, 0x3F, 0x00, 0x1F, 0x00, 0x1E,
  0x00, 0xC1, 0xE1, 0xF0, 0x78, 0x7C, 0x16, 0x1B, 0x0D, 0x8E, 0xC3, 0x63,
  0xB0, 0xD8, 0xCC, 0x66, 0x33, 0x19, 0x9C, 0xC6, 0x66, 0x33, 0x19, 0x8C,
  0xC4, 0xE3, 0x31, 0x30, 0xD8, 0x4C, 0x36, 0x17, 0x0D, 0x85, 0x83, 0xC1,
  0x60, 0xF0, 0x78, 0x3C, 0x1E, 0x0E, 0x07, 0x00, 0x0F, 0x00, 0xF0, 0x70,
  0x1E, 0x07, 0x83, 0xC0, 0x38, 0x38, 0x03, 0xC7, 0x00, 0x1C, 0xF0, 0x01,
  0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0xC0, 0x03, 0x9C, 0x00, 0x71, 0xE0, 0x0F, 0x0E, 0x01, 0xE0, 0xF0,
  0x3C, 0x07, 0x03, 0x80, 0x78, 0xF8, 0x03, 0xC0, 0x1C, 0x03, 0x9E, 0x01,
  0xCE, 0x00, 0xE7, 0x00, 0x73, 0x80, 0x79, 0xC0, 0x38, 0xE0, 0x1C, 0xF0,
  0x0E, 0x70, 0x07, 0x38, 0x03, 0x9C, 0x03, 0xCE, 0x01, 0xC7, 0x00, 0xE3,
  0xC0, 0xF1, 0xF0, 0xF8, 0x7F, 0xDC, 0x1F, 0xCE, 0x01, 0x8F, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F,
  0xE0, 0x00, 0x1F, 0xFF, 0x8F, 0xFF, 0xCF, 0xFF, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x00,
  0xFF, 0xFE, 0x7F, 0xFF, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xC0, 0x07, 0xF0,
  0x03, 0xFC, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0,
  0x00, 0x38, 0x00, 0x1E, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xF0, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0x78, 0x00, 0x07, 0x07,
  0x07, 0x0F, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x1E, 0x1C, 0x1C, 0x1C, 0x1C,
  0x1C, 0x1C, 0x3C, 0x38, 0x38, 0x38, 0x38, 0x38, 0x78, 0x70, 0x70, 0x70,
  0x70, 0x70, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0x07, 0xC0, 0x01, 0xF8, 0x00,
  0x7F, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xFF, 0x00, 0x3F, 0x80, 0x3F, 0xE0,
  0x1E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x01,
  0xCF, 0xE0, 0xE7, 0xFC, 0x39, 0xC7, 0x8E, 0x70, 0xF7, 0xB8, 0x3F, 0xCE,
  0x07, 0xE0,
};

const GFXglyph JetBrainsMono_Italic35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 21, 0, -1 },
  { 1, 8, 26, 21, 7, -26 },
  { 27, 11, 11, 21, 7, -26 },
  { 43, 20, 26, 21, 1, -26 },
  { 108, 18, 35, 21, 2, -30 },
  { 187, 24, 26, 21, -1, -26 },
  { 265, 19, 26, 21, 1, -26 },
  { 327, 5, 11, 21, 10, -26 },
  { 334, 14, 34, 21, 6, -30 },
  { 394, 14, 34, 21, 2, -30 },
  { 454, 18, 18, 21, 2, -21 },
  { 495, 17, 17, 21, 2, -20 },
  { 532, 10, 11, 21, 3, -5 },
  { 546, 12, 3, 21, 5, -13 },
  { 551, 6, 5, 21, 6, -5 },
  { 555, 21, 33, 21, 0, -29 },
  { 642, 18, 26, 21, 2, -26 },
  { 701, 16, 26, 21, 2, -26 },
  { 753, 18, 26, 21, 2, -26 },
  { 812, 18, 26, 21, 2, -26 },
  { 871, 17, 26, 21, 2, -26 },
  { 927, 18, 26, 21, 2, -26 },
  { 986, 17, 26, 21, 2, -26 },
  { 1042, 17, 26, 21, 4, -26 },
  { 1098, 18, 26, 21, 2, -26 },
  { 1157, 17, 26, 21, 3, -26 },
  { 1213, 9, 20, 21, 6, -20 },
  { 1236, 11, 26, 21, 4, -20 },
  { 1272, 17, 19, 21, 3, -21 },
  { 1313, 17, 11, 21, 2, -17 },
  { 1337, 17, 19, 21, 2, -21 },
  { 1378, 14, 26, 21, 5, -26 },
  { 1424, 21, 32, 21, 0, -26 },
  { 1508, 18, 26, 21, 0, -26 },
  { 1567, 18, 26, 21, 2, -26 },
  { 1626, 18, 26, 21, 2, -26 },
  { 1685, 18, 26, 21, 2, -26 },
  { 1744, 19, 26, 21, 2, -26 },
  { 1806, 19, 26, 21, 2, -26 },
  { 1868, 18, 26, 21, 2, -26 },
  { 1927, 18, 26, 21, 2, -26 },
  { 1986, 18, 26, 21, 2, -26 },
  { 2045, 19, 26, 21, 1, -26 },
  { 2107, 20, 26, 21, 2, -26 },
  { 2172, 16, 26, 21, 2, -26 },
  { 2224, 20, 26, 21, 1, -26 },
  { 2289, 18, 26, 21, 2, -26 },
  { 2348, 18, 26, 21, 2, -26 },
  { 2407, 19, 26, 21, 2, -26 },
  { 2469, 18, 32, 21, 2, -26 },
  { 2541, 18, 26, 21, 2, -26 },
  { 2600, 18, 26, 21, 2, -26 },
  { 2659, 18, 26, 21, 4, -26 },
  { 2718, 18, 26, 21, 2, -26 },
  { 2777, 18, 26, 21, 4, -26 },
  { 2836, 21, 26, 21, 2, -26 },
  { 2905, 22, 26, 21, 0, -26 },
  { 2977, 18, 26, 21, 4, -26 },
  { 3036, 19, 26, 21, 1, -26 },
  { 3098, 14, 33, 21, 5, -29 },
  { 3156, 10, 33, 21, 6, -29 },
  { 3198, 14, 33, 21, 3, -29 },
  { 3256, 16, 14, 21, 3, -26 },
  { 3284, 17, 3, 21, 0, 1 },
  { 3291, 7, 4, 21, 9, -27 },
  { 3295, 17, 20, 21, 2, -20 },
  { 3338, 17, 26, 21, 2, -26 },
  { 3394, 17, 20, 21, 2, -20 },
  { 3437, 18, 26, 21, 2, -26 },
  { 3496, 17, 20, 21, 2, -20 },
  { 3539, 24, 32, 21, -2, -26 },
  { 3635, 17, 26, 21, 2, -20 },
  { 3691, 17, 26, 21, 2, -26 },
  { 3747, 17, 27, 21, 1, -27 },
  { 3805, 19, 33, 21, 0, -27 },
  { 3884, 19, 26, 21, 2, -26 },
  { 3946, 15, 26, 21, 3, -26 },
  { 3995, 19, 20, 21, 1, -20 },
  { 4043, 17, 20, 21, 2, -20 },
  { 4086, 17, 20, 21, 2, -20 },
  { 4129, 18, 26, 21, 1, -20 },
  { 4188, 17, 26, 21, 2, -20 },
  { 4244, 18, 20, 21, 2, -20 },
  { 4289, 17, 20, 21, 2, -20 },
  { 4332, 17, 25, 21, 3, -25 },
  { 4386, 17, 19, 21, 2, -19 },
  { 4427, 16, 19, 21, 4, -19 },
  { 4465, 18, 19, 21, 3, -19 },
  { 4508, 20, 19, 21, 0, -19 },
  { 4556, 17, 25, 21, 2, -19 },
  { 4610, 17, 19, 21, 2, -19 },
  { 4651, 18, 33, 21, 3, -29 },
  { 4726, 8, 33, 21, 7, -29 },
  { 4759, 18, 33, 21, 1, -29 },
  { 4834, 18, 7, 21, 2, -16 },
};

const GFXfont JetBrainsMono_Italic35pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Italic35pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Italic35pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _JETBRAINSMONO_ITALIC35PT7B_H_
