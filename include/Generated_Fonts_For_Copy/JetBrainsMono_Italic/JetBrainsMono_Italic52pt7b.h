#ifndef _JETBRAINSMONO_ITALIC52PT7B_H_
#define _JETBRAINSMONO_ITALIC52PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Italic.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Italic52pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x7E, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0x80,
  0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x07, 0xF0, 0xFF, 0x0F, 0xF0, 0xFE, 0x07, 0xC0, 0x7E, 0x0F,
  0xBE, 0x07, 0xDF, 0x03, 0xEF, 0x83, 0xF7, 0xC1, 0xF3, 0xE0, 0xF9, 0xE0,
  0x7D, 0xF0, 0x3E, 0xF8, 0x1F, 0x7C, 0x0F, 0x3E, 0x07, 0x9E, 0x03, 0xCF,
  0x01, 0xE7, 0x81, 0xF3, 0xC0, 0xF1, 0xE0, 0x78, 0x00, 0x03, 0xC0, 0x3C,
  0x00, 0x1E, 0x01, 0xE0, 0x00, 0x78, 0x07, 0x80, 0x01, 0xE0, 0x1E, 0x00,
  0x0F, 0x00, 0xF0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0xF0, 0x0E, 0x00, 0x07,
  0x80, 0x78, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x78, 0x07, 0x00, 0x7F, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xF0, 0x07, 0x80, 0x78, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0xF0, 0x0F, 0x00,
  0x03, 0xC0, 0x3C, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x78, 0x07, 0x80, 0x01,
  0xE0, 0x1E, 0x00, 0x07, 0x00, 0x70, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0xF0,
  0x0F, 0x00, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0xF0, 0x00, 0x3C, 0x03, 0xC0,
  0x00, 0xE0, 0x1E, 0x00, 0x07, 0x80, 0x78, 0x00, 0x1E, 0x01, 0xE0, 0x00,
  0x70, 0x0F, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x78,
  0x07, 0x80, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0x9C,
  0x7E, 0x03, 0xF1, 0xC3, 0xE0, 0x3E, 0x1C, 0x3E, 0x07, 0xC1, 0xC1, 0xE0,
  0x7C, 0x1C, 0x1E, 0x07, 0xC1, 0xC3, 0xE0, 0x7C, 0x3C, 0x00, 0x07, 0xC3,
  0x80, 0x00, 0x7C, 0x38, 0x00, 0x07, 0xE3, 0x80, 0x00, 0x7E, 0x38, 0x00,
  0x03, 0xFB, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0xF3, 0xF0, 0x00, 0x0E, 0x1F, 0x80, 0x00, 0xE0, 0xF8, 0x00,
  0x0E, 0x0F, 0x80, 0x00, 0xE0, 0xF8, 0x00, 0x0E, 0x0F, 0x87, 0xC1, 0xE0,
  0xF8, 0x7C, 0x1C, 0x0F, 0x07, 0xC1, 0xC1, 0xF0, 0x7C, 0x1C, 0x1F, 0x07,
  0xE1, 0xC3, 0xE0, 0x3F, 0x1C, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0xF0, 0x0F, 0xFE, 0x00, 0x1E, 0x01, 0xFF, 0xE0, 0x03, 0xC0, 0x1F,
  0x3F, 0x00, 0x78, 0x03, 0xC0, 0xF0, 0x07, 0x80, 0x3C, 0x0F, 0x00, 0xF0,
  0x03, 0x80, 0xF0, 0x1E, 0x00, 0x78, 0x0F, 0x03, 0xC0, 0x07, 0x80, 0xF0,
  0x78, 0x00, 0x78, 0x0F, 0x0F, 0x00, 0x07, 0x81, 0xE1, 0xE0, 0x00, 0x78,
  0x1E, 0x1E, 0x00, 0x07, 0x81, 0xE3, 0xC0, 0x00, 0x7E, 0x7C, 0x78, 0x00,
  0x07, 0xFF, 0x8F, 0x00, 0x00, 0x3F, 0xF1, 0xE0, 0x00, 0x00, 0xFE, 0x3C,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x3F, 0x80,
  0x00, 0x07, 0x8F, 0xFC, 0x00, 0x00, 0x79, 0xFF, 0xE0, 0x00, 0x0F, 0x3F,
  0x3F, 0x00, 0x01, 0xE3, 0xC0, 0xF0, 0x00, 0x3C, 0x38, 0x0F, 0x00, 0x07,
  0x87, 0x80, 0xF0, 0x00, 0xF0, 0x78, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0xE0,
  0x01, 0xE0, 0x78, 0x1E, 0x00, 0x3C, 0x07, 0x81, 0xE0, 0x07, 0x80, 0x70,
  0x1E, 0x00, 0xF0, 0x07, 0x83, 0xE0, 0x1E, 0x00, 0x7C, 0x7C, 0x01, 0xE0,
  0x07, 0xFF, 0x80, 0x3C, 0x00, 0x3F, 0xF0, 0x0F, 0x80, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0xF8, 0x07, 0xE0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x01,
  0xF1, 0xF1, 0xF0, 0x1F, 0x1F, 0x07, 0xC1, 0xF0, 0xF8, 0x3E, 0x0F, 0x87,
  0xC0, 0xF8, 0xF8, 0x3C, 0x07, 0xEF, 0x81, 0xE0, 0x1F, 0x78, 0x1F, 0x00,
  0xFF, 0xC0, 0xF8, 0x03, 0xFC, 0x07, 0xC0, 0x0F, 0xC0, 0x3E, 0x00, 0x7C,
  0x01, 0xE0, 0x03, 0xF0, 0x0F, 0x80, 0x3F, 0x80, 0x7C, 0x03, 0xFE, 0x03,
  0xF0, 0x3F, 0xF8, 0x1F, 0xFF, 0xE7, 0xC0, 0x7F, 0xFE, 0x1F, 0x03, 0xFF,
  0xE0, 0xF8, 0x07, 0xFC, 0x03, 0xE0, 0x02, 0x00, 0x00, 0x00, 0x7E, 0xF9,
  0xF3, 0xE7, 0xCF, 0xBF, 0x7C, 0xF9, 0xF3, 0xE7, 0x8F, 0x1E, 0x3C, 0x78,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x70, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00,
  0x1F, 0xC0, 0x00, 0xF8, 0x00, 0x07, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x70, 0x0F, 0x00, 0xEF, 0xC1, 0xE0, 0xFF, 0xFE, 0x38, 0x7F,
  0xFF, 0xE7, 0x3F, 0xF7, 0xFF, 0xDF, 0xF8, 0x1F, 0xFF, 0xFC, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1E, 0xF0, 0x00,
  0x07, 0x9F, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x87,
  0xE0, 0x07, 0xE0, 0x7C, 0x01, 0xF8, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03,
  0x80, 0x1E, 0x00, 0x20, 0x01, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x07, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xE0, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x01, 0xFC, 0x07, 0xE0, 0x3F, 0x00,
  0xFC, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x7C, 0x01,
  0xF0, 0x07, 0x80, 0x3E, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xE7, 0xFF, 0xFB,
  0xFF, 0xFE, 0x1F, 0x0F, 0xE7, 0xF9, 0xFE, 0x7F, 0xBF, 0xE7, 0xF1, 0xF8,
  0x08, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xC0, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0x1F, 0x83, 0xF0, 0x01, 0xF0,
  0x7C, 0x00, 0x3E, 0x0F, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x78, 0x7C, 0x00,
  0x0F, 0x0F, 0x80, 0x03, 0xE1, 0xE0, 0x00, 0x7C, 0x3C, 0x00, 0x0F, 0x87,
  0x80, 0x01, 0xE1, 0xF0, 0x00, 0x3C, 0x3E, 0x1E, 0x07, 0x87, 0xC7, 0xE1,
  0xF0, 0xF0, 0xFC, 0x3E, 0x1E, 0x1F, 0x87, 0xC3, 0xC1, 0xF0, 0xF8, 0xF8,
  0x3C, 0x1E, 0x1F, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x1F,
  0x0F, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x0F, 0x80,
  0x01, 0xE1, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x87, 0xE0, 0x03, 0xE0,
  0x7C, 0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0xFE, 0xF8, 0x01, 0xFC, 0xF8, 0x07, 0xF0, 0xF0, 0x07, 0xE0, 0xF0,
  0x07, 0x81, 0xF0, 0x07, 0x01, 0xF0, 0x04, 0x01, 0xF0, 0x08, 0x01, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF,
  0xE0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0x80, 0xFC, 0x07,
  0xC0, 0x0F, 0xC1, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x03,
  0xE1, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x87, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x3C, 0x1F, 0x00, 0x0F, 0x83,
  0xE0, 0x01, 0xF0, 0x7E, 0x00, 0x7C, 0x07, 0xE0, 0x3F, 0x00, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x1F, 0x03, 0xF0, 0x0F, 0x81,
  0xF0, 0x07, 0xC1, 0xF0, 0x03, 0xE1, 0xF0, 0x01, 0xF1, 0xF0, 0x00, 0xF1,
  0xF8, 0x00, 0xF8, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x3F, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC3, 0xF8, 0x00,
  0xF3, 0xFF, 0x80, 0x3D, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x07, 0xF8, 0x3F,
  0x81, 0xFC, 0x03, 0xF0, 0x7C, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xC1, 0xE0, 0x01, 0xF0, 0x7C, 0x00,
  0xF8, 0x1F, 0x80, 0x7E, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x84, 0x00, 0x0F, 0xBF, 0xE0, 0x0F,
  0xBF, 0xFC, 0x07, 0xFF, 0xFF, 0x07, 0xF8, 0x7F, 0x87, 0xF0, 0x07, 0xE3,
  0xF0, 0x03, 0xF3, 0xF0, 0x00, 0xF9, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x1E,
  0xF8, 0x00, 0x0F, 0x7C, 0x00, 0x07, 0xBE, 0x00, 0x03, 0xDF, 0x00, 0x03,
  0xEF, 0x80, 0x01, 0xF7, 0xC0, 0x00, 0xF3, 0xE0, 0x00, 0xF9, 0xF0, 0x00,
  0xF8, 0x7C, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x0F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x80, 0x00, 0x3F,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE,
  0x7C, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0xC7, 0xC0, 0x01, 0xF1, 0xE0, 0x00,
  0xF8, 0x78, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF,
  0xE0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0xFC, 0x07, 0xE0, 0x7E,
  0x00, 0xFC, 0x1F, 0x00, 0x1F, 0x07, 0x80, 0x07, 0xC3, 0xE0, 0x01, 0xF0,
  0xF8, 0x00, 0x78, 0x3E, 0x00, 0x1E, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x07,
  0xC0, 0x7C, 0x01, 0xF0, 0x1F, 0x81, 0xF8, 0x03, 0xF0, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0xFE, 0xFE, 0x00, 0xFC, 0x1F, 0xC0, 0x7E, 0x01, 0xF0, 0x3E, 0x00, 0x3E,
  0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0x78, 0x78, 0x00,
  0x1E, 0x3E, 0x00, 0x07, 0x8F, 0x80, 0x03, 0xE3, 0xE0, 0x00, 0xF8, 0xF8,
  0x00, 0x7C, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x1F, 0x81, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xC0, 0xFC, 0x07, 0xF0, 0xF8, 0x01, 0xF8, 0xF8, 0x00, 0x7C, 0x7C,
  0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xDE, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0xF7, 0xC0, 0x00, 0xFB, 0xE0, 0x00, 0x7D,
  0xF0, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0x3E, 0x00, 0x3F, 0x1F, 0x80, 0x3F,
  0x0F, 0xF0, 0xFF, 0x83, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x3F, 0xE7,
  0xC0, 0x01, 0x87, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x3F, 0x83, 0xFE, 0x1F, 0xF0, 0xFF, 0x07, 0xF8, 0x1F, 0x80,
  0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x3F, 0xE0, 0xFE, 0x07, 0xE0, 0x04,
  0x00, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x07, 0xF8, 0x03, 0xF8, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00,
  0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xF8, 0x08, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xFC, 0x07,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0xFE, 0x01, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF,
  0xC0, 0x07, 0xF0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x78, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F,
  0x83, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0x3C, 0x01, 0xF0,
  0x00, 0x3E, 0x03, 0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x1E, 0x0F, 0x00,
  0x00, 0x1E, 0x0F, 0x00, 0x3F, 0x1E, 0x0F, 0x00, 0xFF, 0x9E, 0x0F, 0x01,
  0xFF, 0xDC, 0x1F, 0x03, 0xF0, 0xFC, 0x1E, 0x03, 0xC0, 0x7C, 0x1E, 0x07,
  0xC0, 0x7C, 0x1E, 0x07, 0x80, 0x7C, 0x1E, 0x07, 0x80, 0x7C, 0x1E, 0x07,
  0x80, 0x78, 0x3E, 0x07, 0x80, 0x78, 0x3E, 0x0F, 0x80, 0x78, 0x3C, 0x0F,
  0x00, 0x78, 0x3C, 0x0F, 0x00, 0x78, 0x3C, 0x0F, 0x00, 0xF8, 0x3C, 0x0F,
  0x00, 0xF8, 0x3C, 0x0F, 0x00, 0xF0, 0x7C, 0x0F, 0x00, 0xF0, 0x78, 0x0F,
  0x01, 0xF0, 0x78, 0x0F, 0xC7, 0xF0, 0x78, 0x0F, 0xFE, 0xF0, 0x78, 0x07,
  0xFC, 0xF0, 0x78, 0x03, 0xF8, 0xE0, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xF7, 0x80, 0x00, 0x7D, 0xE0, 0x00, 0x1F, 0x78, 0x00, 0x07, 0x9E, 0x00,
  0x03, 0xE7, 0x80, 0x00, 0xF1, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x1F,
  0x00, 0x07, 0x83, 0xC0, 0x03, 0xE0, 0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x7C,
  0x0F, 0x00, 0x1F, 0x03, 0xC0, 0x0F, 0x80, 0xF0, 0x03, 0xE0, 0x3C, 0x00,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x3E,
  0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFE, 0x0F, 0x80, 0x07, 0x83, 0xE0, 0x01, 0xE1, 0xF0, 0x00, 0x7C, 0x7C,
  0x00, 0x1F, 0x1F, 0x00, 0x07, 0xCF, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0x7D,
  0xF0, 0x00, 0x0F, 0x7C, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xF0, 0x07, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0,
  0x78, 0x07, 0xF8, 0x0F, 0x00, 0x1F, 0x81, 0xE0, 0x01, 0xF0, 0x7C, 0x00,
  0x3E, 0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x3C, 0x00, 0x1F, 0x07,
  0x80, 0x03, 0xC0, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x07,
  0xC0, 0xF8, 0x03, 0xF0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x03, 0xE0, 0x1F, 0xE0, 0x7C, 0x00, 0xFC,
  0x0F, 0x80, 0x0F, 0xC1, 0xE0, 0x00, 0xF8, 0x3C, 0x00, 0x1F, 0x07, 0x80,
  0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF0,
  0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x83, 0xC0, 0x03, 0xF0, 0xF8, 0x00,
  0xFC, 0x1F, 0x00, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x1F, 0x81, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x0F, 0x80,
  0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0xF0, 0x00, 0x7C,
  0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x03, 0xE0, 0x7E, 0x00, 0xFC, 0x0F, 0xE0,
  0x3F, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x3C, 0x03, 0xFC,
  0x07, 0x80, 0x1F, 0x81, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x07, 0xC0,
  0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x83, 0xC0, 0x01, 0xF0,
  0x78, 0x00, 0x3C, 0x1F, 0x00, 0x07, 0x83, 0xE0, 0x01, 0xF0, 0x7C, 0x00,
  0x3E, 0x0F, 0x80, 0x07, 0xC1, 0xE0, 0x00, 0xF8, 0x3C, 0x00, 0x1E, 0x0F,
  0x80, 0x03, 0xC1, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x03,
  0xE0, 0xF8, 0x00, 0x7C, 0x1E, 0x00, 0x0F, 0x07, 0xC0, 0x01, 0xE0, 0xF8,
  0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x3C,
  0x0F, 0x00, 0x0F, 0x81, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0xFC, 0x0F, 0x80,
  0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xE0, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF,
  0xC0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x1F, 0x81, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x07,
  0xC1, 0xF0, 0x00, 0xF8, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x07,
  0xFF, 0xC3, 0xE0, 0xFF, 0xF0, 0x7C, 0x1F, 0xFE, 0x0F, 0x03, 0xFF, 0xC1,
  0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE1, 0xF0, 0x00,
  0x7C, 0x3E, 0x00, 0x0F, 0x07, 0xC0, 0x03, 0xE0, 0xF0, 0x00, 0x7C, 0x1F,
  0x00, 0x0F, 0x83, 0xE0, 0x03, 0xE0, 0x7E, 0x00, 0xFC, 0x0F, 0xE0, 0x3F,
  0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x00,
  0x7C, 0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x3C, 0x0F,
  0x00, 0x07, 0x81, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x07,
  0xC1, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xC0, 0xF0,
  0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x7C,
  0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC1,
  0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x1E, 0x07, 0x80, 0x07, 0xC1, 0xF0, 0x00,
  0xF8, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x78, 0x1E,
  0x00, 0x0F, 0x03, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x0F,
  0x83, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x81, 0xE0,
  0x01, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1E, 0x00, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xF0, 0x78, 0x00, 0x1F,
  0x07, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0x7C,
  0x00, 0x7C, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x03, 0xE0, 0x3E, 0x00, 0x1F, 0x80,
  0xF8, 0x00, 0x7C, 0x03, 0xE0, 0x03, 0xE0, 0x0F, 0x00, 0x1F, 0x80, 0x7C,
  0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x1F, 0x00,
  0x7C, 0x00, 0x7C, 0x03, 0xE0, 0x01, 0xE0, 0x1F, 0x80, 0x07, 0x80, 0x7C,
  0x00, 0x3E, 0x03, 0xE0, 0x00, 0xF8, 0x1F, 0x80, 0x03, 0xE0, 0x7C, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF0,
  0x3E, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0xF8, 0x07,
  0xC0, 0x03, 0xE0, 0x0F, 0x80, 0x0F, 0x80, 0x3E, 0x00, 0x3E, 0x00, 0xFC,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0xC0, 0x0F, 0x00, 0x1F, 0x80,
  0x7C, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0xF8, 0x07, 0xC0, 0x03, 0xF0, 0x1F,
  0x00, 0x07, 0xC0, 0x78, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x03,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xF0, 0x01, 0xF8,
  0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x00, 0xFE, 0x0E, 0xE0, 0x0F, 0xE0, 0x77,
  0x00, 0x7F, 0x03, 0xBC, 0x07, 0xB8, 0x1D, 0xE0, 0x3F, 0xC1, 0xEF, 0x03,
  0xDE, 0x0F, 0x78, 0x1E, 0xF0, 0x79, 0xC1, 0xE7, 0x03, 0xCE, 0x0F, 0x78,
  0x1E, 0x78, 0xF3, 0xC0, 0xF3, 0xC7, 0x9E, 0x07, 0x9E, 0x78, 0xF0, 0x7C,
  0xF3, 0xC7, 0x83, 0xC3, 0x9C, 0x7C, 0x1E, 0x1D, 0xE3, 0xC0, 0xF0, 0xEE,
  0x1E, 0x07, 0x87, 0xF0, 0xF0, 0x3C, 0x3F, 0x0F, 0x83, 0xE1, 0xF8, 0x7C,
  0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0xF0, 0x3C,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x00,
  0x1F, 0x07, 0xC0, 0x00, 0xF0, 0x3E, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x3C,
  0x0F, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x3E,
  0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xE0, 0x78, 0x00,
  0x1F, 0x00, 0x03, 0xF8, 0x00, 0xF0, 0x3F, 0x80, 0x1F, 0x03, 0xF8, 0x01,
  0xF0, 0x3F, 0x80, 0x1F, 0x03, 0xFC, 0x01, 0xF0, 0x3F, 0xC0, 0x1E, 0x07,
  0xFC, 0x01, 0xE0, 0x7B, 0xC0, 0x1E, 0x07, 0xBC, 0x03, 0xE0, 0x7B, 0xE0,
  0x3E, 0x07, 0x9E, 0x03, 0xE0, 0x79, 0xE0, 0x3C, 0x0F, 0x9E, 0x03, 0xC0,
  0xF9, 0xE0, 0x3C, 0x0F, 0x9F, 0x07, 0xC0, 0xF0, 0xF0, 0x7C, 0x0F, 0x0F,
  0x07, 0xC0, 0xF0, 0xF0, 0x7C, 0x1F, 0x0F, 0x07, 0x81, 0xF0, 0xF8, 0x78,
  0x1F, 0x07, 0x8F, 0x81, 0xF0, 0x78, 0xF8, 0x1E, 0x07, 0x8F, 0x81, 0xE0,
  0x78, 0xF8, 0x1E, 0x07, 0xCF, 0x03, 0xE0, 0x3C, 0xF0, 0x3E, 0x03, 0xCF,
  0x03, 0xE0, 0x3C, 0xF0, 0x3C, 0x03, 0xDF, 0x03, 0xC0, 0x3F, 0xF0, 0x3C,
  0x01, 0xFE, 0x07, 0xC0, 0x1F, 0xE0, 0x7C, 0x01, 0xFE, 0x07, 0xC0, 0x1F,
  0xE0, 0x78, 0x01, 0xFE, 0x07, 0x80, 0x0F, 0xE0, 0x78, 0x00, 0xFC, 0x0F,
  0x80, 0x0F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFE, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x7C,
  0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x01, 0xF0,
  0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x1F, 0x00, 0x07, 0x87, 0xC0, 0x01,
  0xE1, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x1E, 0x00, 0x0F, 0x87, 0x80,
  0x03, 0xE3, 0xE0, 0x00, 0xF0, 0xF8, 0x00, 0x3C, 0x3E, 0x00, 0x1F, 0x0F,
  0x80, 0x07, 0xC3, 0xC0, 0x01, 0xF0, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x1F,
  0x1F, 0x00, 0x07, 0x87, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x7C, 0x00,
  0x3E, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x07, 0xC1, 0xF0, 0x01, 0xF0, 0x7C,
  0x00, 0xF8, 0x1F, 0xC0, 0x7E, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80,
  0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xC0, 0x3C, 0x00, 0xFF, 0x01, 0xE0, 0x01, 0xF8, 0x1F, 0x00, 0x07, 0xC0,
  0xF8, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC1, 0xF0,
  0x00, 0x3E, 0x0F, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x1F, 0x07, 0xC0, 0x00,
  0xF8, 0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x07, 0xE0,
  0x78, 0x00, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x03,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x1F,
  0x83, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x0F, 0x00, 0x07, 0xC3, 0xE0,
  0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0x7C,
  0x3C, 0x00, 0x0F, 0x87, 0x80, 0x01, 0xE1, 0xF0, 0x00, 0x3C, 0x3E, 0x00,
  0x0F, 0x87, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x1E, 0x00, 0x07, 0xC3,
  0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x1E, 0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x00,
  0xF8, 0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE1, 0xE0, 0x00, 0x7C, 0x7C,
  0x00, 0x0F, 0x0F, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x0F,
  0x87, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x00, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x03, 0xC0, 0x1F,
  0xE0, 0x3C, 0x00, 0x7E, 0x07, 0xC0, 0x03, 0xF0, 0x7C, 0x00, 0x1F, 0x07,
  0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x78, 0x00,
  0x1F, 0x07, 0x80, 0x01, 0xE0, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE0,
  0xF8, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0xC0, 0xF0, 0x0F, 0xF8, 0x0F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00,
  0x1F, 0x03, 0xE0, 0x01, 0xE0, 0x3E, 0x00, 0x1E, 0x01, 0xF0, 0x03, 0xE0,
  0x1F, 0x00, 0x3E, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xFC, 0x03, 0xC0, 0x07, 0xC0, 0x7C,
  0x00, 0x7C, 0x07, 0xC0, 0x07, 0xE0, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x03,
  0xE0, 0x78, 0x00, 0x3F, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x00, 0x40, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xC0, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x03, 0xE0, 0x3E, 0x00, 0x3E,
  0x07, 0xC0, 0x01, 0xE0, 0x7C, 0x00, 0x1E, 0x07, 0xC0, 0x03, 0xE0, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x87, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x07, 0xC0, 0x01, 0xF0,
  0x7C, 0x00, 0x1F, 0x07, 0xE0, 0x03, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x03, 0xE0,
  0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x01, 0xF0, 0x78, 0x00,
  0x3E, 0x0F, 0x00, 0x07, 0x83, 0xE0, 0x00, 0xF0, 0x7C, 0x00, 0x3E, 0x0F,
  0x80, 0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x3C, 0x00, 0x1F, 0x07, 0x80, 0x03,
  0xC1, 0xF0, 0x00, 0x78, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE0, 0xF8,
  0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x83, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x3C,
  0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x0F, 0x80,
  0x07, 0xC1, 0xE0, 0x00, 0xF8, 0x3C, 0x00, 0x1E, 0x0F, 0x80, 0x03, 0xC1,
  0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x00,
  0x78, 0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x0F,
  0xC0, 0x3F, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x08, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xF7, 0x80, 0x00, 0x79, 0xE0, 0x00, 0x3E, 0x78, 0x00, 0x0F,
  0x9F, 0x00, 0x07, 0xC7, 0xC0, 0x01, 0xF1, 0xF0, 0x00, 0xF8, 0x7C, 0x00,
  0x3E, 0x1F, 0x00, 0x0F, 0x07, 0xC0, 0x07, 0xC1, 0xF0, 0x01, 0xF0, 0x3C,
  0x00, 0xF8, 0x0F, 0x00, 0x3E, 0x03, 0xC0, 0x0F, 0x00, 0xF0, 0x07, 0xC0,
  0x3E, 0x01, 0xE0, 0x0F, 0x80, 0xF8, 0x03, 0xE0, 0x3E, 0x00, 0xF8, 0x0F,
  0x00, 0x3E, 0x07, 0xC0, 0x0F, 0x81, 0xE0, 0x01, 0xE0, 0xF8, 0x00, 0x78,
  0x3E, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x87, 0xC0, 0x01, 0xE1, 0xE0, 0x00,
  0x7C, 0xF8, 0x00, 0x1F, 0x3C, 0x00, 0x07, 0xCF, 0x00, 0x01, 0xF7, 0xC0,
  0x00, 0x7D, 0xE0, 0x00, 0x0F, 0x78, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3C, 0x03, 0xE0, 0x3E, 0x78, 0x07, 0xC0, 0x78, 0xF0, 0x1F, 0x80, 0xF1,
  0xE0, 0x3F, 0x03, 0xE3, 0xC0, 0x7E, 0x07, 0x87, 0x81, 0xDC, 0x0F, 0x0F,
  0x03, 0xB8, 0x1E, 0x1E, 0x07, 0x70, 0x7C, 0x3C, 0x0E, 0xE0, 0xF0, 0x78,
  0x39, 0x81, 0xE0, 0xF0, 0x77, 0x03, 0xC1, 0xE0, 0xEE, 0x0F, 0x07, 0xC3,
  0x9C, 0x1E, 0x0F, 0x87, 0x38, 0x3C, 0x1F, 0x0E, 0x70, 0x78, 0x3E, 0x1C,
  0xE1, 0xE0, 0x78, 0x71, 0xC3, 0xC0, 0xF0, 0xE3, 0x87, 0x81, 0xE1, 0xC7,
  0x1F, 0x03, 0xC7, 0x0E, 0x3C, 0x07, 0x8E, 0x1C, 0x78, 0x0F, 0x1C, 0x38,
  0xF0, 0x1E, 0x38, 0x73, 0xC0, 0x3C, 0xE0, 0xE7, 0x80, 0x79, 0xC1, 0xCF,
  0x00, 0xF3, 0x83, 0x9E, 0x01, 0xEE, 0x07, 0x78, 0x03, 0xDC, 0x0E, 0xF0,
  0x07, 0xB8, 0x1D, 0xE0, 0x0F, 0x70, 0x3B, 0xC0, 0x1F, 0xC0, 0x7F, 0x00,
  0x3F, 0x80, 0xDE, 0x00, 0x77, 0x03, 0xBC, 0x00, 0xEE, 0x07, 0x70, 0x01,
  0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x1F, 0xC0, 0x0F, 0xE0, 0x3F, 0x80, 0x1F,
  0x80, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x3E,
  0x01, 0xF0, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0x7C, 0x01, 0xF0, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x7C, 0x03, 0xE0,
  0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x1E, 0x0F, 0x80,
  0x00, 0x1F, 0x1F, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x0F, 0xBE, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x3E, 0xF8, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x7C, 0x7C, 0x00,
  0x00, 0xF8, 0x7C, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x01, 0xF0, 0x3E, 0x00,
  0x03, 0xE0, 0x3E, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x0F, 0xC0, 0x1F, 0x00,
  0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x0F, 0x80, 0x3F, 0x00, 0x0F, 0x80,
  0x3E, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x07, 0xE0,
  0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0x3C, 0x00,
  0x07, 0xC7, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x0F, 0x00, 0x0F, 0x81,
  0xF0, 0x03, 0xE0, 0x3E, 0x00, 0x7C, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x03,
  0xC0, 0x0F, 0x80, 0xF8, 0x00, 0xF0, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x03,
  0xE1, 0xF0, 0x00, 0x3C, 0x7C, 0x00, 0x07, 0xCF, 0x80, 0x00, 0xFB, 0xE0,
  0x00, 0x0F, 0x78, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xFE, 0x01, 0xFF,
  0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F,
  0x00, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x01, 0xFF, 0xF0,
  0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFE, 0x00,
  0x07, 0xBC, 0x00, 0x0F, 0x78, 0x00, 0x3C, 0x70, 0x00, 0x78, 0xF0, 0x01,
  0xE1, 0xE0, 0x07, 0xC1, 0xC0, 0x0F, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78,
  0x0F, 0x01, 0xE0, 0x0F, 0x07, 0xC0, 0x1E, 0x0F, 0x00, 0x3C, 0x3C, 0x00,
  0x78, 0xF8, 0x00, 0x79, 0xE0, 0x00, 0xF7, 0xC0, 0x01, 0xF0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xF8,
  0x3E, 0x1F, 0x07, 0xC1, 0xE0, 0xF8, 0x3E, 0x00, 0x3F, 0x87, 0xC0, 0x3F,
  0xF1, 0xF0, 0x3F, 0xFE, 0x78, 0x1F, 0xFF, 0xDE, 0x07, 0xE0, 0x7F, 0x83,
  0xF0, 0x0F, 0xE1, 0xF8, 0x01, 0xF8, 0x7C, 0x00, 0x7E, 0x1E, 0x00, 0x1F,
  0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x3E, 0x00,
  0x1F, 0x0F, 0x00, 0x07, 0xC3, 0xC0, 0x01, 0xE1, 0xF0, 0x00, 0x78, 0x7C,
  0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xF8,
  0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x07, 0xC1, 0xF0, 0x03,
  0xF0, 0x7E, 0x01, 0xFC, 0x0F, 0xFF, 0xDF, 0x03, 0xFF, 0xF7, 0xC0, 0x7F,
  0xF9, 0xE0, 0x0F, 0xF8, 0x78, 0x00, 0x20, 0x20, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0xFE, 0x00, 0x78, 0xFF, 0xE0, 0x1E, 0x7F, 0xFC,
  0x07, 0xBF, 0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0xFE, 0x00, 0xF8, 0x3F, 0x00,
  0x3E, 0x0F, 0x80, 0x07, 0x83, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0x7C,
  0x00, 0x1E, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xF8,
  0x78, 0x00, 0x3E, 0x1E, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xC3, 0xE0, 0x01,
  0xF0, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC3, 0xE0,
  0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x7F, 0x00, 0x7E, 0x1F, 0xE0, 0x3F, 0x07,
  0xFF, 0xFF, 0x81, 0xF7, 0xFF, 0xC0, 0x79, 0xFF, 0xE0, 0x1E, 0x1F, 0xE0,
  0x08, 0x00, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x7F, 0x07, 0xF0, 0x7E, 0x00, 0xF8, 0x7E,
  0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x1E, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0xCF,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x03, 0xE3, 0xE0, 0x01,
  0xF1, 0xF0, 0x01, 0xF0, 0xFC, 0x01, 0xF8, 0x7F, 0x01, 0xF8, 0x1F, 0xFF,
  0xF8, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x07, 0xF0, 0xF8,
  0x03, 0xFF, 0x1F, 0x01, 0xFF, 0xF3, 0xC0, 0x7F, 0xFF, 0x78, 0x0F, 0xC0,
  0xFF, 0x03, 0xF0, 0x0F, 0xE0, 0xFC, 0x00, 0xFC, 0x1F, 0x00, 0x1F, 0x83,
  0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x01,
  0xF0, 0x7C, 0x00, 0x3E, 0x0F, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0xF8, 0x7C,
  0x00, 0x1E, 0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x1F,
  0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x03, 0xE0,
  0x03, 0xE0, 0x7C, 0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x80, 0xFF, 0xFD, 0xF0,
  0x1F, 0xFF, 0xBE, 0x01, 0xFF, 0xE7, 0x80, 0x1F, 0xF0, 0xF0, 0x00, 0x20,
  0x20, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0xFF, 0xC0, 0x7E, 0x03, 0xF0, 0x7C, 0x00, 0xF8, 0x3C, 0x00, 0x7C,
  0x3E, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x1F, 0x00, 0x07, 0x8F, 0x80, 0x03,
  0xC7, 0xC0, 0x01, 0xE3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFC, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0,
  0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x7E, 0x01, 0xF8, 0x1F, 0xEF, 0xF8, 0x07,
  0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x0F, 0x80, 0xFF, 0xE7, 0xC1, 0xFF, 0xF3, 0xC1,
  0xFF, 0xFD, 0xE0, 0xFC, 0x0F, 0xF0, 0xFC, 0x03, 0xF8, 0xFC, 0x00, 0xFC,
  0x7C, 0x00, 0x7E, 0x3E, 0x00, 0x1E, 0x3E, 0x00, 0x0F, 0x1F, 0x00, 0x0F,
  0x8F, 0x80, 0x07, 0xC7, 0xC0, 0x03, 0xE3, 0xE0, 0x01, 0xF1, 0xE0, 0x00,
  0xF0, 0xF0, 0x00, 0x78, 0xF8, 0x00, 0x3C, 0x7C, 0x00, 0x3E, 0x3E, 0x00,
  0x1F, 0x1F, 0x00, 0x1F, 0x8F, 0x80, 0x0F, 0xC7, 0xE0, 0x0F, 0xC1, 0xF8,
  0x1D, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFE, 0xF8, 0x0F, 0xFE, 0x7C, 0x03,
  0xFC, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0,
  0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0xFE, 0x00, 0x7C, 0xFF,
  0xE0, 0x1E, 0x7F, 0xFC, 0x07, 0xBF, 0xFF, 0x83, 0xFC, 0x0F, 0xE0, 0xFE,
  0x00, 0xF8, 0x3F, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x01, 0xE0,
  0xF0, 0x00, 0x78, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x03,
  0xE1, 0xF0, 0x00, 0xF8, 0x78, 0x00, 0x3E, 0x1E, 0x00, 0x0F, 0x0F, 0x80,
  0x03, 0xC3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x0F,
  0x80, 0x07, 0xC3, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0x7C, 0x00, 0x3E,
  0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x78, 0x00,
  0x3C, 0x3E, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF,
  0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0x80, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0x0F, 0x80, 0x07, 0xE0, 0xF8,
  0x00, 0xFC, 0x0F, 0x00, 0x1F, 0x80, 0xF0, 0x01, 0xF0, 0x1F, 0x00, 0x3E,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x01, 0xF0, 0x1F, 0x80, 0x1E,
  0x03, 0xF0, 0x01, 0xE0, 0x7E, 0x00, 0x3E, 0x0F, 0xC0, 0x03, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x03,
  0xC0, 0xF8, 0x00, 0x7C, 0x0F, 0x80, 0x07, 0xC0, 0x7C, 0x00, 0x7C, 0x07,
  0xC0, 0x07, 0xC0, 0x3E, 0x00, 0x7C, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00,
  0x78, 0x01, 0xF0, 0x0F, 0x80, 0x0F, 0x80, 0xF8, 0x00, 0xF8, 0x0F, 0x80,
  0x07, 0xC0, 0xF8, 0x00, 0x7C, 0x0F, 0x00, 0x03, 0xE0, 0x7F, 0xFC, 0x01,
  0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x07, 0x9F, 0x07, 0xC0, 0xFB, 0xF9,
  0xFE, 0x0F, 0x7F, 0xDF, 0xF0, 0xF6, 0xFF, 0xFF, 0x0F, 0x83, 0xE1, 0xF0,
  0xF0, 0x3C, 0x0F, 0x0F, 0x03, 0xC0, 0xF0, 0xF0, 0x3C, 0x0F, 0x1F, 0x03,
  0x81, 0xF1, 0xF0, 0x78, 0x1F, 0x1E, 0x07, 0x81, 0xE1, 0xE0, 0x78, 0x1E,
  0x1E, 0x07, 0x81, 0xE1, 0xE0, 0x78, 0x1E, 0x3E, 0x07, 0x83, 0xE3, 0xE0,
  0x70, 0x3E, 0x3C, 0x0F, 0x03, 0xC3, 0xC0, 0xF0, 0x3C, 0x3C, 0x0F, 0x03,
  0xC3, 0xC0, 0xF0, 0x3C, 0x7C, 0x0F, 0x07, 0xC7, 0xC0, 0xE0, 0x7C, 0x78,
  0x1E, 0x07, 0xC7, 0x81, 0xE0, 0x78, 0x78, 0x1E, 0x07, 0x87, 0x81, 0xE0,
  0x78, 0x78, 0x1E, 0x07, 0x8F, 0x81, 0xC0, 0xF8, 0xF8, 0x3C, 0x0F, 0x80,
  0x07, 0xC3, 0xF8, 0x01, 0xF3, 0xFF, 0x80, 0x79, 0xFF, 0xF0, 0x1E, 0xFF,
  0xFE, 0x0F, 0xF0, 0x3F, 0x83, 0xF8, 0x03, 0xE0, 0xFC, 0x00, 0xF8, 0x3E,
  0x00, 0x3E, 0x0F, 0x80, 0x07, 0x83, 0xC0, 0x01, 0xE1, 0xF0, 0x00, 0xF8,
  0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xE1, 0xE0, 0x00,
  0xF8, 0x78, 0x00, 0x3C, 0x3E, 0x00, 0x0F, 0x0F, 0x80, 0x07, 0xC3, 0xE0,
  0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x0F, 0x00, 0x07, 0x83,
  0xC0, 0x01, 0xE1, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x0F,
  0x87, 0xC0, 0x03, 0xE1, 0xE0, 0x00, 0xF0, 0xF8, 0x00, 0x3C, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0,
  0x7E, 0x07, 0xF0, 0x7E, 0x01, 0xF8, 0x7E, 0x00, 0x7C, 0x3E, 0x00, 0x3E,
  0x1E, 0x00, 0x0F, 0x1F, 0x00, 0x07, 0x8F, 0x80, 0x03, 0xC7, 0xC0, 0x03,
  0xE3, 0xE0, 0x01, 0xF1, 0xE0, 0x00, 0xF8, 0xF0, 0x00, 0x7C, 0xF8, 0x00,
  0x3E, 0x7C, 0x00, 0x1E, 0x3E, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x8F, 0x80,
  0x07, 0xC7, 0x80, 0x03, 0xE3, 0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0xF8,
  0x01, 0xF0, 0x7E, 0x01, 0xF8, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x03,
  0xFF, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0x00, 0x00, 0x03, 0xE1, 0xFC,
  0x00, 0x7C, 0xFF, 0xE0, 0x0F, 0x3F, 0xFE, 0x01, 0xEF, 0xFF, 0xC0, 0x7F,
  0xC1, 0xFC, 0x0F, 0xE0, 0x0F, 0x81, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x1E,
  0x07, 0xC0, 0x03, 0xC0, 0xF0, 0x00, 0x78, 0x3E, 0x00, 0x0F, 0x07, 0xC0,
  0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x83, 0xC0, 0x01, 0xF0,
  0x78, 0x00, 0x3C, 0x1F, 0x00, 0x07, 0x83, 0xE0, 0x01, 0xF0, 0x7C, 0x00,
  0x3E, 0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x0F,
  0xC0, 0x07, 0xC1, 0xFC, 0x01, 0xF8, 0x3F, 0xC0, 0x7E, 0x07, 0xFF, 0xFF,
  0x80, 0xFB, 0xFF, 0xE0, 0x1E, 0x7F, 0xF8, 0x03, 0xC3, 0xFE, 0x00, 0xF8,
  0x0C, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x87, 0xC0, 0x3F, 0xF1,
  0xE0, 0x3F, 0xFE, 0x78, 0x1F, 0xFF, 0xFE, 0x0F, 0xE0, 0x7F, 0x83, 0xF0,
  0x0F, 0xE1, 0xF8, 0x01, 0xF8, 0x7C, 0x00, 0x7E, 0x1E, 0x00, 0x1F, 0x0F,
  0x80, 0x07, 0xC3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x1F,
  0x0F, 0x00, 0x07, 0xC3, 0xC0, 0x01, 0xE1, 0xF0, 0x00, 0x78, 0x7C, 0x00,
  0x3E, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x78,
  0x00, 0x3C, 0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x07, 0xC1, 0xF0, 0x03, 0xF0,
  0x7E, 0x03, 0xFC, 0x1F, 0xFF, 0xDF, 0x03, 0xFF, 0xF7, 0xC0, 0x7F, 0xF9,
  0xE0, 0x0F, 0xF8, 0x78, 0x00, 0x20, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xC3,
  0xF8, 0x01, 0xE3, 0xFF, 0x80, 0x79, 0xFF, 0xF0, 0x1E, 0xFF, 0xFC, 0x0F,
  0xF0, 0x1F, 0x83, 0xF8, 0x03, 0xE0, 0xFC, 0x00, 0xF8, 0x3E, 0x00, 0x1F,
  0x0F, 0x80, 0x07, 0xC3, 0xC0, 0x01, 0xF1, 0xF0, 0x00, 0x78, 0x7C, 0x00,
  0x3E, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFE, 0x03,
  0xF0, 0x7C, 0x00, 0xFC, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0xF1, 0xF0, 0x00, 0xF8,
  0xFC, 0x00, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC,
  0x00, 0xFF, 0xF8, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFE, 0x00,
  0x0F, 0x80, 0x07, 0xC3, 0xC0, 0x01, 0xF0, 0xF0, 0x00, 0x78, 0x7C, 0x00,
  0x1E, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x78,
  0x00, 0x3E, 0x1E, 0x00, 0x0F, 0x0F, 0x80, 0x03, 0xC3, 0xE0, 0x01, 0xF0,
  0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC3, 0xC0, 0x01,
  0xF0, 0xF0, 0x00, 0x78, 0x7C, 0x00, 0x1E, 0x1F, 0x00, 0x0F, 0x87, 0xC0,
  0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x3C, 0x1F, 0x00, 0x1F, 0x07,
  0xC0, 0x07, 0xC1, 0xF8, 0x03, 0xE0, 0x7F, 0x03, 0xF8, 0x0F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x08,
  0x00, 0x00, 0xF8, 0x00, 0x0F, 0xBC, 0x00, 0x07, 0xDE, 0x00, 0x07, 0xCF,
  0x00, 0x03, 0xE7, 0xC0, 0x01, 0xE3, 0xE0, 0x01, 0xF1, 0xF0, 0x00, 0xF0,
  0x78, 0x00, 0xF8, 0x3C, 0x00, 0x78, 0x1E, 0x00, 0x7C, 0x0F, 0x80, 0x3C,
  0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x1F, 0x00, 0x78, 0x0F,
  0x80, 0x3C, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x87, 0xC0, 0x07, 0xC3,
  0xE0, 0x01, 0xE1, 0xE0, 0x00, 0xF1, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x3C,
  0xF8, 0x00, 0x1F, 0x78, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xF0, 0x1F, 0x00,
  0xFF, 0x01, 0xF0, 0x1E, 0xF0, 0x1F, 0x01, 0xEF, 0x01, 0xF0, 0x1E, 0xF0,
  0x3F, 0x03, 0xCF, 0x03, 0xF0, 0x3C, 0xF0, 0x37, 0x03, 0xCF, 0x07, 0x70,
  0x78, 0xF0, 0x77, 0x07, 0x8F, 0x07, 0x70, 0x78, 0xF0, 0xE7, 0x07, 0x0F,
  0x0E, 0x70, 0xF0, 0xF0, 0xE7, 0x0F, 0x0F, 0x1C, 0x70, 0xE0, 0xF1, 0xC7,
  0x1E, 0x0F, 0x1C, 0x71, 0xE0, 0xF3, 0x87, 0x1C, 0x0F, 0x38, 0x73, 0xC0,
  0xF3, 0x87, 0x3C, 0x0F, 0x70, 0x73, 0x80, 0xF7, 0x07, 0x38, 0x0F, 0x70,
  0x77, 0x80, 0xFE, 0x07, 0x70, 0x0F, 0xE0, 0x77, 0x00, 0xFE, 0x07, 0xF0,
  0x0F, 0xC0, 0x7E, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0x7E, 0x00, 0xF8,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0x80, 0xF8,
  0x00, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0xFC, 0x00, 0xF8, 0x0F,
  0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x7C, 0x00,
  0x03, 0xE7, 0xE0, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3E, 0x7C, 0x00,
  0x03, 0xF3, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x1F,
  0x01, 0xF0, 0x01, 0xF0, 0x0F, 0x80, 0x1F, 0x80, 0x3E, 0x01, 0xF8, 0x01,
  0xF0, 0x0F, 0x80, 0x0F, 0xC0, 0xF8, 0x00, 0x3E, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x1F, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0xC7, 0x80, 0x03, 0xC3, 0xC0,
  0x01, 0xE3, 0xE0, 0x01, 0xF1, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x7C, 0x7C,
  0x00, 0x3E, 0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x1F, 0x00, 0x0F, 0x8F,
  0x80, 0x07, 0xC7, 0xC0, 0x03, 0xE3, 0xE0, 0x01, 0xF1, 0xE0, 0x00, 0xF8,
  0xF0, 0x00, 0x78, 0xF8, 0x00, 0x3C, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x1F,
  0x1F, 0x00, 0x1F, 0x8F, 0xC0, 0x0F, 0xC7, 0xE0, 0x0F, 0xC1, 0xFC, 0x1D,
  0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFE, 0xF8, 0x0F, 0xFE, 0x7C, 0x01, 0xF8,
  0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x1F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0xFF,
  0xC0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x3C,
  0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3C, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x07, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0xF1, 0xFF, 0xC0,
  0x7C, 0xFF, 0xF0, 0x1F, 0x3E, 0x7E, 0x07, 0xDF, 0x0F, 0xC1, 0xE7, 0x81,
  0xF8, 0xF9, 0xE0, 0x3F, 0xFC, 0x78, 0x07, 0xFF, 0x3E, 0x01, 0xFF, 0x8F,
  0x80, 0x1F, 0x80,
};

const GFXglyph JetBrainsMono_Italic52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 31, 0, -1 },
  { 1, 12, 38, 31, 10, -38 },
  { 58, 17, 16, 31, 10, -38 },
  { 92, 30, 38, 31, 1, -38 },
  { 235, 28, 52, 31, 2, -45 },
  { 417, 36, 38, 31, -2, -38 },
  { 588, 29, 39, 31, 1, -38 },
  { 730, 7, 16, 31, 15, -38 },
  { 744, 22, 51, 31, 8, -44 },
  { 885, 21, 51, 31, 3, -44 },
  { 1019, 27, 27, 31, 3, -32 },
  { 1111, 26, 24, 31, 3, -29 },
  { 1189, 14, 16, 31, 5, -8 },
  { 1217, 18, 4, 31, 7, -19 },
  { 1226, 10, 9, 31, 9, -8 },
  { 1238, 31, 49, 31, 1, -43 },
  { 1428, 27, 39, 31, 3, -38 },
  { 1560, 24, 38, 31, 2, -38 },
  { 1674, 27, 38, 31, 2, -38 },
  { 1803, 27, 39, 31, 2, -38 },
  { 1935, 25, 38, 31, 3, -38 },
  { 2054, 26, 39, 31, 3, -38 },
  { 2181, 25, 39, 31, 3, -38 },
  { 2303, 26, 38, 31, 6, -38 },
  { 2427, 26, 40, 31, 3, -39 },
  { 2557, 25, 38, 31, 5, -38 },
  { 2676, 13, 30, 31, 9, -29 },
  { 2725, 17, 37, 31, 5, -29 },
  { 2804, 25, 28, 31, 4, -31 },
  { 2892, 25, 16, 31, 4, -25 },
  { 2942, 25, 28, 31, 3, -31 },
  { 3030, 21, 38, 31, 7, -38 },
  { 3130, 32, 47, 31, 0, -38 },
  { 3318, 26, 38, 31, 0, -38 },
  { 3442, 27, 38, 31, 3, -38 },
  { 3571, 27, 39, 31, 3, -38 },
  { 3703, 27, 38, 31, 2, -38 },
  { 3832, 28, 38, 31, 3, -38 },
  { 3965, 28, 38, 31, 3, -38 },
  { 4098, 27, 39, 31, 3, -38 },
  { 4230, 27, 38, 31, 3, -38 },
  { 4359, 26, 38, 31, 3, -38 },
  { 4483, 28, 39, 31, 1, -38 },
  { 4620, 30, 38, 31, 2, -38 },
  { 4763, 22, 38, 31, 4, -38 },
  { 4868, 29, 38, 31, 2, -38 },
  { 5006, 28, 38, 31, 2, -38 },
  { 5139, 26, 39, 31, 3, -38 },
  { 5266, 29, 38, 31, 2, -38 },
  { 5404, 27, 47, 31, 3, -38 },
  { 5563, 28, 38, 31, 2, -38 },
  { 5696, 28, 40, 31, 2, -39 },
  { 5836, 26, 38, 31, 6, -38 },
  { 5960, 27, 39, 31, 3, -38 },
  { 6092, 26, 38, 31, 6, -38 },
  { 6216, 31, 38, 31, 3, -38 },
  { 6364, 32, 38, 31, 0, -38 },
  { 6516, 27, 38, 31, 6, -38 },
  { 6645, 28, 38, 31, 2, -38 },
  { 6778, 21, 49, 31, 7, -43 },
  { 6907, 16, 49, 31, 8, -43 },
  { 7005, 20, 49, 31, 5, -43 },
  { 7128, 23, 20, 31, 5, -38 },
  { 7186, 26, 4, 31, 0, 1 },
  { 7199, 9, 7, 31, 14, -41 },
  { 7207, 26, 30, 31, 3, -29 },
  { 7305, 26, 39, 31, 2, -38 },
  { 7432, 25, 30, 31, 3, -29 },
  { 7526, 27, 39, 31, 3, -38 },
  { 7658, 25, 30, 31, 3, -29 },
  { 7752, 35, 47, 31, -2, -38 },
  { 7958, 25, 38, 31, 4, -29 },
  { 8077, 26, 38, 31, 2, -38 },
  { 8201, 25, 40, 31, 2, -40 },
  { 8326, 27, 49, 31, 1, -40 },
  { 8492, 28, 38, 31, 3, -38 },
  { 8625, 22, 38, 31, 5, -38 },
  { 8730, 28, 29, 31, 1, -29 },
  { 8832, 26, 29, 31, 2, -29 },
  { 8927, 25, 30, 31, 3, -29 },
  { 9021, 27, 38, 31, 1, -29 },
  { 9150, 26, 38, 31, 3, -29 },
  { 9274, 26, 29, 31, 3, -29 },
  { 9369, 25, 30, 31, 3, -29 },
  { 9463, 25, 36, 31, 4, -36 },
  { 9576, 26, 30, 31, 3, -29 },
  { 9674, 25, 29, 31, 5, -29 },
  { 9765, 28, 29, 31, 4, -29 },
  { 9867, 29, 29, 31, 1, -29 },
  { 9973, 25, 38, 31, 4, -29 },
  { 10092, 26, 29, 31, 2, -29 },
  { 10187, 26, 49, 31, 5, -43 },
  { 10347, 12, 49, 31, 10, -43 },
  { 10421, 27, 49, 31, 1, -43 },
  { 10587, 26, 11, 31, 3, -24 },
};

const GFXfont JetBrainsMono_Italic52pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Italic52pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Italic52pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _JETBRAINSMONO_ITALIC52PT7B_H_
