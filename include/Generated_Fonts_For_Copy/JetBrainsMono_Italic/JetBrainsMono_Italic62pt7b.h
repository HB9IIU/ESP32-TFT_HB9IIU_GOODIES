#ifndef _JETBRAINSMONO_ITALIC62PT7B_H_
#define _JETBRAINSMONO_ITALIC62PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Italic.ttf
// Size: 62pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Italic62pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78,
  0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x1F, 0xE0, 0xFF,
  0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xC0, 0x7E, 0x00, 0x3F, 0x03, 0xF7, 0xF0,
  0x3F, 0x7E, 0x03, 0xF7, 0xE0, 0x3F, 0x7E, 0x03, 0xF7, 0xE0, 0x7E, 0x7E,
  0x07, 0xE7, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xCF,
  0xC0, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x0F, 0xCF, 0x80, 0xF8,
  0xF8, 0x0F, 0x8F, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x07, 0x80,
  0x00, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x03, 0xE0, 0x00, 0x07, 0x80,
  0x1E, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x3E,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0x00, 0x7C, 0x00,
  0x00, 0xF0, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x1E, 0x00, 0x00, 0x7C, 0x01,
  0xF0, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x78, 0x00, 0x01,
  0xF0, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x01, 0xE0,
  0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x03, 0xE0,
  0x07, 0x80, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x0F,
  0x00, 0x3C, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x1F, 0x00,
  0x00, 0x3C, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x1E, 0x00,
  0x7C, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00,
  0x78, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xF9, 0xCF, 0xF0, 0x07, 0xF0, 0xE1, 0xF8,
  0x03, 0xF0, 0xF0, 0xFE, 0x03, 0xF0, 0x78, 0x3F, 0x01, 0xF8, 0x3C, 0x1F,
  0x80, 0xF8, 0x1E, 0x0F, 0xC0, 0xFC, 0x0F, 0x07, 0xE0, 0x7E, 0x07, 0x00,
  0x00, 0x3F, 0x07, 0x80, 0x00, 0x1F, 0x83, 0xC0, 0x00, 0x0F, 0xC1, 0xE0,
  0x00, 0x07, 0xF0, 0xF0, 0x00, 0x01, 0xFC, 0x78, 0x00, 0x00, 0xFF, 0x38,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x79, 0xFE, 0x00, 0x00, 0x3C, 0x3F, 0x80, 0x00, 0x1E, 0x1F, 0xC0, 0x00,
  0x0F, 0x07, 0xE0, 0x00, 0x07, 0x03, 0xF0, 0x00, 0x07, 0x81, 0xF8, 0x00,
  0x03, 0xC0, 0xFC, 0x1F, 0x01, 0xE0, 0x7E, 0x1F, 0x80, 0xF0, 0x3F, 0x0F,
  0xC0, 0x78, 0x1F, 0x07, 0xE0, 0x38, 0x1F, 0x81, 0xF8, 0x3C, 0x1F, 0xC0,
  0xFE, 0x1E, 0x1F, 0xC0, 0x7F, 0x8F, 0x1F, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20,
  0x03, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x1E, 0x00, 0x3F,
  0xFF, 0x00, 0x07, 0x80, 0x0F, 0xFF, 0xE0, 0x01, 0xF0, 0x03, 0xF0, 0x7C,
  0x00, 0x7C, 0x00, 0x7C, 0x07, 0xC0, 0x1F, 0x00, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x00, 0x7C, 0x03, 0xC0, 0x3C, 0x00,
  0x0F, 0x00, 0x78, 0x0F, 0x80, 0x01, 0xE0, 0x1F, 0x03, 0xE0, 0x00, 0x3C,
  0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x80, 0x7C, 0x3E, 0x00, 0x01, 0xF0, 0x0F,
  0x07, 0x80, 0x00, 0x3E, 0x03, 0xE1, 0xE0, 0x00, 0x03, 0xE0, 0xFC, 0x7C,
  0x00, 0x00, 0x7F, 0xFF, 0x1F, 0x00, 0x00, 0x0F, 0xFF, 0xC7, 0xC0, 0x00,
  0x00, 0xFF, 0xF1, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0xFF, 0x00, 0x00, 0x00, 0x78, 0x7F, 0xF8,
  0x00, 0x00, 0x1F, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xC7, 0xFF, 0xF0, 0x00,
  0x01, 0xF1, 0xF8, 0x3E, 0x00, 0x00, 0x7C, 0x3E, 0x03, 0xE0, 0x00, 0x1F,
  0x0F, 0x80, 0x7C, 0x00, 0x03, 0xC1, 0xF0, 0x0F, 0x00, 0x00, 0xF8, 0x3E,
  0x01, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x3C, 0x00, 0x0F, 0x80, 0xF0, 0x0F,
  0x80, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x00,
  0x1E, 0x00, 0xF8, 0x07, 0x80, 0x07, 0x80, 0x1F, 0x01, 0xF0, 0x01, 0xF0,
  0x01, 0xF0, 0x7E, 0x00, 0x7C, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0x00, 0x07,
  0xFF, 0xE0, 0x07, 0xC0, 0x00, 0x7F, 0xF8, 0x01, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x03, 0xE0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xE0,
  0x01, 0xF8, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0x0F,
  0xE7, 0xE0, 0x0F, 0xC3, 0xF0, 0x7E, 0x01, 0xF0, 0x7E, 0x0F, 0xC0, 0x7E,
  0x0F, 0x80, 0xFC, 0x1F, 0x83, 0xF0, 0x1F, 0x87, 0xE0, 0x7E, 0x01, 0xF8,
  0xF8, 0x0F, 0xC0, 0x3F, 0xBF, 0x01, 0xF8, 0x03, 0xFF, 0xC0, 0x3E, 0x00,
  0x3F, 0xF0, 0x07, 0xC0, 0x07, 0xFE, 0x00, 0xF8, 0x00, 0x7F, 0x80, 0x3F,
  0x00, 0x0F, 0xE0, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x3F, 0xC0,
  0x1F, 0x80, 0x0F, 0xF8, 0x03, 0xF0, 0x03, 0xFF, 0x80, 0x7F, 0x01, 0xFF,
  0xF0, 0x0F, 0xFD, 0xFF, 0x3F, 0x00, 0xFF, 0xFF, 0xC7, 0xE0, 0x0F, 0xFF,
  0xF0, 0x7E, 0x01, 0xFF, 0xFC, 0x0F, 0xE0, 0x0F, 0xFE, 0x00, 0xFC, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x1F, 0x9F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC,
  0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x7C,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x0C, 0x00, 0xF8, 0x01, 0x8F, 0x80, 0x78, 0x07, 0xC7, 0xF8, 0x3C,
  0x0F, 0xF7, 0xFE, 0x1E, 0x3F, 0xFF, 0xFF, 0xCE, 0x3F, 0xFD, 0xFF, 0xF7,
  0x7F, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xEF, 0x80, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x03,
  0xF0, 0xFC, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x01,
  0xF8, 0x0F, 0xE0, 0x01, 0xF8, 0x03, 0xF0, 0x01, 0xFC, 0x01, 0xFC, 0x01,
  0xFC, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xF8, 0x07,
  0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F,
  0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC,
  0x00, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x06, 0x03, 0xF8, 0xFF, 0x3F, 0xF7, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFE, 0x7F, 0x8F, 0xE0, 0x30, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xC0, 0x7F,
  0x80, 0xFE, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7E,
  0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x03, 0xF0,
  0xF8, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x1F, 0x8F,
  0x80, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0xF8, 0x7C,
  0x00, 0x03, 0xF1, 0xF8, 0x08, 0x07, 0xE3, 0xF0, 0x7C, 0x0F, 0xC7, 0xE1,
  0xFC, 0x1F, 0x0F, 0x83, 0xF8, 0x3E, 0x1F, 0x07, 0xF0, 0x7C, 0x3E, 0x0F,
  0xE1, 0xF8, 0xFC, 0x1F, 0xC3, 0xF1, 0xF8, 0x1E, 0x07, 0xE3, 0xF0, 0x00,
  0x0F, 0x87, 0xC0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x3E, 0x1F, 0x00, 0x00,
  0x7C, 0x7E, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x07,
  0xC3, 0xE0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x7E,
  0x1F, 0x80, 0x00, 0xF8, 0x3F, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x0F, 0xC0,
  0x7F, 0x00, 0x3F, 0x80, 0xFF, 0x83, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFD, 0xF0, 0x00, 0x3F,
  0xDF, 0x80, 0x07, 0xF8, 0xFC, 0x00, 0x7F, 0x87, 0xE0, 0x03, 0xF0, 0x3F,
  0x00, 0x3F, 0x01, 0xF0, 0x01, 0xE0, 0x0F, 0x80, 0x0E, 0x00, 0xFC, 0x00,
  0x40, 0x07, 0xE0, 0x04, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0x03, 0xFC,
  0x01, 0xFC, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x7E,
  0x07, 0xE0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3F,
  0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF0,
  0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xC0,
  0x7E, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0xE1, 0xFF, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x7C, 0x03,
  0xF0, 0x01, 0xF0, 0x1F, 0xC0, 0x0F, 0xC0, 0xFE, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0xFC, 0x1F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0x87, 0xE0, 0x00,
  0x3E, 0x1F, 0x80, 0x01, 0xF8, 0x7C, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x1F,
  0x87, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F,
  0xCF, 0xFF, 0x00, 0x1F, 0x3F, 0xFF, 0x00, 0x3E, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0x01, 0xFF, 0x83, 0xFE, 0x03, 0xFC, 0x00, 0xFE, 0x07, 0xF0,
  0x01, 0xFC, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x87, 0xE0, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xF8,
  0x3F, 0x80, 0x07, 0xE0, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0xE3, 0xFF, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE3, 0xF8, 0x00, 0x3F, 0x3F, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFD, 0xFF, 0xC0, 0xFF, 0x00, 0x7F, 0x87, 0xF0,
  0x00, 0xFE, 0x1F, 0x80, 0x01, 0xF8, 0xFE, 0x00, 0x07, 0xF3, 0xF0, 0x00,
  0x0F, 0xCF, 0x80, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x03,
  0xF7, 0xC0, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0xFB,
  0xF0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0xFC, 0x7E,
  0x00, 0x03, 0xF1, 0xF8, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0xFE, 0x0F, 0xE0,
  0x0F, 0xF0, 0x3F, 0xF1, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xB0, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFB, 0xF0, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x07, 0xE3, 0xE0,
  0x00, 0x1F, 0x0F, 0x80, 0x00, 0xFC, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF,
  0x03, 0xFE, 0x01, 0xFC, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x7E, 0x03, 0xF0,
  0x00, 0x7E, 0x03, 0xF0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xE0,
  0x00, 0x3E, 0x03, 0xE0, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x7E, 0x03, 0xE0,
  0x00, 0x7C, 0x03, 0xF0, 0x00, 0xFC, 0x03, 0xF0, 0x01, 0xF8, 0x03, 0xF8,
  0x03, 0xF0, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFE, 0x7F, 0xC0, 0x03, 0xF8,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x07, 0xF0, 0x1F, 0x80,
  0x03, 0xF0, 0x3F, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x01, 0xF0, 0x3E, 0x00,
  0x01, 0xF0, 0x7E, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x01, 0xF0, 0x7C, 0x00,
  0x01, 0xF0, 0x7C, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x7E, 0x00,
  0x07, 0xE0, 0x7F, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x1F, 0xC0, 0x3F, 0xF1,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xE0, 0x7F, 0xC0, 0xFE, 0x00, 0x7F,
  0x07, 0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x01, 0xF8, 0xFC, 0x00, 0x07, 0xE3,
  0xE0, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0xF9, 0xF0,
  0x00, 0x03, 0xEF, 0xC0, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x7E, 0xFC, 0x00,
  0x01, 0xFB, 0xF0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x3F, 0x3F, 0x00, 0x00,
  0xFC, 0xFE, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFE,
  0x1F, 0xF0, 0x1F, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFB, 0xF0, 0x01, 0xFF, 0xDF, 0x80, 0x00, 0xF8, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x03, 0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F,
  0xE1, 0xFF, 0xC3, 0xFF, 0x03, 0xFE, 0x03, 0xF8, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x01, 0xFE, 0x07, 0xFC, 0x0F, 0xFC, 0x3F,
  0xF8, 0x7F, 0xF0, 0xFF, 0xC0, 0xFF, 0x81, 0xFE, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x80, 0x01, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xF0,
  0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x80, 0x1F, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F,
  0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0x0F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0xFF, 0xE0, 0x00, 0xFF, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0xFC, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x00,
  0x3E, 0x07, 0xC0, 0x03, 0xF0, 0xF8, 0x1F, 0x00, 0x3F, 0xF3, 0xC0, 0xF8,
  0x01, 0xFF, 0xEF, 0x03, 0xE0, 0x0F, 0xFF, 0xBC, 0x0F, 0x80, 0x7E, 0x07,
  0xF0, 0x3E, 0x01, 0xF0, 0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0x3F, 0x03, 0xE0,
  0x3E, 0x00, 0xFC, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0x0F,
  0x81, 0xF0, 0x1F, 0x00, 0x3E, 0x07, 0xC0, 0x7C, 0x00, 0xF8, 0x1F, 0x01,
  0xF0, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x1F, 0x00, 0x7C,
  0x0F, 0x80, 0xF8, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x0F,
  0x80, 0x1F, 0x03, 0xE0, 0x3E, 0x00, 0x7C, 0x0F, 0x80, 0xF8, 0x03, 0xF0,
  0x3E, 0x03, 0xE0, 0x0F, 0x81, 0xF0, 0x0F, 0xC0, 0x7E, 0x07, 0xC0, 0x3F,
  0xCF, 0xF8, 0x1F, 0x00, 0x7F, 0xFD, 0xE0, 0x7C, 0x01, 0xFF, 0xEF, 0x81,
  0xF0, 0x01, 0xFF, 0x3E, 0x07, 0xC0, 0x00, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x0F, 0xBC, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x7C, 0xF8, 0x00,
  0x00, 0xF9, 0xF0, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x07, 0xC7, 0xC0, 0x00,
  0x1F, 0x8F, 0x80, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x01,
  0xF8, 0x7C, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x1F,
  0x03, 0xF0, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0xFC, 0x07, 0xC0, 0x01, 0xF0,
  0x0F, 0x80, 0x07, 0xE0, 0x1F, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x3F, 0x00,
  0x7C, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03,
  0xF0, 0x07, 0xC0, 0x07, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC,
  0x0F, 0xC0, 0x00, 0xF8, 0x1F, 0x80, 0x01, 0xF0, 0x7E, 0x00, 0x03, 0xE0,
  0xFC, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x1F, 0x8F,
  0xC0, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x7D, 0xF8,
  0x00, 0x00, 0xFB, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xE0, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xF0, 0x01, 0xFE, 0x03,
  0xF0, 0x00, 0xFE, 0x03, 0xE0, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x3F, 0x03,
  0xE0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3E, 0x07,
  0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x7E, 0x07,
  0xC0, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0xF8, 0x0F, 0xC0, 0x03, 0xF8, 0x0F,
  0xC0, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F,
  0x80, 0x0F, 0xF0, 0x1F, 0x80, 0x03, 0xF0, 0x1F, 0x00, 0x01, 0xF8, 0x1F,
  0x00, 0x01, 0xF8, 0x1F, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0xF8, 0x3F,
  0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0xF8, 0x3E,
  0x00, 0x01, 0xF8, 0x3E, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x01, 0xF0, 0x7E,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xE0, 0x7C,
  0x00, 0x7F, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0x80, 0xFE,
  0x00, 0x7F, 0x01, 0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7E, 0x0F, 0xC0,
  0x00, 0xFC, 0x1F, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x03, 0xF0, 0xFC, 0x00,
  0x07, 0xE1, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0x80,
  0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0x7F, 0x80,
  0x7F, 0x80, 0x7F, 0xE7, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xF0,
  0x03, 0xFC, 0x03, 0xF0, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x7E, 0x03, 0xE0,
  0x00, 0x7E, 0x03, 0xE0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x3E, 0x07, 0xE0,
  0x00, 0x3E, 0x07, 0xE0, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x7E, 0x07, 0xC0,
  0x00, 0x7E, 0x07, 0xC0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0xC0,
  0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0xFC, 0x0F, 0x80,
  0x00, 0xFC, 0x0F, 0x80, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0xFC, 0x1F, 0x80,
  0x00, 0xF8, 0x1F, 0x80, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0xF8, 0x1F, 0x80,
  0x01, 0xF8, 0x1F, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x01, 0xF8, 0x3F, 0x00,
  0x01, 0xF0, 0x3F, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x01, 0xF0, 0x3F, 0x00,
  0x03, 0xF0, 0x3E, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x03, 0xE0, 0x7E, 0x00,
  0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0x7E, 0x00,
  0x3F, 0x80, 0x7C, 0x00, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x80, 0x1F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0x80, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0,
  0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xE0,
  0xFF, 0x80, 0xFE, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x00,
  0x7E, 0x0F, 0xC0, 0x00, 0xFC, 0x1F, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x03,
  0xF0, 0xFC, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x81, 0xFF, 0xFC, 0x3F,
  0x03, 0xFF, 0xF8, 0x7E, 0x07, 0xFF, 0xF0, 0xF8, 0x0F, 0xFF, 0xC1, 0xF0,
  0x3F, 0xFF, 0x83, 0xE0, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x7E, 0x1F, 0x80,
  0x00, 0xFC, 0x3F, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x03, 0xF0, 0xF8, 0x00,
  0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00,
  0x7E, 0x0F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x3F, 0x00, 0x0F,
  0xC0, 0x7F, 0x00, 0x3F, 0x80, 0x7F, 0xC3, 0xFE, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0x0F, 0xC0, 0x7C, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x03, 0xE0, 0x3F, 0x00,
  0x01, 0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0xFC, 0x07, 0xE0,
  0x00, 0x7E, 0x03, 0xE0, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0xFC, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x07, 0xE0, 0x3F,
  0x00, 0x03, 0xF0, 0x1F, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0xF8, 0x07,
  0xC0, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x3F, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0x80, 0x01, 0xF8,
  0x0F, 0xC0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x3E,
  0x01, 0xF0, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x0F,
  0xC0, 0x7E, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x01,
  0xF8, 0x0F, 0x80, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x7C, 0x07, 0xE0, 0x00,
  0x7E, 0x03, 0xF0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0x0F, 0xC0, 0x7C, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x03, 0xE0, 0x3F, 0x00,
  0x01, 0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x7E, 0x00,
  0x01, 0xF8, 0x1F, 0x80, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x1F, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xF0, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xF0, 0x1F, 0x00, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x1F, 0xC0,
  0x1F, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x07,
  0xF0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0,
  0x01, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0xFC,
  0x00, 0x07, 0xC0, 0x1F, 0xC0, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x3F, 0x00, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x01,
  0xF0, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x07, 0xF0,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x3F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x7C, 0x00,
  0x07, 0xE0, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0xC0,
  0x03, 0xFC, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0xEF, 0x00, 0x1E, 0xE0, 0x3D,
  0xE0, 0x07, 0xFC, 0x07, 0xBC, 0x00, 0xFF, 0x80, 0xF7, 0x80, 0x3E, 0xF0,
  0x1E, 0xF8, 0x07, 0xDE, 0x03, 0xDF, 0x01, 0xF7, 0xC0, 0x79, 0xE0, 0x3E,
  0xF0, 0x1F, 0x3C, 0x0F, 0x9E, 0x03, 0xE7, 0x81, 0xF3, 0xC0, 0x7C, 0xF0,
  0x3C, 0xF8, 0x0F, 0x9F, 0x0F, 0x9F, 0x01, 0xF3, 0xE1, 0xE3, 0xE0, 0x3E,
  0x3C, 0x7C, 0x78, 0x0F, 0x87, 0x8F, 0x1F, 0x01, 0xF0, 0xF3, 0xE3, 0xE0,
  0x3E, 0x1E, 0x78, 0x7C, 0x07, 0xC3, 0xDF, 0x0F, 0x80, 0xF8, 0x7F, 0xC3,
  0xF0, 0x1F, 0x07, 0xF8, 0x7E, 0x03, 0xE0, 0xFE, 0x0F, 0x80, 0xFC, 0x1F,
  0xC1, 0xF0, 0x1F, 0x83, 0xF0, 0x3E, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x7C,
  0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x7E, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x3E, 0x00, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0xF8, 0x00,
  0x03, 0xE0, 0x3F, 0x00, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0xFC,
  0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x0F, 0xC0,
  0x7C, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x07,
  0xC0, 0x7E, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFE,
  0x00, 0x0F, 0x80, 0xFF, 0x00, 0x0F, 0xC0, 0x7F, 0x80, 0x07, 0xE0, 0x7F,
  0xC0, 0x03, 0xE0, 0x3F, 0xE0, 0x01, 0xF0, 0x1F, 0xF8, 0x00, 0xF8, 0x0F,
  0xFC, 0x00, 0x7C, 0x07, 0xFE, 0x00, 0x7E, 0x03, 0xFF, 0x00, 0x3F, 0x03,
  0xFF, 0x80, 0x1F, 0x81, 0xF3, 0xE0, 0x0F, 0x80, 0xF9, 0xF0, 0x07, 0xC0,
  0x7C, 0xF8, 0x03, 0xE0, 0x3E, 0x7C, 0x03, 0xF0, 0x1F, 0x3E, 0x01, 0xF8,
  0x0F, 0x8F, 0x80, 0xFC, 0x0F, 0xC7, 0xC0, 0x7C, 0x07, 0xE3, 0xE0, 0x3E,
  0x03, 0xE1, 0xF0, 0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x80, 0xF8, 0x3E, 0x0F,
  0xC0, 0x7C, 0x1F, 0x07, 0xE0, 0x7E, 0x0F, 0x83, 0xE0, 0x3F, 0x07, 0xC1,
  0xF0, 0x1F, 0x83, 0xE0, 0xF8, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xC0, 0x7C,
  0x7E, 0x03, 0xE0, 0x3E, 0x3F, 0x03, 0xF0, 0x1F, 0x1F, 0x81, 0xF8, 0x0F,
  0x8F, 0x80, 0xFC, 0x03, 0xE7, 0xC0, 0x7C, 0x01, 0xF3, 0xE0, 0x3E, 0x00,
  0xF9, 0xF0, 0x1F, 0x00, 0x7C, 0xF8, 0x0F, 0x80, 0x3E, 0xFC, 0x0F, 0xC0,
  0x0F, 0xFC, 0x07, 0xE0, 0x07, 0xFE, 0x03, 0xE0, 0x03, 0xFF, 0x01, 0xF0,
  0x01, 0xFF, 0x80, 0xF8, 0x00, 0xFF, 0xC0, 0x7C, 0x00, 0x3F, 0xE0, 0x7E,
  0x00, 0x1F, 0xE0, 0x3F, 0x00, 0x0F, 0xF0, 0x1F, 0x80, 0x07, 0xF8, 0x0F,
  0x80, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80,
  0x3F, 0xE0, 0xFF, 0x00, 0xFE, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0xF8, 0x1F, 0x00, 0x01, 0xF0, 0x7E,
  0x00, 0x03, 0xE0, 0xFC, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x83, 0xE0,
  0x00, 0x3F, 0x07, 0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x00,
  0x01, 0xF8, 0x7E, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x1F, 0x83, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x00,
  0xFC, 0x3F, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07,
  0xC1, 0xF0, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x7E,
  0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xE0,
  0xF8, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x3F, 0x0F,
  0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0x3F,
  0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0xC7, 0xFE, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x16, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0x00, 0x03,
  0xF8, 0x0F, 0xC0, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x1F, 0xC0, 0xF8, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x01, 0xF8, 0x1F,
  0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xC0,
  0xFC, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x03, 0xF8, 0x0F, 0x80, 0x03, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0x80, 0xFE, 0x00, 0x7F, 0x03, 0xF8,
  0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x00,
  0x01, 0xF8, 0x7C, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x07, 0xE3, 0xF0, 0x00,
  0x0F, 0xC7, 0xE0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x00,
  0x7C, 0x3E, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x07,
  0xE3, 0xF0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x3E,
  0x1F, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03, 0xF1,
  0xF8, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x1F, 0x0F,
  0x80, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x01, 0xF8, 0xFC,
  0x00, 0x03, 0xF1, 0xF8, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x0F, 0x87, 0xE0,
  0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x00,
  0x03, 0xF0, 0x7F, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x7F, 0x80, 0xFF, 0xC7,
  0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0x80, 0x07,
  0xF8, 0x0F, 0xC0, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x7E, 0x03, 0xE0, 0x00,
  0x3F, 0x81, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0xF8, 0x1F, 0x00,
  0x00, 0xFC, 0x0F, 0x80, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7F, 0x07, 0xE0,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x7F, 0x80, 0xF8,
  0x00, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07,
  0xC0, 0x3F, 0x00, 0x03, 0xE0, 0x1F, 0x80, 0x01, 0xF0, 0x07, 0xE0, 0x01,
  0xF8, 0x03, 0xF0, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xE0,
  0x0F, 0xC0, 0x03, 0xF0, 0x07, 0xE0, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0xFE,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x0F,
  0xE0, 0x3E, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00,
  0xFE, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xC0, 0x07, 0xF8, 0x1F, 0xF0, 0x07, 0xF0, 0x01, 0xF8, 0x03,
  0xF0, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0xF8, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x1F, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x3F, 0x0F, 0xC0,
  0x00, 0x1F, 0x07, 0xE0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x1F, 0xC0, 0xFE,
  0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x1F, 0xC0, 0x1F, 0xF9, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x3F, 0x03,
  0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x3E, 0x07,
  0xE0, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x7E, 0x07,
  0xC0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7C, 0x0F,
  0xC0, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0xFC, 0x0F,
  0x80, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xF8, 0x1F,
  0x80, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x1F,
  0x00, 0x01, 0xF8, 0x1F, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF0, 0x3F,
  0x00, 0x01, 0xF0, 0x3F, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x03, 0xF0, 0x3E,
  0x00, 0x03, 0xF0, 0x3E, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x7E,
  0x00, 0x03, 0xE0, 0x7E, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x07, 0xE0, 0x7C,
  0x00, 0x07, 0xE0, 0x7C, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x07, 0xC0, 0x7C,
  0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0x80, 0x7E,
  0x00, 0x3F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0xE3, 0xFF, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x01, 0xFB, 0xE0, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x0F, 0xCF, 0xC0,
  0x00, 0x1F, 0x9F, 0x80, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0xFC, 0x7E, 0x00,
  0x01, 0xF0, 0xFC, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x0F, 0xC1, 0xF0, 0x00,
  0x3F, 0x03, 0xE0, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0xF8, 0x0F, 0x80, 0x03,
  0xF0, 0x1F, 0x80, 0x07, 0xC0, 0x3F, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x3F,
  0x00, 0xFC, 0x00, 0x7C, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x03, 0xE0, 0x0F, 0xC0, 0x07, 0xC0, 0x1F, 0x00, 0x0F, 0x80, 0x3E, 0x00,
  0x1F, 0x00, 0xFC, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00,
  0xFC, 0x0F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07,
  0xE0, 0xF8, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x1F,
  0x1F, 0x80, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0xF9,
  0xF8, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF3, 0xE0, 0x0F, 0xC0, 0x1F, 0x3E,
  0x01, 0xFC, 0x03, 0xE3, 0xE0, 0x1F, 0xC0, 0x3E, 0x3E, 0x01, 0xFC, 0x03,
  0xE3, 0xE0, 0x1F, 0xC0, 0x7E, 0x3E, 0x03, 0xFC, 0x07, 0xC3, 0xE0, 0x3F,
  0xC0, 0x7C, 0x3E, 0x03, 0xBC, 0x07, 0xC3, 0xE0, 0x7B, 0xC0, 0xF8, 0x3E,
  0x07, 0xBC, 0x0F, 0x87, 0xE0, 0x73, 0xC0, 0xF8, 0x7C, 0x07, 0x3C, 0x0F,
  0x87, 0xC0, 0xF3, 0xC1, 0xF0, 0x7C, 0x0F, 0x38, 0x1F, 0x07, 0xC0, 0xE3,
  0x81, 0xF0, 0x7C, 0x1E, 0x38, 0x1E, 0x07, 0xC1, 0xE3, 0x83, 0xE0, 0x7C,
  0x1C, 0x38, 0x3E, 0x07, 0xC1, 0xC3, 0x83, 0xE0, 0x7C, 0x3C, 0x38, 0x3C,
  0x07, 0xC3, 0xC3, 0x87, 0xC0, 0x7C, 0x38, 0x38, 0x7C, 0x07, 0xC7, 0x83,
  0x87, 0xC0, 0x7C, 0x78, 0x78, 0xF8, 0x07, 0xC7, 0x87, 0x8F, 0x80, 0x7C,
  0x70, 0x78, 0xF8, 0x07, 0xCF, 0x07, 0x8F, 0x00, 0x7C, 0xF0, 0x79, 0xF0,
  0x07, 0xCE, 0x07, 0x9F, 0x00, 0x79, 0xE0, 0x79, 0xF0, 0x07, 0x9E, 0x07,
  0x9E, 0x00, 0x79, 0xE0, 0x7B, 0xE0, 0x07, 0x9C, 0x07, 0xBE, 0x00, 0xFB,
  0xC0, 0x7B, 0xE0, 0x0F, 0xBC, 0x07, 0xBC, 0x00, 0xFB, 0x80, 0x77, 0xC0,
  0x0F, 0xF8, 0x07, 0x7C, 0x00, 0xFF, 0x80, 0x77, 0x80, 0x0F, 0xF8, 0x07,
  0x78, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x00,
  0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00,
  0x00, 0x7C, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0xFC, 0x00, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x03, 0xF7, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x00, 0x03,
  0xF1, 0xF8, 0x00, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x00, 0x3F, 0x83, 0xF0,
  0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x07,
  0xF0, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x0F,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x3F, 0x1F, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x1F, 0x87, 0xE0, 0x00,
  0x0F, 0x83, 0xF0, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x0F, 0xC0, 0x7E, 0x00,
  0x07, 0xE0, 0x3F, 0x00, 0x07, 0xE0, 0x0F, 0x80, 0x07, 0xE0, 0x07, 0xE0,
  0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x7E,
  0x01, 0xF8, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00,
  0x7E, 0x7E, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x0F, 0xBF, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0xFF, 0xFE, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0x3E, 0xF0, 0x00, 0x0F, 0x9F, 0x00, 0x01,
  0xF1, 0xE0, 0x00, 0x7C, 0x3C, 0x00, 0x1F, 0x87, 0xC0, 0x03, 0xE0, 0xF8,
  0x00, 0xF8, 0x0F, 0x00, 0x1F, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x07, 0xC0, 0x3E, 0x00, 0x78, 0x0F, 0x80, 0x0F, 0x81, 0xF0, 0x01, 0xF0,
  0x7C, 0x00, 0x1E, 0x1F, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x7C, 0xF8, 0x00,
  0x0F, 0xBF, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x1F, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x7E,
  0x03, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xFF, 0xE1, 0xF0, 0x0F, 0xFF,
  0xCF, 0xC0, 0x7F, 0xFF, 0xBF, 0x03, 0xFF, 0xFE, 0xFC, 0x1F, 0xF0, 0x7B,
  0xF0, 0x7F, 0x00, 0x7F, 0x83, 0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xF8,
  0x7E, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0x7E, 0x3F,
  0x00, 0x01, 0xF0, 0xFC, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x3F, 0x0F, 0x80,
  0x00, 0xFC, 0x3E, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x0F, 0xC7, 0xE0, 0x00,
  0x3E, 0x1F, 0x80, 0x00, 0xF8, 0x7E, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x1F,
  0x87, 0xC0, 0x00, 0x7E, 0x1F, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x07, 0xE3,
  0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xF0, 0x7E,
  0x00, 0x3F, 0xC1, 0xFC, 0x01, 0xFF, 0x07, 0xFC, 0x1E, 0xFC, 0x0F, 0xFF,
  0xFB, 0xE0, 0x3F, 0xFF, 0xCF, 0x80, 0x7F, 0xFE, 0x7E, 0x00, 0x7F, 0xE1,
  0xF8, 0x00, 0x38, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x03, 0xE0, 0x01, 0xF8,
  0x7F, 0xF0, 0x07, 0xE7, 0xFF, 0xE0, 0x1F, 0x3F, 0xFF, 0xC0, 0x7D, 0xFF,
  0xFF, 0x01, 0xF7, 0x83, 0xFE, 0x0F, 0xF8, 0x03, 0xF8, 0x3F, 0xC0, 0x07,
  0xF0, 0xFE, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xFC,
  0x3E, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x3E, 0x1F,
  0x80, 0x00, 0xF8, 0x7E, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x1F, 0x87, 0xC0,
  0x00, 0x7E, 0x1F, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x07, 0xC3, 0xF0, 0x00,
  0x1F, 0x0F, 0xC0, 0x00, 0x7C, 0x3F, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x0F,
  0xC3, 0xE0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0xF8, 0x7F, 0x00, 0x07, 0xE1,
  0xFC, 0x00, 0x1F, 0x87, 0xF8, 0x00, 0xFC, 0x1F, 0x60, 0x0F, 0xF0, 0x7D,
  0xF0, 0xFF, 0x81, 0xF7, 0xFF, 0xFC, 0x0F, 0xCF, 0xFF, 0xE0, 0x3F, 0x3F,
  0xFF, 0x00, 0xFC, 0x3F, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xF8, 0x7F, 0xC0, 0x7F, 0x00, 0x7F,
  0x83, 0xF8, 0x00, 0xFE, 0x0F, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x07, 0xE1,
  0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x1F, 0x87,
  0xC0, 0x00, 0x7C, 0x1F, 0x80, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0xC1, 0xFC,
  0x00, 0xFE, 0x03, 0xFE, 0x3F, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x3F, 0xF8,
  0x7C, 0x00, 0xFF, 0xFC, 0xFC, 0x01, 0xFF, 0xFE, 0xFC, 0x03, 0xFF, 0xFE,
  0xFC, 0x07, 0xFC, 0x1E, 0xFC, 0x07, 0xF0, 0x07, 0xF8, 0x0F, 0xC0, 0x03,
  0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x01,
  0xF8, 0x1F, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x01,
  0xF0, 0x3F, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x03,
  0xF0, 0x3E, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x03,
  0xE0, 0x7E, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x07,
  0xE0, 0x7C, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F,
  0xC0, 0xFC, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x3F,
  0xC0, 0x7F, 0x00, 0x7F, 0xC0, 0x7F, 0xC1, 0xEF, 0xC0, 0x3F, 0xFF, 0xEF,
  0x80, 0x3F, 0xFF, 0xCF, 0x80, 0x1F, 0xFF, 0x9F, 0x80, 0x07, 0xFE, 0x1F,
  0x80, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x01,
  0xFC, 0x07, 0xF8, 0x1F, 0x80, 0x1F, 0xC1, 0xF8, 0x00, 0x7E, 0x0F, 0x80,
  0x01, 0xF8, 0xFC, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x7E, 0x3E, 0x00, 0x03,
  0xF3, 0xF0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x07, 0xC7,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xFC, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x87, 0xE0,
  0x01, 0xF8, 0x3F, 0x80, 0x1F, 0xC0, 0xFF, 0x03, 0xFC, 0x07, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0xB0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xFF, 0xE1,
  0xF0, 0x0F, 0xFF, 0xCF, 0xC0, 0x7F, 0xFF, 0xBF, 0x03, 0xFF, 0xFE, 0xFC,
  0x1F, 0xF0, 0x7F, 0xF0, 0x7F, 0x00, 0x7F, 0x83, 0xF0, 0x00, 0xFE, 0x0F,
  0xC0, 0x03, 0xF8, 0x7E, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x1F, 0x87, 0xC0,
  0x00, 0x7E, 0x3F, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x07, 0xC3, 0xF0, 0x00,
  0x1F, 0x0F, 0xC0, 0x00, 0xFC, 0x3E, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x0F,
  0xC7, 0xE0, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0xF8, 0x7E, 0x00, 0x03, 0xE1,
  0xF8, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7E, 0x1F, 0x80, 0x01, 0xF8, 0x7E,
  0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x07, 0xF0, 0x03, 0x7C, 0x0F, 0xF0,
  0x3D, 0xF0, 0x3F, 0xFF, 0xEF, 0xC0, 0x7F, 0xFF, 0xBF, 0x00, 0xFF, 0xFC,
  0xFC, 0x01, 0xFF, 0xC3, 0xE0, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7E, 0x03, 0xE0, 0x01, 0xF8, 0x7F, 0xF0, 0x07, 0xE7, 0xFF, 0xE0, 0x1F,
  0xBF, 0xFF, 0xC0, 0x7D, 0xFF, 0xFF, 0x81, 0xF7, 0x81, 0xFE, 0x0F, 0xF8,
  0x03, 0xF8, 0x3F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xC3, 0xF0, 0x00,
  0x3F, 0x0F, 0xC0, 0x00, 0xFC, 0x3E, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x0F,
  0x87, 0xE0, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0xF8, 0x7E, 0x00, 0x07, 0xE1,
  0xF0, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0x7E, 0x1F, 0x00, 0x01, 0xF8, 0xFC,
  0x00, 0x07, 0xC3, 0xF0, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x00,
  0x03, 0xF0, 0xF8, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x3F, 0x1F, 0x80, 0x00,
  0xF8, 0x7E, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7E,
  0x1F, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x1F, 0x0F,
  0xC0, 0x00, 0x7C, 0x3F, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x01,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x07,
  0xF0, 0x3F, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x03, 0xF0, 0x0F, 0x80, 0x03,
  0xF0, 0x07, 0xC0, 0x03, 0xF8, 0x03, 0xE0, 0x03, 0xF8, 0x03, 0xF0, 0x03,
  0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x7C, 0x01,
  0xF8, 0x00, 0x3E, 0x01, 0xFC, 0x00, 0x1F, 0x01, 0xFC, 0x00, 0x1F, 0x81,
  0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFC,
  0x07, 0xE0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x7E, 0x00, 0x0F, 0x80, 0x1F, 0x80, 0x07, 0xC0, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x07, 0xE0,
  0x1F, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0xF9, 0xFC, 0x3F,
  0xC0, 0x7C, 0xFF, 0x9F, 0xF8, 0x1F, 0x7F, 0xEF, 0xFE, 0x07, 0xDF, 0xFB,
  0xFF, 0x81, 0xF8, 0x3F, 0x83, 0xF0, 0x7C, 0x07, 0xC0, 0xFC, 0x1F, 0x01,
  0xF0, 0x3F, 0x07, 0xC0, 0x78, 0x0F, 0xC3, 0xF0, 0x1E, 0x03, 0xE0, 0xF8,
  0x0F, 0x80, 0xF8, 0x3E, 0x03, 0xE0, 0x3E, 0x0F, 0x80, 0xF8, 0x0F, 0x83,
  0xE0, 0x3E, 0x03, 0xE0, 0xF8, 0x0F, 0x01, 0xF8, 0x7E, 0x03, 0xC0, 0x7C,
  0x1F, 0x00, 0xF0, 0x1F, 0x07, 0xC0, 0x7C, 0x07, 0xC1, 0xF0, 0x1F, 0x01,
  0xF0, 0x7C, 0x07, 0xC0, 0x7C, 0x1F, 0x01, 0xE0, 0x1F, 0x0F, 0xC0, 0x78,
  0x0F, 0xC3, 0xF0, 0x1E, 0x03, 0xE0, 0xF8, 0x0F, 0x80, 0xF8, 0x3E, 0x03,
  0xE0, 0x3E, 0x0F, 0x80, 0xF8, 0x0F, 0x83, 0xE0, 0x3C, 0x03, 0xE0, 0xF8,
  0x0F, 0x01, 0xF8, 0x7E, 0x03, 0xC0, 0x7C, 0x1F, 0x01, 0xF0, 0x1F, 0x07,
  0xC0, 0x7C, 0x07, 0xC1, 0xF0, 0x1F, 0x01, 0xF0, 0x7C, 0x07, 0xC0, 0x7C,
  0x1F, 0x01, 0xE0, 0x3F, 0x0F, 0xC0, 0x78, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x1F, 0x87, 0xFF, 0x00, 0x7E, 0x7F, 0xFE, 0x01, 0xFB, 0xFF, 0xFC,
  0x07, 0xDF, 0xFF, 0xF8, 0x1F, 0x78, 0x1F, 0xE0, 0xFF, 0x80, 0x3F, 0x83,
  0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0xF8, 0x7E, 0x00,
  0x03, 0xE1, 0xF8, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x7E, 0x1F, 0x00, 0x01,
  0xF8, 0x7C, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x7C,
  0x3F, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3F, 0x0F,
  0x80, 0x00, 0xFC, 0x3E, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x0F, 0x87, 0xE0,
  0x00, 0x3E, 0x1F, 0x80, 0x01, 0xF8, 0x7E, 0x00, 0x07, 0xE1, 0xF0, 0x00,
  0x1F, 0x87, 0xC0, 0x00, 0x7E, 0x1F, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x07,
  0xC3, 0xF0, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFE, 0x03, 0xFE, 0x0F, 0xF8, 0x1F, 0xC0, 0x1F, 0xC1, 0xF8,
  0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x0F, 0xC7, 0xC0, 0x00,
  0x7E, 0x7E, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0xF8,
  0xFC, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x7E, 0x3E, 0x00, 0x03, 0xF3, 0xF0,
  0x00, 0x1F, 0x9F, 0x80, 0x00, 0xFC, 0xFC, 0x00, 0x07, 0xE7, 0xE0, 0x00,
  0x3E, 0x3E, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0xFC,
  0xFC, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x1F, 0x07, 0xE0, 0x01, 0xF8, 0x3F, 0x80, 0x3F, 0x80, 0xFF, 0x8F,
  0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x01, 0xF8, 0x7F, 0xF0, 0x01, 0xF9, 0xFF, 0xF8, 0x01, 0xFB, 0xFF, 0xFC,
  0x01, 0xF7, 0xFF, 0xFE, 0x01, 0xF7, 0x83, 0xFE, 0x03, 0xFE, 0x00, 0xFE,
  0x03, 0xFC, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x3F,
  0x07, 0xE0, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x7E,
  0x07, 0xC0, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x7C,
  0x0F, 0xC0, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0xFC,
  0x1F, 0x80, 0x00, 0xF8, 0x1F, 0xC0, 0x01, 0xF8, 0x1F, 0xC0, 0x01, 0xF8,
  0x1F, 0x60, 0x03, 0xF0, 0x1F, 0x70, 0x0F, 0xF0, 0x1F, 0x7C, 0x3F, 0xE0,
  0x3F, 0x7F, 0xFF, 0xC0, 0x3F, 0x3F, 0xFF, 0x80, 0x3F, 0x1F, 0xFF, 0x00,
  0x3F, 0x0F, 0xFC, 0x00, 0x3E, 0x01, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xFF, 0xC3, 0xF0, 0x0F, 0xFF, 0xCF, 0xC0,
  0x7F, 0xFF, 0xBF, 0x03, 0xFF, 0xFE, 0xFC, 0x1F, 0xF0, 0x7B, 0xE0, 0xFF,
  0x00, 0x6F, 0x83, 0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xF8, 0x7E, 0x00,
  0x07, 0xE1, 0xF0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x7C, 0x3F, 0x00, 0x01,
  0xF0, 0xFC, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0xFC,
  0x3E, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x3E, 0x1F,
  0x80, 0x00, 0xF8, 0x7E, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x1F, 0x87, 0xC0,
  0x00, 0x7E, 0x1F, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x07, 0xC3, 0xF0, 0x00,
  0x3F, 0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x80, 0x07, 0xF0, 0x7E, 0x00, 0x3F,
  0xC1, 0xFC, 0x01, 0xFF, 0x07, 0xFC, 0x1E, 0xF8, 0x0F, 0xFF, 0xFB, 0xE0,
  0x3F, 0xFF, 0xCF, 0x80, 0x7F, 0xFE, 0x7E, 0x00, 0x7F, 0xE1, 0xF8, 0x00,
  0x38, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0xC3, 0xFF,
  0x80, 0x1F, 0x9F, 0xFF, 0x80, 0x3F, 0x7F, 0xFF, 0x80, 0x7D, 0xFF, 0xFF,
  0x80, 0xFB, 0xC0, 0xFF, 0x01, 0xFE, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x7E,
  0x0F, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0x03, 0xF0,
  0x7E, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x1F, 0x87,
  0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x3F, 0x80, 0x0F, 0xE1, 0xF8,
  0x00, 0x3F, 0x0F, 0x80, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF9, 0xF8,
  0x00, 0x1F, 0x8F, 0xC0, 0x00, 0xFC, 0x7F, 0x00, 0x0F, 0xC3, 0xFF, 0x07,
  0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xE0, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x3F, 0x00, 0x03, 0xF0, 0xF8, 0x00,
  0x0F, 0xC3, 0xE0, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0xFC, 0x7E, 0x00, 0x03,
  0xE1, 0xF8, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x7E, 0x1F, 0x00, 0x01, 0xF8,
  0x7C, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x7C, 0x3F,
  0x00, 0x01, 0xF0, 0xFC, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x3F, 0x0F, 0x80,
  0x00, 0xFC, 0x3E, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x0F, 0xC7, 0xE0, 0x00,
  0x3E, 0x1F, 0x80, 0x00, 0xF8, 0x7E, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x1F,
  0x87, 0xC0, 0x00, 0x7E, 0x1F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0xC1,
  0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xE0, 0x7F,
  0x00, 0x7F, 0x00, 0xFF, 0x8F, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x03, 0xE7, 0xC0, 0x00,
  0x1F, 0x9F, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x0F,
  0x87, 0xE0, 0x00, 0x7E, 0x0F, 0x80, 0x01, 0xF0, 0x3E, 0x00, 0x0F, 0xC0,
  0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0x1F,
  0x00, 0x3F, 0x00, 0x7C, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x1F, 0x80, 0x1F, 0x80, 0x7C, 0x00, 0x7E, 0x03, 0xF0, 0x01, 0xF8, 0x0F,
  0x80, 0x03, 0xE0, 0x7E, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x3E, 0x0F, 0xC0,
  0x00, 0xFC, 0x3E, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x07, 0xC7, 0xC0, 0x00,
  0x1F, 0x3F, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x07,
  0xDF, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xF8, 0x07,
  0xE0, 0x0F, 0xFC, 0x03, 0xF0, 0x0F, 0xBE, 0x01, 0xF8, 0x07, 0xDF, 0x01,
  0xFC, 0x03, 0xEF, 0x80, 0xEE, 0x01, 0xE7, 0xC0, 0x77, 0x01, 0xF3, 0xE0,
  0x7B, 0x80, 0xF9, 0xE0, 0x3D, 0xC0, 0x78, 0xF0, 0x1C, 0xE0, 0x7C, 0x78,
  0x1E, 0x70, 0x3E, 0x3C, 0x0F, 0x78, 0x1E, 0x1E, 0x07, 0x3C, 0x1F, 0x0F,
  0x07, 0x9E, 0x0F, 0x87, 0x83, 0xCF, 0x07, 0x83, 0xC1, 0xC7, 0x83, 0xC1,
  0xE1, 0xE3, 0xC3, 0xE0, 0xF0, 0xF1, 0xE1, 0xE0, 0x78, 0x70, 0xF0, 0xF0,
  0x3C, 0x38, 0x78, 0xF8, 0x1E, 0x3C, 0x3C, 0x78, 0x0F, 0x1C, 0x1E, 0x3C,
  0x07, 0x8E, 0x0F, 0x3E, 0x03, 0xCF, 0x07, 0x9E, 0x01, 0xE7, 0x03, 0xCF,
  0x00, 0xF3, 0x81, 0xEF, 0x80, 0x7B, 0xC0, 0xF7, 0x80, 0x3D, 0xC0, 0x7B,
  0xC0, 0x1E, 0xE0, 0x3D, 0xE0, 0x0F, 0xF0, 0x1F, 0xE0, 0x07, 0xF0, 0x0F,
  0xF0, 0x03, 0xF8, 0x07, 0xF8, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0xFE, 0x01,
  0xFC, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x3F, 0x00, 0x03, 0xF8, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x7E, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x03,
  0xF0, 0xFC, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x00, 0xFD, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00,
  0x07, 0xF0, 0xFC, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0xFE, 0x00,
  0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xE0, 0x00, 0xFC, 0x01, 0xF8,
  0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x0F, 0xC0, 0x00, 0x7C, 0x3F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xC3,
  0xE0, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0xFC, 0x7E, 0x00, 0x03, 0xE1, 0xF8,
  0x00, 0x0F, 0x87, 0xE0, 0x00, 0x3E, 0x1F, 0x80, 0x01, 0xF8, 0x7C, 0x00,
  0x07, 0xE1, 0xF0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x7C, 0x3F, 0x00, 0x01,
  0xF0, 0xFC, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0xFC,
  0x3E, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x3E, 0x1F,
  0x80, 0x00, 0xF8, 0x7E, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x1F, 0x87, 0xE0,
  0x00, 0xFE, 0x1F, 0x80, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xC1, 0xFE, 0x00,
  0xDF, 0x03, 0xFE, 0x1F, 0xFC, 0x0F, 0xFF, 0xFB, 0xF0, 0x1F, 0xFF, 0xCF,
  0xC0, 0x3F, 0xFE, 0x3F, 0x00, 0x3F, 0xF0, 0xF8, 0x00, 0x08, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x7E, 0x1F, 0xFC, 0x00, 0xFC, 0x7F,
  0xFC, 0x01, 0xF1, 0xFF, 0xFC, 0x03, 0xE3, 0xFB, 0xF8, 0x07, 0xCF, 0xC1,
  0xF8, 0x0F, 0x9F, 0x03, 0xF8, 0x3F, 0x3E, 0x03, 0xF8, 0xFC, 0xFC, 0x03,
  0xFF, 0xF9, 0xF0, 0x07, 0xFF, 0xE3, 0xE0, 0x07, 0xFF, 0x87, 0xC0, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x80, 0x00,
};

const GFXglyph JetBrainsMono_Italic62pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 37, 0, -1 },
  { 1, 14, 45, 37, 12, -45 },
  { 80, 20, 18, 37, 12, -45 },
  { 125, 37, 45, 37, 1, -45 },
  { 334, 33, 63, 37, 3, -54 },
  { 594, 43, 46, 37, -2, -46 },
  { 842, 35, 47, 37, 1, -46 },
  { 1048, 9, 18, 37, 17, -45 },
  { 1069, 26, 60, 37, 10, -52 },
  { 1264, 25, 60, 37, 3, -52 },
  { 1452, 33, 32, 37, 3, -38 },
  { 1584, 30, 29, 37, 4, -35 },
  { 1693, 16, 19, 37, 6, -9 },
  { 1731, 20, 5, 37, 9, -23 },
  { 1744, 11, 11, 37, 11, -10 },
  { 1760, 37, 58, 37, 1, -51 },
  { 2029, 31, 47, 37, 4, -46 },
  { 2212, 29, 45, 37, 3, -45 },
  { 2376, 32, 46, 37, 3, -46 },
  { 2560, 32, 46, 37, 3, -45 },
  { 2744, 30, 45, 37, 4, -45 },
  { 2913, 31, 46, 37, 4, -45 },
  { 3092, 30, 46, 37, 3, -45 },
  { 3265, 30, 45, 37, 8, -45 },
  { 3434, 32, 47, 37, 3, -46 },
  { 3622, 30, 46, 37, 6, -46 },
  { 3795, 15, 36, 37, 11, -35 },
  { 3863, 20, 45, 37, 6, -35 },
  { 3976, 30, 33, 37, 5, -37 },
  { 4100, 30, 19, 37, 4, -30 },
  { 4172, 30, 33, 37, 3, -37 },
  { 4296, 25, 45, 37, 9, -45 },
  { 4437, 38, 57, 37, 0, -46 },
  { 4708, 31, 45, 37, 0, -45 },
  { 4883, 32, 45, 37, 3, -45 },
  { 5063, 31, 47, 37, 4, -46 },
  { 5246, 32, 45, 37, 3, -45 },
  { 5426, 34, 45, 37, 3, -45 },
  { 5618, 34, 45, 37, 3, -45 },
  { 5810, 31, 47, 37, 4, -46 },
  { 5993, 33, 45, 37, 3, -45 },
  { 6179, 31, 45, 37, 4, -45 },
  { 6354, 34, 46, 37, 1, -45 },
  { 6550, 36, 45, 37, 3, -45 },
  { 6753, 27, 45, 37, 4, -45 },
  { 6905, 35, 45, 37, 2, -45 },
  { 7102, 33, 45, 37, 3, -45 },
  { 7288, 31, 47, 37, 4, -46 },
  { 7471, 34, 45, 37, 3, -45 },
  { 7663, 31, 57, 37, 4, -46 },
  { 7884, 33, 45, 37, 3, -45 },
  { 8070, 33, 47, 37, 3, -46 },
  { 8264, 31, 45, 37, 7, -45 },
  { 8439, 32, 46, 37, 4, -45 },
  { 8623, 31, 45, 37, 8, -45 },
  { 8798, 36, 45, 37, 4, -45 },
  { 9001, 39, 45, 37, 0, -45 },
  { 9221, 33, 45, 37, 7, -45 },
  { 9407, 33, 45, 37, 3, -45 },
  { 9593, 24, 58, 37, 9, -51 },
  { 9767, 19, 58, 37, 10, -51 },
  { 9905, 24, 58, 37, 6, -51 },
  { 10079, 27, 24, 37, 6, -45 },
  { 10160, 31, 4, 37, 0, 2 },
  { 10176, 12, 9, 37, 16, -49 },
  { 10190, 30, 36, 37, 4, -35 },
  { 10325, 30, 46, 37, 3, -45 },
  { 10498, 30, 36, 37, 4, -35 },
  { 10633, 32, 46, 37, 4, -45 },
  { 10817, 29, 36, 37, 4, -35 },
  { 10948, 43, 56, 37, -3, -45 },
  { 11249, 30, 46, 37, 4, -35 },
  { 11422, 30, 45, 37, 3, -45 },
  { 11591, 30, 48, 37, 2, -48 },
  { 11771, 32, 59, 37, 1, -48 },
  { 12007, 33, 45, 37, 3, -45 },
  { 12193, 26, 45, 37, 6, -45 },
  { 12340, 34, 35, 37, 1, -35 },
  { 12489, 30, 35, 37, 3, -35 },
  { 12621, 29, 36, 37, 4, -35 },
  { 12752, 32, 46, 37, 1, -35 },
  { 12936, 30, 46, 37, 4, -35 },
  { 13109, 31, 35, 37, 4, -35 },
  { 13245, 29, 36, 37, 4, -35 },
  { 13376, 30, 43, 37, 5, -43 },
  { 13538, 30, 35, 37, 4, -34 },
  { 13670, 30, 34, 37, 6, -34 },
  { 13798, 33, 34, 37, 5, -34 },
  { 13939, 35, 34, 37, 1, -34 },
  { 14088, 30, 45, 37, 4, -34 },
  { 14257, 31, 34, 37, 3, -34 },
  { 14389, 31, 58, 37, 6, -51 },
  { 14614, 15, 58, 37, 12, -51 },
  { 14723, 32, 58, 37, 1, -51 },
  { 14955, 31, 13, 37, 4, -28 },
};

const GFXfont JetBrainsMono_Italic62pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Italic62pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Italic62pt7bGlyphs,
  0x20, 0x7E, 82
};

#endif // _JETBRAINSMONO_ITALIC62PT7B_H_
