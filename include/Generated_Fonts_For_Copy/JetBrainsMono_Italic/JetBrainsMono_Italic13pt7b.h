#ifndef _JETBRAINSMONO_ITALIC13PT7B_H_
#define _JETBRAINSMONO_ITALIC13PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Italic.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Italic13pt7bBitmaps[] PROGMEM = {
  0x00, 0x32, 0x22, 0x24, 0x04, 0xC0, 0x5A, 0xB4, 0x1B, 0x12, 0x7F, 0x24,
  0x24, 0xB6, 0x48, 0x48, 0xD8, 0x08, 0x67, 0xD5, 0x51, 0xC3, 0x8B, 0x26,
  0xAF, 0x08, 0x20, 0x20, 0xAC, 0x94, 0x8A, 0x86, 0x80, 0x80, 0x78, 0x54,
  0x4A, 0x47, 0x00, 0x08, 0x6C, 0x99, 0x03, 0x0A, 0x53, 0xA6, 0xCC, 0xEC,
  0xE0, 0x08, 0x88, 0x84, 0x21, 0x18, 0x86, 0x10, 0xE1, 0x00, 0x23, 0x86,
  0x10, 0x84, 0x62, 0x10, 0x89, 0x88, 0x00, 0x10, 0x23, 0x5B, 0xC3, 0x0B,
  0x22, 0x00, 0x10, 0x4F, 0xC8, 0x20, 0x80, 0x36, 0x4C, 0xF0, 0x78, 0x01,
  0x02, 0x06, 0x04, 0x0C, 0x08, 0x18, 0x10, 0x30, 0x20, 0x40, 0xC0, 0x19,
  0xB4, 0x71, 0x96, 0xD8, 0x63, 0x8B, 0xC0, 0x39, 0x61, 0x04, 0x10, 0x41,
  0x0C, 0xFC, 0x19, 0xB4, 0x61, 0x0C, 0x63, 0x18, 0xC3, 0xE0, 0x7C, 0x21,
  0x0E, 0x0C, 0x38, 0xA2, 0xF0, 0x0C, 0x43, 0x18, 0x4E, 0x2F, 0x82, 0x08,
  0x7D, 0x04, 0x1E, 0xCC, 0x10, 0xE2, 0xF0, 0x18, 0xC2, 0x1E, 0xCE, 0x18,
  0x62, 0xF0, 0xFE, 0x21, 0x84, 0x30, 0x84, 0x10, 0x80, 0x19, 0xB4, 0x51,
  0x79, 0xEC, 0xE3, 0x8B, 0xC0, 0x18, 0xD9, 0x16, 0x2C, 0x4F, 0x82, 0x08,
  0x20, 0xC0, 0x64, 0x00, 0xF0, 0x31, 0x80, 0x00, 0x19, 0x88, 0xC0, 0x04,
  0x33, 0x30, 0xE0, 0xC0, 0x80, 0xFC, 0x00, 0x3F, 0x81, 0x81, 0x81, 0x19,
  0x88, 0x00, 0x78, 0x42, 0x26, 0x20, 0x10, 0xC0, 0x0C, 0x32, 0x61, 0x41,
  0x4D, 0x52, 0x52, 0x92, 0x9E, 0x80, 0xC0, 0x70, 0x0C, 0x28, 0x51, 0xA2,
  0x47, 0x91, 0x22, 0xC6, 0x7D, 0x14, 0x52, 0xFA, 0x18, 0x62, 0xF0, 0x19,
  0xB4, 0x50, 0xC2, 0x08, 0x23, 0x89, 0xC0, 0x7D, 0x14, 0x71, 0xC6, 0x38,
  0xA2, 0xF0, 0x7E, 0x81, 0x02, 0x2F, 0x90, 0x20, 0x40, 0xF8, 0x7E, 0xFD,
  0x02, 0x04, 0x1F, 0xA0, 0x40, 0x81, 0x00, 0x19, 0xB4, 0x50, 0xC2, 0x78,
  0x63, 0x89, 0xC0, 0x46, 0x89, 0x12, 0x2F, 0xD1, 0xA2, 0x44, 0x88, 0x7C,
  0x41, 0x04, 0x30, 0x82, 0x08, 0xF8, 0x0E, 0x04, 0x08, 0x10, 0x60, 0xB1,
  0x62, 0x78, 0x46, 0x99, 0x26, 0x8F, 0x12, 0x22, 0x44, 0x8C, 0x61, 0x04,
  0x10, 0x43, 0x08, 0x20, 0xFC, 0x33, 0x36, 0x56, 0x5A, 0x5A, 0x42, 0x46,
  0x44, 0xC4, 0x66, 0xC9, 0x97, 0x29, 0x53, 0xA6, 0x4C, 0x98, 0x19, 0xB4,
  0x51, 0xC6, 0x18, 0xE2, 0x8B, 0xC0, 0x7C, 0x8D, 0x1E, 0x2F, 0x90, 0x20,
  0x40, 0x80, 0x19, 0xB4, 0x71, 0xC6, 0x18, 0x63, 0x8B, 0xC1, 0x06, 0x7C,
  0x89, 0x16, 0x2F, 0x92, 0x26, 0x44, 0x8C, 0x19, 0xB4, 0x50, 0x60, 0xE0,
  0xC1, 0x8B, 0xC0, 0x7F, 0xFC, 0x40, 0x81, 0x06, 0x08, 0x10, 0x20, 0x40,
  0x46, 0x89, 0x16, 0x28, 0x51, 0xA2, 0x44, 0xF0, 0x8E, 0x28, 0xA4, 0x92,
  0xCA, 0x28, 0xC0, 0x93, 0x26, 0xCD, 0xAB, 0x5A, 0xB6, 0x6C, 0x98, 0x23,
  0x36, 0x14, 0x18, 0x18, 0x38, 0x2C, 0x44, 0xC6, 0xC6, 0x89, 0xA1, 0x43,
  0x04, 0x08, 0x10, 0x20, 0x7E, 0x18, 0x20, 0x82, 0x0C, 0x10, 0x40, 0xF8,
  0x39, 0x18, 0x84, 0x21, 0x08, 0xC6, 0x21, 0xC0, 0x8C, 0x44, 0x44, 0x22,
  0x22, 0x31, 0x38, 0x42, 0x11, 0x88, 0x42, 0x10, 0x8D, 0xC0, 0x18, 0xA6,
  0x91, 0x84, 0xFC, 0xC4, 0x7D, 0x18, 0x63, 0x8A, 0x2F, 0x80, 0x41, 0x07,
  0xF1, 0xC6, 0x38, 0xA2, 0xF0, 0x7D, 0x18, 0x20, 0x86, 0x27, 0x00, 0x06,
  0x09, 0xF2, 0x28, 0x51, 0xA2, 0x44, 0xF8, 0x79, 0x18, 0x7F, 0x82, 0x27,
  0x00, 0x07, 0x86, 0x02, 0x07, 0xE0, 0x80, 0x40, 0x20, 0x10, 0x18, 0x08,
  0x3C, 0x00, 0x7D, 0x18, 0x63, 0x8B, 0x62, 0x82, 0xF0, 0x41, 0x07, 0xF1,
  0xC6, 0x38, 0xA2, 0x88, 0x0C, 0x10, 0x01, 0xC0, 0x81, 0x02, 0x0C, 0x11,
  0xFC, 0x06, 0x08, 0x01, 0xE0, 0x40, 0x83, 0x04, 0x08, 0x10, 0x27, 0x80,
  0x40, 0x85, 0x12, 0x4D, 0x1E, 0x24, 0x4C, 0x8C, 0xF0, 0x82, 0x08, 0x20,
  0x86, 0x18, 0x3C, 0x7E, 0x95, 0x2A, 0x95, 0x2A, 0x65, 0x00, 0x7F, 0x1C,
  0x63, 0x8A, 0x28, 0x80, 0x79, 0x18, 0x63, 0x8A, 0x2F, 0x00, 0x3E, 0xC5,
  0x8A, 0x34, 0x48, 0x9E, 0x20, 0xC0, 0x7D, 0x18, 0x63, 0x8A, 0x2F, 0x82,
  0x18, 0x7D, 0x14, 0x70, 0x82, 0x08, 0x00, 0x7D, 0x1C, 0x1E, 0x0A, 0x2F,
  0x80, 0x30, 0xCF, 0xC8, 0x20, 0x82, 0x18, 0x38, 0x47, 0x18, 0x63, 0x8A,
  0x27, 0x00, 0xC6, 0x89, 0x22, 0x45, 0x0A, 0x18, 0x00, 0x93, 0x6A, 0xD5,
  0xAD, 0x9B, 0x26, 0x00, 0x63, 0x34, 0x18, 0x18, 0x38, 0x6C, 0xC6, 0x47,
  0x1C, 0x63, 0x8B, 0xE0, 0x82, 0xF0, 0x7C, 0x21, 0x08, 0x42, 0x0F, 0x80,
  0x06, 0x10, 0x60, 0xC1, 0x02, 0x38, 0x08, 0x10, 0x60, 0x81, 0xC0, 0x69,
  0x24, 0xB4, 0x92, 0x40, 0x30, 0x10, 0x20, 0xC1, 0x02, 0x03, 0x88, 0x10,
  0x20, 0xC7, 0x00, 0x66, 0xD9, 0x80,
};

const GFXglyph JetBrainsMono_Italic13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 4, 9, 8, 2, -9 },
  { 6, 5, 3, 8, 2, -9 },
  { 8, 8, 9, 8, 0, -9 },
  { 17, 6, 13, 8, 1, -11 },
  { 27, 9, 10, 8, 0, -10 },
  { 39, 7, 10, 8, 0, -10 },
  { 48, 1, 3, 8, 4, -9 },
  { 49, 5, 13, 8, 2, -11 },
  { 58, 5, 13, 8, 1, -11 },
  { 67, 7, 7, 8, 1, -8 },
  { 74, 6, 6, 8, 1, -7 },
  { 79, 4, 4, 8, 1, -2 },
  { 81, 4, 1, 8, 2, -5 },
  { 82, 3, 2, 8, 2, -2 },
  { 83, 8, 12, 8, 0, -11 },
  { 95, 6, 10, 8, 1, -10 },
  { 103, 6, 9, 8, 1, -9 },
  { 110, 6, 10, 8, 1, -10 },
  { 118, 6, 9, 8, 1, -9 },
  { 125, 6, 9, 8, 1, -9 },
  { 132, 6, 9, 8, 1, -9 },
  { 139, 6, 9, 8, 1, -9 },
  { 146, 6, 9, 8, 2, -9 },
  { 153, 6, 10, 8, 1, -10 },
  { 161, 7, 10, 8, 1, -10 },
  { 170, 3, 7, 8, 2, -7 },
  { 173, 5, 9, 8, 1, -7 },
  { 179, 6, 7, 8, 1, -8 },
  { 185, 6, 4, 8, 1, -6 },
  { 188, 6, 7, 8, 1, -8 },
  { 194, 5, 9, 8, 2, -9 },
  { 200, 8, 12, 8, 0, -10 },
  { 212, 7, 9, 8, 0, -9 },
  { 220, 6, 9, 8, 1, -9 },
  { 227, 6, 10, 8, 1, -10 },
  { 235, 6, 9, 8, 1, -9 },
  { 242, 7, 9, 8, 1, -9 },
  { 250, 7, 10, 8, 1, -10 },
  { 259, 6, 10, 8, 1, -10 },
  { 267, 7, 9, 8, 1, -9 },
  { 275, 6, 9, 8, 1, -9 },
  { 282, 7, 9, 8, 0, -9 },
  { 290, 7, 9, 8, 1, -9 },
  { 298, 6, 9, 8, 1, -9 },
  { 305, 8, 9, 8, 0, -9 },
  { 314, 7, 9, 8, 1, -9 },
  { 322, 6, 10, 8, 1, -10 },
  { 330, 7, 9, 8, 1, -9 },
  { 338, 6, 12, 8, 1, -10 },
  { 347, 7, 9, 8, 1, -9 },
  { 355, 6, 10, 8, 1, -10 },
  { 363, 7, 10, 8, 1, -10 },
  { 372, 7, 9, 8, 1, -9 },
  { 380, 6, 9, 8, 2, -9 },
  { 387, 7, 9, 8, 1, -9 },
  { 395, 8, 9, 8, 0, -9 },
  { 404, 7, 9, 8, 1, -9 },
  { 412, 7, 9, 8, 1, -9 },
  { 420, 5, 12, 8, 2, -11 },
  { 428, 4, 12, 8, 2, -11 },
  { 434, 5, 12, 8, 1, -11 },
  { 442, 6, 5, 8, 1, -9 },
  { 446, 6, 1, 8, 0, 0 },
  { 447, 3, 2, 8, 3, -10 },
  { 448, 6, 7, 8, 1, -7 },
  { 454, 6, 9, 8, 1, -9 },
  { 461, 6, 7, 8, 1, -7 },
  { 467, 7, 9, 8, 1, -9 },
  { 475, 6, 7, 8, 1, -7 },
  { 481, 9, 11, 8, -1, -9 },
  { 494, 6, 9, 8, 1, -7 },
  { 501, 6, 9, 8, 1, -9 },
  { 508, 7, 10, 8, 0, -10 },
  { 517, 7, 12, 8, 0, -10 },
  { 528, 7, 9, 8, 1, -9 },
  { 536, 6, 9, 8, 1, -9 },
  { 543, 7, 7, 8, 0, -7 },
  { 550, 6, 7, 8, 1, -7 },
  { 556, 6, 7, 8, 1, -7 },
  { 562, 7, 9, 8, 0, -7 },
  { 570, 6, 9, 8, 1, -7 },
  { 577, 6, 7, 8, 1, -7 },
  { 583, 6, 7, 8, 1, -7 },
  { 589, 6, 9, 8, 1, -9 },
  { 596, 6, 7, 8, 1, -7 },
  { 602, 7, 7, 8, 1, -7 },
  { 609, 7, 7, 8, 1, -7 },
  { 616, 8, 7, 8, 0, -7 },
  { 623, 6, 9, 8, 1, -7 },
  { 630, 6, 7, 8, 1, -7 },
  { 636, 7, 12, 8, 1, -11 },
  { 647, 3, 12, 8, 3, -11 },
  { 652, 7, 12, 8, 0, -11 },
  { 663, 6, 3, 8, 1, -6 },
};

const GFXfont JetBrainsMono_Italic13pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Italic13pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Italic13pt7bGlyphs,
  0x20, 0x7E, 17
};

#endif // _JETBRAINSMONO_ITALIC13PT7B_H_
