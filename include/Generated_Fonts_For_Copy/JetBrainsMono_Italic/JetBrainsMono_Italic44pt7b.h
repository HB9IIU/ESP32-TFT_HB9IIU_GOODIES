#ifndef _JETBRAINSMONO_ITALIC44PT7B_H_
#define _JETBRAINSMONO_ITALIC44PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Italic.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Italic44pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xE0, 0x78, 0x0F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x07, 0xE1, 0xFC, 0x3F, 0x83, 0xE0, 0x3C, 0x1E, 0xF8,
  0x7D, 0xF0, 0xFB, 0xC1, 0xE7, 0x83, 0xCF, 0x07, 0x9E, 0x0F, 0x3C, 0x1E,
  0x70, 0x38, 0xE0, 0xF3, 0xC1, 0xE7, 0x83, 0xCF, 0x07, 0x80, 0x00, 0x1E,
  0x03, 0x80, 0x07, 0x01, 0xC0, 0x01, 0xC0, 0x70, 0x00, 0xF0, 0x3C, 0x00,
  0x38, 0x0E, 0x00, 0x0E, 0x03, 0x80, 0x07, 0x81, 0xE0, 0x01, 0xC0, 0x70,
  0x00, 0x70, 0x1C, 0x03, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFE, 0x01, 0xE0, 0x78, 0x00, 0x70, 0x1C, 0x00, 0x1C, 0x07, 0x00, 0x0F,
  0x03, 0xC0, 0x03, 0x80, 0xE0, 0x00, 0xE0, 0x38, 0x00, 0x78, 0x1E, 0x00,
  0x1C, 0x07, 0x00, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xC0, 0x38, 0x0E, 0x00, 0x1C, 0x07, 0x80, 0x07, 0x01, 0xC0, 0x01, 0xC0,
  0x70, 0x00, 0xE0, 0x3C, 0x00, 0x38, 0x0E, 0x00, 0x0E, 0x03, 0x80, 0x07,
  0x01, 0xC0, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xFC, 0x07, 0xCC, 0xF8, 0x1F,
  0x38, 0xF8, 0x3C, 0x70, 0xF0, 0xF0, 0xE1, 0xE1, 0xE1, 0xC3, 0xC3, 0xC3,
  0x80, 0x07, 0x86, 0x00, 0x0F, 0x0C, 0x00, 0x1F, 0x38, 0x00, 0x3F, 0x70,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x3B, 0xF0, 0x00, 0x73, 0xE0, 0x00, 0xE3, 0xE0,
  0x01, 0x83, 0xC0, 0x03, 0x07, 0x81, 0x0E, 0x0F, 0x3C, 0x1C, 0x3C, 0x7C,
  0x38, 0x78, 0x78, 0x70, 0xF0, 0xF8, 0xE3, 0xC1, 0xF9, 0x9F, 0x01, 0xFF,
  0xFE, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x3C, 0x0F, 0xF8, 0x01, 0xE0, 0x7F, 0xF0, 0x0F,
  0x01, 0xC1, 0xC0, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0x38, 0x1C, 0x0E, 0x00,
  0xE0, 0x70, 0x70, 0x03, 0x81, 0xC3, 0xC0, 0x1E, 0x0F, 0x1E, 0x00, 0x78,
  0x3C, 0x70, 0x01, 0xE0, 0xE3, 0x80, 0x03, 0xFF, 0x9C, 0x00, 0x0F, 0xFC,
  0xE0, 0x00, 0x1F, 0xC7, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x30, 0x00, 0x01, 0xC7, 0xF8,
  0x00, 0x0F, 0x3F, 0xE0, 0x00, 0x79, 0xF7, 0xC0, 0x03, 0xCF, 0x07, 0x00,
  0x0E, 0x38, 0x1C, 0x00, 0x70, 0xE0, 0x70, 0x03, 0x83, 0x81, 0xC0, 0x1C,
  0x0E, 0x07, 0x00, 0xF0, 0x78, 0x3C, 0x07, 0x81, 0xE0, 0xE0, 0x1C, 0x07,
  0x87, 0x80, 0xE0, 0x0F, 0xFC, 0x07, 0x00, 0x3F, 0xE0, 0x38, 0x00, 0x3F,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xF8, 0x03, 0xE0, 0xF8, 0x03, 0xC0, 0x78, 0x07, 0xC0, 0x7C, 0x07, 0x80,
  0x7C, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0x78, 0x0F, 0x3C, 0x7C, 0x1E, 0x3C, 0x3C,
  0x3E, 0x78, 0x1E, 0x3C, 0x78, 0x1E, 0x78, 0x78, 0x0F, 0xF0, 0x78, 0x0F,
  0xF0, 0x78, 0x07, 0xE0, 0x78, 0x07, 0xC0, 0x78, 0x07, 0xC0, 0xF0, 0x07,
  0xE0, 0xF8, 0x0F, 0xE0, 0x7C, 0x3E, 0xF0, 0x7F, 0xFC, 0xF8, 0x3F, 0xF8,
  0x78, 0x1F, 0xE0, 0x7C, 0x3C, 0xF3, 0xDF, 0x7D, 0xE7, 0x9E, 0x79, 0xE7,
  0x1C, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0xFF, 0x00,
  0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x07, 0xE0, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x01, 0xF0, 0x00, 0x1C,
  0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x78, 0x00, 0x1F, 0x80, 0x0F, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0xC0,
  0x03, 0xE0, 0x03, 0xF0, 0x07, 0xF8, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x38,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x20, 0x1C,
  0x02, 0x38, 0x1C, 0x1E, 0x7E, 0x1C, 0x7E, 0xFF, 0x99, 0xFF, 0x3F, 0xDF,
  0xFC, 0x0F, 0xFF, 0xE0, 0x00, 0x38, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xEE,
  0x00, 0x03, 0xCF, 0x00, 0x07, 0xCF, 0x00, 0x07, 0x8F, 0x80, 0x0F, 0x07,
  0x80, 0x1F, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1C, 0x03, 0x80, 0x08, 0x01,
  0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xF0, 0x7E,
  0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xC0,
  0x3C, 0x07, 0x80, 0x78, 0x0F, 0x00, 0x7F, 0xFE, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1C, 0x7E, 0xFE, 0xFE, 0xFE, 0xFE, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F,
  0xC0, 0xF8, 0x3C, 0x01, 0xE1, 0xE0, 0x07, 0xC7, 0x80, 0x0F, 0x1C, 0x00,
  0x3C, 0xF0, 0x00, 0xF3, 0xC0, 0x03, 0xCF, 0x00, 0x1E, 0x3C, 0x00, 0x78,
  0xF0, 0x01, 0xE7, 0x87, 0x07, 0x9E, 0x3E, 0x1E, 0x78, 0xF8, 0x79, 0xE3,
  0xE1, 0xC7, 0x87, 0x8F, 0x1E, 0x08, 0x3C, 0x70, 0x00, 0xF3, 0xC0, 0x03,
  0xCF, 0x00, 0x0F, 0x3C, 0x00, 0x38, 0xF0, 0x01, 0xE3, 0xC0, 0x07, 0x8F,
  0x00, 0x1E, 0x3C, 0x00, 0xF0, 0xF8, 0x07, 0xC1, 0xF0, 0x7E, 0x07, 0xFF,
  0xF0, 0x0F, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x03, 0xFC,
  0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x07, 0xE7, 0x80, 0xFC, 0x78, 0x0F, 0x07,
  0x80, 0xE0, 0x78, 0x08, 0x0F, 0x01, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xC0,
  0x1F, 0xFF, 0xC0, 0x7E, 0x0F, 0xC0, 0xF0, 0x07, 0x83, 0xC0, 0x0F, 0x07,
  0x80, 0x1F, 0x1E, 0x00, 0x1C, 0x3C, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x7C, 0x00, 0x78, 0xF0,
  0x00, 0xF1, 0xE0, 0x03, 0xC3, 0xE0, 0x07, 0x83, 0xC0, 0x1E, 0x07, 0xE0,
  0xFC, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x03, 0xC3, 0xE0, 0x1E, 0x1E, 0x00, 0xF1, 0xE0, 0x0F, 0x1E, 0x00, 0x78,
  0xF0, 0x03, 0xCF, 0x00, 0x1E, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x07, 0xFF,
  0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x9F, 0xC0, 0x1E, 0xFF, 0xC0, 0xF7, 0xFF,
  0x83, 0xFC, 0xFE, 0x0F, 0xC0, 0x7C, 0x3E, 0x01, 0xF0, 0xF0, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE3, 0xC0, 0x0F, 0x8F, 0x00, 0x3C,
  0x3E, 0x01, 0xF0, 0x7C, 0x1F, 0x81, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x03,
  0xFE, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x9F, 0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x07, 0xF9, 0xFC, 0x3F, 0x00,
  0xF8, 0xF8, 0x03, 0xE3, 0xC0, 0x07, 0x9E, 0x00, 0x1E, 0x78, 0x00, 0x79,
  0xE0, 0x01, 0xE7, 0x80, 0x07, 0xBC, 0x00, 0x1E, 0xF8, 0x00, 0xF1, 0xE0,
  0x03, 0xC7, 0x80, 0x1F, 0x1F, 0x00, 0xF8, 0x7F, 0x0F, 0xC0, 0xFF, 0xFE,
  0x01, 0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xFF, 0xFD, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0x9E, 0x00, 0x1E, 0x78, 0x00, 0x79, 0xE0, 0x03, 0xC7, 0x80,
  0x1F, 0x3C, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3E, 0x07,
  0xC0, 0xF8, 0x07, 0x81, 0xE0, 0x0F, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0x3C,
  0x1E, 0x00, 0x78, 0x3C, 0x00, 0xF0, 0x78, 0x03, 0xC0, 0x78, 0x0F, 0x00,
  0xF8, 0x3C, 0x00, 0xFD, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x07,
  0xFF, 0x00, 0x1F, 0x9F, 0x00, 0x78, 0x1F, 0x01, 0xE0, 0x1F, 0x07, 0x80,
  0x1E, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x78, 0x00, 0xF0, 0xF0, 0x01,
  0xE1, 0xE0, 0x03, 0xC3, 0xC0, 0x0F, 0x07, 0xC0, 0x3E, 0x0F, 0xC1, 0xF8,
  0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x00, 0x0C, 0x00,
  0x0F, 0xFC, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xE1, 0xF8, 0x3F, 0x0F, 0x00,
  0x7C, 0xF0, 0x01, 0xEF, 0x80, 0x0F, 0x78, 0x00, 0x7B, 0xC0, 0x03, 0xDE,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x7B, 0xE0, 0x03,
  0xCF, 0x00, 0x3E, 0x7C, 0x03, 0xE3, 0xFD, 0xFF, 0x0F, 0xFE, 0xF0, 0x3F,
  0xEF, 0x00, 0x7C, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0x01, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x83, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x07, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0x7C, 0x00, 0x00,
  0x30, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x1F,
  0x00, 0x7E, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00,
  0x78, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xE0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0x3F, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFC, 0x00, 0x01, 0xC0, 0x00, 0x02, 0x00,
  0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xF3, 0xFF, 0xFF, 0x80, 0x08, 0x00, 0x00, 0x70, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x70,
  0x00, 0x1F, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x78,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0x81, 0xFF, 0xF0,
  0xFF, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0xC0, 0x07, 0xE0, 0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xF8, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x7E, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0x00, 0x78, 0x07, 0xC0,
  0x07, 0x80, 0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xC1,
  0xE0, 0x00, 0x38, 0x38, 0x00, 0x07, 0x0F, 0x00, 0x00, 0xE1, 0xE0, 0x3F,
  0x9C, 0x3C, 0x0F, 0xFB, 0x87, 0x03, 0xF7, 0x70, 0xE0, 0x78, 0x3C, 0x1C,
  0x1E, 0x03, 0x87, 0x83, 0xC0, 0x70, 0xF0, 0x70, 0x1E, 0x1E, 0x0E, 0x03,
  0xC3, 0xC1, 0xC0, 0x78, 0x70, 0x78, 0x0F, 0x0E, 0x0F, 0x01, 0xC1, 0xC1,
  0xE0, 0x38, 0x78, 0x3C, 0x0F, 0x0F, 0x07, 0x81, 0xE1, 0xE0, 0xF0, 0x7C,
  0x38, 0x1F, 0x1F, 0x87, 0x01, 0xFE, 0xE0, 0xE0, 0x3F, 0xDC, 0x1C, 0x00,
  0xC0, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00,
  0x0E, 0xF0, 0x00, 0x7B, 0xC0, 0x01, 0xEF, 0x00, 0x07, 0x3C, 0x00, 0x3C,
  0xF0, 0x00, 0xF3, 0xC0, 0x07, 0x8F, 0x00, 0x1E, 0x1C, 0x00, 0xF0, 0x70,
  0x03, 0xC1, 0xC0, 0x0F, 0x07, 0x80, 0x78, 0x1E, 0x01, 0xE0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x81, 0xE0, 0x1E, 0x07, 0xFF, 0xF8, 0x1F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x83, 0xC0, 0x0E, 0x1F, 0x00, 0x3C, 0x78, 0x00, 0xF1,
  0xE0, 0x03, 0xCF, 0x00, 0x0F, 0x3C, 0x00, 0x3D, 0xE0, 0x00, 0xF7, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xE0, 0x3C, 0x1F, 0xE0, 0x70, 0x07, 0xC1, 0xE0, 0x07, 0x83, 0xC0, 0x0F,
  0x87, 0x80, 0x1F, 0x0F, 0x00, 0x3C, 0x1E, 0x00, 0x78, 0x38, 0x00, 0xF0,
  0xF0, 0x03, 0xC1, 0xE0, 0x0F, 0x83, 0xC0, 0xFC, 0x07, 0xFF, 0xF0, 0x0F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x78, 0x07, 0xE0, 0xF0, 0x03, 0xC1, 0xE0,
  0x07, 0xC3, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x3C, 0x00,
  0x3C, 0x78, 0x00, 0xF0, 0xF0, 0x01, 0xE1, 0xE0, 0x07, 0xC3, 0xC0, 0x1F,
  0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFE, 0x00,
  0x00, 0x04, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x07,
  0xC1, 0xF8, 0x3E, 0x01, 0xE0, 0xF0, 0x07, 0xC7, 0x80, 0x0F, 0x1E, 0x00,
  0x3C, 0x78, 0x00, 0xF3, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x01, 0xE3, 0xC0, 0x07, 0x8F,
  0x00, 0x1E, 0x3E, 0x00, 0xF0, 0xF8, 0x07, 0xC1, 0xF8, 0x7E, 0x07, 0xFF,
  0xF0, 0x0F, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xE0, 0x3C, 0x1F, 0xC0, 0xF0, 0x07, 0xC1, 0xE0, 0x07,
  0x83, 0xC0, 0x0F, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0x3C, 0x1E, 0x00, 0x78,
  0x3C, 0x00, 0xF0, 0xF0, 0x01, 0xE1, 0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x87,
  0x80, 0x1E, 0x0F, 0x00, 0x3C, 0x1E, 0x00, 0x78, 0x78, 0x00, 0xF0, 0xF0,
  0x01, 0xE1, 0xE0, 0x03, 0xC3, 0xC0, 0x0F, 0x07, 0x80, 0x1E, 0x0F, 0x00,
  0x3C, 0x3C, 0x00, 0x78, 0x78, 0x00, 0xF0, 0xF0, 0x03, 0xC1, 0xE0, 0x0F,
  0x83, 0xC0, 0x3E, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80,
  0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x04, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0xFF, 0xFC, 0x07, 0xC1, 0xF8, 0x3E, 0x01, 0xE0, 0xF0, 0x07, 0xC7, 0x80,
  0x0F, 0x1E, 0x00, 0x3C, 0x78, 0x00, 0xF3, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0xFF, 0xC7, 0x83, 0xFF, 0x1E, 0x1F, 0xFC, 0x78, 0x00,
  0xF1, 0xE0, 0x03, 0xC7, 0x80, 0x0F, 0x3C, 0x00, 0x78, 0xF0, 0x01, 0xE3,
  0xC0, 0x07, 0x8F, 0x00, 0x1E, 0x3E, 0x00, 0xF0, 0xF8, 0x07, 0xC1, 0xF8,
  0x7E, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x07, 0x80,
  0x1E, 0x0F, 0x00, 0x3C, 0x1E, 0x00, 0x78, 0x3C, 0x00, 0xF0, 0x70, 0x01,
  0xE1, 0xE0, 0x03, 0xC3, 0xC0, 0x0F, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0x3C,
  0x1E, 0x00, 0x78, 0x3C, 0x00, 0xF0, 0xF0, 0x01, 0xE1, 0xE0, 0x07, 0x83,
  0xC0, 0x0F, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x78,
  0x00, 0xF0, 0xF0, 0x01, 0xE1, 0xE0, 0x07, 0x83, 0xC0, 0x0F, 0x07, 0x80,
  0x1E, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x78, 0x00, 0xF0, 0xF0, 0x03,
  0xC1, 0xE0, 0x07, 0x83, 0xC0, 0x0F, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0x3C,
  0x3C, 0x00, 0x78, 0x78, 0x01, 0xE0, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xC0, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0xFF,
  0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0xF0, 0x00,
  0xF0, 0xF0, 0x01, 0xF0, 0xF8, 0x01, 0xE0, 0x78, 0x03, 0xE0, 0x7E, 0x0F,
  0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0x80,
  0x07, 0x83, 0xC0, 0x07, 0x81, 0xE0, 0x07, 0xC0, 0xF0, 0x03, 0xC0, 0xF0,
  0x03, 0xC0, 0x78, 0x03, 0xE0, 0x3C, 0x03, 0xE0, 0x1E, 0x01, 0xE0, 0x0F,
  0x01, 0xF0, 0x07, 0x81, 0xF0, 0x03, 0x80, 0xF0, 0x03, 0xC0, 0xF8, 0x01,
  0xE0, 0xF8, 0x00, 0xF0, 0x78, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x1F, 0xFE, 0x00, 0x1E, 0x0F, 0x80, 0x0F, 0x03, 0xC0, 0x07, 0x81, 0xE0,
  0x03, 0xC0, 0xF8, 0x01, 0xE0, 0x3C, 0x00, 0xF0, 0x1E, 0x00, 0xF0, 0x0F,
  0x80, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF8, 0x0F, 0x00,
  0x3C, 0x07, 0x80, 0x1E, 0x07, 0x80, 0x0F, 0x83, 0xC0, 0x03, 0xC1, 0xE0,
  0x01, 0xF0, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xE0, 0x0F, 0x83, 0xF0, 0x0F,
  0xC1, 0xF8, 0x07, 0xE0, 0xFC, 0x07, 0xF0, 0x7E, 0x03, 0xB8, 0x3F, 0x83,
  0xF8, 0x3D, 0xC1, 0xDC, 0x1C, 0xE1, 0xEE, 0x0E, 0x70, 0xE7, 0x07, 0x38,
  0xF7, 0x83, 0x9C, 0x73, 0xC1, 0xCE, 0x39, 0xC1, 0xE3, 0xB8, 0xE0, 0xF1,
  0xDC, 0xF0, 0x78, 0xFC, 0x78, 0x3C, 0x7E, 0x3C, 0x1E, 0x3E, 0x1E, 0x0F,
  0x1F, 0x0E, 0x07, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x03, 0xC1,
  0xE0, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0x78, 0x00, 0x70, 0x38, 0x00, 0x78,
  0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x07,
  0x83, 0xC0, 0x03, 0xC1, 0xE0, 0x03, 0xC1, 0xE0, 0x01, 0xE0, 0x07, 0xC0,
  0x0F, 0x07, 0xE0, 0x0E, 0x07, 0xE0, 0x1E, 0x07, 0xE0, 0x1E, 0x0F, 0xE0,
  0x1E, 0x0F, 0xE0, 0x1E, 0x0F, 0xF0, 0x1E, 0x0F, 0xF0, 0x1C, 0x0E, 0x70,
  0x3C, 0x0E, 0x70, 0x3C, 0x1E, 0x70, 0x3C, 0x1E, 0x78, 0x3C, 0x1E, 0x78,
  0x3C, 0x1E, 0x38, 0x38, 0x1E, 0x38, 0x78, 0x1C, 0x38, 0x78, 0x3C, 0x3C,
  0x78, 0x3C, 0x3C, 0x78, 0x3C, 0x1C, 0x78, 0x3C, 0x1C, 0x78, 0x3C, 0x1C,
  0x70, 0x3C, 0x1E, 0xF0, 0x38, 0x1E, 0xF0, 0x78, 0x0E, 0xF0, 0x78, 0x0E,
  0xF0, 0x78, 0x0E, 0xF0, 0x78, 0x0F, 0xE0, 0x78, 0x0F, 0xE0, 0x70, 0x07,
  0xE0, 0xF0, 0x07, 0xE0, 0xF0, 0x07, 0xE0, 0xF0, 0x07, 0xE0, 0x00, 0x0E,
  0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xC1, 0xF8,
  0x3E, 0x01, 0xE0, 0xF0, 0x07, 0x87, 0x80, 0x1E, 0x1E, 0x00, 0x78, 0x78,
  0x01, 0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x1E, 0x3C, 0x00, 0x78, 0xF0, 0x01,
  0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x3C, 0x3C, 0x00, 0xF1, 0xE0, 0x03, 0xC7,
  0x80, 0x0F, 0x1E, 0x00, 0x3C, 0x78, 0x00, 0xF1, 0xE0, 0x07, 0x87, 0x80,
  0x1E, 0x3C, 0x00, 0x78, 0xF0, 0x01, 0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x3C,
  0x3E, 0x00, 0xF0, 0xF8, 0x07, 0x81, 0xF8, 0x7E, 0x07, 0xFF, 0xF0, 0x0F,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x07,
  0xFF, 0xFC, 0x07, 0x81, 0xFE, 0x0F, 0x00, 0x3F, 0x0F, 0x00, 0x1F, 0x0F,
  0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0E,
  0x00, 0x1F, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x1E,
  0x00, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x3F,
  0xFE, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x03, 0xFF, 0x00, 0x1F,
  0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xC1, 0xF8, 0x3E, 0x01, 0xE1, 0xF0, 0x07,
  0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x3C, 0xF0, 0x00, 0xF3, 0xC0, 0x03, 0xCF,
  0x00, 0x1E, 0x3C, 0x00, 0x78, 0xF0, 0x01, 0xE7, 0x80, 0x07, 0x9E, 0x00,
  0x1E, 0x78, 0x00, 0x79, 0xE0, 0x03, 0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x3C,
  0x78, 0x00, 0xF3, 0xC0, 0x03, 0xCF, 0x00, 0x0F, 0x3C, 0x00, 0x78, 0xF0,
  0x01, 0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x1E, 0x3C, 0x00, 0xF0, 0xF8, 0x07,
  0xC1, 0xF0, 0x7E, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x07, 0xFF,
  0xE0, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x07, 0x81, 0xFC, 0x0F, 0x00,
  0x3E, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x0F, 0x00,
  0x1E, 0x0F, 0x00, 0x1E, 0x0E, 0x00, 0x1E, 0x1E, 0x00, 0x3E, 0x1E, 0x00,
  0x3C, 0x1E, 0x00, 0x7C, 0x1E, 0x03, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xE0, 0x3F, 0xFF, 0x80, 0x3C, 0x1F, 0x00, 0x3C, 0x0F, 0x00, 0x3C, 0x0F,
  0x00, 0x3C, 0x0F, 0x80, 0x3C, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07,
  0xC0, 0x78, 0x03, 0xC0, 0x78, 0x03, 0xC0, 0x78, 0x03, 0xE0, 0x78, 0x03,
  0xE0, 0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xF0, 0xF0, 0x01, 0xF0, 0x00, 0x03,
  0x00, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3E, 0x07,
  0xC0, 0xF8, 0x07, 0xC1, 0xE0, 0x07, 0x87, 0x80, 0x0F, 0x0F, 0x00, 0x1E,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x08, 0x00, 0x79, 0xE0, 0x01,
  0xE3, 0xC0, 0x03, 0xC3, 0xC0, 0x0F, 0x87, 0xC0, 0x3E, 0x0F, 0xC0, 0xF8,
  0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x78, 0x3C, 0x00, 0xF0, 0x78, 0x01,
  0xE1, 0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x0F, 0x00, 0x3C,
  0x1E, 0x00, 0x78, 0x3C, 0x00, 0xF0, 0xF0, 0x01, 0xE1, 0xE0, 0x03, 0xC3,
  0xC0, 0x07, 0x87, 0x80, 0x1E, 0x0F, 0x00, 0x3C, 0x1E, 0x00, 0x78, 0x78,
  0x00, 0xF0, 0xF0, 0x01, 0xE1, 0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x87, 0x80,
  0x1E, 0x0F, 0x00, 0x3C, 0x1E, 0x00, 0x78, 0x78, 0x00, 0xF0, 0xF0, 0x01,
  0xE1, 0xE0, 0x07, 0x83, 0xE0, 0x0F, 0x07, 0xC0, 0x3C, 0x07, 0xC1, 0xF8,
  0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0xF0, 0x00, 0x3D,
  0xE0, 0x00, 0xF7, 0x80, 0x07, 0x9E, 0x00, 0x1E, 0x78, 0x00, 0xF1, 0xE0,
  0x03, 0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x78, 0x78, 0x01, 0xE1, 0xE0, 0x0F,
  0x07, 0x80, 0x3C, 0x0E, 0x00, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0xF0, 0x0F, 0x03, 0xC0, 0x3C, 0x1E, 0x00, 0xF0, 0x78, 0x03, 0xC1,
  0xE0, 0x0F, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0x71, 0xE0, 0x01, 0xC7, 0x80,
  0x07, 0x9E, 0x00, 0x1E, 0xF0, 0x00, 0x7B, 0xC0, 0x01, 0xEE, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x78, 0x1F, 0x03, 0xBC, 0x0F, 0x03, 0xDE, 0x07, 0x81, 0xEF, 0x07,
  0xC0, 0xE7, 0x83, 0xE0, 0x73, 0xC1, 0xB0, 0x79, 0xE1, 0xD8, 0x3C, 0xF0,
  0xEC, 0x1C, 0x70, 0x66, 0x0E, 0x38, 0x33, 0x0F, 0x1C, 0x39, 0x87, 0x8E,
  0x1C, 0xC3, 0x87, 0x0C, 0xE3, 0xC3, 0x8E, 0x71, 0xE1, 0xC7, 0x38, 0xE0,
  0xE3, 0x1C, 0x70, 0x71, 0x8E, 0x78, 0x79, 0xC7, 0x3C, 0x3C, 0xE3, 0x9C,
  0x1E, 0x61, 0xCE, 0x0F, 0x70, 0xEF, 0x07, 0xB8, 0x77, 0x83, 0xD8, 0x3B,
  0x81, 0xEC, 0x19, 0xC0, 0xFE, 0x0D, 0xE0, 0x77, 0x06, 0xE0, 0x3B, 0x03,
  0x70, 0x1D, 0x81, 0xB8, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x7C, 0x03, 0xE0,
  0x3E, 0x01, 0xF0, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x78, 0x00, 0x78,
  0x0F, 0x80, 0x1E, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xF0, 0x01, 0xE0,
  0x3C, 0x00, 0x3C, 0x0F, 0x80, 0x07, 0xC1, 0xE0, 0x00, 0x78, 0x78, 0x00,
  0x0F, 0x1E, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3D, 0xE0,
  0x00, 0x0F, 0x3C, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x78, 0x78, 0x00, 0x1E,
  0x0F, 0x00, 0x07, 0xC1, 0xF0, 0x01, 0xF0, 0x1E, 0x00, 0x3C, 0x03, 0xE0,
  0x0F, 0x80, 0x3C, 0x03, 0xE0, 0x07, 0x80, 0x78, 0x00, 0xF8, 0x1E, 0x00,
  0x0F, 0x07, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x79, 0xE0,
  0x01, 0xE3, 0xC0, 0x03, 0xC7, 0x80, 0x0F, 0x07, 0x80, 0x3C, 0x0F, 0x00,
  0x78, 0x1E, 0x01, 0xE0, 0x3E, 0x07, 0xC0, 0x3C, 0x0F, 0x00, 0x78, 0x3C,
  0x00, 0xF0, 0xF8, 0x00, 0xF1, 0xE0, 0x01, 0xE7, 0x80, 0x03, 0xCF, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xC0,
  0x7F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFE, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0xFF,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF8, 0x00, 0xF0, 0x07, 0x80, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0,
  0x7F, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x0F, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0E, 0xF0, 0x03,
  0xCE, 0x00, 0xF1, 0xC0, 0x1C, 0x3C, 0x07, 0x83, 0x80, 0xE0, 0x70, 0x3C,
  0x0E, 0x0F, 0x01, 0xE1, 0xC0, 0x1C, 0x78, 0x03, 0x8E, 0x00, 0x7B, 0xC0,
  0x0F, 0xF0, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0x80, 0xF0, 0xF0, 0x78, 0x3C, 0x3C, 0x1E, 0x0F, 0x00, 0x30, 0x00, 0x1F,
  0xF3, 0xC1, 0xFF, 0xDE, 0x1F, 0xFE, 0xF1, 0xF8, 0x3F, 0x8F, 0x00, 0xFC,
  0xF8, 0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x00, 0xF3, 0xC0, 0x07, 0x9E, 0x00,
  0x3C, 0xF0, 0x01, 0xE7, 0x80, 0x1E, 0x3C, 0x00, 0xF1, 0xE0, 0x07, 0x9E,
  0x00, 0x3C, 0xF0, 0x01, 0xE7, 0x80, 0x0F, 0x3C, 0x00, 0xF1, 0xF0, 0x07,
  0x8F, 0x80, 0x7C, 0x3E, 0x0F, 0xE1, 0xFF, 0xEF, 0x07, 0xFE, 0x78, 0x1F,
  0xE7, 0xC0, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0xC0,
  0x0F, 0x3F, 0xE0, 0x3D, 0xFF, 0xC0, 0xEF, 0xFF, 0x07, 0xB0, 0x7E, 0x1F,
  0x00, 0xF8, 0x7C, 0x01, 0xE1, 0xE0, 0x07, 0x87, 0x80, 0x1E, 0x1E, 0x00,
  0x78, 0xF0, 0x01, 0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x1E, 0x3C, 0x00, 0xF0,
  0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x1E, 0x00, 0x3C, 0x78, 0x00, 0xF1, 0xE0,
  0x07, 0x87, 0xC0, 0x1E, 0x1F, 0x00, 0xF8, 0x7F, 0x0F, 0xC3, 0xDF, 0xFE,
  0x0F, 0x3F, 0xF0, 0x3C, 0x7F, 0x80, 0x00, 0x3C, 0x00, 0x0F, 0xFC, 0x01,
  0xFF, 0xF8, 0x1F, 0xFF, 0xC1, 0xF8, 0x1F, 0x0F, 0x00, 0x78, 0xF0, 0x03,
  0xC7, 0x80, 0x1F, 0x3C, 0x00, 0xF3, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x0F, 0x3C, 0x00, 0x79, 0xF0, 0x07, 0x8F, 0x80,
  0x7C, 0x3F, 0x0F, 0xC1, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x18, 0x3C, 0x03,
  0xFE, 0x78, 0x0F, 0xFE, 0xF0, 0x3F, 0xFD, 0xE0, 0xFC, 0x1F, 0xC1, 0xE0,
  0x1F, 0x87, 0xC0, 0x1E, 0x0F, 0x00, 0x3C, 0x1E, 0x00, 0x78, 0x78, 0x00,
  0xF0, 0xF0, 0x01, 0xE1, 0xE0, 0x03, 0xC3, 0xC0, 0x0F, 0x07, 0x80, 0x1E,
  0x0F, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x78, 0x00, 0xF0, 0xF0, 0x01, 0xE1,
  0xE0, 0x07, 0xC3, 0xE0, 0x0F, 0x07, 0xC0, 0x3E, 0x07, 0xC1, 0xFC, 0x0F,
  0xFF, 0x78, 0x0F, 0xFC, 0xF0, 0x0F, 0xF3, 0xE0, 0x00, 0x18, 0x00, 0x0F,
  0xFC, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0xC1, 0xF0, 0x1F, 0x0F, 0x00, 0x78,
  0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x38, 0x00, 0xF3, 0xC0, 0x07, 0x9E, 0x00,
  0x3C, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF1, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x07,
  0x87, 0x80, 0x7C, 0x3E, 0x07, 0xC1, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x1F,
  0xF3, 0xC1, 0xFF, 0xDE, 0x1F, 0xFE, 0xF1, 0xF8, 0x3F, 0x8F, 0x00, 0xFC,
  0xF8, 0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x00, 0xF3, 0xC0, 0x07, 0x9E, 0x00,
  0x3C, 0xF0, 0x01, 0xE7, 0x80, 0x0E, 0x3C, 0x00, 0xF1, 0xE0, 0x07, 0x8F,
  0x00, 0x3C, 0xF8, 0x01, 0xE3, 0xC0, 0x1F, 0x1E, 0x01, 0xF8, 0xFC, 0x1F,
  0x87, 0xFF, 0xFC, 0x1F, 0xFD, 0xE0, 0x7F, 0x8F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x3F, 0xFF, 0x81, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC1, 0xC0, 0x0F, 0x3F, 0xE0,
  0x3D, 0xFF, 0xC0, 0xEF, 0xFF, 0x07, 0xB0, 0x3E, 0x1F, 0x00, 0x78, 0x7C,
  0x01, 0xE1, 0xE0, 0x07, 0x87, 0x80, 0x1E, 0x1E, 0x00, 0x78, 0xF0, 0x01,
  0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x1E, 0x3C, 0x00, 0xF0, 0xF0, 0x03, 0xC3,
  0xC0, 0x0F, 0x1E, 0x00, 0x3C, 0x78, 0x00, 0xF1, 0xE0, 0x03, 0xC7, 0x80,
  0x1E, 0x1E, 0x00, 0x78, 0x78, 0x01, 0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x1E,
  0x3C, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x10, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1E, 0x00, 0x01, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0xFF,
  0xE0, 0x03, 0xFC, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x01, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x3C, 0x0F,
  0x00, 0x7C, 0x1E, 0x00, 0xF8, 0x1E, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x1E,
  0x07, 0xC0, 0x1E, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0x1E, 0x1F, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3C, 0x3E, 0x00, 0x3C,
  0x1E, 0x00, 0x3C, 0x1F, 0x00, 0x78, 0x0F, 0x00, 0x78, 0x0F, 0x80, 0x78,
  0x07, 0x80, 0x78, 0x07, 0xC0, 0x78, 0x03, 0xC0, 0x78, 0x03, 0xE0, 0xF0,
  0x01, 0xE0, 0xF0, 0x01, 0xF0, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0,
  0x40, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00,
  0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0x10, 0x30,
  0x0E, 0xFC, 0x7E, 0x0E, 0xFE, 0xFE, 0x1F, 0xBF, 0xBE, 0x1E, 0x1F, 0x0F,
  0x1E, 0x0E, 0x0F, 0x1E, 0x0E, 0x0E, 0x1C, 0x1E, 0x0E, 0x1C, 0x1C, 0x1E,
  0x3C, 0x1C, 0x1E, 0x3C, 0x1C, 0x1E, 0x3C, 0x1C, 0x1E, 0x3C, 0x1C, 0x1E,
  0x38, 0x3C, 0x1C, 0x38, 0x3C, 0x1C, 0x78, 0x38, 0x3C, 0x78, 0x38, 0x3C,
  0x78, 0x38, 0x3C, 0x78, 0x38, 0x3C, 0x78, 0x38, 0x38, 0x70, 0x78, 0x38,
  0x70, 0x70, 0x78, 0xF0, 0x70, 0x78, 0xF0, 0x70, 0x78, 0xF0, 0x70, 0x78,
  0x00, 0x07, 0x00, 0x3C, 0xFF, 0x80, 0xF7, 0xFF, 0x07, 0xBF, 0xFC, 0x1E,
  0xC0, 0xF8, 0x7C, 0x01, 0xE1, 0xF0, 0x07, 0x87, 0x80, 0x1E, 0x1E, 0x00,
  0x78, 0x78, 0x01, 0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x1E, 0x3C, 0x00, 0x78,
  0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x0F, 0x00, 0x3C, 0x78, 0x00, 0xF1, 0xE0,
  0x03, 0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x78, 0x78, 0x01, 0xE1, 0xE0, 0x07,
  0x8F, 0x00, 0x1E, 0x3C, 0x00, 0x78, 0xF0, 0x01, 0xE0, 0x00, 0x1C, 0x00,
  0x0F, 0xFC, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0xC1, 0xF8, 0x3F, 0x0F, 0x00,
  0xF8, 0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x00, 0xF3, 0xC0, 0x07, 0x9E,
  0x00, 0x3C, 0xF0, 0x01, 0xE7, 0x80, 0x0F, 0x3C, 0x00, 0xF1, 0xE0, 0x07,
  0x9E, 0x00, 0x3C, 0xF0, 0x01, 0xE7, 0x80, 0x0F, 0x3C, 0x00, 0xF1, 0xE0,
  0x07, 0x8F, 0x80, 0x78, 0x3E, 0x0F, 0xC1, 0xFF, 0xFC, 0x07, 0xFF, 0xC0,
  0x0F, 0xF8, 0x00, 0x00, 0x01, 0x80, 0x0F, 0x3F, 0xE0, 0x1E, 0xFF, 0xE0,
  0x7B, 0xFF, 0xC0, 0xF6, 0x0F, 0xC1, 0xF0, 0x0F, 0x83, 0xE0, 0x0F, 0x07,
  0x80, 0x1E, 0x0F, 0x00, 0x3C, 0x1E, 0x00, 0x78, 0x78, 0x00, 0xF0, 0xF0,
  0x01, 0xE1, 0xE0, 0x03, 0xC3, 0xC0, 0x0F, 0x07, 0x80, 0x1E, 0x0F, 0x00,
  0x3C, 0x3C, 0x00, 0x78, 0x78, 0x00, 0xF0, 0xF0, 0x03, 0xC1, 0xF0, 0x07,
  0x83, 0xE0, 0x1F, 0x07, 0xF0, 0xFC, 0x1E, 0xFF, 0xF0, 0x3C, 0xFF, 0xC0,
  0x78, 0xFF, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x1F, 0xF3, 0xC1, 0xFF, 0xDE, 0x1F, 0xFE,
  0xF1, 0xF8, 0x37, 0x8F, 0x00, 0xFC, 0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x3C,
  0x00, 0xF3, 0xC0, 0x07, 0x9E, 0x00, 0x3C, 0xF0, 0x01, 0xE7, 0x80, 0x1E,
  0x3C, 0x00, 0xF1, 0xE0, 0x07, 0x9E, 0x00, 0x3C, 0xF0, 0x01, 0xE7, 0x80,
  0x0F, 0x3C, 0x00, 0xF1, 0xE0, 0x07, 0x8F, 0x80, 0x7C, 0x3E, 0x0F, 0xE1,
  0xFF, 0xEF, 0x07, 0xFE, 0x78, 0x1F, 0xE3, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x3C, 0xFF, 0x01, 0xE7,
  0xFF, 0x07, 0xBF, 0xFC, 0x1F, 0xC0, 0xF8, 0x7C, 0x01, 0xE1, 0xE0, 0x07,
  0x87, 0x80, 0x1E, 0x1E, 0x00, 0x78, 0xF0, 0x01, 0xE3, 0xC0, 0x07, 0x8F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xE0, 0xFF, 0xFF,
  0x1F, 0x01, 0xF1, 0xE0, 0x0F, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x3F,
  0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xEF, 0x00, 0x3C, 0xF0, 0x03, 0xCF, 0x80, 0xFC, 0xFF, 0xFF, 0x87,
  0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x1E, 0x00, 0x78, 0xF0, 0x03, 0xCF, 0x00, 0x1E, 0x78,
  0x00, 0xF3, 0xC0, 0x07, 0x9E, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x1E,
  0x78, 0x00, 0xF3, 0xC0, 0x07, 0x9E, 0x00, 0x3C, 0xF0, 0x01, 0xE7, 0x80,
  0x1E, 0x3C, 0x00, 0xF1, 0xE0, 0x07, 0x9E, 0x00, 0x3C, 0xF0, 0x01, 0xE7,
  0x80, 0x1E, 0x3E, 0x00, 0xF0, 0xF0, 0x0F, 0x07, 0xC1, 0xF8, 0x3F, 0xFF,
  0x80, 0xFF, 0xF8, 0x01, 0xFF, 0x00, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xBC,
  0x00, 0x79, 0xE0, 0x03, 0xCF, 0x00, 0x3C, 0x78, 0x01, 0xE1, 0xE0, 0x1E,
  0x0F, 0x00, 0xF0, 0x78, 0x0F, 0x03, 0xC0, 0x78, 0x1E, 0x03, 0x80, 0xF0,
  0x3C, 0x03, 0x81, 0xE0, 0x1E, 0x1E, 0x00, 0xF0, 0xF0, 0x07, 0x8F, 0x00,
  0x3C, 0x78, 0x01, 0xE7, 0x80, 0x07, 0x3C, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0xF0, 0x3C, 0x0F,
  0xF0, 0x3C, 0x0E, 0xF0, 0x7C, 0x0E, 0xF0, 0x6C, 0x1E, 0xF0, 0x6C, 0x1C,
  0xF0, 0xEC, 0x1C, 0xF0, 0xCC, 0x3C, 0xF0, 0xCC, 0x38, 0xF1, 0xCC, 0x38,
  0xF1, 0x8C, 0x78, 0xF1, 0x8C, 0x70, 0xF3, 0x8C, 0x70, 0xF3, 0x8C, 0x70,
  0xF3, 0x0C, 0xE0, 0xF7, 0x0C, 0xE0, 0xF7, 0x0C, 0xE0, 0xF6, 0x0D, 0xC0,
  0xEE, 0x0D, 0xC0, 0xEE, 0x0D, 0xC0, 0xEC, 0x0F, 0x80, 0xEC, 0x0F, 0x80,
  0xFC, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0xF8, 0x0F, 0x00, 0x07, 0xC0, 0x0F,
  0x81, 0xE0, 0x0F, 0x80, 0xF8, 0x07, 0x80, 0x3C, 0x07, 0x80, 0x1F, 0x07,
  0xC0, 0x07, 0x87, 0xC0, 0x03, 0xC3, 0xC0, 0x00, 0xF3, 0xC0, 0x00, 0x7B,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xEF, 0x80, 0x01,
  0xE3, 0xC0, 0x01, 0xE1, 0xF0, 0x01, 0xF0, 0x78, 0x01, 0xF0, 0x3E, 0x01,
  0xF0, 0x0F, 0x00, 0xF0, 0x07, 0xC0, 0xF0, 0x01, 0xE1, 0xF8, 0x00, 0xF8,
  0x1E, 0x00, 0x78, 0xF0, 0x03, 0xCF, 0x00, 0x1E, 0x78, 0x00, 0xF3, 0xC0,
  0x07, 0x9E, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x00, 0xF3,
  0xC0, 0x07, 0x9E, 0x00, 0x3C, 0xF0, 0x01, 0xC7, 0x80, 0x1E, 0x3C, 0x00,
  0xF1, 0xE0, 0x07, 0x8F, 0x00, 0x3C, 0x78, 0x03, 0xE3, 0xE0, 0x2F, 0x1F,
  0x87, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xBC, 0x07, 0xF1, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x1F, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xFC, 0x00,
  0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x0C, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x1F, 0xFC,
  0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00,
  0x7C, 0x00, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0x78, 0x1E,
  0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x07,
  0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x00, 0x01, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x3C, 0xFF,
  0x80, 0xF3, 0xFF, 0x03, 0x9E, 0x7C, 0x1E, 0xF0, 0xF8, 0x7B, 0xC1, 0xF3,
  0xEF, 0x03, 0xFF, 0x3C, 0x07, 0xF8, 0xE0, 0x0F, 0x80,
};

const GFXglyph JetBrainsMono_Italic44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 26, 0, -1 },
  { 1, 11, 32, 26, 8, -32 },
  { 45, 15, 13, 26, 8, -32 },
  { 70, 26, 32, 26, 1, -32 },
  { 174, 23, 44, 26, 2, -38 },
  { 301, 30, 32, 26, -1, -32 },
  { 421, 24, 33, 26, 1, -33 },
  { 520, 6, 13, 26, 12, -32 },
  { 530, 18, 43, 26, 7, -37 },
  { 627, 18, 43, 26, 2, -37 },
  { 724, 24, 23, 26, 2, -27 },
  { 793, 21, 21, 26, 3, -25 },
  { 849, 12, 14, 26, 4, -7 },
  { 870, 15, 3, 26, 6, -16 },
  { 876, 8, 7, 26, 8, -7 },
  { 883, 26, 42, 26, 1, -37 },
  { 1020, 22, 33, 26, 3, -33 },
  { 1111, 20, 32, 26, 2, -32 },
  { 1191, 23, 33, 26, 2, -33 },
  { 1286, 23, 32, 26, 2, -32 },
  { 1378, 21, 32, 26, 3, -32 },
  { 1462, 22, 32, 26, 3, -32 },
  { 1550, 22, 32, 26, 2, -32 },
  { 1638, 22, 32, 26, 5, -32 },
  { 1726, 23, 33, 26, 2, -33 },
  { 1821, 21, 33, 26, 4, -33 },
  { 1908, 11, 25, 26, 8, -25 },
  { 1943, 15, 32, 26, 4, -25 },
  { 2003, 21, 23, 26, 4, -26 },
  { 2064, 21, 15, 26, 3, -22 },
  { 2104, 21, 23, 26, 2, -26 },
  { 2165, 18, 32, 26, 6, -32 },
  { 2237, 27, 41, 26, 0, -33 },
  { 2376, 22, 32, 26, 0, -32 },
  { 2464, 23, 32, 26, 2, -32 },
  { 2556, 22, 33, 26, 3, -33 },
  { 2647, 23, 32, 26, 2, -32 },
  { 2739, 24, 32, 26, 2, -32 },
  { 2835, 24, 32, 26, 2, -32 },
  { 2931, 22, 33, 26, 3, -33 },
  { 3022, 23, 32, 26, 2, -32 },
  { 3114, 22, 32, 26, 3, -32 },
  { 3202, 24, 32, 26, 1, -32 },
  { 3298, 25, 32, 26, 2, -32 },
  { 3398, 19, 32, 26, 3, -32 },
  { 3474, 25, 32, 26, 1, -32 },
  { 3574, 24, 32, 26, 2, -32 },
  { 3670, 22, 33, 26, 3, -33 },
  { 3761, 24, 32, 26, 2, -32 },
  { 3857, 22, 41, 26, 3, -33 },
  { 3970, 24, 32, 26, 2, -32 },
  { 4066, 23, 33, 26, 2, -33 },
  { 4161, 22, 32, 26, 5, -32 },
  { 4249, 23, 32, 26, 3, -32 },
  { 4341, 22, 32, 26, 5, -32 },
  { 4429, 25, 32, 26, 3, -32 },
  { 4529, 27, 32, 26, 0, -32 },
  { 4637, 23, 32, 26, 5, -32 },
  { 4729, 23, 32, 26, 2, -32 },
  { 4821, 18, 42, 26, 6, -37 },
  { 4916, 13, 42, 26, 7, -37 },
  { 4985, 17, 42, 26, 4, -37 },
  { 5075, 19, 17, 26, 4, -32 },
  { 5116, 22, 3, 26, 0, 1 },
  { 5125, 8, 7, 26, 12, -35 },
  { 5132, 21, 25, 26, 3, -25 },
  { 5198, 22, 32, 26, 2, -32 },
  { 5286, 21, 25, 26, 3, -25 },
  { 5352, 23, 32, 26, 3, -32 },
  { 5444, 21, 25, 26, 3, -25 },
  { 5510, 30, 40, 26, -2, -32 },
  { 5660, 21, 33, 26, 3, -25 },
  { 5747, 22, 32, 26, 2, -32 },
  { 5835, 21, 34, 26, 2, -34 },
  { 5925, 22, 42, 26, 1, -34 },
  { 6041, 24, 32, 26, 2, -32 },
  { 6137, 19, 32, 26, 4, -32 },
  { 6213, 24, 25, 26, 1, -25 },
  { 6288, 22, 25, 26, 2, -25 },
  { 6357, 21, 25, 26, 3, -25 },
  { 6423, 23, 33, 26, 1, -25 },
  { 6518, 21, 33, 26, 3, -25 },
  { 6605, 22, 25, 26, 3, -25 },
  { 6674, 20, 25, 26, 3, -25 },
  { 6737, 21, 31, 26, 4, -31 },
  { 6819, 21, 24, 26, 3, -24 },
  { 6882, 21, 24, 26, 5, -24 },
  { 6945, 24, 24, 26, 3, -24 },
  { 7017, 25, 24, 26, 0, -24 },
  { 7092, 21, 32, 26, 3, -24 },
  { 7176, 22, 24, 26, 2, -24 },
  { 7242, 22, 42, 26, 4, -37 },
  { 7358, 10, 42, 26, 9, -37 },
  { 7411, 23, 42, 26, 1, -37 },
  { 7532, 22, 9, 26, 3, -20 },
};

const GFXfont JetBrainsMono_Italic44pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Italic44pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Italic44pt7bGlyphs,
  0x20, 0x7E, 58
};

#endif // _JETBRAINSMONO_ITALIC44PT7B_H_
