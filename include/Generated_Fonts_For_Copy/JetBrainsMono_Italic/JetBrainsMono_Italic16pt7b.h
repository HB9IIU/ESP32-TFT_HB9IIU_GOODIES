#ifndef _JETBRAINSMONO_ITALIC16PT7B_H_
#define _JETBRAINSMONO_ITALIC16PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Italic.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Italic16pt7bBitmaps[] PROGMEM = {
  0x00, 0x33, 0x22, 0x26, 0x64, 0x40, 0xCC, 0x4E, 0x77, 0x39, 0x80, 0x04,
  0x82, 0x20, 0x88, 0x24, 0x3F, 0xC4, 0xC3, 0x20, 0x88, 0xFF, 0x19, 0x04,
  0x41, 0x30, 0x04, 0x04, 0x1E, 0x3F, 0x69, 0x68, 0x68, 0x38, 0x1E, 0x16,
  0x12, 0x92, 0xD6, 0x7C, 0x10, 0x20, 0x38, 0x6D, 0x99, 0x36, 0x24, 0x87,
  0xA0, 0x68, 0x02, 0x00, 0xFC, 0x34, 0x84, 0x91, 0x32, 0x43, 0x80, 0x0E,
  0x0D, 0x8C, 0x46, 0x01, 0x01, 0xC1, 0xA2, 0x9A, 0x47, 0x23, 0x13, 0x8F,
  0x60, 0xEA, 0x80, 0x04, 0x31, 0x08, 0x61, 0x0C, 0x30, 0xC2, 0x08, 0x20,
  0xC3, 0x07, 0x0C, 0x20, 0xC1, 0x83, 0x04, 0x10, 0x41, 0x0C, 0x30, 0x82,
  0x18, 0xCE, 0x20, 0x08, 0x08, 0x89, 0xEF, 0x3C, 0x38, 0x6C, 0xC6, 0x44,
  0x08, 0x08, 0x18, 0xFF, 0x18, 0x10, 0x10, 0x39, 0x98, 0x8C, 0x00, 0xFC,
  0x5F, 0x00, 0x00, 0xC0, 0x60, 0x10, 0x0C, 0x02, 0x01, 0x80, 0x40, 0x30,
  0x08, 0x06, 0x03, 0x00, 0xC0, 0x60, 0x10, 0x0C, 0x00, 0x1E, 0x37, 0x63,
  0x41, 0x43, 0x5B, 0xDA, 0xC2, 0xC2, 0x82, 0xC4, 0x78, 0x0C, 0x79, 0xB2,
  0x60, 0xC1, 0x02, 0x04, 0x18, 0x30, 0x67, 0xF0, 0x1E, 0x37, 0x63, 0x43,
  0x03, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC0, 0xFE, 0x3F, 0x3F, 0x06, 0x0C,
  0x10, 0x1E, 0x06, 0x02, 0x02, 0x86, 0xCC, 0x78, 0x03, 0x06, 0x0C, 0x18,
  0x10, 0x22, 0x62, 0xC2, 0xFE, 0x06, 0x06, 0x04, 0x3F, 0x3F, 0x60, 0x60,
  0x6C, 0x7E, 0x42, 0x02, 0x02, 0xC6, 0xC4, 0x78, 0x06, 0x0C, 0x18, 0x10,
  0x20, 0x7E, 0x42, 0xC2, 0x82, 0x82, 0xC6, 0x78, 0xFF, 0xFF, 0xC2, 0x06,
  0x0C, 0x08, 0x18, 0x10, 0x30, 0x20, 0x60, 0xC0, 0x1E, 0x37, 0x63, 0x63,
  0x62, 0x3C, 0x3C, 0x46, 0xC2, 0x82, 0xC6, 0x7C, 0x1E, 0x37, 0x61, 0x41,
  0x41, 0x43, 0x7E, 0x14, 0x0C, 0x18, 0x30, 0x60, 0x77, 0x00, 0x00, 0x0E,
  0xC0, 0x39, 0xC0, 0x00, 0x00, 0x4C, 0x66, 0x31, 0x00, 0x01, 0x03, 0x0E,
  0x30, 0x40, 0xE0, 0x38, 0x0E, 0x02, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x40,
  0x60, 0x38, 0x0F, 0x02, 0x0E, 0x38, 0xE0, 0x80, 0x78, 0xF8, 0x10, 0x30,
  0x41, 0x8E, 0x30, 0x60, 0x01, 0x87, 0x00, 0x0F, 0x06, 0x62, 0x0D, 0x83,
  0x47, 0x93, 0x24, 0x89, 0x22, 0x48, 0xB2, 0x6C, 0xF3, 0x00, 0xC0, 0x18,
  0x03, 0x80, 0x06, 0x0E, 0x0A, 0x0A, 0x1A, 0x12, 0x33, 0x23, 0x3F, 0x63,
  0x41, 0xC1, 0x3C, 0x7F, 0x63, 0x63, 0x42, 0x7C, 0x7E, 0xC2, 0xC2, 0xC2,
  0x8E, 0xF8, 0x1E, 0x37, 0x63, 0x43, 0x40, 0x40, 0x40, 0xC0, 0xC0, 0xC6,
  0xC4, 0x78, 0x3C, 0x7E, 0x63, 0x63, 0x43, 0x43, 0x42, 0xC2, 0xC2, 0xC6,
  0x8C, 0xF8, 0x3F, 0x3F, 0x60, 0x60, 0x60, 0x7E, 0x7E, 0x40, 0xC0, 0xC0,
  0xC0, 0xFE, 0x3F, 0xBF, 0x98, 0x0C, 0x04, 0x03, 0xF1, 0xF8, 0x80, 0xC0,
  0x60, 0x20, 0x10, 0x00, 0x1E, 0x37, 0x63, 0x43, 0x40, 0x40, 0x4F, 0xC2,
  0xC2, 0xC6, 0xC4, 0x78, 0x21, 0x61, 0x63, 0x63, 0x43, 0x7E, 0x7E, 0xC2,
  0xC2, 0xC6, 0x86, 0x84, 0x3F, 0x3F, 0x08, 0x08, 0x08, 0x18, 0x18, 0x18,
  0x10, 0x10, 0x10, 0xFC, 0x07, 0x83, 0xC0, 0x60, 0x30, 0x10, 0x08, 0x04,
  0x06, 0x03, 0x61, 0x99, 0x8F, 0x80, 0x21, 0xB0, 0x98, 0x8C, 0xC4, 0x43,
  0xC1, 0xE1, 0x98, 0xCC, 0x62, 0x21, 0x90, 0xC0, 0x20, 0x40, 0x83, 0x06,
  0x0C, 0x10, 0x20, 0x40, 0x83, 0x07, 0xF0, 0x61, 0xB1, 0x9C, 0xCA, 0xA5,
  0x52, 0xDB, 0x6D, 0x84, 0x82, 0x41, 0x20, 0x90, 0xC0, 0x31, 0x71, 0x71,
  0x53, 0x53, 0x5A, 0x5A, 0xCA, 0xCA, 0xCA, 0x8E, 0x8E, 0x1E, 0x37, 0x63,
  0x43, 0x43, 0x43, 0x42, 0xC2, 0xC2, 0xC6, 0xC4, 0x78, 0x3E, 0x3F, 0x98,
  0x4C, 0x24, 0x12, 0x19, 0xF9, 0x80, 0xC0, 0x60, 0x20, 0x10, 0x00, 0x1E,
  0x37, 0x63, 0x41, 0x43, 0x43, 0xC2, 0xC2, 0xC2, 0xC6, 0xC4, 0x78, 0x08,
  0x0C, 0x0C, 0x3C, 0x7F, 0x61, 0x61, 0x43, 0x46, 0x7C, 0xCC, 0xCC, 0xC4,
  0x86, 0x86, 0x1E, 0x37, 0x61, 0x60, 0x60, 0x38, 0x1E, 0x06, 0x02, 0x82,
  0xC6, 0x7C, 0xFF, 0xFF, 0x10, 0x10, 0x10, 0x30, 0x30, 0x30, 0x20, 0x20,
  0x20, 0x60, 0x21, 0x61, 0x61, 0x63, 0x43, 0x42, 0x42, 0xC2, 0xC2, 0xC6,
  0xC4, 0x78, 0x83, 0xC2, 0xC2, 0xC6, 0xC4, 0xCC, 0x48, 0x48, 0x58, 0x50,
  0x70, 0x60, 0x4C, 0xE6, 0x73, 0x7A, 0xAD, 0x56, 0xAB, 0x9D, 0x54, 0xAA,
  0x55, 0x33, 0x99, 0x80, 0x30, 0xCC, 0x61, 0x10, 0x6C, 0x0E, 0x03, 0x00,
  0xC0, 0x70, 0x36, 0x08, 0x86, 0x33, 0x0C, 0x81, 0xC2, 0xC6, 0x44, 0x6C,
  0x78, 0x30, 0x30, 0x20, 0x20, 0x20, 0x60, 0x3F, 0x7F, 0x02, 0x06, 0x0C,
  0x08, 0x10, 0x30, 0x60, 0x40, 0xC0, 0xFE, 0x1E, 0x60, 0xC1, 0x82, 0x04,
  0x08, 0x30, 0x60, 0xC1, 0x02, 0x04, 0x1E, 0x3C, 0x00, 0x88, 0xCC, 0x44,
  0x66, 0x22, 0x23, 0x31, 0x10, 0x1E, 0x08, 0x10, 0x20, 0x41, 0x83, 0x04,
  0x08, 0x10, 0x20, 0xC1, 0x8F, 0x3C, 0x00, 0x0C, 0x18, 0x51, 0xB2, 0x28,
  0x70, 0x80, 0xFF, 0xFF, 0xC8, 0x80, 0x3F, 0x67, 0x42, 0x42, 0xC2, 0xC2,
  0xC6, 0xC6, 0x7E, 0x20, 0x60, 0x60, 0x7E, 0x66, 0x42, 0x42, 0xC2, 0xC2,
  0xC6, 0xC4, 0xBC, 0x1C, 0x66, 0x43, 0x40, 0xC0, 0xC0, 0xC6, 0xC6, 0x78,
  0x01, 0x01, 0x03, 0x3F, 0x67, 0x42, 0x42, 0xC2, 0xC2, 0xC6, 0xC6, 0x7E,
  0x1C, 0x66, 0x42, 0x42, 0xFE, 0xC0, 0xC0, 0xC6, 0x78, 0x01, 0xE0, 0x7C,
  0x18, 0x03, 0x03, 0xFC, 0x08, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x20,
  0x04, 0x00, 0x80, 0x30, 0x3C, 0x00, 0x3F, 0x67, 0x42, 0x42, 0xC2, 0xC2,
  0xC6, 0x7E, 0x06, 0x04, 0x0C, 0xF8, 0x20, 0x60, 0x60, 0x7E, 0x66, 0x42,
  0x42, 0xC2, 0xC2, 0xC6, 0x86, 0x86, 0x0C, 0x18, 0x03, 0xE7, 0x81, 0x02,
  0x0C, 0x18, 0x30, 0x47, 0xF0, 0x03, 0x01, 0x00, 0x3F, 0x3E, 0x02, 0x02,
  0x02, 0x06, 0x06, 0x06, 0x04, 0x04, 0x18, 0xF0, 0x20, 0x60, 0x60, 0x63,
  0x42, 0x44, 0x4C, 0x78, 0xC8, 0xCC, 0x84, 0x86, 0xF3, 0xC3, 0x08, 0x20,
  0x86, 0x18, 0x61, 0x06, 0x0F, 0x3F, 0x92, 0xD9, 0x2D, 0xB4, 0x9A, 0x49,
  0x24, 0x92, 0xC9, 0x00, 0x7E, 0x66, 0x42, 0x42, 0xC2, 0xC2, 0xC6, 0x86,
  0x86, 0x1C, 0x66, 0x42, 0x42, 0xC2, 0xC2, 0xC6, 0xC4, 0x78, 0x3F, 0x19,
  0x88, 0x44, 0x26, 0x13, 0x09, 0x8C, 0xC4, 0x5E, 0x20, 0x10, 0x18, 0x00,
  0x3F, 0x67, 0x42, 0x42, 0xC2, 0xC2, 0xC6, 0xC6, 0x7C, 0x04, 0x04, 0x04,
  0x6E, 0x73, 0x63, 0x43, 0x40, 0x40, 0xC0, 0xC0, 0xC0, 0x3E, 0x62, 0x41,
  0x60, 0x3C, 0x06, 0x06, 0xC6, 0x7C, 0x18, 0x18, 0x7F, 0xFF, 0x10, 0x10,
  0x30, 0x30, 0x20, 0x30, 0x3E, 0x63, 0x43, 0x42, 0x42, 0xC2, 0xC2, 0xC6,
  0xC4, 0x78, 0x83, 0x0E, 0x16, 0x6C, 0x8B, 0x14, 0x38, 0x60, 0x89, 0xCC,
  0xA6, 0x53, 0x2A, 0xA5, 0x52, 0xA9, 0x98, 0xCC, 0x00, 0x31, 0x98, 0x84,
  0x83, 0xC0, 0xC0, 0xE0, 0xD8, 0xC4, 0xC3, 0x00, 0x63, 0x43, 0x42, 0x42,
  0xC2, 0xC2, 0xC6, 0x7E, 0x06, 0x04, 0x0C, 0xF8, 0x7F, 0x7E, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC0, 0xFE, 0x07, 0x82, 0x01, 0x01, 0x80, 0xC0, 0x60,
  0x61, 0xE0, 0x08, 0x04, 0x06, 0x03, 0x01, 0x00, 0xE0, 0x30, 0x33, 0x22,
  0x22, 0x66, 0x64, 0x44, 0xCC, 0xC0, 0x1C, 0x06, 0x01, 0x01, 0x80, 0xC0,
  0x40, 0x32, 0x1E, 0x08, 0x0C, 0x06, 0x03, 0x01, 0x03, 0x83, 0x80, 0x71,
  0xDB, 0x8E,
};

const GFXglyph JetBrainsMono_Italic16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 4, 12, 10, 3, -12 },
  { 7, 5, 5, 10, 3, -12 },
  { 11, 10, 12, 10, 0, -12 },
  { 26, 8, 16, 10, 1, -14 },
  { 42, 11, 12, 10, 0, -12 },
  { 59, 9, 12, 10, 0, -12 },
  { 73, 2, 5, 10, 5, -12 },
  { 75, 6, 16, 10, 3, -14 },
  { 87, 6, 16, 10, 1, -14 },
  { 99, 8, 9, 10, 1, -10 },
  { 108, 8, 7, 10, 1, -9 },
  { 115, 5, 5, 10, 1, -2 },
  { 119, 6, 1, 10, 2, -6 },
  { 120, 3, 3, 10, 3, -3 },
  { 122, 10, 15, 10, 0, -13 },
  { 141, 8, 12, 10, 1, -12 },
  { 153, 7, 12, 10, 1, -12 },
  { 164, 8, 12, 10, 1, -12 },
  { 176, 8, 12, 10, 1, -12 },
  { 188, 8, 12, 10, 1, -12 },
  { 200, 8, 12, 10, 1, -12 },
  { 212, 8, 12, 10, 1, -12 },
  { 224, 8, 12, 10, 2, -12 },
  { 236, 8, 12, 10, 1, -12 },
  { 248, 8, 12, 10, 1, -12 },
  { 260, 4, 9, 10, 3, -9 },
  { 265, 5, 12, 10, 2, -9 },
  { 273, 8, 9, 10, 1, -10 },
  { 282, 8, 5, 10, 1, -8 },
  { 287, 8, 9, 10, 1, -10 },
  { 296, 7, 12, 10, 2, -12 },
  { 307, 10, 15, 10, 0, -12 },
  { 326, 8, 12, 10, 0, -12 },
  { 338, 8, 12, 10, 1, -12 },
  { 350, 8, 12, 10, 1, -12 },
  { 362, 8, 12, 10, 1, -12 },
  { 374, 8, 12, 10, 1, -12 },
  { 386, 9, 12, 10, 1, -12 },
  { 400, 8, 12, 10, 1, -12 },
  { 412, 8, 12, 10, 1, -12 },
  { 424, 8, 12, 10, 1, -12 },
  { 436, 9, 12, 10, 0, -12 },
  { 450, 9, 12, 10, 1, -12 },
  { 464, 7, 12, 10, 1, -12 },
  { 475, 9, 12, 10, 1, -12 },
  { 489, 8, 12, 10, 1, -12 },
  { 501, 8, 12, 10, 1, -12 },
  { 513, 9, 12, 10, 1, -12 },
  { 527, 8, 15, 10, 1, -12 },
  { 542, 8, 12, 10, 1, -12 },
  { 554, 8, 12, 10, 1, -12 },
  { 566, 8, 12, 10, 2, -12 },
  { 578, 8, 12, 10, 1, -12 },
  { 590, 8, 12, 10, 2, -12 },
  { 602, 9, 12, 10, 1, -12 },
  { 616, 10, 12, 10, 0, -12 },
  { 631, 8, 12, 10, 2, -12 },
  { 643, 8, 12, 10, 1, -12 },
  { 655, 7, 15, 10, 2, -13 },
  { 669, 4, 15, 10, 3, -13 },
  { 677, 7, 15, 10, 1, -13 },
  { 691, 7, 7, 10, 1, -12 },
  { 698, 8, 2, 10, 0, 0 },
  { 700, 3, 3, 10, 4, -13 },
  { 702, 8, 9, 10, 1, -9 },
  { 711, 8, 12, 10, 1, -12 },
  { 723, 8, 9, 10, 1, -9 },
  { 732, 8, 12, 10, 1, -12 },
  { 744, 8, 9, 10, 1, -9 },
  { 753, 11, 15, 10, -1, -12 },
  { 774, 8, 12, 10, 1, -9 },
  { 786, 8, 12, 10, 1, -12 },
  { 798, 7, 12, 10, 1, -12 },
  { 809, 8, 15, 10, 0, -12 },
  { 824, 8, 12, 10, 1, -12 },
  { 836, 6, 12, 10, 2, -12 },
  { 845, 9, 9, 10, 0, -9 },
  { 856, 8, 9, 10, 1, -9 },
  { 865, 8, 9, 10, 1, -9 },
  { 874, 9, 12, 10, 0, -9 },
  { 888, 8, 12, 10, 1, -9 },
  { 900, 8, 9, 10, 1, -9 },
  { 909, 8, 9, 10, 1, -9 },
  { 918, 8, 11, 10, 1, -11 },
  { 929, 8, 9, 10, 1, -9 },
  { 938, 7, 9, 10, 2, -9 },
  { 946, 9, 9, 10, 1, -9 },
  { 957, 9, 9, 10, 0, -9 },
  { 968, 8, 12, 10, 1, -9 },
  { 980, 8, 9, 10, 1, -9 },
  { 989, 9, 15, 10, 1, -13 },
  { 1006, 4, 15, 10, 3, -13 },
  { 1014, 9, 15, 10, 0, -13 },
  { 1031, 8, 3, 10, 1, -7 },
};

const GFXfont JetBrainsMono_Italic16pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Italic16pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Italic16pt7bGlyphs,
  0x20, 0x7E, 21
};

#endif // _JETBRAINSMONO_ITALIC16PT7B_H_
