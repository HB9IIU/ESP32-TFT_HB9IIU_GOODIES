#ifndef _JETBRAINSMONO_ITALIC23PT7B_H_
#define _JETBRAINSMONO_ITALIC23PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Italic.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Italic23pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x71, 0x86, 0x18, 0x61, 0x8C, 0x30, 0xC3, 0x0C, 0x00, 0x06,
  0x3C, 0xE0, 0x63, 0x63, 0x67, 0x66, 0x66, 0xC6, 0xC6, 0x02, 0x18, 0x31,
  0x81, 0x8C, 0x18, 0x40, 0xC6, 0x3F, 0xFC, 0x61, 0x03, 0x18, 0x10, 0xC1,
  0x84, 0x0C, 0x61, 0xFF, 0xC6, 0x10, 0x31, 0x81, 0x0C, 0x18, 0x40, 0xC6,
  0x00, 0x01, 0x80, 0x18, 0x01, 0x00, 0x7C, 0x0F, 0xE1, 0x97, 0x33, 0x33,
  0x30, 0x33, 0x03, 0xA0, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x6E, 0x06, 0x60,
  0x46, 0xC4, 0x6E, 0x4C, 0x7F, 0x83, 0xF0, 0x0C, 0x00, 0x80, 0x08, 0x00,
  0x0F, 0x03, 0x1F, 0x86, 0x11, 0x8C, 0x31, 0x88, 0x31, 0x98, 0x31, 0xB0,
  0x3F, 0x60, 0x0E, 0xC0, 0x01, 0x80, 0x01, 0x30, 0x03, 0x7C, 0x06, 0xCC,
  0x0C, 0x8C, 0x18, 0x8C, 0x31, 0x8C, 0x20, 0xD8, 0xC0, 0xF0, 0x07, 0x81,
  0xFC, 0x18, 0xE3, 0x06, 0x30, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x7C, 0x06,
  0xE3, 0xC6, 0x6C, 0x3C, 0xC3, 0x8C, 0x18, 0xC3, 0xCF, 0xEC, 0x7C, 0xE0,
  0x76, 0x66, 0x66, 0xC0, 0x01, 0x83, 0xC3, 0x83, 0x03, 0x81, 0x81, 0xC0,
  0xC0, 0x60, 0x30, 0x18, 0x1C, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x30,
  0x1C, 0x07, 0x01, 0xC0, 0x20, 0x0C, 0x07, 0x80, 0x70, 0x0E, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x03, 0x80, 0xC0, 0x30,
  0x0C, 0x06, 0x03, 0x81, 0xC0, 0xE0, 0xF0, 0x20, 0x00, 0x03, 0x00, 0x30,
  0x03, 0x04, 0x21, 0xF2, 0x77, 0xFE, 0x06, 0x00, 0xF0, 0x1B, 0x83, 0x18,
  0x71, 0xC2, 0x08, 0x06, 0x00, 0xC0, 0x18, 0x06, 0x0F, 0xFF, 0xFF, 0x83,
  0x00, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x00, 0x1C, 0xE3, 0x9C, 0x61, 0x8C,
  0x00, 0x7F, 0xFF, 0x27, 0xFF, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x80, 0x0C,
  0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x30,
  0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0xE0,
  0x03, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x00, 0x07, 0xC1, 0xFE, 0x18,
  0x73, 0x03, 0x30, 0x33, 0x03, 0x60, 0x36, 0x66, 0x67, 0x66, 0x66, 0x60,
  0x66, 0x06, 0x60, 0x6E, 0x0C, 0x60, 0xC7, 0xF8, 0x3F, 0x00, 0x03, 0x80,
  0xF0, 0x76, 0x1C, 0xC2, 0x18, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x03, 0x80, 0x60, 0x0C, 0x01, 0x87, 0xFF, 0xFF, 0xC0, 0x07, 0xC1,
  0xFE, 0x18, 0x73, 0x03, 0x30, 0x30, 0x03, 0x00, 0x60, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x60, 0x0F, 0xFC, 0xFF, 0xC0,
  0x1F, 0xF1, 0xFF, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x70, 0x07, 0x00, 0xFC,
  0x01, 0xC0, 0x0E, 0x00, 0x60, 0x06, 0xC0, 0xCC, 0x0C, 0xE1, 0xC7, 0xF8,
  0x3F, 0x00, 0x00, 0x60, 0x18, 0x07, 0x01, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC3, 0x38, 0x6E, 0x0D, 0x83, 0xBF, 0xE7, 0xFD, 0x01, 0x80, 0x30, 0x06,
  0x01, 0xC0, 0x1F, 0xF1, 0xFF, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x37,
  0x83, 0xFC, 0x30, 0xE7, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE6, 0x0C, 0x60,
  0xC7, 0xF8, 0x3F, 0x00, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x80, 0x60, 0x18,
  0x06, 0x01, 0xBE, 0x38, 0xEC, 0x0D, 0x81, 0xF0, 0x3C, 0x07, 0x81, 0xD8,
  0x33, 0xFC, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0x03, 0x60, 0x6C, 0x18, 0x03,
  0x00, 0xC0, 0x18, 0x06, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0x80, 0x60, 0x0C,
  0x03, 0x00, 0xE0, 0x00, 0x07, 0xC1, 0xFE, 0x18, 0x73, 0x03, 0x30, 0x33,
  0x06, 0x18, 0xE1, 0xF8, 0x0F, 0x03, 0x9C, 0x70, 0xC6, 0x06, 0x60, 0x6E,
  0x0C, 0x60, 0xC7, 0xF8, 0x3F, 0x00, 0x0F, 0x87, 0xF8, 0xC3, 0xB0, 0x36,
  0x07, 0x80, 0xF0, 0x1F, 0x06, 0x61, 0xCF, 0xF0, 0x6E, 0x01, 0x80, 0x60,
  0x18, 0x07, 0x01, 0xC0, 0x70, 0x00, 0x18, 0xF3, 0x84, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x3C, 0xF0, 0x06, 0x0F, 0x0E, 0x04, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x38, 0x38, 0x30, 0x60, 0x60, 0xC0, 0x00, 0x20, 0x1C,
  0x0F, 0x87, 0x83, 0xC1, 0xE0, 0x30, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x1E,
  0x00, 0xC0, 0x04, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xBF,
  0xF0, 0x20, 0x06, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x18, 0x0F,
  0x07, 0x87, 0xC3, 0xC0, 0x60, 0x08, 0x00, 0x3E, 0x3F, 0x80, 0xE0, 0x30,
  0x18, 0x0C, 0x06, 0x06, 0x3E, 0x1E, 0x0C, 0x06, 0x00, 0x00, 0x01, 0x81,
  0xE0, 0xE0, 0x00, 0x03, 0xF0, 0x3F, 0xE1, 0xC1, 0x86, 0x03, 0x30, 0x0C,
  0xC0, 0x33, 0x1E, 0xC8, 0xE6, 0x63, 0x19, 0x8C, 0x66, 0x21, 0x99, 0x86,
  0x66, 0x19, 0x18, 0xCC, 0x7D, 0x30, 0xEC, 0xC0, 0x03, 0x80, 0x06, 0x00,
  0x0F, 0xC0, 0x1F, 0x00, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x3C, 0x06, 0xC0,
  0x64, 0x06, 0x60, 0xC6, 0x0C, 0x61, 0x86, 0x18, 0x63, 0xFE, 0x3F, 0xE3,
  0x06, 0x60, 0x66, 0x06, 0xE0, 0x30, 0x1F, 0xC1, 0xFE, 0x30, 0x73, 0x03,
  0x30, 0x33, 0x07, 0x30, 0x63, 0xFC, 0x7F, 0xC6, 0x0E, 0x60, 0x66, 0x06,
  0x60, 0x66, 0x0E, 0x60, 0xCF, 0xF8, 0xFF, 0x00, 0x0F, 0x83, 0xF8, 0xC3,
  0xB0, 0x36, 0x06, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x0D, 0x83, 0x30, 0x67, 0xF8, 0x7E, 0x00, 0x1F, 0x81, 0xFE, 0x30,
  0x63, 0x07, 0x30, 0x33, 0x03, 0x30, 0x63, 0x06, 0x70, 0x66, 0x06, 0x60,
  0x66, 0x06, 0x60, 0xC6, 0x0C, 0x61, 0xCF, 0xF8, 0xFE, 0x00, 0x1F, 0xF8,
  0xFF, 0x86, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x07, 0xFC, 0x3F,
  0xC3, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0F, 0xF8,
  0xFF, 0xC0, 0x1F, 0xF8, 0xFF, 0xCC, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x3F, 0xE3, 0xFF, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x18, 0x00, 0xC0, 0x00, 0x0F, 0x83, 0xF8, 0xC3, 0xB0, 0x36,
  0x06, 0xC0, 0x18, 0x03, 0x00, 0xC7, 0xD8, 0xFB, 0x23, 0x60, 0x6C, 0x0D,
  0x83, 0x30, 0x67, 0xF8, 0x7E, 0x00, 0x18, 0x31, 0x83, 0x30, 0x33, 0x03,
  0x30, 0x33, 0x06, 0x30, 0x63, 0xFE, 0x7F, 0xE6, 0x06, 0x60, 0x66, 0x0E,
  0x60, 0xC6, 0x0C, 0x60, 0xCC, 0x0C, 0xC0, 0xC0, 0x1F, 0xF1, 0xFF, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0xE0, 0x0C, 0x07, 0xFC, 0xFF, 0x80, 0x01, 0xF8,
  0x0F, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x03, 0x80, 0x18, 0x00, 0xC6, 0x06, 0x30, 0x31, 0x83, 0x0F, 0xF8,
  0x3F, 0x00, 0x18, 0x18, 0xC1, 0x8C, 0x1C, 0x60, 0xC3, 0x0C, 0x18, 0xE0,
  0xC6, 0x07, 0xE0, 0x7F, 0x03, 0x18, 0x18, 0xE0, 0xC3, 0x06, 0x18, 0x30,
  0xE1, 0x83, 0x18, 0x18, 0xC0, 0xE0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x1C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x0C,
  0x03, 0xFF, 0xFF, 0x80, 0x38, 0x39, 0xC3, 0x8E, 0x1C, 0x59, 0xA2, 0xCF,
  0x16, 0xD9, 0xB6, 0xCC, 0xA6, 0x67, 0x63, 0x33, 0x18, 0x18, 0xC0, 0xCC,
  0x06, 0x60, 0x33, 0x03, 0x18, 0x18, 0xC0, 0xC0, 0x1C, 0x31, 0xC3, 0x3C,
  0x33, 0xC3, 0x3C, 0x33, 0x63, 0x36, 0x63, 0x66, 0x66, 0x66, 0x66, 0x63,
  0x66, 0x36, 0x63, 0x46, 0x3C, 0xC3, 0xCC, 0x1C, 0xC1, 0xC0, 0x0F, 0x83,
  0xF8, 0xC3, 0xB0, 0x36, 0x06, 0xC0, 0xD8, 0x33, 0x06, 0xC0, 0xD8, 0x1B,
  0x03, 0x60, 0x6C, 0x19, 0x83, 0x30, 0xE7, 0xF8, 0x7E, 0x00, 0x1F, 0xC0,
  0xFF, 0x8C, 0x1C, 0x60, 0x73, 0x03, 0x98, 0x18, 0xC0, 0xC6, 0x0E, 0x7F,
  0xE3, 0xFC, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00,
  0xC0, 0x00, 0x07, 0xC1, 0xFE, 0x18, 0x73, 0x03, 0x30, 0x33, 0x03, 0x70,
  0x36, 0x06, 0x60, 0x66, 0x06, 0x60, 0x66, 0x06, 0x60, 0x6E, 0x0C, 0x61,
  0xC7, 0xF8, 0x3F, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0x80, 0x1F, 0xC1,
  0xFE, 0x30, 0x73, 0x03, 0x30, 0x33, 0x03, 0x30, 0x33, 0x06, 0x7F, 0xC7,
  0xF8, 0x63, 0x06, 0x38, 0x61, 0x86, 0x18, 0x61, 0xCC, 0x0C, 0xC0, 0xE0,
  0x07, 0xC0, 0xFE, 0x18, 0x73, 0x03, 0x30, 0x03, 0x00, 0x38, 0x01, 0xE0,
  0x0F, 0x80, 0x3C, 0x00, 0xE0, 0x06, 0x00, 0x6C, 0x06, 0xE0, 0xC7, 0xF8,
  0x3F, 0x00, 0xFF, 0xFF, 0xFC, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x00, 0x18, 0x31, 0x83, 0x30, 0x33, 0x03, 0x30, 0x33, 0x07, 0x30,
  0x63, 0x06, 0x60, 0x66, 0x06, 0x60, 0x66, 0x06, 0x60, 0xC6, 0x0C, 0x61,
  0xC7, 0xF8, 0x3F, 0x00, 0xC0, 0x78, 0x0F, 0x03, 0x60, 0x6C, 0x1D, 0x83,
  0x30, 0x63, 0x18, 0x63, 0x0C, 0xC1, 0x98, 0x33, 0x06, 0xC0, 0xD8, 0x1E,
  0x03, 0xC0, 0x78, 0x00, 0x63, 0x8D, 0x8E, 0x36, 0x39, 0x98, 0xE6, 0x67,
  0x19, 0x94, 0x46, 0x53, 0x1B, 0x4C, 0x69, 0x31, 0xA4, 0x86, 0x96, 0x1E,
  0x58, 0x51, 0x41, 0x47, 0x07, 0x1C, 0x1C, 0x70, 0xE1, 0x80, 0x18, 0x0C,
  0x70, 0x60, 0xC3, 0x83, 0x0C, 0x06, 0x60, 0x1B, 0x80, 0x6C, 0x00, 0xE0,
  0x03, 0x00, 0x1E, 0x00, 0x78, 0x03, 0x70, 0x18, 0xC0, 0xE3, 0x03, 0x06,
  0x18, 0x18, 0xE0, 0x70, 0xE0, 0x3B, 0x01, 0x98, 0x18, 0x61, 0xC3, 0x0C,
  0x18, 0xC0, 0xEE, 0x03, 0x60, 0x1E, 0x00, 0xF0, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x1F, 0xF3, 0xFF, 0x00,
  0x30, 0x06, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xE0, 0x0C,
  0x01, 0x80, 0x30, 0x07, 0x00, 0x60, 0x0F, 0xFC, 0xFF, 0xC0, 0x0F, 0x8F,
  0xC6, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x0F, 0xC7, 0xE0, 0xC1,
  0x83, 0x03, 0x06, 0x0C, 0x18, 0x38, 0x30, 0x60, 0xC1, 0x81, 0x83, 0x06,
  0x0C, 0x1C, 0x18, 0x30, 0x60, 0xC0, 0xC0, 0x1F, 0x8F, 0xC0, 0x60, 0x70,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x0C, 0x06, 0x03, 0x01, 0x8F, 0xC7, 0xE0, 0x07, 0x01, 0xC0, 0xD0,
  0x26, 0x19, 0x8C, 0x63, 0x09, 0x83, 0xC0, 0xC0, 0xFF, 0xE0, 0xE6, 0x30,
  0x0F, 0x31, 0xFF, 0x38, 0xE3, 0x06, 0x60, 0x66, 0x06, 0x60, 0x66, 0x0E,
  0x60, 0xC6, 0x0C, 0x61, 0xC7, 0xFC, 0x3E, 0xC0, 0x18, 0x03, 0x00, 0xC0,
  0x18, 0x03, 0x38, 0x7F, 0xCE, 0x39, 0x83, 0x70, 0x6C, 0x0D, 0x81, 0xB0,
  0x36, 0x0C, 0xC1, 0x98, 0x36, 0xFC, 0xDF, 0x00, 0x0F, 0x07, 0xF9, 0xC3,
  0x30, 0x6C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x3B, 0x06, 0x7F,
  0x87, 0xE0, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x0F, 0x31, 0xFF, 0x38,
  0xE3, 0x06, 0x60, 0x66, 0x06, 0x60, 0x66, 0x0E, 0x60, 0xC6, 0x0C, 0x61,
  0xC7, 0xFC, 0x3E, 0xC0, 0x0F, 0x0F, 0xE7, 0x0D, 0x83, 0xC0, 0xF0, 0x3F,
  0xFF, 0x00, 0xC0, 0x30, 0x0C, 0x1B, 0xFC, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0xFE, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x1F, 0xFC, 0x1F,
  0xFC, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0xFC,
  0x00, 0xF8, 0x00, 0x1E, 0x67, 0xFD, 0xC7, 0x30, 0x6C, 0x0D, 0x81, 0xB0,
  0x36, 0x06, 0xC1, 0x98, 0x33, 0xFE, 0x3E, 0xC0, 0x18, 0x03, 0x00, 0xC7,
  0xF8, 0xFE, 0x00, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x03, 0x38, 0x7F, 0xCE,
  0x39, 0x83, 0x70, 0x6C, 0x0D, 0x81, 0xB0, 0x36, 0x0C, 0xC1, 0x98, 0x36,
  0x06, 0xC0, 0xC0, 0x01, 0x80, 0x70, 0x0E, 0x00, 0x00, 0x00, 0x7E, 0x0F,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0xFF, 0xFF, 0xFC, 0x00, 0x70, 0x07, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xFE, 0x1F, 0xE0, 0x06, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x30, 0x7F, 0x0F,
  0xC0, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x03, 0x98, 0x38, 0xC3,
  0x86, 0x38, 0x31, 0x83, 0x18, 0x1F, 0x80, 0xCE, 0x06, 0x30, 0x31, 0xC1,
  0x86, 0x18, 0x38, 0xC0, 0xE0, 0x7C, 0x3F, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x03, 0x00,
  0x7F, 0x1F, 0xC0, 0x37, 0x71, 0xFB, 0xCC, 0x66, 0x62, 0x33, 0x31, 0x99,
  0x88, 0x8C, 0xCC, 0x66, 0x62, 0x33, 0x11, 0x99, 0x8C, 0xCC, 0x6E, 0x66,
  0x00, 0x33, 0x87, 0xFC, 0xE3, 0x98, 0x37, 0x06, 0xC0, 0xD8, 0x1B, 0x03,
  0x60, 0xCC, 0x19, 0x83, 0x60, 0x6C, 0x0C, 0x0F, 0x0F, 0xE7, 0x1D, 0x83,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC1, 0xB0, 0x6C, 0x3B, 0xFC, 0x7E, 0x00,
  0x19, 0xC1, 0xFF, 0x1C, 0x71, 0x83, 0x38, 0x33, 0x03, 0x30, 0x33, 0x03,
  0x30, 0x63, 0x06, 0x70, 0x66, 0xFC, 0x6F, 0x86, 0x00, 0x60, 0x06, 0x00,
  0xE0, 0x00, 0x0F, 0x31, 0xFE, 0x38, 0xE3, 0x06, 0x60, 0x66, 0x06, 0x60,
  0x66, 0x0E, 0x60, 0xC6, 0x0C, 0x61, 0xC7, 0xFC, 0x3E, 0xC0, 0x0C, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x37, 0x8D, 0xF9, 0xC3, 0x30, 0x76, 0x06, 0xC1,
  0x98, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x0F, 0x83,
  0xFC, 0xC1, 0x98, 0x03, 0x00, 0x70, 0x07, 0xE0, 0x1E, 0x00, 0xC0, 0x1B,
  0x83, 0x3F, 0xE3, 0xF0, 0x0C, 0x01, 0x80, 0x30, 0x7F, 0xFF, 0xFE, 0x38,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x0F,
  0xE0, 0xFC, 0x30, 0x33, 0x07, 0x30, 0x63, 0x06, 0x60, 0x66, 0x06, 0x60,
  0x66, 0x06, 0x60, 0xC6, 0x0C, 0x61, 0xC7, 0xF8, 0x3F, 0x00, 0xC0, 0x6C,
  0x0D, 0x83, 0x30, 0x66, 0x18, 0xC3, 0x18, 0xC1, 0x98, 0x36, 0x06, 0xC0,
  0xD8, 0x1E, 0x03, 0xC0, 0xC6, 0x3C, 0xE3, 0xCA, 0x2C, 0xA6, 0x8A, 0x69,
  0xA4, 0x92, 0xC9, 0x2C, 0xB2, 0x8A, 0x38, 0xA3, 0x8E, 0x30, 0xC3, 0x00,
  0x18, 0x18, 0xC1, 0x83, 0x1C, 0x19, 0xC0, 0x6C, 0x03, 0xC0, 0x0C, 0x00,
  0xF0, 0x0D, 0x80, 0xCE, 0x0E, 0x30, 0xE1, 0xCE, 0x07, 0x00, 0x60, 0x6C,
  0x1D, 0x83, 0x30, 0x6E, 0x0D, 0x81, 0xB0, 0x36, 0x06, 0xC1, 0x98, 0x73,
  0xFE, 0x3E, 0xC0, 0x18, 0x03, 0x00, 0xC7, 0xF8, 0xFE, 0x00, 0x3F, 0xE7,
  0xFC, 0x03, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x7F, 0xEF, 0xFC, 0x00, 0xF0, 0x1F, 0x03, 0x80, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0xFC, 0x0F, 0xC0, 0x06, 0x00,
  0x60, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xE0, 0x0F, 0x80,
  0x10, 0x0C, 0x31, 0xC6, 0x18, 0x61, 0x86, 0x18, 0xC3, 0x0C, 0x30, 0xC3,
  0x18, 0x61, 0x86, 0x18, 0x63, 0x80, 0x1E, 0x03, 0xC0, 0x1C, 0x01, 0x80,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x0F, 0x83, 0xF0, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x00, 0x60, 0x1C, 0x0F, 0x01, 0x00,
  0x00, 0x3C, 0x36, 0x63, 0x67, 0x6C, 0x3C,
};

const GFXglyph JetBrainsMono_Italic23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 6, 17, 14, 4, -17 },
  { 14, 8, 7, 14, 4, -17 },
  { 21, 13, 17, 14, 1, -17 },
  { 49, 12, 23, 14, 1, -20 },
  { 84, 16, 17, 14, -1, -17 },
  { 118, 12, 17, 14, 1, -17 },
  { 144, 4, 7, 14, 6, -17 },
  { 148, 9, 22, 14, 4, -19 },
  { 173, 10, 22, 14, 1, -19 },
  { 201, 12, 12, 14, 1, -14 },
  { 219, 11, 11, 14, 2, -13 },
  { 235, 6, 7, 14, 2, -3 },
  { 241, 8, 2, 14, 3, -9 },
  { 243, 4, 4, 14, 4, -4 },
  { 245, 14, 22, 14, 0, -19 },
  { 284, 12, 17, 14, 1, -17 },
  { 310, 11, 17, 14, 1, -17 },
  { 334, 12, 17, 14, 1, -17 },
  { 360, 12, 17, 14, 1, -17 },
  { 386, 11, 17, 14, 1, -17 },
  { 410, 12, 17, 14, 1, -17 },
  { 436, 11, 17, 14, 1, -17 },
  { 460, 11, 17, 14, 3, -17 },
  { 484, 12, 17, 14, 1, -17 },
  { 510, 11, 17, 14, 2, -17 },
  { 534, 6, 13, 14, 4, -13 },
  { 544, 8, 17, 14, 2, -13 },
  { 561, 11, 13, 14, 2, -14 },
  { 579, 11, 7, 14, 2, -11 },
  { 589, 11, 13, 14, 1, -14 },
  { 607, 9, 17, 14, 3, -17 },
  { 627, 14, 21, 14, 0, -17 },
  { 664, 12, 17, 14, 0, -17 },
  { 690, 12, 17, 14, 1, -17 },
  { 716, 11, 17, 14, 2, -17 },
  { 740, 12, 17, 14, 1, -17 },
  { 766, 13, 17, 14, 1, -17 },
  { 794, 13, 17, 14, 1, -17 },
  { 822, 11, 17, 14, 2, -17 },
  { 846, 12, 17, 14, 1, -17 },
  { 872, 12, 17, 14, 1, -17 },
  { 898, 13, 17, 14, 0, -17 },
  { 926, 13, 17, 14, 1, -17 },
  { 954, 10, 17, 14, 2, -17 },
  { 976, 13, 17, 14, 1, -17 },
  { 1004, 12, 17, 14, 1, -17 },
  { 1030, 11, 17, 14, 2, -17 },
  { 1054, 13, 17, 14, 1, -17 },
  { 1082, 12, 21, 14, 1, -17 },
  { 1114, 12, 17, 14, 1, -17 },
  { 1140, 12, 17, 14, 1, -17 },
  { 1166, 11, 17, 14, 3, -17 },
  { 1190, 12, 17, 14, 1, -17 },
  { 1216, 11, 17, 14, 3, -17 },
  { 1240, 14, 17, 14, 1, -17 },
  { 1270, 14, 17, 14, 0, -17 },
  { 1300, 13, 17, 14, 2, -17 },
  { 1328, 12, 17, 14, 1, -17 },
  { 1354, 9, 22, 14, 3, -19 },
  { 1379, 7, 22, 14, 4, -19 },
  { 1399, 9, 22, 14, 2, -19 },
  { 1424, 10, 9, 14, 2, -17 },
  { 1436, 11, 1, 14, 0, 1 },
  { 1438, 4, 3, 14, 6, -18 },
  { 1440, 12, 13, 14, 1, -13 },
  { 1460, 11, 17, 14, 1, -17 },
  { 1484, 11, 13, 14, 2, -13 },
  { 1502, 12, 17, 14, 1, -17 },
  { 1528, 10, 13, 14, 2, -13 },
  { 1545, 16, 21, 14, -1, -17 },
  { 1587, 11, 17, 14, 2, -13 },
  { 1611, 11, 17, 14, 1, -17 },
  { 1635, 11, 18, 14, 1, -18 },
  { 1660, 12, 22, 14, 0, -18 },
  { 1693, 13, 17, 14, 1, -17 },
  { 1721, 10, 17, 14, 2, -17 },
  { 1743, 13, 13, 14, 0, -13 },
  { 1765, 11, 13, 14, 1, -13 },
  { 1783, 10, 13, 14, 2, -13 },
  { 1800, 12, 17, 14, 0, -13 },
  { 1826, 12, 17, 14, 1, -13 },
  { 1852, 11, 13, 14, 2, -13 },
  { 1870, 11, 13, 14, 1, -13 },
  { 1888, 11, 16, 14, 2, -16 },
  { 1910, 12, 13, 14, 1, -13 },
  { 1930, 11, 13, 14, 2, -13 },
  { 1948, 12, 13, 14, 2, -13 },
  { 1968, 13, 13, 14, 0, -13 },
  { 1990, 11, 17, 14, 2, -13 },
  { 2014, 11, 13, 14, 1, -13 },
  { 2032, 12, 22, 14, 2, -19 },
  { 2065, 6, 22, 14, 4, -19 },
  { 2082, 11, 22, 14, 1, -19 },
  { 2113, 12, 4, 14, 1, -10 },
};

const GFXfont JetBrainsMono_Italic23pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Italic23pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Italic23pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _JETBRAINSMONO_ITALIC23PT7B_H_
