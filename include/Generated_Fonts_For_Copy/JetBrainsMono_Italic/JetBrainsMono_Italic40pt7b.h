#ifndef _JETBRAINSMONO_ITALIC40PT7B_H_
#define _JETBRAINSMONO_ITALIC40PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Italic.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Italic40pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xC1, 0xF0, 0x7C, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x81,
  0xC0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x1F, 0x07, 0xE1, 0xF0,
  0x7C, 0x00, 0x3C, 0x3C, 0xE0, 0xF7, 0x83, 0x9E, 0x1E, 0x78, 0x79, 0xE1,
  0xE7, 0x87, 0x9C, 0x1C, 0x70, 0x71, 0xC1, 0xC7, 0x07, 0x38, 0x1C, 0x00,
  0x38, 0x1E, 0x00, 0x70, 0x38, 0x00, 0xE0, 0x70, 0x03, 0x81, 0xC0, 0x07,
  0x03, 0x80, 0x0C, 0x07, 0x00, 0x38, 0x1C, 0x00, 0x70, 0x38, 0x1F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFC, 0x07, 0x03, 0x80, 0x1C, 0x07, 0x00, 0x38, 0x1C,
  0x00, 0x70, 0x38, 0x01, 0xC0, 0x70, 0x03, 0x81, 0xC0, 0x07, 0x03, 0x80,
  0x1C, 0x07, 0x03, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x03,
  0x81, 0xC0, 0x07, 0x03, 0x80, 0x1C, 0x07, 0x00, 0x38, 0x1C, 0x00, 0x70,
  0x38, 0x01, 0xC0, 0x60, 0x03, 0x81, 0xC0, 0x07, 0x03, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0,
  0x00, 0x07, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xF0, 0x3C,
  0xE7, 0x83, 0xC7, 0x1C, 0x1C, 0x30, 0xF1, 0xE1, 0x87, 0x8F, 0x0C, 0x00,
  0x78, 0xE0, 0x03, 0xC7, 0x00, 0x1F, 0x38, 0x00, 0x7D, 0x80, 0x03, 0xFC,
  0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00,
  0x0C, 0x78, 0x00, 0x61, 0xE0, 0x03, 0x0F, 0x00, 0x18, 0x79, 0xE1, 0xC3,
  0xCF, 0x0E, 0x1C, 0x78, 0x71, 0xE3, 0xE3, 0x1F, 0x0F, 0x99, 0xF0, 0x7F,
  0xFF, 0x01, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0xE0, 0xFF, 0x80, 0x38, 0x1C, 0x78, 0x0E, 0x07, 0x07, 0x03,
  0x80, 0xE0, 0xE0, 0xE0, 0x1C, 0x1C, 0x3C, 0x07, 0x03, 0x87, 0x00, 0xE0,
  0xE1, 0xC0, 0x1C, 0x1C, 0x70, 0x03, 0xC3, 0x9C, 0x00, 0x7F, 0xE7, 0x00,
  0x07, 0xF9, 0xE0, 0x00, 0x7E, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0xFC, 0x00, 0x0E, 0x3F, 0xC0,
  0x01, 0xCF, 0xFC, 0x00, 0x73, 0x83, 0x80, 0x1C, 0x70, 0x70, 0x07, 0x0E,
  0x0E, 0x01, 0xC1, 0x81, 0xC0, 0x70, 0x70, 0x30, 0x0E, 0x0E, 0x0E, 0x03,
  0x81, 0xC1, 0xC0, 0xE0, 0x3F, 0xF0, 0x38, 0x03, 0xFE, 0x0E, 0x00, 0x3F,
  0x00, 0x00, 0x0C, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF8,
  0x07, 0xC1, 0xE0, 0x1E, 0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xFC, 0x01, 0x3C, 0xF0, 0x38,
  0xE1, 0xE1, 0xE7, 0x87, 0x8F, 0x1E, 0x0F, 0x78, 0x78, 0x1D, 0xC1, 0xC0,
  0x7F, 0x07, 0x00, 0xF8, 0x3C, 0x03, 0xC0, 0xF0, 0x0F, 0x83, 0xC0, 0x7E,
  0x0F, 0x83, 0xFC, 0x1F, 0xFE, 0x70, 0x7F, 0xF1, 0xE0, 0x7F, 0x03, 0xC0,
  0x3D, 0xE7, 0x9E, 0x79, 0xE7, 0x1C, 0x73, 0xCF, 0x38, 0x00, 0x00, 0x80,
  0x03, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01,
  0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x01, 0x80, 0x02, 0x00, 0x03, 0xC0,
  0x03, 0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x7F, 0x00, 0xFC, 0x00, 0xF0, 0x00,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x10, 0x1C, 0x05, 0xE0, 0xC1, 0xEF, 0xC6, 0x3F, 0xFF,
  0xB7, 0xF8, 0xFF, 0xFE, 0x00, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x80,
  0x01, 0xCE, 0x00, 0x1E, 0x78, 0x01, 0xE3, 0xC0, 0x1E, 0x0F, 0x01, 0xE0,
  0x78, 0x0F, 0x01, 0xE0, 0x30, 0x0C, 0x00, 0x00, 0x78, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC3, 0xE0, 0xF8, 0x7C, 0x1F, 0x07,
  0x83, 0xE0, 0xF0, 0x78, 0x1E, 0x07, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x3C, 0xFF, 0xFF, 0xFF, 0xEF, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x07, 0xFE, 0x00,
  0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x78, 0x0F, 0x07, 0x80, 0x78, 0x78, 0x01,
  0xC3, 0xC0, 0x0F, 0x1C, 0x00, 0x70, 0xE0, 0x03, 0x87, 0x00, 0x1C, 0x78,
  0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x38, 0x78, 0xE3, 0xE3, 0x87, 0x1F, 0x1C,
  0x38, 0xF8, 0xE3, 0xC3, 0x87, 0x1E, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x00,
  0x1E, 0x38, 0x00, 0xE1, 0xC0, 0x07, 0x0E, 0x00, 0x78, 0x70, 0x03, 0xC3,
  0xC0, 0x3C, 0x1F, 0x03, 0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0xC0, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x1F, 0xF0, 0x0F, 0xB8, 0x0F, 0x8E,
  0x03, 0xC7, 0x81, 0xC1, 0xE0, 0x60, 0x78, 0x10, 0x1E, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1C, 0x00, 0x07, 0xFC,
  0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xF8, 0x1F, 0x07, 0x80, 0x78, 0x78,
  0x01, 0xC3, 0x80, 0x0E, 0x3C, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x7F,
  0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xF0, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xCF, 0x00, 0x3C, 0xF0, 0x03, 0xCF,
  0x00, 0x78, 0xF0, 0x07, 0x87, 0x81, 0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0,
  0x0F, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x81, 0xE0,
  0xF0, 0x1E, 0x1F, 0x01, 0xE1, 0xE0, 0x1C, 0x3C, 0x01, 0xC7, 0x80, 0x3C,
  0x78, 0x03, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFF, 0xFF,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x8F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x07, 0x80, 0x00, 0xF3, 0xF8, 0x1F, 0xFF, 0x83, 0xBF, 0xF8, 0x7C,
  0x1F, 0x0F, 0x01, 0xF3, 0xC0, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE7, 0x00,
  0x38, 0xF0, 0x0F, 0x1F, 0x03, 0xC1, 0xFF, 0xF8, 0x3F, 0xFC, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0xBF, 0x80, 0xEF, 0xF8, 0x3F, 0xFF, 0x8F, 0xC1,
  0xF9, 0xE0, 0x1F, 0x78, 0x01, 0xEF, 0x00, 0x3D, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x77, 0x80, 0x1E, 0x78, 0x07,
  0x8F, 0x81, 0xF0, 0xFF, 0xFC, 0x0F, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xFF,
  0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0x00, 0x3D, 0xE0, 0x07,
  0xBC, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x00, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x0F, 0xFC,
  0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0x81, 0xF0, 0xF0, 0x0F, 0x0E, 0x00,
  0xF0, 0xE0, 0x0F, 0x1E, 0x00, 0xF0, 0xE0, 0x0E, 0x0E, 0x01, 0xE0, 0xF0,
  0x3C, 0x07, 0x87, 0x80, 0x3F, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0xE0, 0x07,
  0xDF, 0x01, 0xF0, 0xF8, 0x3C, 0x03, 0xC3, 0x80, 0x3C, 0x78, 0x01, 0xC7,
  0x00, 0x1C, 0x70, 0x01, 0xCF, 0x00, 0x3C, 0xF0, 0x03, 0xC7, 0x80, 0x78,
  0x7C, 0x0F, 0x87, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x70,
  0x00, 0x7F, 0xC0, 0x3F, 0xFE, 0x0F, 0xFF, 0xE3, 0xE0, 0x7C, 0x78, 0x07,
  0xDE, 0x00, 0x7B, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xEF, 0x00, 0x3D, 0xE0, 0x07, 0xBE, 0x01, 0xE3, 0xE0, 0xFC,
  0x7F, 0xFF, 0x07, 0xFF, 0xC0, 0x3E, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x87,
  0xF1, 0xFC, 0x7E, 0x1F, 0x81, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x1F, 0x87, 0xE3, 0xF8, 0xFE,
  0x1F, 0x00, 0x01, 0xF0, 0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1E, 0x01, 0xF0,
  0x0F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x06, 0x00, 0x01, 0xE0, 0x00, 0xFE, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xE0,
  0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0x78, 0x00, 0x01, 0x00, 0x3F, 0xFF, 0xE7, 0xFF, 0xFD, 0xFF, 0xFF,
  0xBF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0xFF, 0xF8,
  0x10, 0x00, 0x03, 0x80, 0x00, 0x7C, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7C,
  0x00, 0x03, 0x80, 0x01, 0xF0, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0x78, 0x00, 0x0C,
  0x00, 0x00, 0x3F, 0xE0, 0x3F, 0xF8, 0x3F, 0xFC, 0x00, 0x7E, 0x00, 0x3E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x7C, 0x03, 0xF8, 0x1F, 0xF0, 0x1F, 0xC0, 0x1E, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xFC, 0x01, 0xF8, 0x7E,
  0x03, 0xC0, 0x1E, 0x07, 0x80, 0x0F, 0x07, 0x00, 0x0F, 0x0F, 0x00, 0x07,
  0x0E, 0x00, 0x07, 0x1E, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x1C, 0x07, 0xE7,
  0x1C, 0x0F, 0xF6, 0x1C, 0x1E, 0x1E, 0x3C, 0x1C, 0x1E, 0x3C, 0x38, 0x0E,
  0x38, 0x38, 0x0E, 0x38, 0x38, 0x1E, 0x38, 0x38, 0x1C, 0x38, 0x78, 0x1C,
  0x38, 0x78, 0x1C, 0x78, 0x70, 0x1C, 0x70, 0x70, 0x3C, 0x70, 0x70, 0x3C,
  0x70, 0x78, 0x7C, 0x70, 0x7F, 0xF8, 0x70, 0x3F, 0xB8, 0x70, 0x0F, 0x00,
  0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0xC0, 0x01,
  0xDC, 0x00, 0x3D, 0xC0, 0x03, 0xDC, 0x00, 0x39, 0xC0, 0x07, 0x9C, 0x00,
  0x71, 0xC0, 0x0F, 0x1C, 0x00, 0xF1, 0xC0, 0x0E, 0x1C, 0x01, 0xE1, 0xE0,
  0x1C, 0x1E, 0x03, 0xC1, 0xE0, 0x3C, 0x0E, 0x07, 0x80, 0xE0, 0x78, 0x0E,
  0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE1, 0xE0, 0x0E, 0x1E, 0x00,
  0xF1, 0xC0, 0x0F, 0x3C, 0x00, 0xF3, 0x80, 0x0F, 0x78, 0x00, 0xF7, 0x80,
  0x07, 0xF0, 0x00, 0x70, 0x0F, 0xFF, 0x80, 0x7F, 0xFE, 0x03, 0xFF, 0xF8,
  0x1E, 0x03, 0xE0, 0xE0, 0x0F, 0x07, 0x00, 0x78, 0x38, 0x01, 0xC3, 0xC0,
  0x0E, 0x1E, 0x00, 0xF0, 0xF0, 0x07, 0x87, 0x00, 0x78, 0x38, 0x07, 0x81,
  0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0x83, 0xF8, 0x38, 0x03,
  0xC1, 0xC0, 0x0F, 0x0E, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x3C,
  0x00, 0xF1, 0xE0, 0x07, 0x0E, 0x00, 0x78, 0x70, 0x07, 0x87, 0x80, 0xFC,
  0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0x03, 0xE1, 0xE0, 0x1E,
  0x1C, 0x00, 0xE3, 0xC0, 0x0E, 0x3C, 0x00, 0xE3, 0xC0, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x03, 0x8F, 0x00, 0x78, 0xF0, 0x07, 0x8F,
  0x00, 0xF0, 0xF8, 0x1E, 0x07, 0xFF, 0xE0, 0x3F, 0xF8, 0x01, 0xFF, 0x00,
  0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xF0, 0x3E, 0x0E, 0x00,
  0xF0, 0xE0, 0x0F, 0x1E, 0x00, 0xF1, 0xE0, 0x0F, 0x1E, 0x00, 0xF1, 0xE0,
  0x0F, 0x1C, 0x00, 0xF1, 0xC0, 0x0F, 0x1C, 0x00, 0xE3, 0xC0, 0x0E, 0x3C,
  0x01, 0xE3, 0xC0, 0x1E, 0x3C, 0x01, 0xE3, 0x80, 0x1E, 0x38, 0x01, 0xC7,
  0x80, 0x1C, 0x78, 0x03, 0xC7, 0x80, 0x3C, 0x78, 0x03, 0xC7, 0x00, 0x78,
  0x70, 0x0F, 0x8F, 0x03, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x01,
  0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x83, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xFF, 0xFF, 0x83,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x1F, 0xF8, 0x03, 0xFF,
  0xC0, 0x7F, 0xFE, 0x0F, 0x03, 0xE1, 0xE0, 0x1E, 0x1C, 0x00, 0xE3, 0xC0,
  0x0E, 0x3C, 0x00, 0xE3, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x87, 0xFC, 0x78, 0x7F, 0xC7,
  0x0F, 0xFC, 0x70, 0x03, 0xCF, 0x00, 0x3C, 0xF0, 0x03, 0x8F, 0x00, 0x38,
  0xF0, 0x03, 0x8F, 0x00, 0x78, 0xF0, 0x07, 0x8F, 0x00, 0xF0, 0xF8, 0x1E,
  0x07, 0xFF, 0xE0, 0x3F, 0xF8, 0x01, 0xFF, 0x00, 0x0F, 0x00, 0x78, 0x78,
  0x03, 0xC3, 0xC0, 0x1E, 0x1E, 0x00, 0xF0, 0xE0, 0x07, 0x07, 0x00, 0x38,
  0x38, 0x03, 0xC3, 0xC0, 0x1E, 0x1E, 0x00, 0xF0, 0xF0, 0x07, 0x87, 0x80,
  0x38, 0x38, 0x01, 0xC1, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x87,
  0xFF, 0xFC, 0x3C, 0x01, 0xE1, 0xC0, 0x0E, 0x0E, 0x00, 0x70, 0xF0, 0x07,
  0x87, 0x80, 0x3C, 0x3C, 0x01, 0xE1, 0xE0, 0x0F, 0x0E, 0x00, 0x70, 0x70,
  0x03, 0x87, 0x80, 0x3C, 0x3C, 0x01, 0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0x78,
  0x00, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x04, 0x1F, 0xFF, 0xC0,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xC3, 0xC0, 0x07, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0xF0,
  0xF8, 0x07, 0x81, 0xF0, 0x3C, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0x00, 0x3E, 0x1E, 0x00, 0x78, 0x3C, 0x01, 0xE0, 0x78,
  0x07, 0x80, 0xE0, 0x0F, 0x01, 0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x0F, 0x01,
  0xE0, 0x1E, 0x07, 0x80, 0x3C, 0x1E, 0x00, 0x70, 0x3C, 0x00, 0xE0, 0xF0,
  0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1E, 0x1E, 0x00,
  0x3C, 0x3C, 0x00, 0x70, 0x3C, 0x00, 0xE0, 0x78, 0x03, 0xC0, 0xF0, 0x07,
  0x80, 0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x38, 0x03, 0xC0, 0x70,
  0x07, 0x81, 0xE0, 0x0F, 0x03, 0xC0, 0x0F, 0x07, 0x80, 0x1E, 0x0F, 0x00,
  0x3E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0xFC, 0x3F, 0x01,
  0xF0, 0x7E, 0x07, 0x60, 0xFC, 0x0F, 0xC1, 0xD8, 0x3B, 0x83, 0xB8, 0x77,
  0x07, 0x71, 0xCE, 0x0E, 0xE3, 0xB8, 0x39, 0xCE, 0x70, 0x73, 0x9C, 0xE0,
  0xE3, 0x39, 0xC1, 0xC7, 0xE7, 0x83, 0x8F, 0xCF, 0x07, 0x1F, 0x1E, 0x1E,
  0x3E, 0x38, 0x3C, 0x00, 0x70, 0x78, 0x01, 0xE0, 0xE0, 0x03, 0xC1, 0xC0,
  0x07, 0x83, 0x80, 0x0F, 0x0F, 0x00, 0x1C, 0x1E, 0x00, 0x38, 0x3C, 0x00,
  0x70, 0x78, 0x01, 0xE0, 0xE0, 0x03, 0xC1, 0xC0, 0x07, 0x83, 0x80, 0x0E,
  0x0F, 0x00, 0x1C, 0x00, 0x0F, 0x80, 0x38, 0x7E, 0x01, 0xC3, 0xF0, 0x1E,
  0x1F, 0x80, 0xF0, 0xFC, 0x07, 0x87, 0xE0, 0x38, 0x7F, 0x81, 0xC3, 0xDC,
  0x0E, 0x1C, 0xE0, 0xF0, 0xE7, 0x07, 0x87, 0x38, 0x3C, 0x39, 0xE1, 0xC3,
  0xC7, 0x0E, 0x1E, 0x38, 0x70, 0xF1, 0xC7, 0x87, 0x0E, 0x3C, 0x38, 0x79,
  0xE1, 0xC1, 0xCE, 0x1E, 0x0E, 0x70, 0xF0, 0x73, 0x87, 0x83, 0x9C, 0x3C,
  0x1F, 0xE1, 0xC0, 0x7F, 0x0E, 0x03, 0xF8, 0x70, 0x1F, 0x87, 0x80, 0xFC,
  0x3C, 0x07, 0xE1, 0xE0, 0x1F, 0x0E, 0x00, 0xF8, 0x00, 0x00, 0x38, 0x00,
  0x1F, 0xF0, 0x03, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0x03, 0xE1, 0xE0, 0x1E,
  0x1C, 0x01, 0xE3, 0xC0, 0x0E, 0x3C, 0x00, 0xE3, 0xC0, 0x1E, 0x38, 0x01,
  0xE3, 0x80, 0x1E, 0x38, 0x01, 0xE7, 0x80, 0x1C, 0x78, 0x01, 0xC7, 0x80,
  0x3C, 0x78, 0x03, 0xC7, 0x00, 0x3C, 0x70, 0x03, 0xCF, 0x00, 0x38, 0xF0,
  0x03, 0x8F, 0x00, 0x78, 0xF0, 0x07, 0x8F, 0x00, 0x78, 0xF0, 0x07, 0x0F,
  0x00, 0xF0, 0xF8, 0x1E, 0x07, 0xFF, 0xC0, 0x3F, 0xF8, 0x01, 0xFF, 0x00,
  0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x03, 0xC0, 0x3E, 0x0E,
  0x00, 0x78, 0x38, 0x00, 0xF1, 0xE0, 0x03, 0xC7, 0x80, 0x0F, 0x1E, 0x00,
  0x3C, 0x78, 0x00, 0xE1, 0xC0, 0x07, 0x87, 0x00, 0x3E, 0x1C, 0x01, 0xF0,
  0xF0, 0x1F, 0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x07,
  0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x78, 0x1F, 0x07, 0x80, 0x78,
  0x78, 0x01, 0xC3, 0xC0, 0x0F, 0x1C, 0x00, 0x70, 0xE0, 0x03, 0x87, 0x00,
  0x1C, 0x78, 0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x78, 0xE0, 0x03, 0x87,
  0x00, 0x1C, 0x38, 0x00, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x03,
  0xC7, 0x80, 0x1E, 0x38, 0x00, 0xE1, 0xC0, 0x07, 0x0E, 0x00, 0x78, 0x70,
  0x03, 0xC3, 0xC0, 0x3C, 0x1F, 0x03, 0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0xC0,
  0x07, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xFF,
  0x80, 0x7F, 0xFF, 0x03, 0xFF, 0xFC, 0x1E, 0x03, 0xE0, 0xE0, 0x0F, 0x87,
  0x00, 0x3C, 0x78, 0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x03,
  0xC7, 0x00, 0x3C, 0x38, 0x01, 0xE1, 0xC0, 0x1E, 0x1F, 0xFF, 0xE0, 0xFF,
  0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x01, 0xC1, 0xE0, 0x0E, 0x07, 0x80,
  0xF0, 0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x0E, 0x01,
  0xE0, 0x70, 0x07, 0x87, 0x80, 0x3C, 0x3C, 0x01, 0xE1, 0xE0, 0x0F, 0x8F,
  0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xF8, 0x07,
  0xFF, 0xE0, 0x78, 0x0F, 0x07, 0x80, 0x38, 0x38, 0x01, 0xE3, 0xC0, 0x0F,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80,
  0x00, 0x7E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF3, 0xC0, 0x07, 0x9E, 0x00, 0x38, 0xF0, 0x03, 0xC7, 0xC0, 0x3E, 0x1F,
  0x03, 0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x38, 0x78, 0x03, 0xC3, 0xC0, 0x1E, 0x1E, 0x00, 0xF0, 0xE0, 0x07,
  0x87, 0x00, 0x38, 0x78, 0x01, 0xC3, 0xC0, 0x1E, 0x1E, 0x00, 0xF0, 0xF0,
  0x07, 0x87, 0x00, 0x3C, 0x38, 0x01, 0xC3, 0xC0, 0x0E, 0x1E, 0x00, 0xF0,
  0xF0, 0x07, 0x87, 0x80, 0x3C, 0x38, 0x01, 0xE1, 0xC0, 0x0E, 0x0E, 0x00,
  0x70, 0xF0, 0x03, 0x87, 0x80, 0x3C, 0x3C, 0x01, 0xE1, 0xE0, 0x0F, 0x0F,
  0x00, 0xF0, 0x78, 0x07, 0x83, 0xE0, 0x78, 0x0F, 0xFF, 0x80, 0x3F, 0xF8,
  0x00, 0xFF, 0x80, 0x00, 0xF0, 0x00, 0xFF, 0x00, 0x1E, 0xF0, 0x01, 0xEF,
  0x00, 0x1C, 0xF0, 0x03, 0xCF, 0x00, 0x3C, 0x70, 0x07, 0x87, 0x00, 0x78,
  0x70, 0x07, 0x07, 0x00, 0xF0, 0x70, 0x0E, 0x07, 0x81, 0xE0, 0x78, 0x1E,
  0x07, 0x81, 0xC0, 0x78, 0x3C, 0x07, 0x83, 0x80, 0x38, 0x78, 0x03, 0x87,
  0x00, 0x38, 0x70, 0x03, 0x8F, 0x00, 0x38, 0xE0, 0x03, 0x9E, 0x00, 0x3D,
  0xC0, 0x03, 0xDC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x00, 0x70, 0x3C, 0x1E, 0xE0, 0x78, 0x39, 0xC1,
  0xF0, 0x73, 0x83, 0xE0, 0xE7, 0x07, 0xC3, 0xCE, 0x1F, 0x87, 0x1C, 0x37,
  0x0E, 0x38, 0x6E, 0x1C, 0xF0, 0xD8, 0x71, 0xE3, 0xB0, 0xE3, 0xC6, 0x61,
  0xC7, 0x8C, 0xC7, 0x8F, 0x39, 0x8E, 0x1C, 0x63, 0x1C, 0x38, 0xC6, 0x38,
  0x71, 0x8C, 0xF0, 0xE7, 0x19, 0xC1, 0xCC, 0x33, 0x83, 0x98, 0x67, 0x07,
  0x70, 0xDC, 0x0E, 0xE1, 0xB8, 0x1D, 0x83, 0x70, 0x3B, 0x06, 0xE0, 0x7E,
  0x0F, 0x80, 0xF8, 0x3F, 0x01, 0xF0, 0x7E, 0x03, 0xE0, 0xFC, 0x07, 0xC1,
  0xF0, 0x0F, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x0F, 0x81, 0xE0, 0x07, 0x80,
  0xF0, 0x07, 0x80, 0x78, 0x07, 0x80, 0x1E, 0x07, 0xC0, 0x0F, 0x03, 0xC0,
  0x03, 0x83, 0xC0, 0x01, 0xE3, 0xC0, 0x00, 0xF1, 0xE0, 0x00, 0x39, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x79, 0xC0, 0x00, 0x3C, 0xF0, 0x00, 0x3C, 0x78, 0x00, 0x3C,
  0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x03, 0x80, 0x1E, 0x01, 0xE0, 0x1E,
  0x00, 0xF0, 0x0F, 0x00, 0x3C, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x80,
  0xF0, 0x00, 0x7B, 0x80, 0x03, 0x9E, 0x00, 0x3C, 0xF0, 0x03, 0xC3, 0x80,
  0x1C, 0x1E, 0x01, 0xE0, 0xF0, 0x1E, 0x03, 0x80, 0xF0, 0x1E, 0x0F, 0x00,
  0xF0, 0x70, 0x03, 0x87, 0x80, 0x1E, 0x78, 0x00, 0xF3, 0x80, 0x03, 0xBC,
  0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF,
  0xFE, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x38,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFE,
  0x0F, 0xFC, 0x1F, 0xF8, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01,
  0xE0, 0x03, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0xF0, 0x03, 0x80, 0x1E,
  0x00, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0xE0,
  0x07, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x01, 0xC0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x07, 0xFE, 0x0F,
  0xFC, 0x1F, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07,
  0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x3B, 0x80, 0x3D, 0xC0, 0x1C, 0xE0, 0x1C, 0x38, 0x1E, 0x1C,
  0x0E, 0x0E, 0x0F, 0x07, 0x07, 0x01, 0xC7, 0x00, 0xE7, 0x80, 0x73, 0x80,
  0x1F, 0xC0, 0x0E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0xF0,
  0xF0, 0xE1, 0xE1, 0xE0, 0x01, 0xFC, 0xF0, 0x7F, 0xEF, 0x0F, 0xFF, 0xF0,
  0xF0, 0x3F, 0x1E, 0x01, 0xE1, 0xC0, 0x1E, 0x3C, 0x01, 0xE3, 0xC0, 0x1E,
  0x3C, 0x01, 0xE3, 0x80, 0x1E, 0x38, 0x01, 0xC7, 0x80, 0x1C, 0x78, 0x03,
  0xC7, 0x80, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x3C, 0x78, 0x07, 0x87, 0x80,
  0x78, 0x7C, 0x0B, 0x83, 0xFF, 0xF8, 0x3F, 0xF7, 0x81, 0xFE, 0x78, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE7, 0xF8, 0x1E, 0xFF, 0xC1, 0xFF, 0xFC,
  0x1D, 0x03, 0xE1, 0xE0, 0x1E, 0x1E, 0x01, 0xE3, 0xC0, 0x1E, 0x3C, 0x01,
  0xE3, 0xC0, 0x1E, 0x3C, 0x01, 0xE3, 0x80, 0x1E, 0x38, 0x01, 0xC7, 0x80,
  0x1C, 0x78, 0x03, 0xC7, 0x80, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x38, 0x78,
  0x07, 0x8F, 0xC0, 0xF0, 0xFF, 0xFF, 0x0F, 0x7F, 0xE0, 0xF3, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F, 0x03, 0xE3, 0xC0, 0x3C,
  0x70, 0x03, 0x9E, 0x00, 0x73, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x3C, 0xF0, 0x07, 0x9E, 0x01, 0xE3, 0xE0, 0x7C, 0x3F, 0xFF, 0x03,
  0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x3F, 0x9E, 0x07, 0xFE, 0xF0, 0x7F, 0xFF, 0x83, 0xC0, 0xFC, 0x3C, 0x03,
  0xC1, 0xC0, 0x1E, 0x1E, 0x00, 0xF0, 0xF0, 0x07, 0x87, 0x80, 0x3C, 0x38,
  0x01, 0xE1, 0xC0, 0x0E, 0x1E, 0x00, 0x70, 0xF0, 0x07, 0x87, 0x80, 0x3C,
  0x3C, 0x01, 0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0xF0, 0x78, 0x07, 0x83, 0xE0,
  0x5C, 0x0F, 0xFF, 0xE0, 0x7F, 0xEF, 0x01, 0xFE, 0x78, 0x00, 0x03, 0xFE,
  0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x78, 0x1F, 0x3C, 0x03, 0xCE, 0x00, 0xF7,
  0x80, 0x1D, 0xE0, 0x0F, 0x70, 0x03, 0xDF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xFE, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x07,
  0xBC, 0x03, 0xCF, 0x81, 0xF1, 0xFF, 0xF8, 0x3F, 0xFC, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF9, 0xE1, 0xFF, 0xBC, 0x7F,
  0xFF, 0x8F, 0x03, 0xF3, 0xC0, 0x3C, 0x70, 0x07, 0x9E, 0x00, 0xF3, 0xC0,
  0x1E, 0x78, 0x03, 0xCE, 0x00, 0x79, 0xC0, 0x0E, 0x78, 0x01, 0xCF, 0x00,
  0x39, 0xE0, 0x0F, 0x3C, 0x01, 0xE7, 0x80, 0x7C, 0xF8, 0x1F, 0x0F, 0xFE,
  0xE1, 0xFF, 0xDC, 0x1F, 0xE7, 0x80, 0x60, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x07, 0xC1, 0xFF, 0xF0, 0x3F, 0xFC,
  0x07, 0xFE, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE7, 0xF8, 0x1E,
  0xFF, 0xC1, 0xFF, 0xFC, 0x1D, 0x03, 0xE1, 0xE0, 0x1E, 0x1E, 0x01, 0xE3,
  0xC0, 0x1E, 0x3C, 0x01, 0xE3, 0xC0, 0x1E, 0x38, 0x01, 0xE3, 0x80, 0x1C,
  0x38, 0x01, 0xC7, 0x80, 0x1C, 0x78, 0x03, 0xC7, 0x80, 0x3C, 0x78, 0x03,
  0xC7, 0x00, 0x3C, 0x70, 0x03, 0x8F, 0x00, 0x38, 0xF0, 0x07, 0x8F, 0x00,
  0x78, 0xF0, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x0F, 0x1E,
  0x00, 0xF0, 0xF0, 0x0F, 0x07, 0x80, 0xF8, 0x38, 0x0F, 0x81, 0xC0, 0x78,
  0x1E, 0x07, 0x80, 0xF0, 0x78, 0x07, 0x87, 0x80, 0x3F, 0xF8, 0x01, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x70, 0xF0, 0x07, 0x83, 0xC0, 0x3C, 0x1E, 0x01,
  0xE0, 0x78, 0x0F, 0x03, 0xC0, 0x70, 0x0F, 0x03, 0x80, 0x78, 0x3C, 0x01,
  0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0x3C, 0x00, 0xFF, 0xE0, 0x7F, 0xE0, 0x3F,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x03, 0xFF, 0xE0, 0xFF, 0xE0, 0x3F, 0xF0, 0x1E, 0xF9, 0xF0,
  0x77, 0xEF, 0xE1, 0xF7, 0xA7, 0x87, 0x0F, 0x0E, 0x1C, 0x1C, 0x38, 0xF0,
  0xE0, 0xE3, 0xC3, 0x83, 0x8F, 0x0E, 0x0E, 0x38, 0x38, 0x78, 0xE0, 0xE1,
  0xE3, 0x83, 0x87, 0x0E, 0x1C, 0x1C, 0x78, 0x70, 0x71, 0xE1, 0xC1, 0xC7,
  0x07, 0x0F, 0x1C, 0x1C, 0x3C, 0x70, 0x70, 0xE1, 0xC3, 0x83, 0x8F, 0x0E,
  0x0E, 0x3C, 0x38, 0x38, 0xE0, 0xE0, 0xE3, 0x83, 0x87, 0x80, 0x1E, 0x7F,
  0x81, 0xEF, 0xFC, 0x1F, 0xFF, 0xC1, 0xD0, 0x3E, 0x1E, 0x01, 0xE1, 0xE0,
  0x1E, 0x3C, 0x01, 0xE3, 0xC0, 0x1E, 0x3C, 0x01, 0xE3, 0x80, 0x1E, 0x38,
  0x01, 0xC3, 0x80, 0x1C, 0x78, 0x01, 0xC7, 0x80, 0x3C, 0x78, 0x03, 0xC7,
  0x80, 0x3C, 0x70, 0x03, 0xC7, 0x00, 0x38, 0xF0, 0x03, 0x8F, 0x00, 0x78,
  0xF0, 0x07, 0x8F, 0x00, 0x78, 0x03, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xF8,
  0x78, 0x1F, 0x3C, 0x03, 0xCE, 0x00, 0xF7, 0x80, 0x3D, 0xE0, 0x0F, 0x70,
  0x03, 0xDC, 0x00, 0xF7, 0x00, 0x3F, 0xC0, 0x0E, 0xF0, 0x03, 0xBC, 0x01,
  0xEF, 0x00, 0x7B, 0xC0, 0x1E, 0xF0, 0x07, 0x3C, 0x03, 0xCF, 0x81, 0xE1,
  0xFF, 0xF0, 0x3F, 0xF8, 0x07, 0xFC, 0x00, 0x0F, 0x3F, 0xC0, 0x7B, 0xFF,
  0x03, 0xFF, 0xF8, 0x1D, 0x83, 0xE0, 0xF0, 0x0F, 0x07, 0x80, 0x78, 0x78,
  0x03, 0xC3, 0xC0, 0x1E, 0x1E, 0x00, 0xF0, 0xF0, 0x07, 0x87, 0x00, 0x3C,
  0x38, 0x01, 0xC3, 0xC0, 0x0E, 0x1E, 0x00, 0xF0, 0xF0, 0x07, 0x87, 0x80,
  0x3C, 0x3C, 0x01, 0xC1, 0xE0, 0x1E, 0x1F, 0x81, 0xE0, 0xFF, 0xFF, 0x07,
  0xBF, 0xF0, 0x3C, 0xFE, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0xF0, 0x7F, 0xEF, 0x0F, 0xFF, 0xF0, 0xF0, 0x3F, 0x1E, 0x01,
  0xE1, 0xC0, 0x1E, 0x3C, 0x01, 0xE3, 0xC0, 0x1E, 0x38, 0x01, 0xE3, 0x80,
  0x1E, 0x38, 0x01, 0xC7, 0x80, 0x1C, 0x78, 0x03, 0xC7, 0x80, 0x3C, 0x78,
  0x03, 0xC7, 0x80, 0x3C, 0x78, 0x07, 0x87, 0x80, 0x78, 0x7C, 0x0B, 0x83,
  0xFF, 0xF8, 0x3F, 0xF7, 0x81, 0xFE, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x1E, 0x7F, 0x03, 0x9F, 0xF8, 0x77, 0xFF, 0x0F, 0x81, 0xF3, 0xE0,
  0x1E, 0x78, 0x03, 0xCF, 0x00, 0x79, 0xE0, 0x0F, 0x38, 0x01, 0xE7, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0xF8, 0x3F,
  0xFF, 0x8F, 0x80, 0xF1, 0xE0, 0x0E, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1F, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x01,
  0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xDE, 0x00,
  0x71, 0xE0, 0x3E, 0x3F, 0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x00,
  0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x1C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x1F, 0xF0, 0x1E, 0x00, 0xF1,
  0xE0, 0x0F, 0x1E, 0x00, 0xF1, 0xC0, 0x0F, 0x1C, 0x00, 0xE3, 0xC0, 0x0E,
  0x3C, 0x01, 0xE3, 0xC0, 0x1E, 0x3C, 0x01, 0xE3, 0x80, 0x1E, 0x38, 0x01,
  0xC3, 0x80, 0x1C, 0x78, 0x01, 0xC7, 0x80, 0x3C, 0x78, 0x03, 0xC7, 0x80,
  0x3C, 0x78, 0x07, 0x87, 0x80, 0x78, 0x7C, 0x1F, 0x03, 0xFF, 0xE0, 0x1F,
  0xFC, 0x00, 0xFF, 0x00, 0xF0, 0x01, 0xFE, 0x00, 0x3D, 0xC0, 0x0F, 0x38,
  0x01, 0xE7, 0x00, 0x78, 0xF0, 0x0F, 0x1E, 0x01, 0xC3, 0xC0, 0x78, 0x38,
  0x0E, 0x07, 0x03, 0xC0, 0xE0, 0x70, 0x1E, 0x1E, 0x03, 0xC3, 0x80, 0x78,
  0xF0, 0x07, 0x1C, 0x00, 0xE7, 0x80, 0x1C, 0xE0, 0x03, 0xBC, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0xE0, 0x70, 0x3F,
  0x07, 0x81, 0xF8, 0x3C, 0x0F, 0xC1, 0xE0, 0xEE, 0x1F, 0x07, 0x70, 0xD8,
  0x3B, 0x86, 0xC3, 0x9C, 0x36, 0x1C, 0xE3, 0x30, 0xE7, 0x19, 0x8E, 0x38,
  0xCC, 0x71, 0xCE, 0x63, 0x8E, 0x63, 0x38, 0x73, 0x19, 0xC3, 0xB8, 0xCE,
  0x1D, 0x86, 0x60, 0xEC, 0x37, 0x07, 0xE1, 0xB8, 0x3E, 0x0D, 0x81, 0xF0,
  0x7C, 0x0F, 0x83, 0xE0, 0x78, 0x1E, 0x00, 0x0F, 0x80, 0x3E, 0x0F, 0x00,
  0x78, 0x0F, 0x01, 0xE0, 0x1E, 0x07, 0x80, 0x1E, 0x1E, 0x00, 0x3C, 0x3C,
  0x00, 0x3C, 0xF0, 0x00, 0x7B, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3D, 0xE0, 0x00,
  0x7B, 0xC0, 0x01, 0xE3, 0xC0, 0x07, 0x87, 0x80, 0x1E, 0x07, 0x80, 0x78,
  0x0F, 0x01, 0xF0, 0x0F, 0x03, 0xC0, 0x1E, 0x1F, 0x00, 0x1E, 0x00, 0x3C,
  0x01, 0xE7, 0x80, 0x3C, 0xF0, 0x07, 0x9C, 0x00, 0xF3, 0x80, 0x1C, 0x70,
  0x03, 0x9E, 0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x03, 0xCF, 0x00, 0x79, 0xC0,
  0x0E, 0x38, 0x01, 0xCF, 0x00, 0x39, 0xE0, 0x0F, 0x3C, 0x01, 0xE7, 0x80,
  0x7C, 0xF8, 0x1F, 0x8F, 0xFE, 0xE0, 0xFF, 0x9C, 0x0F, 0xE7, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x07,
  0xC1, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFE, 0x00, 0x0F, 0xFF, 0xF1, 0xFF,
  0xFE, 0x1F, 0xFF, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF,
  0x8F, 0xFF, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x0F, 0xFE, 0x00,
  0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00,
  0x03, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x38, 0x1C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xC0, 0xE0, 0x70, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x03, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x38, 0x1C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xC0, 0xE0,
  0x70, 0x78, 0x3C, 0x1E, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x80, 0x07,
  0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x03, 0xFF, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x71, 0xFE, 0x07, 0x3F, 0xF0, 0x77, 0x8F,
  0x0F, 0x70, 0x78, 0xF7, 0x07, 0xFE, 0x70, 0x3F, 0xCF, 0x00, 0xF8,
};

const GFXglyph JetBrainsMono_Italic40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 24, 0, -1 },
  { 1, 10, 29, 24, 7, -29 },
  { 38, 14, 12, 24, 7, -29 },
  { 59, 23, 29, 24, 1, -29 },
  { 143, 21, 41, 24, 2, -35 },
  { 251, 27, 29, 24, -1, -29 },
  { 349, 22, 30, 24, 1, -30 },
  { 432, 6, 12, 24, 11, -29 },
  { 441, 17, 39, 24, 6, -34 },
  { 524, 16, 39, 24, 2, -34 },
  { 602, 21, 20, 24, 2, -24 },
  { 655, 19, 19, 24, 3, -23 },
  { 701, 10, 12, 24, 4, -6 },
  { 716, 13, 3, 24, 6, -15 },
  { 721, 7, 6, 24, 7, -6 },
  { 727, 23, 37, 24, 1, -33 },
  { 834, 21, 30, 24, 2, -30 },
  { 913, 18, 29, 24, 2, -29 },
  { 979, 21, 30, 24, 2, -30 },
  { 1058, 20, 29, 24, 2, -29 },
  { 1131, 20, 29, 24, 2, -29 },
  { 1204, 19, 29, 24, 3, -29 },
  { 1273, 19, 29, 24, 2, -29 },
  { 1342, 19, 29, 24, 5, -29 },
  { 1411, 20, 30, 24, 2, -30 },
  { 1486, 19, 30, 24, 4, -30 },
  { 1558, 10, 22, 24, 7, -22 },
  { 1586, 13, 28, 24, 4, -22 },
  { 1632, 20, 21, 24, 3, -24 },
  { 1685, 19, 13, 24, 3, -20 },
  { 1716, 19, 21, 24, 2, -24 },
  { 1766, 16, 29, 24, 6, -29 },
  { 1824, 24, 37, 24, 0, -30 },
  { 1935, 20, 29, 24, 0, -29 },
  { 2008, 21, 29, 24, 2, -29 },
  { 2085, 20, 30, 24, 3, -30 },
  { 2160, 20, 29, 24, 2, -29 },
  { 2233, 22, 29, 24, 2, -29 },
  { 2313, 22, 29, 24, 2, -29 },
  { 2393, 20, 30, 24, 3, -30 },
  { 2468, 21, 29, 24, 2, -29 },
  { 2545, 21, 29, 24, 2, -29 },
  { 2622, 22, 29, 24, 1, -29 },
  { 2702, 23, 29, 24, 2, -29 },
  { 2786, 17, 29, 24, 3, -29 },
  { 2848, 23, 29, 24, 1, -29 },
  { 2932, 21, 29, 24, 2, -29 },
  { 3009, 20, 30, 24, 3, -30 },
  { 3084, 22, 29, 24, 2, -29 },
  { 3164, 21, 37, 24, 2, -30 },
  { 3262, 21, 29, 24, 2, -29 },
  { 3339, 21, 30, 24, 2, -30 },
  { 3418, 20, 29, 24, 5, -29 },
  { 3491, 21, 29, 24, 2, -29 },
  { 3568, 20, 29, 24, 5, -29 },
  { 3641, 23, 29, 24, 3, -29 },
  { 3725, 25, 29, 24, 0, -29 },
  { 3816, 21, 29, 24, 4, -29 },
  { 3893, 21, 29, 24, 2, -29 },
  { 3970, 15, 37, 24, 6, -33 },
  { 4040, 13, 37, 24, 6, -33 },
  { 4101, 15, 37, 24, 4, -33 },
  { 4171, 17, 15, 24, 4, -29 },
  { 4203, 20, 3, 24, 0, 1 },
  { 4211, 7, 5, 24, 11, -31 },
  { 4216, 20, 22, 24, 2, -22 },
  { 4271, 20, 29, 24, 2, -29 },
  { 4344, 19, 22, 24, 3, -22 },
  { 4397, 21, 29, 24, 2, -29 },
  { 4474, 18, 22, 24, 3, -22 },
  { 4524, 28, 36, 24, -2, -29 },
  { 4650, 19, 29, 24, 3, -22 },
  { 4719, 20, 29, 24, 2, -29 },
  { 4792, 20, 31, 24, 1, -31 },
  { 4870, 21, 38, 24, 0, -31 },
  { 4970, 21, 29, 24, 2, -29 },
  { 5047, 17, 29, 24, 4, -29 },
  { 5109, 22, 22, 24, 1, -22 },
  { 5170, 20, 22, 24, 2, -22 },
  { 5225, 18, 22, 24, 3, -22 },
  { 5275, 21, 29, 24, 1, -22 },
  { 5352, 20, 29, 24, 2, -22 },
  { 5425, 19, 22, 24, 3, -22 },
  { 5478, 19, 22, 24, 2, -22 },
  { 5531, 20, 28, 24, 3, -28 },
  { 5601, 20, 22, 24, 2, -22 },
  { 5656, 19, 22, 24, 4, -22 },
  { 5709, 21, 22, 24, 3, -22 },
  { 5767, 23, 22, 24, 0, -22 },
  { 5831, 19, 29, 24, 3, -22 },
  { 5900, 20, 22, 24, 2, -22 },
  { 5955, 20, 37, 24, 4, -33 },
  { 6048, 9, 37, 24, 8, -33 },
  { 6090, 20, 37, 24, 1, -33 },
  { 6183, 20, 8, 24, 2, -18 },
};

const GFXfont JetBrainsMono_Italic40pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Italic40pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Italic40pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _JETBRAINSMONO_ITALIC40PT7B_H_
