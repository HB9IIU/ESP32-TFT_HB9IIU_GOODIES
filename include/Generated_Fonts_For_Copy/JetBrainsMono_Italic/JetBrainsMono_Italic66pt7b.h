#ifndef _JETBRAINSMONO_ITALIC66PT7B_H_
#define _JETBRAINSMONO_ITALIC66PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Italic.ttf
// Size: 66pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Italic66pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xFC, 0x01,
  0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01,
  0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x3F,
  0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF, 0xC0, 0x7F, 0x80, 0x7F,
  0x00, 0x1F, 0x80, 0xFC, 0xFE, 0x03, 0xF3, 0xF8, 0x0F, 0xCF, 0xC0, 0x7F,
  0x3F, 0x01, 0xFC, 0xFC, 0x07, 0xF3, 0xF0, 0x1F, 0x9F, 0xC0, 0x7E, 0x7F,
  0x01, 0xF9, 0xF8, 0x07, 0xE7, 0xE0, 0x1F, 0x1F, 0x80, 0xFC, 0x7E, 0x03,
  0xF1, 0xF0, 0x0F, 0xC7, 0xC0, 0x3F, 0x1F, 0x00, 0xF8, 0x7C, 0x03, 0xE3,
  0xF0, 0x0F, 0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x0F, 0x80, 0x1F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x01, 0xE0,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0x00, 0xF0, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x3E, 0x00, 0x00, 0x78, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xC7,
  0x8F, 0xE0, 0x07, 0xF0, 0xF0, 0xFE, 0x01, 0xFC, 0x1E, 0x0F, 0xC0, 0x3F,
  0x07, 0x81, 0xF8, 0x0F, 0xC0, 0xF0, 0x3F, 0x01, 0xF8, 0x1E, 0x07, 0xE0,
  0x3F, 0x03, 0xC0, 0xFC, 0x07, 0xE0, 0x78, 0x00, 0x00, 0xFC, 0x0F, 0x00,
  0x00, 0x1F, 0x81, 0xE0, 0x00, 0x03, 0xF0, 0x78, 0x00, 0x00, 0x7F, 0x0F,
  0x00, 0x00, 0x0F, 0xE1, 0xE0, 0x00, 0x01, 0xFE, 0x3C, 0x00, 0x00, 0x1F,
  0xF7, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1E,
  0xFF, 0xC0, 0x00, 0x03, 0xC7, 0xF8, 0x00, 0x00, 0x78, 0x7F, 0x80, 0x00,
  0x0F, 0x07, 0xF0, 0x00, 0x01, 0xE0, 0x7E, 0x00, 0x00, 0x3C, 0x0F, 0xC0,
  0x00, 0x07, 0x81, 0xF8, 0x00, 0x01, 0xE0, 0x3F, 0x07, 0xE0, 0x3C, 0x07,
  0xE0, 0xFC, 0x07, 0x80, 0xFC, 0x1F, 0x80, 0xF0, 0x3F, 0x03, 0xF0, 0x1E,
  0x07, 0xE0, 0x7E, 0x03, 0xC1, 0xFC, 0x0F, 0xE0, 0xF0, 0x3F, 0x01, 0xFE,
  0x1E, 0x1F, 0xE0, 0x1F, 0xE3, 0xC7, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xC0, 0x0F, 0xFF, 0x80,
  0x00, 0x7C, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xC0, 0x0F, 0xFF, 0xF0, 0x00,
  0x7C, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xC0, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x01, 0xF0, 0x03, 0xE0, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0xF8, 0x03, 0xE0, 0x3E, 0x00, 0x07,
  0xC0, 0x1E, 0x03, 0xE0, 0x00, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0x01, 0xF0,
  0x0F, 0x81, 0xF0, 0x00, 0x0F, 0x80, 0x7C, 0x1F, 0x00, 0x00, 0x7C, 0x03,
  0xE1, 0xF0, 0x00, 0x03, 0xE0, 0x3E, 0x1F, 0x00, 0x00, 0x1F, 0x83, 0xF1,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x0F, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0xF8, 0x00,
  0x00, 0x00, 0x30, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x00,
  0x07, 0xC3, 0xFF, 0x80, 0x00, 0x00, 0x7C, 0x3F, 0xFE, 0x00, 0x00, 0x03,
  0xE3, 0xFF, 0xF8, 0x00, 0x00, 0x3E, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xE3,
  0xF0, 0x3F, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0xF8,
  0x07, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x3E, 0x00, 0x03, 0xF0, 0x7C, 0x01,
  0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x0F, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00,
  0x1F, 0x00, 0x3C, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x1F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0xF8, 0x00, 0xF8, 0x00, 0x7E, 0x1F, 0xC0, 0x0F, 0x80,
  0x03, 0xFF, 0xFC, 0x00, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0x80, 0x00,
  0x3F, 0xFC, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x03, 0xFC, 0x3F, 0xE0,
  0x00, 0x7F, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0x7E, 0x00, 0x3F, 0x1F, 0xC7, 0xF0, 0x07, 0xE3, 0xF8,
  0x3F, 0x00, 0xFC, 0x3F, 0x03, 0xF8, 0x1F, 0xC3, 0xF0, 0x1F, 0x81, 0xF8,
  0x3F, 0x01, 0xFC, 0x3F, 0x07, 0xE0, 0x0F, 0xE7, 0xE0, 0x7E, 0x00, 0x7E,
  0x7E, 0x07, 0xE0, 0x07, 0xFF, 0xC0, 0x7E, 0x00, 0x3F, 0xF8, 0x07, 0xE0,
  0x03, 0xFF, 0x00, 0x7E, 0x00, 0x1F, 0xF0, 0x07, 0xE0, 0x01, 0xFE, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x1F,
  0xF0, 0x0F, 0xC0, 0x03, 0xFF, 0x00, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xF0,
  0x1F, 0xDF, 0x80, 0x7F, 0xFF, 0xF9, 0xFC, 0x07, 0xFF, 0xFF, 0x0F, 0xC0,
  0x3F, 0xFF, 0xE0, 0x7E, 0x01, 0xFF, 0xFC, 0x07, 0xF0, 0x0F, 0xFF, 0x00,
  0x3F, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3F, 0x3F, 0x3F, 0x7F, 0x7F, 0x7F,
  0x7E, 0x7E, 0x7E, 0xFE, 0xFE, 0xFC, 0xFC, 0xFC, 0xFC, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0x00, 0x1F, 0x00, 0x08, 0xF8, 0x03, 0xE0, 0x0F, 0x9F, 0xE0,
  0x7C, 0x0F, 0xF7, 0xFF, 0x0F, 0x07, 0xFE, 0xFF, 0xF1, 0xE3, 0xFF, 0xFF,
  0xFF, 0xB9, 0xFF, 0xF8, 0xFF, 0xFB, 0x7F, 0xF8, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x0F,
  0xCF, 0x80, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x00, 0xFC, 0x3F, 0x80, 0x00,
  0x3F, 0x83, 0xF0, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x03, 0xF8, 0x0F, 0xE0,
  0x00, 0xFF, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x3F, 0xE0,
  0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xC0,
  0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07,
  0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0x83, 0xFC,
  0x7F, 0xE7, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0xFC, 0x7F, 0xC7, 0xF8,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F,
  0xE0, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x07, 0xE0,
  0x7E, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x1F,
  0x83, 0xF0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00,
  0x7E, 0x0F, 0x80, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x07, 0xC1, 0xF8, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x07, 0xC0,
  0xF8, 0x0F, 0xC1, 0xF0, 0x7F, 0x03, 0xF0, 0xFC, 0x1F, 0xE0, 0xF8, 0x3F,
  0x07, 0xF8, 0x3E, 0x0F, 0xC1, 0xFE, 0x1F, 0x83, 0xF0, 0x7F, 0x07, 0xE0,
  0xFC, 0x0F, 0xC1, 0xF8, 0x3E, 0x01, 0xC0, 0x7E, 0x1F, 0x80, 0x00, 0x1F,
  0x07, 0xE0, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00,
  0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x0F, 0xC3, 0xF0, 0x00,
  0x03, 0xF0, 0xFC, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0x7E, 0x0F, 0xC0,
  0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x03, 0xF0, 0x1F,
  0x80, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x3F, 0xF9, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFD,
  0xF8, 0x00, 0x1F, 0xE3, 0xF0, 0x00, 0xFF, 0x87, 0xC0, 0x03, 0xFC, 0x1F,
  0x80, 0x07, 0xF0, 0x3F, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x1E, 0x00, 0xFC,
  0x00, 0x30, 0x01, 0xF8, 0x00, 0xC0, 0x03, 0xF0, 0x01, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x0B, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFD, 0xFF, 0xC0, 0x0F, 0xF0,
  0x07, 0xF8, 0x07, 0xF0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0xFC,
  0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x40,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x00,
  0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x03, 0xF8, 0x03,
  0xFC, 0x03, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0xFC, 0x03, 0xF8,
  0x00, 0xFC, 0x07, 0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xE0,
  0x00, 0xFC, 0x1F, 0xC0, 0x00, 0xFC, 0x3F, 0x80, 0x01, 0xF8, 0x7F, 0x00,
  0x01, 0xF8, 0x7E, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x01, 0xF8, 0x7E, 0x00,
  0x01, 0xF8, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x3C, 0x00, 0x03, 0xE1, 0xFF, 0xC0, 0x03, 0xF3, 0xFF, 0xF8,
  0x01, 0xFB, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x01,
  0xFC, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0x87, 0xE0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x0F, 0xC1, 0xFC,
  0x00, 0x07, 0xE0, 0x7E, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x07, 0xF0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x01, 0xFD, 0xFF,
  0xE0, 0x03, 0xFB, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFC, 0x07, 0xFE, 0x0F, 0xF0, 0x01, 0xFE, 0x1F, 0xE0, 0x00,
  0xFE, 0x1F, 0xC0, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x7F, 0x3F, 0x00, 0x00,
  0x3F, 0x3F, 0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00,
  0x3F, 0x7E, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00,
  0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00,
  0xFC, 0x7E, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x03,
  0xF8, 0x3F, 0x80, 0x07, 0xF0, 0x3F, 0xE0, 0x1F, 0xE0, 0x1F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0E, 0x80, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00,
  0xFE, 0x7E, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x01,
  0xF8, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFC, 0xFF, 0xE0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x1F, 0x80,
  0x7E, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x7E,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x01,
  0xF8, 0x0F, 0xC0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0xFF,
  0x07, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xF8, 0x7F, 0xC0, 0x03, 0xF8, 0x07, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x03,
  0xF0, 0x1F, 0x80, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0xF8, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x00, 0x7C, 0x1F, 0x80,
  0x00, 0x3F, 0x07, 0xE0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xF0, 0x7E,
  0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x07, 0xA0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xBF, 0xFC, 0x07, 0xF8, 0x03, 0xFC, 0x0F, 0xE0,
  0x01, 0xFE, 0x1F, 0xC0, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0x7E, 0x3F, 0x80,
  0x00, 0x7F, 0x3F, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x3F, 0x7E, 0x00,
  0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0x7E, 0x00,
  0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00,
  0x00, 0xFE, 0x7E, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x01, 0xFC, 0x7F, 0x00,
  0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF8, 0x7F, 0xC0, 0x0F, 0xF0, 0x3F, 0xF0,
  0x3F, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0x9F, 0x80, 0x00, 0x3C, 0x3F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xF8,
  0x03, 0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFF, 0x0F, 0xFE, 0x0F, 0xFE,
  0x07, 0xFC, 0x07, 0xFC, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0xC0, 0x7F, 0xE0,
  0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0x80,
  0x0C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F,
  0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x3F, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8,
  0x02, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xF0, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x01, 0xF8, 0x00,
  0x00, 0x3E, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x00, 0x3E,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x07, 0xE0,
  0x00, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xFC, 0x3E, 0x07, 0xC0, 0x07, 0xFF,
  0x3E, 0x07, 0xC0, 0x0F, 0xFF, 0x3E, 0x07, 0xC0, 0x1F, 0xFF, 0xBE, 0x0F,
  0xC0, 0x3F, 0xC3, 0xFC, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x0F, 0x80, 0x7E,
  0x00, 0xFC, 0x0F, 0x80, 0x7C, 0x00, 0xFC, 0x0F, 0x80, 0x7C, 0x00, 0xFC,
  0x0F, 0x80, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0xFC, 0x00, 0xF8, 0x1F, 0x80,
  0xF8, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x00,
  0xF8, 0x1F, 0x00, 0xF8, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x01, 0xF8, 0x3F,
  0x01, 0xF8, 0x01, 0xF8, 0x3F, 0x01, 0xF8, 0x01, 0xF0, 0x3E, 0x01, 0xF0,
  0x01, 0xF0, 0x3E, 0x01, 0xF0, 0x01, 0xF0, 0x3E, 0x01, 0xF0, 0x03, 0xF0,
  0x3E, 0x01, 0xF0, 0x03, 0xF0, 0x3E, 0x01, 0xF8, 0x07, 0xF0, 0x7E, 0x01,
  0xFC, 0x0F, 0xE0, 0x7E, 0x01, 0xFF, 0xFD, 0xE0, 0x7C, 0x00, 0xFF, 0xFB,
  0xE0, 0x7C, 0x00, 0x7F, 0xF3, 0xE0, 0x7C, 0x00, 0x3F, 0xE3, 0xE0, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFB, 0xE0,
  0x00, 0x00, 0xFD, 0xF0, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0x3E, 0x7E,
  0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x1F, 0x8F,
  0xC0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x07, 0xE0,
  0xF8, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x01, 0xF8,
  0x1F, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0xFC,
  0x03, 0xF0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F,
  0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x01, 0xF8, 0x03,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7E, 0x00, 0x07, 0xE0,
  0x7E, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x00, 0xF8, 0x3F, 0x80, 0x00, 0x7C,
  0x1F, 0x80, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x0F,
  0xC7, 0xE0, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x01,
  0xFB, 0xF8, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x1F, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x03,
  0xF0, 0x03, 0xFF, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x0F, 0x80, 0x00, 0xFE,
  0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0xFC, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0xFC, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x03, 0xF8,
  0x03, 0xF0, 0x00, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x0F, 0xF0, 0x0F,
  0xC0, 0x00, 0xFF, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x00, 0xFC,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00,
  0x7E, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x01, 0xF8, 0x1F, 0x80,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x01, 0xF8, 0x0F,
  0xC0, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x03, 0xF8,
  0x0F, 0xC0, 0x01, 0xFF, 0x01, 0xF8, 0x01, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xF8, 0x03, 0xFC,
  0x03, 0xF8, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01,
  0xF8, 0x3E, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x03, 0xF8,
  0x1F, 0xE0, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7E, 0x00, 0xFF, 0xC0,
  0x1F, 0x80, 0x07, 0xF8, 0x07, 0xE0, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0xFC, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00,
  0x7E, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x07, 0xE0, 0x7E, 0x00,
  0x01, 0xF8, 0x1F, 0x80, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0x07, 0xE0, 0x7E, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0xFC, 0x07,
  0xC0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x03, 0xF0,
  0x3F, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x0F,
  0x80, 0xFC, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x07, 0xE0, 0x7E, 0x00,
  0x01, 0xF8, 0x1F, 0x80, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x01, 0xF8, 0x0F,
  0xC0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0xF8, 0x00, 0x0F, 0xC0,
  0x7E, 0x00, 0x0F, 0xF0, 0x1F, 0x80, 0x07, 0xF8, 0x07, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x03, 0xF8, 0x00,
  0x7F, 0x03, 0xF8, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x3E, 0x00,
  0x00, 0xFC, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x81, 0xFF, 0xFE, 0x0F,
  0xC0, 0xFF, 0xFF, 0x0F, 0xC0, 0x7F, 0xFF, 0x87, 0xE0, 0x3F, 0xFF, 0xC3,
  0xF0, 0x1F, 0xFF, 0xE1, 0xF8, 0x0F, 0xFF, 0xE0, 0xFC, 0x00, 0x03, 0xF0,
  0x7E, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x7E,
  0x1F, 0x80, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1F,
  0x83, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07,
  0xE0, 0x7E, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x1F, 0xC0, 0x03,
  0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x1F, 0x80, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x03,
  0xF0, 0x1F, 0x80, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x7E, 0x00,
  0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x7E,
  0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x3F, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x07,
  0xE0, 0x3F, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0x07, 0xE0, 0x1F, 0x80, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x7F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x3F, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x7E, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x7E, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x7E, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x08, 0x0F, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x7E, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x7E, 0x00,
  0x00, 0xFC, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x03, 0xF8, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x0E, 0x80, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0x0F, 0xE0,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x7E, 0x00,
  0x0F, 0xE0, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x01,
  0xFC, 0x00, 0x0F, 0xC0, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x01,
  0xF8, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x7F,
  0x00, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x1F, 0xC0,
  0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x01, 0xF8,
  0x03, 0xF8, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x1F, 0xC0,
  0x00, 0xFC, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x00, 0x3F, 0x80,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x7F, 0xC0,
  0x03, 0xFE, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x01, 0xF7, 0x80,
  0xF7, 0x80, 0x0F, 0xF8, 0x07, 0xBE, 0x00, 0xFB, 0xC0, 0x3D, 0xF0, 0x07,
  0xDE, 0x03, 0xEF, 0x80, 0x7C, 0xF0, 0x1F, 0x7C, 0x03, 0xEF, 0x80, 0xFB,
  0xE0, 0x3E, 0x7C, 0x07, 0xCF, 0x01, 0xF3, 0xE0, 0x3E, 0x78, 0x1F, 0x1E,
  0x01, 0xE3, 0xE0, 0xF9, 0xF0, 0x1F, 0x1F, 0x07, 0x8F, 0x80, 0xF8, 0xF8,
  0x7C, 0x7C, 0x07, 0xC7, 0xC3, 0xC3, 0xE0, 0x3E, 0x1E, 0x3E, 0x3F, 0x01,
  0xF0, 0xF1, 0xF1, 0xF0, 0x0F, 0x87, 0xDF, 0x0F, 0x80, 0xFC, 0x3E, 0xF8,
  0x7C, 0x07, 0xE1, 0xF7, 0x87, 0xE0, 0x3F, 0x0F, 0xFC, 0x3F, 0x01, 0xF8,
  0x3F, 0xC1, 0xF8, 0x0F, 0xC1, 0xFE, 0x0F, 0x80, 0x7C, 0x0F, 0xE0, 0x7C,
  0x03, 0xE0, 0x7F, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x7C, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x7E, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x01, 0xF8,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0xF8, 0x07,
  0xC0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xE0, 0x3F,
  0xE0, 0x00, 0xFC, 0x07, 0xFC, 0x00, 0x1F, 0x80, 0xFF, 0x80, 0x03, 0xF0,
  0x1F, 0xF0, 0x00, 0x7E, 0x03, 0xFF, 0x00, 0x0F, 0xC0, 0x7F, 0xE0, 0x01,
  0xF0, 0x1F, 0xFC, 0x00, 0x7E, 0x03, 0xFF, 0x80, 0x0F, 0xC0, 0x7D, 0xF0,
  0x01, 0xF8, 0x0F, 0xBF, 0x00, 0x3F, 0x01, 0xF3, 0xE0, 0x07, 0xE0, 0x3E,
  0x7C, 0x00, 0xF8, 0x0F, 0xCF, 0x80, 0x3F, 0x01, 0xF9, 0xF0, 0x07, 0xE0,
  0x3F, 0x3F, 0x00, 0xFC, 0x07, 0xE3, 0xE0, 0x1F, 0x80, 0xFC, 0x7C, 0x03,
  0xF0, 0x1F, 0x0F, 0x80, 0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x80, 0xFC, 0x3F,
  0x03, 0xF0, 0x1F, 0x83, 0xE0, 0x7E, 0x03, 0xF0, 0x7C, 0x0F, 0xC0, 0x7E,
  0x0F, 0x81, 0xF8, 0x0F, 0xC1, 0xF0, 0x3E, 0x01, 0xF0, 0x3F, 0x07, 0xC0,
  0x7E, 0x03, 0xE1, 0xF8, 0x0F, 0xC0, 0x7C, 0x3F, 0x01, 0xF8, 0x0F, 0x87,
  0xE0, 0x3F, 0x01, 0xF0, 0xFC, 0x07, 0xE0, 0x3F, 0x1F, 0x80, 0xF8, 0x03,
  0xE3, 0xE0, 0x3F, 0x00, 0x7C, 0x7C, 0x07, 0xE0, 0x0F, 0x9F, 0x80, 0xFC,
  0x01, 0xF3, 0xF0, 0x1F, 0x80, 0x3F, 0x7E, 0x03, 0xF0, 0x03, 0xEF, 0xC0,
  0x7C, 0x00, 0x7D, 0xF0, 0x0F, 0x80, 0x0F, 0xBE, 0x03, 0xF0, 0x01, 0xF7,
  0xC0, 0x7E, 0x00, 0x3F, 0xF8, 0x0F, 0xC0, 0x03, 0xFF, 0x01, 0xF8, 0x00,
  0x7F, 0xE0, 0x3F, 0x00, 0x0F, 0xF8, 0x07, 0xC0, 0x01, 0xFF, 0x01, 0xF8,
  0x00, 0x3F, 0xE0, 0x3F, 0x00, 0x03, 0xFC, 0x07, 0xE0, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0xFE, 0x03, 0xF8, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00, 0xFC, 0x3F, 0x00,
  0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xE1, 0xF8,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x3F,
  0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3F, 0x0F,
  0xC0, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01, 0xF8,
  0x3E, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x07,
  0xF0, 0x3F, 0x80, 0x03, 0xF0, 0x1F, 0xC0, 0x07, 0xF8, 0x07, 0xF8, 0x07,
  0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0E,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0x80, 0x07, 0xFE, 0x01, 0xF8, 0x00, 0x1F, 0xE0, 0x1F,
  0x80, 0x00, 0xFF, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x00, 0x7F,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x3F, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x7E,
  0x00, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x7E,
  0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x01, 0xFC, 0x07, 0xC0, 0x00,
  0x3F, 0x80, 0xFC, 0x00, 0x07, 0xF8, 0x0F, 0xC0, 0x03, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x3F, 0xF9, 0xFF, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x01,
  0xFE, 0x03, 0xF8, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x07, 0xE0, 0x7E, 0x00,
  0x01, 0xF8, 0x1F, 0x80, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x7E, 0x0F,
  0x80, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xF0,
  0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00,
  0x7E, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x07, 0xE0, 0xFC, 0x00,
  0x01, 0xF8, 0x3F, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x1F, 0x07, 0xE0,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x1F,
  0x80, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x03, 0xF0,
  0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x1F,
  0x83, 0xF8, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x01,
  0xF8, 0x07, 0xF0, 0x00, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xF0, 0x01,
  0xFF, 0x80, 0x7E, 0x00, 0x0F, 0xF0, 0x0F, 0xC0, 0x00, 0xFF, 0x03, 0xF0,
  0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0x81,
  0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0xFC, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x00, 0x7E, 0x03, 0xF0,
  0x00, 0x1F, 0xC0, 0x7C, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x03, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x0F, 0xC0, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x07,
  0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xE0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x0F, 0xC0, 0x03,
  0xF8, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x0F, 0xC0,
  0x00, 0xFE, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x01, 0xFC, 0x07,
  0xE0, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x7F,
  0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xF7, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x01,
  0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x3F, 0x00,
  0x00, 0xFC, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x7E, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x3F, 0x01, 0xFE, 0x00, 0x1F,
  0xE0, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x03, 0xF0, 0x3F,
  0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0xFC, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x7E,
  0x07, 0xE0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x01,
  0xF8, 0x1F, 0x80, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x3F, 0x01, 0xF0, 0x00,
  0x0F, 0xC0, 0xFC, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0xFC, 0x0F, 0xC0,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x07, 0xE0, 0x3F,
  0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x1F, 0x81,
  0xF8, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x7E,
  0x07, 0xE0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x03,
  0xF0, 0x3F, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0xFC, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x01, 0xF8, 0x1F, 0x80,
  0x00, 0x7E, 0x07, 0xE0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x07, 0xE0, 0x7E,
  0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x3F, 0x01,
  0xF8, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x07, 0xF8,
  0x03, 0xFC, 0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x0F, 0xE7,
  0xC0, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x03, 0xF0,
  0xFC, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFC,
  0x1F, 0x80, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x0F,
  0xC0, 0x3F, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x07, 0xE0, 0x0F, 0xC0, 0x07,
  0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x7E, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x03, 0xF0,
  0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x00,
  0xF8, 0xFC, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00,
  0x1F, 0xBE, 0x00, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x7E, 0x00, 0xFE, 0x00, 0xF8, 0xFC,
  0x01, 0xFC, 0x01, 0xF1, 0xF8, 0x07, 0xF8, 0x07, 0xE3, 0xF0, 0x0F, 0xF0,
  0x0F, 0x87, 0xE0, 0x1F, 0xE0, 0x1F, 0x0F, 0xC0, 0x3B, 0x80, 0x3E, 0x1F,
  0x80, 0xF7, 0x00, 0xFC, 0x3E, 0x01, 0xEE, 0x01, 0xF0, 0x7C, 0x03, 0xDC,
  0x03, 0xE0, 0xF8, 0x0F, 0x38, 0x0F, 0xC1, 0xF0, 0x1E, 0x70, 0x1F, 0x03,
  0xE0, 0x3C, 0xE0, 0x3E, 0x07, 0xC0, 0x73, 0xC0, 0x7C, 0x0F, 0x81, 0xE7,
  0x81, 0xF8, 0x1F, 0x03, 0xCF, 0x03, 0xE0, 0x3E, 0x07, 0x9E, 0x07, 0xC0,
  0x7C, 0x1E, 0x3C, 0x0F, 0x80, 0xF8, 0x3C, 0x78, 0x3F, 0x01, 0xF0, 0x78,
  0xF0, 0x7C, 0x07, 0xE0, 0xE1, 0xE0, 0xF8, 0x0F, 0xC3, 0xC3, 0xC1, 0xF0,
  0x1F, 0x87, 0x87, 0x87, 0xC0, 0x3F, 0x0F, 0x0F, 0x0F, 0x80, 0x7E, 0x3C,
  0x1E, 0x1F, 0x00, 0xF8, 0x78, 0x3C, 0x7E, 0x01, 0xF0, 0xF0, 0x78, 0xF8,
  0x03, 0xE1, 0xE0, 0xF1, 0xF0, 0x07, 0xC7, 0x81, 0xE3, 0xE0, 0x0F, 0x8F,
  0x03, 0x8F, 0xC0, 0x1F, 0x1E, 0x07, 0x1F, 0x00, 0x3E, 0x78, 0x0E, 0x3E,
  0x00, 0x7C, 0xF0, 0x1C, 0x7C, 0x00, 0xF9, 0xE0, 0x39, 0xF0, 0x01, 0xF3,
  0xC0, 0xF3, 0xE0, 0x03, 0xEF, 0x01, 0xE7, 0xC0, 0x07, 0xDE, 0x03, 0xCF,
  0x80, 0x0F, 0xBC, 0x07, 0xBE, 0x00, 0x1F, 0xF0, 0x0F, 0x7C, 0x00, 0x3F,
  0xE0, 0x1E, 0xF8, 0x00, 0x7F, 0xC0, 0x3D, 0xE0, 0x00, 0xF7, 0x80, 0x7F,
  0xC0, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x0F,
  0xF8, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x00, 0x0F, 0xC0, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x00, 0x0F, 0xC3, 0xF8, 0x00,
  0x00, 0x07, 0xE3, 0xF8, 0x00, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x00,
  0xFD, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x00, 0x1F,
  0x8F, 0xC0, 0x00, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x00, 0x1F, 0xC1, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00,
  0x0F, 0xE0, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x07, 0xE0,
  0x03, 0xF0, 0x00, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x7E,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0xFC, 0x00, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x01, 0xF9, 0xF8, 0x00,
  0x00, 0x7E, 0x3F, 0x00, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x03, 0xF0, 0x7E,
  0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x07, 0xE0,
  0x1F, 0x80, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x1F, 0x80, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x3F, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0x01, 0xF8, 0x7E, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x03, 0xF3, 0xF0,
  0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8,
  0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x3F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x03, 0xE3,
  0xE0, 0x00, 0x3F, 0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x83, 0xE0,
  0x00, 0xF8, 0x1F, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0xFC, 0x03, 0xC0, 0x07,
  0xC0, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x3E, 0x00,
  0x1F, 0x03, 0xF0, 0x00, 0xF8, 0x1F, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x3E,
  0x1F, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x3E, 0x7C,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xFC, 0x3F, 0x00, 0x7F, 0xFF, 0x3F, 0x00, 0xFF, 0xFF, 0x3F, 0x01, 0xFF,
  0xFF, 0xBF, 0x03, 0xFE, 0x0F, 0xBF, 0x07, 0xF8, 0x03, 0xBF, 0x07, 0xF0,
  0x01, 0xBE, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0,
  0x00, 0xFE, 0x1F, 0x80, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x7E, 0x1F, 0x80,
  0x00, 0xFC, 0x1F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x00,
  0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x00,
  0x00, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x01, 0xF8, 0x7E, 0x00,
  0x01, 0xF8, 0x7E, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x01, 0xF8, 0x7E, 0x00,
  0x03, 0xF8, 0x7E, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x7E, 0x00,
  0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x1F, 0xF0, 0x7F, 0x80,
  0x3B, 0xF0, 0x3F, 0xFB, 0xFF, 0xE0, 0x3F, 0xFF, 0xF7, 0xE0, 0x1F, 0xFF,
  0xE7, 0xE0, 0x0F, 0xFF, 0xC7, 0xE0, 0x07, 0xFF, 0x07, 0xE0, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0x07, 0xF0, 0x00, 0x3F, 0x0F, 0xFF, 0x00, 0x1F, 0x9F, 0xFF, 0xC0,
  0x1F, 0x9F, 0xFF, 0xF0, 0x0F, 0xDF, 0xFF, 0xF8, 0x07, 0xEF, 0x87, 0xFE,
  0x03, 0xFE, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F,
  0xE0, 0x7E, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00,
  0xFC, 0x1F, 0x80, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xE0, 0x00,
  0x3F, 0x03, 0xF0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x3F, 0x00,
  0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7E, 0x0F, 0xC0,
  0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x07, 0xF0, 0x7F,
  0x80, 0x03, 0xF0, 0x3F, 0xE0, 0x03, 0xF8, 0x1F, 0xF8, 0x07, 0xF8, 0x0F,
  0xDF, 0xFF, 0xFC, 0x07, 0xEF, 0xFF, 0xFC, 0x03, 0xF7, 0xFF, 0xFC, 0x03,
  0xF1, 0xFF, 0xF8, 0x01, 0xF8, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0x1F,
  0xFC, 0x07, 0xF8, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x00,
  0x7E, 0x0F, 0xC0, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x00,
  0x7E, 0x1F, 0x80, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x01,
  0xF8, 0x7E, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x07,
  0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x7E,
  0x00, 0x1F, 0xFC, 0x3F, 0x00, 0x1F, 0xFF, 0xCF, 0xC0, 0x0F, 0xFF, 0xF3,
  0xF0, 0x07, 0xFF, 0xFE, 0xFC, 0x03, 0xFE, 0x0F, 0xBF, 0x01, 0xFE, 0x00,
  0xEF, 0xC0, 0x7F, 0x00, 0x1B, 0xE0, 0x3F, 0x80, 0x03, 0xF8, 0x0F, 0xC0,
  0x00, 0xFE, 0x07, 0xF0, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x07, 0xE0, 0x7E,
  0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0xFC,
  0x0F, 0xC0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x07,
  0xE0, 0x7E, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x7E, 0x07, 0xE0, 0x00,
  0x1F, 0x81, 0xF8, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x03, 0xF8, 0x1F, 0x80,
  0x00, 0xFC, 0x07, 0xE0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x7F,
  0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x07, 0xFC, 0x07, 0xF8, 0x03, 0xBF, 0x00,
  0xFF, 0xEF, 0xFF, 0x80, 0x3F, 0xFF, 0xF7, 0xE0, 0x07, 0xFF, 0xF9, 0xF8,
  0x00, 0xFF, 0xFC, 0x7E, 0x00, 0x1F, 0xFC, 0x1F, 0x80, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xC0,
  0xFF, 0x80, 0xFE, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x00,
  0xFE, 0x1F, 0x80, 0x00, 0xFC, 0x7E, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03,
  0xF1, 0xF8, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x1F,
  0x1F, 0x80, 0x00, 0x7E, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xE3, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0,
  0x03, 0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0x3F, 0xF1, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0xF8, 0xFC, 0x03, 0xFF, 0xF9, 0xF8, 0x0F, 0xFF, 0xFB, 0xF0,
  0x3F, 0xFF, 0xF7, 0xE0, 0xFF, 0x83, 0xEF, 0xC3, 0xFC, 0x01, 0xDF, 0x87,
  0xF0, 0x01, 0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x00, 0x03, 0xF8, 0xFE,
  0x00, 0x03, 0xF1, 0xF8, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x0F, 0xC7, 0xE0,
  0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0xFC, 0x7E, 0x00,
  0x01, 0xF8, 0xFC, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x07, 0xE3, 0xF0, 0x00,
  0x0F, 0x87, 0xE0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x7E, 0x3F, 0x00, 0x00,
  0xFC, 0x7E, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x0F,
  0xE3, 0xF8, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x07, 0xFE,
  0x0F, 0xFE, 0x7E, 0xFC, 0x0F, 0xFF, 0xFD, 0xF8, 0x0F, 0xFF, 0xF3, 0xF0,
  0x0F, 0xFF, 0xCF, 0xC0, 0x0F, 0xFE, 0x1F, 0x80, 0x03, 0xE0, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x3F, 0x0F, 0xFF, 0x00,
  0x1F, 0x9F, 0xFF, 0xC0, 0x1F, 0x9F, 0xFF, 0xF0, 0x0F, 0xDF, 0xFF, 0xFC,
  0x07, 0xEF, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x1F,
  0xC0, 0xFE, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x01,
  0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7E, 0x0F, 0xC0, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00,
  0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x80,
  0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x07, 0xE0, 0x7C,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x1F,
  0x80, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x20, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0x03, 0xF0,
  0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x3F, 0x80,
  0x3E, 0x00, 0x03, 0xF8, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x0F,
  0xE0, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x07, 0xE0,
  0x07, 0xF0, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x1F, 0xE0, 0x00,
  0xFC, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x00, 0xFC, 0x07, 0xF0,
  0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x01, 0xF8, 0x0F, 0xE0,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x07, 0xF0, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0xFE,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x01, 0xF8, 0x0F,
  0xC0, 0x00, 0x1F, 0xC0, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x01,
  0xF0, 0x1F, 0x80, 0x3E, 0x3F, 0xC3, 0xFC, 0x03, 0xE7, 0xFC, 0x7F, 0xE0,
  0x3E, 0xFF, 0xEF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0x07, 0xF8,
  0x3F, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x7E, 0x03, 0xE0, 0x3F, 0x07, 0xE0,
  0x3E, 0x03, 0xF0, 0x7C, 0x03, 0xE0, 0x3F, 0x07, 0xC0, 0x3E, 0x03, 0xF0,
  0xFC, 0x03, 0xC0, 0x3E, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0xFC, 0x07, 0xC0,
  0x3E, 0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0xF8, 0x07, 0xC0, 0x7E, 0x0F, 0x80,
  0x7C, 0x07, 0xE0, 0xF8, 0x07, 0x80, 0x7C, 0x1F, 0x80, 0xF8, 0x07, 0xC1,
  0xF8, 0x0F, 0x80, 0x7C, 0x1F, 0x80, 0xF8, 0x0F, 0xC1, 0xF0, 0x0F, 0x80,
  0xFC, 0x1F, 0x00, 0xF8, 0x0F, 0xC1, 0xF0, 0x0F, 0x00, 0xF8, 0x3F, 0x01,
  0xF0, 0x0F, 0x83, 0xF0, 0x1F, 0x00, 0xF8, 0x3F, 0x01, 0xF0, 0x1F, 0x83,
  0xE0, 0x1F, 0x01, 0xF8, 0x3E, 0x01, 0xF0, 0x1F, 0x83, 0xE0, 0x1E, 0x01,
  0xF8, 0x7E, 0x01, 0xE0, 0x1F, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x7E, 0x03,
  0xE0, 0x1F, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x7C, 0x03, 0xE0, 0x3F, 0x07,
  0xC0, 0x3E, 0x03, 0xF0, 0xFC, 0x03, 0xC0, 0x3E, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x01, 0xF8, 0x7F, 0xF8, 0x00, 0xFC, 0xFF, 0xFE, 0x00, 0xFC, 0xFF,
  0xFF, 0x80, 0x7E, 0xFF, 0xFF, 0xE0, 0x3F, 0x78, 0x1F, 0xF0, 0x1F, 0xF0,
  0x03, 0xF8, 0x0F, 0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x07, 0xF0,
  0x00, 0x1F, 0x83, 0xF8, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x1F,
  0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x0F, 0xC0,
  0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01, 0xF8,
  0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7E,
  0x07, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01,
  0xF0, 0x3F, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0x00,
  0x7E, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0x80, 0x7F, 0xE1, 0xFF, 0x81, 0xFE, 0x00, 0xFF, 0x03, 0xF8, 0x00,
  0x7E, 0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0xFC, 0x7E, 0x00, 0x01,
  0xF8, 0xFC, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x0F,
  0xCF, 0xC0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0xFC,
  0x7E, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x07, 0xE3,
  0xE0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x7E, 0x3F,
  0x00, 0x00, 0xFC, 0x7E, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03, 0xF1, 0xF8,
  0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7F, 0x0F, 0xE0,
  0x00, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xE0, 0x1F, 0xE0, 0x3F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xA0, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0x87, 0xFF, 0x80, 0x03, 0xF3, 0xFF, 0xF8, 0x00,
  0xFC, 0xFF, 0xFF, 0x80, 0x1F, 0xBF, 0xFF, 0xF8, 0x03, 0xF7, 0xC3, 0xFF,
  0x00, 0x7F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x00, 0xFE, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x7F, 0x00, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x3F, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0xFC, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x7E, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x7E, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x7E, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x3F,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x01, 0xF8, 0x07, 0xFC, 0x00,
  0x7F, 0x00, 0xFF, 0xC0, 0x3F, 0xC0, 0x1F, 0xBF, 0xFF, 0xF8, 0x03, 0xF7,
  0xFF, 0xFE, 0x00, 0x7C, 0x7F, 0xFF, 0x80, 0x1F, 0x8F, 0xFF, 0xC0, 0x03,
  0xF0, 0x7F, 0xF0, 0x00, 0x7E, 0x01, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0xFC, 0x3F, 0x00, 0x7F, 0xFF, 0x3F, 0x00, 0xFF, 0xFF,
  0x3F, 0x01, 0xFF, 0xFF, 0xBF, 0x03, 0xFE, 0x0F, 0xBF, 0x07, 0xF8, 0x03,
  0xFE, 0x07, 0xF0, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xC0, 0x00,
  0xFE, 0x1F, 0x80, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0xFE, 0x1F, 0x80, 0x00,
  0xFE, 0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00,
  0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00,
  0xFC, 0x3F, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x01,
  0xF8, 0x7E, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x01,
  0xF8, 0x7E, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x03,
  0xF0, 0x7E, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x1F,
  0xF0, 0x7F, 0x80, 0x3B, 0xE0, 0x3F, 0xFB, 0xFF, 0xE0, 0x3F, 0xFF, 0xF7,
  0xE0, 0x1F, 0xFF, 0xE7, 0xE0, 0x0F, 0xFF, 0xC7, 0xE0, 0x07, 0xFF, 0x07,
  0xE0, 0x00, 0x78, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x7F, 0xF8, 0x00, 0xFC, 0xFF,
  0xFE, 0x00, 0x7E, 0xFF, 0xFF, 0x80, 0x3E, 0xFF, 0xFF, 0xE0, 0x3F, 0x7C,
  0x1F, 0xF0, 0x1F, 0xF0, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0xFE, 0x07, 0xF0,
  0x00, 0x3F, 0x03, 0xF8, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x0F, 0xC1, 0xFC,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x3F,
  0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xC0, 0xFF, 0x81, 0xFC, 0x00,
  0x3F, 0x83, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xCF, 0xC0,
  0x00, 0x3F, 0x1F, 0x80, 0x00, 0x7E, 0x3F, 0x80, 0x01, 0xFC, 0x7F, 0x80,
  0x0F, 0xF0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x40, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00,
  0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x80,
  0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x1F,
  0x80, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF8,
  0x1F, 0x80, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0xFE,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xF7, 0xE0, 0x00,
  0x07, 0xE7, 0xC0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x3F, 0x1F, 0x80, 0x00,
  0xFC, 0x3F, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F,
  0xC0, 0xF8, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x01, 0xF8,
  0x07, 0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x7E, 0x01, 0xF0, 0x00,
  0xFC, 0x07, 0xE0, 0x01, 0xF8, 0x0F, 0x80, 0x03, 0xF0, 0x3F, 0x00, 0x03,
  0xE0, 0x7C, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x1F,
  0x8F, 0xC0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7C,
  0xFC, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xF8, 0x03, 0xF0, 0x03, 0xFF, 0x00,
  0x7E, 0x00, 0x7F, 0xE0, 0x0F, 0xC0, 0x1F, 0x7C, 0x03, 0xF8, 0x03, 0xEF,
  0x80, 0x7F, 0x00, 0x7D, 0xF0, 0x0F, 0xE0, 0x1F, 0x3E, 0x03, 0xDC, 0x03,
  0xE7, 0xC0, 0x7B, 0x80, 0x7C, 0xF8, 0x0F, 0x70, 0x1F, 0x1F, 0x01, 0xCE,
  0x03, 0xE3, 0xE0, 0x79, 0xC0, 0x7C, 0x7C, 0x0F, 0x38, 0x1F, 0x0F, 0x81,
  0xC7, 0x03, 0xE1, 0xF0, 0x78, 0xE0, 0x7C, 0x3E, 0x0F, 0x1C, 0x0F, 0x07,
  0xC1, 0xC3, 0x83, 0xE0, 0xF8, 0x78, 0x70, 0x7C, 0x1F, 0x0F, 0x0E, 0x0F,
  0x03, 0xE1, 0xC1, 0xC3, 0xE0, 0x7C, 0x78, 0x38, 0x7C, 0x0F, 0x8F, 0x07,
  0x0F, 0x01, 0xF1, 0xC0, 0xE3, 0xE0, 0x3E, 0x78, 0x1C, 0x7C, 0x07, 0xCF,
  0x03, 0x8F, 0x00, 0xF9, 0xC0, 0x71, 0xE0, 0x1F, 0x78, 0x0E, 0x7C, 0x03,
  0xEF, 0x01, 0xCF, 0x00, 0x7D, 0xC0, 0x39, 0xE0, 0x0F, 0xF8, 0x07, 0x7C,
  0x01, 0xFF, 0x00, 0xEF, 0x00, 0x3F, 0xE0, 0x1D, 0xE0, 0x07, 0xF8, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x0F, 0xE0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF8, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x1F, 0x80,
  0x00, 0xFC, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x1F, 0x81,
  0xFC, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00,
  0x1F, 0xCF, 0xE0, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x03, 0xF7, 0xE0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x00,
  0x7F, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x3F, 0x01, 0xF8,
  0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00,
  0x3F, 0x81, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x0F,
  0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x7E, 0x1F,
  0x80, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0xFC, 0x1F,
  0x80, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x3F,
  0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xF8, 0x3F,
  0x00, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x01, 0xF8, 0x7E,
  0x00, 0x01, 0xF8, 0x7E, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x01, 0xF8, 0x7E,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x03, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0xFE,
  0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x7F, 0xE0, 0x7F,
  0xFF, 0xF7, 0xE0, 0x3F, 0xFF, 0xF7, 0xE0, 0x1F, 0xFF, 0xE7, 0xE0, 0x0F,
  0xFF, 0x8F, 0xC0, 0x03, 0xFE, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8,
  0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0,
  0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x1F,
  0x83, 0xFF, 0x80, 0x0F, 0xC3, 0xFF, 0xE0, 0x07, 0xE3, 0xFF, 0xF8, 0x03,
  0xF3, 0xFF, 0xFC, 0x01, 0xF1, 0xF8, 0x7F, 0x00, 0xF9, 0xF8, 0x1F, 0xC0,
  0xFC, 0xFC, 0x07, 0xF0, 0x7E, 0x7C, 0x03, 0xFF, 0xFE, 0x3E, 0x00, 0xFF,
  0xFF, 0x3F, 0x00, 0x3F, 0xFF, 0x1F, 0x80, 0x0F, 0xFF, 0x0F, 0xC0, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x10, 0x00,
};

const GFXglyph JetBrainsMono_Italic66pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 40, 0, -1 },
  { 1, 16, 48, 40, 12, -48 },
  { 97, 22, 20, 40, 12, -48 },
  { 152, 38, 48, 40, 2, -48 },
  { 380, 35, 66, 40, 3, -57 },
  { 669, 45, 49, 40, -2, -49 },
  { 945, 36, 50, 40, 2, -49 },
  { 1170, 8, 20, 40, 19, -48 },
  { 1190, 28, 64, 40, 10, -56 },
  { 1414, 27, 64, 40, 3, -56 },
  { 1630, 35, 34, 40, 3, -40 },
  { 1779, 32, 31, 40, 4, -37 },
  { 1903, 18, 21, 40, 6, -10 },
  { 1951, 22, 5, 40, 9, -24 },
  { 1965, 12, 11, 40, 12, -10 },
  { 1982, 39, 62, 40, 1, -55 },
  { 2285, 34, 50, 40, 4, -49 },
  { 2498, 31, 48, 40, 3, -48 },
  { 2684, 34, 49, 40, 3, -49 },
  { 2893, 34, 49, 40, 3, -48 },
  { 3102, 32, 48, 40, 4, -48 },
  { 3294, 33, 49, 40, 4, -48 },
  { 3497, 32, 49, 40, 3, -48 },
  { 3693, 32, 48, 40, 8, -48 },
  { 3885, 34, 50, 40, 3, -49 },
  { 4098, 32, 49, 40, 6, -49 },
  { 4294, 16, 38, 40, 12, -37 },
  { 4370, 21, 48, 40, 7, -37 },
  { 4496, 31, 35, 40, 6, -39 },
  { 4632, 32, 21, 40, 4, -32 },
  { 4716, 32, 35, 40, 3, -39 },
  { 4856, 27, 48, 40, 9, -48 },
  { 5018, 40, 61, 40, 0, -49 },
  { 5323, 33, 48, 40, 0, -48 },
  { 5521, 35, 48, 40, 3, -48 },
  { 5731, 33, 50, 40, 4, -49 },
  { 5938, 34, 48, 40, 3, -48 },
  { 6142, 35, 48, 40, 4, -48 },
  { 6352, 36, 48, 40, 3, -48 },
  { 6568, 33, 50, 40, 4, -49 },
  { 6775, 35, 48, 40, 3, -48 },
  { 6985, 33, 48, 40, 4, -48 },
  { 7183, 36, 49, 40, 1, -48 },
  { 7404, 38, 48, 40, 3, -48 },
  { 7632, 28, 48, 40, 5, -48 },
  { 7800, 37, 48, 40, 2, -48 },
  { 8022, 35, 48, 40, 3, -48 },
  { 8232, 33, 50, 40, 4, -49 },
  { 8439, 36, 48, 40, 3, -48 },
  { 8655, 34, 61, 40, 4, -49 },
  { 8915, 35, 48, 40, 3, -48 },
  { 9125, 35, 50, 40, 3, -49 },
  { 9344, 33, 48, 40, 8, -48 },
  { 9542, 34, 49, 40, 4, -48 },
  { 9751, 33, 48, 40, 8, -48 },
  { 9949, 39, 48, 40, 4, -48 },
  { 10183, 41, 48, 40, 0, -48 },
  { 10429, 35, 48, 40, 7, -48 },
  { 10639, 35, 48, 40, 3, -48 },
  { 10849, 26, 62, 40, 9, -55 },
  { 11051, 20, 62, 40, 11, -55 },
  { 11206, 26, 62, 40, 6, -55 },
  { 11408, 29, 26, 40, 6, -48 },
  { 11503, 32, 5, 40, 0, 2 },
  { 11523, 13, 9, 40, 17, -52 },
  { 11538, 32, 38, 40, 4, -37 },
  { 11690, 33, 49, 40, 3, -48 },
  { 11893, 32, 38, 40, 4, -37 },
  { 12045, 34, 49, 40, 4, -48 },
  { 12254, 31, 38, 40, 4, -37 },
  { 12402, 45, 60, 40, -3, -48 },
  { 12740, 31, 49, 40, 5, -37 },
  { 12930, 33, 48, 40, 3, -48 },
  { 13128, 32, 51, 40, 2, -51 },
  { 13332, 34, 63, 40, 1, -51 },
  { 13600, 36, 48, 40, 3, -48 },
  { 13816, 27, 48, 40, 7, -48 },
  { 13978, 36, 37, 40, 1, -37 },
  { 14145, 33, 37, 40, 3, -37 },
  { 14298, 31, 38, 40, 4, -37 },
  { 14446, 35, 49, 40, 1, -37 },
  { 14661, 32, 49, 40, 4, -37 },
  { 14857, 33, 37, 40, 4, -37 },
  { 15010, 31, 38, 40, 4, -37 },
  { 15158, 31, 46, 40, 6, -46 },
  { 15337, 33, 37, 40, 4, -36 },
  { 15490, 31, 36, 40, 7, -36 },
  { 15630, 35, 36, 40, 5, -36 },
  { 15788, 37, 36, 40, 1, -36 },
  { 15955, 32, 48, 40, 5, -36 },
  { 16147, 33, 36, 40, 3, -36 },
  { 16296, 34, 62, 40, 6, -55 },
  { 16560, 16, 62, 40, 13, -55 },
  { 16684, 33, 62, 40, 2, -55 },
  { 16940, 33, 14, 40, 4, -30 },
};

const GFXfont JetBrainsMono_Italic66pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Italic66pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Italic66pt7bGlyphs,
  0x20, 0x7E, 87
};

#endif // _JETBRAINSMONO_ITALIC66PT7B_H_
