#ifndef _JETBRAINSMONO_ITALIC20PT7B_H_
#define _JETBRAINSMONO_ITALIC20PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Italic.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Italic20pt7bBitmaps[] PROGMEM = {
  0x00, 0x39, 0x8C, 0x63, 0x18, 0x8C, 0x63, 0x10, 0x00, 0x73, 0x80, 0xCF,
  0x3C, 0xF3, 0xCE, 0x20, 0x02, 0x30, 0x62, 0x04, 0x20, 0x46, 0x3F, 0xF3,
  0xFF, 0x08, 0xC1, 0x88, 0x10, 0x81, 0x1A, 0xFF, 0xC2, 0x10, 0x23, 0x06,
  0x20, 0x46, 0x00, 0x03, 0x00, 0x80, 0x70, 0x7F, 0x32, 0xCD, 0xB2, 0x40,
  0xD0, 0x3C, 0x07, 0xC0, 0x78, 0x36, 0x0C, 0xB2, 0x6C, 0x9B, 0xFC, 0x7E,
  0x02, 0x01, 0x80, 0x40, 0x0E, 0x04, 0x7C, 0x23, 0x31, 0x0C, 0xCC, 0x33,
  0x60, 0xDB, 0x01, 0xC8, 0x00, 0x40, 0x02, 0x60, 0x1B, 0xC0, 0xD9, 0x06,
  0x44, 0x11, 0x10, 0x84, 0xCC, 0x1E, 0x00, 0x07, 0x80, 0xFC, 0x18, 0xC1,
  0x8C, 0x18, 0x01, 0x80, 0x0C, 0x03, 0xC1, 0x66, 0x66, 0x6C, 0x63, 0xC6,
  0x38, 0x43, 0x86, 0x6C, 0x7C, 0xC0, 0xFF, 0xE0, 0x01, 0x83, 0x83, 0x03,
  0x03, 0x01, 0x80, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x08, 0x04, 0x02, 0x01,
  0x80, 0xC0, 0x70, 0x1C, 0x07, 0x00, 0x80, 0x10, 0x1C, 0x0E, 0x06, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x02, 0x06, 0x06, 0x06, 0x0C, 0x0C, 0x18,
  0x70, 0xE0, 0x80, 0x06, 0x00, 0xC0, 0x10, 0x72, 0x77, 0xFC, 0x18, 0x07,
  0x81, 0xB0, 0x63, 0x0C, 0x60, 0x06, 0x01, 0x80, 0x40, 0x30, 0xFF, 0xC3,
  0x00, 0xC0, 0x30, 0x08, 0x00, 0x39, 0x9C, 0xC6, 0x60, 0xFE, 0xFF, 0x80,
  0x00, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x10,
  0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x00,
  0x30, 0x06, 0x00, 0xE0, 0x00, 0x07, 0x07, 0xF3, 0x0C, 0x83, 0x60, 0xD8,
  0x36, 0x4D, 0xB3, 0x4C, 0xD0, 0x2C, 0x1B, 0x06, 0xC1, 0x99, 0xC3, 0xE0,
  0x07, 0x07, 0x8E, 0xC6, 0x64, 0x20, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x01, 0x80, 0xC7, 0xFF, 0xFE, 0x07, 0x07, 0xF3, 0x0C, 0x83, 0x60, 0xC0,
  0x30, 0x18, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xC0, 0x60, 0x3F, 0xEF, 0xF8,
  0x3F, 0xCF, 0xF0, 0x0C, 0x0C, 0x06, 0x03, 0x00, 0xF0, 0x0E, 0x01, 0x80,
  0x60, 0x1B, 0x06, 0xC1, 0xB9, 0xC7, 0xE0, 0x00, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x03, 0x01, 0x80, 0xC2, 0x61, 0x90, 0x6F, 0xFB, 0xFE, 0x01, 0x80,
  0x40, 0x30, 0x1F, 0xCF, 0xF3, 0x00, 0xC0, 0x30, 0x09, 0x87, 0xF9, 0xC6,
  0x00, 0x80, 0x60, 0x18, 0x06, 0xC1, 0x99, 0xC3, 0xE0, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x06, 0x03, 0xF1, 0xEE, 0x61, 0xB0, 0x3C, 0x0B, 0x06,
  0xC1, 0x9D, 0xC3, 0xE0, 0x7F, 0xDF, 0xF6, 0x0D, 0x06, 0x81, 0x80, 0xC0,
  0x20, 0x18, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x06, 0x00, 0x07,
  0x07, 0xF3, 0x0C, 0xC3, 0x30, 0xCC, 0x61, 0xB0, 0x38, 0x33, 0x18, 0x64,
  0x1B, 0x06, 0xC1, 0x9D, 0xC7, 0xE0, 0x0E, 0x0F, 0xE6, 0x1B, 0x02, 0xC0,
  0xB0, 0x6C, 0x1B, 0x8C, 0x7F, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x0C, 0x06,
  0x00, 0x77, 0x70, 0x00, 0x00, 0xEE, 0xE0, 0x1C, 0x71, 0xC0, 0x00, 0x00,
  0x00, 0x38, 0xC3, 0x18, 0x63, 0x00, 0x00, 0x81, 0xC3, 0xC7, 0x8E, 0x04,
  0x03, 0x80, 0x70, 0x0E, 0x03, 0x80, 0x40, 0x7F, 0xDF, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xEF, 0xF8, 0x20, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x20,
  0x38, 0x78, 0x78, 0x38, 0x08, 0x00, 0x78, 0x7E, 0x06, 0x03, 0x03, 0x02,
  0x06, 0x3C, 0x78, 0x60, 0x60, 0x00, 0x00, 0xE0, 0xE0, 0x03, 0xC0, 0xFE,
  0x18, 0x33, 0x03, 0x20, 0x32, 0x1B, 0x63, 0xF6, 0x62, 0x66, 0x24, 0x42,
  0x44, 0x64, 0x46, 0xC6, 0xEC, 0x76, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0xE0,
  0x0C, 0x00, 0x03, 0x80, 0xE0, 0x78, 0x1E, 0x05, 0x83, 0x60, 0x88, 0x62,
  0x18, 0x8C, 0x33, 0xFC, 0x83, 0x60, 0xD8, 0x3C, 0x0C, 0x3F, 0x0F, 0xE3,
  0x0C, 0xC3, 0x20, 0xD8, 0x36, 0x39, 0xFC, 0x61, 0x98, 0x64, 0x09, 0x06,
  0xC1, 0xBF, 0xCF, 0xE0, 0x07, 0x07, 0xF3, 0x0C, 0xC3, 0x20, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x04, 0x03, 0x06, 0xC1, 0x9D, 0xC3, 0xE0, 0x3E,
  0x0F, 0xE3, 0x0C, 0xC3, 0x20, 0xD8, 0x36, 0x0D, 0x83, 0x60, 0x98, 0x64,
  0x19, 0x06, 0xC3, 0x3F, 0xCF, 0xC0, 0x3F, 0xE7, 0xFC, 0xC0, 0x18, 0x03,
  0x00, 0x40, 0x18, 0x03, 0xFC, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x04, 0x01,
  0xFF, 0x3F, 0xE0, 0x3F, 0xE7, 0xFC, 0xC0, 0x18, 0x02, 0x00, 0x40, 0x18,
  0x03, 0xFC, 0x7F, 0x8C, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x00,
  0x07, 0x07, 0xF3, 0x0C, 0xC3, 0x20, 0x18, 0x06, 0x01, 0x80, 0x67, 0xD8,
  0x24, 0x1B, 0x06, 0xC1, 0x9D, 0xC3, 0xE0, 0x30, 0x66, 0x08, 0xC3, 0x18,
  0x62, 0x0C, 0xC1, 0x98, 0x33, 0xFC, 0x61, 0x8C, 0x31, 0x06, 0x20, 0xCC,
  0x19, 0x83, 0x30, 0xC0, 0x1F, 0xCF, 0xF0, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x40, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x08, 0x3F, 0xCF, 0xF0, 0x03,
  0xE0, 0x7C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x20, 0x66, 0x18, 0xE6, 0x0F, 0x80, 0x30, 0x66, 0x0C, 0xC3,
  0x18, 0xC2, 0x18, 0xC6, 0x19, 0x83, 0xF0, 0x66, 0x0C, 0xC1, 0x0C, 0x21,
  0x8C, 0x31, 0x83, 0x30, 0x60, 0x18, 0x08, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x40, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0xFF, 0xFE, 0x30, 0xE6,
  0x1C, 0xE3, 0xBC, 0xE6, 0x94, 0xD6, 0x9A, 0xB3, 0x76, 0x4C, 0xC8, 0x13,
  0x02, 0x60, 0xCC, 0x19, 0x83, 0x20, 0x60, 0x38, 0x67, 0x08, 0xE1, 0x14,
  0x62, 0x8C, 0xD9, 0x9B, 0x33, 0x66, 0x64, 0x8C, 0xB1, 0x1E, 0x63, 0xCC,
  0x79, 0x87, 0x30, 0xC0, 0x07, 0x07, 0xF3, 0x0C, 0xC3, 0x20, 0xD8, 0x36,
  0x0D, 0x83, 0x60, 0x98, 0x64, 0x1B, 0x06, 0xC1, 0x9D, 0xC3, 0xE0, 0x3F,
  0x07, 0xF8, 0xC3, 0x98, 0x32, 0x06, 0xC0, 0xD8, 0x33, 0xFC, 0x7F, 0x0C,
  0x01, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x00, 0x07, 0x07, 0xF3, 0x0C,
  0x83, 0x60, 0xD8, 0x36, 0x0D, 0x83, 0x60, 0xD0, 0x2C, 0x1B, 0x06, 0xC1,
  0x9D, 0xC3, 0xE0, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x3F, 0x07, 0xF8, 0xC3,
  0x18, 0x32, 0x04, 0xC1, 0x98, 0x33, 0xFC, 0x7E, 0x0C, 0xC1, 0x0C, 0x21,
  0x8C, 0x31, 0x83, 0x30, 0x60, 0x07, 0x07, 0xF3, 0x0C, 0xC3, 0x20, 0x0C,
  0x03, 0x80, 0x7C, 0x07, 0x80, 0x60, 0x0B, 0x06, 0xC1, 0xBD, 0xC7, 0xE0,
  0x7F, 0xFF, 0xF0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x10, 0x0C, 0x03, 0x00, 0x30, 0x66, 0x08, 0xC1, 0x18,
  0x62, 0x0C, 0xC1, 0x98, 0x33, 0x06, 0x60, 0x8C, 0x31, 0x06, 0x60, 0xC4,
  0x18, 0xEE, 0x0F, 0x80, 0xC0, 0x50, 0x34, 0x0D, 0x86, 0x61, 0x98, 0x46,
  0x31, 0x88, 0x66, 0x19, 0x86, 0xC0, 0xB0, 0x28, 0x0E, 0x03, 0x80, 0x66,
  0x36, 0x63, 0x66, 0x24, 0x66, 0x4E, 0x64, 0xA6, 0x4A, 0x45, 0xAC, 0x52,
  0xC5, 0x28, 0xD2, 0x8F, 0x38, 0xE3, 0x8E, 0x30, 0xE3, 0x00, 0x30, 0x31,
  0x83, 0x18, 0x60, 0xCC, 0x0C, 0x80, 0xD8, 0x07, 0x00, 0x60, 0x07, 0x00,
  0xF0, 0x19, 0x83, 0x18, 0x31, 0x86, 0x0C, 0xC0, 0xC0, 0xC0, 0x78, 0x19,
  0x82, 0x30, 0xC6, 0x30, 0x64, 0x0D, 0x81, 0xE0, 0x1C, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x00, 0x60, 0x0C, 0x00, 0x3F, 0xE7, 0xF8, 0x03, 0x00, 0xC0,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x06, 0x01,
  0xFF, 0x3F, 0xE0, 0x1F, 0x1F, 0x10, 0x30, 0x30, 0x30, 0x30, 0x30, 0x20,
  0x60, 0x60, 0x60, 0x60, 0x60, 0x40, 0xC0, 0xC0, 0xC0, 0xF8, 0xC3, 0x06,
  0x18, 0x61, 0x82, 0x0C, 0x30, 0xC1, 0x06, 0x18, 0x61, 0x82, 0x0C, 0x30,
  0xC0, 0x1F, 0x1E, 0x22, 0x06, 0x06, 0x06, 0x06, 0x06, 0x04, 0x0C, 0x0C,
  0x0C, 0x0C, 0x0C, 0x08, 0x18, 0x18, 0x18, 0xF8, 0x04, 0x07, 0x07, 0x82,
  0x43, 0x33, 0x19, 0x85, 0x83, 0xFF, 0xFF, 0xF0, 0xC6, 0x30, 0x1E, 0xCE,
  0x76, 0x0D, 0x82, 0x60, 0x98, 0x64, 0x1B, 0x06, 0xC1, 0x99, 0xE7, 0xF0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x2F, 0x9E, 0x66, 0x0D, 0x83, 0x60, 0x98,
  0x64, 0x19, 0x06, 0xC1, 0xBD, 0xCD, 0xE0, 0x1F, 0x8E, 0x66, 0x0D, 0x83,
  0x60, 0x18, 0x04, 0x03, 0x06, 0xC1, 0x9D, 0xC3, 0xE0, 0x00, 0x60, 0x08,
  0x03, 0x00, 0x61, 0xEC, 0x73, 0x98, 0x33, 0x04, 0x60, 0x8C, 0x31, 0x06,
  0x60, 0xCC, 0x18, 0xCF, 0x1F, 0xC0, 0x1F, 0x0C, 0x66, 0x0D, 0x83, 0x60,
  0x9F, 0xE4, 0x03, 0x00, 0xC1, 0x98, 0xC3, 0xE0, 0x00, 0x7C, 0x07, 0xF0,
  0x18, 0x00, 0xC0, 0x03, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0xC0, 0x02, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00,
  0x0C, 0x03, 0xE0, 0x0E, 0x00, 0x00, 0x1E, 0xCE, 0x76, 0x0D, 0x82, 0x60,
  0x98, 0x64, 0x19, 0x86, 0x63, 0x9F, 0x60, 0x10, 0x0C, 0x03, 0x1F, 0x87,
  0x80, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x2F, 0x9E, 0x66, 0x0D, 0x83, 0x60,
  0x98, 0x64, 0x19, 0x06, 0xC1, 0xB0, 0x6C, 0x10, 0x02, 0x03, 0x81, 0xC0,
  0x00, 0x01, 0xF0, 0xF8, 0x0C, 0x06, 0x02, 0x03, 0x01, 0x80, 0xC0, 0x63,
  0xFF, 0xFF, 0x00, 0x40, 0x1C, 0x03, 0x00, 0x00, 0x00, 0x3F, 0x87, 0xE0,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0xC3, 0xF0, 0x78, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x02,
  0x0E, 0x43, 0x18, 0xE3, 0x18, 0x66, 0x0F, 0x81, 0x98, 0x23, 0x0C, 0x31,
  0x86, 0x30, 0x60, 0xF8, 0xF8, 0x18, 0x18, 0x18, 0x18, 0x10, 0x30, 0x30,
  0x30, 0x30, 0x30, 0x30, 0x3F, 0x1F, 0x3E, 0xE6, 0x6C, 0x89, 0x91, 0x36,
  0x66, 0xCC, 0xD9, 0x9B, 0x22, 0x44, 0x48, 0x9B, 0x33, 0x00, 0x3F, 0x9E,
  0x66, 0x0D, 0x83, 0x60, 0x98, 0x64, 0x19, 0x06, 0xC1, 0xB0, 0x6C, 0x10,
  0x1F, 0x0E, 0xE6, 0x0D, 0x83, 0x60, 0x98, 0x64, 0x1B, 0x06, 0xC1, 0x9D,
  0xC3, 0xE0, 0x1F, 0xC7, 0x98, 0xC1, 0x98, 0x33, 0x04, 0x61, 0x88, 0x31,
  0x06, 0x70, 0xCF, 0x71, 0xBC, 0x30, 0x06, 0x00, 0x80, 0x30, 0x00, 0x1E,
  0xCE, 0xF6, 0x0D, 0x82, 0x60, 0x98, 0x64, 0x1B, 0x06, 0xC1, 0x99, 0xE7,
  0xD0, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x37, 0x8E, 0x73, 0x0C, 0x83, 0x60,
  0xD8, 0x06, 0x01, 0x80, 0x60, 0x10, 0x0C, 0x00, 0x1F, 0x8C, 0x66, 0x0D,
  0x80, 0x78, 0x0F, 0xC0, 0x38, 0x06, 0xC1, 0xB8, 0xC7, 0xE0, 0x18, 0x0C,
  0x06, 0x1F, 0xFF, 0xF8, 0x80, 0x40, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0xF0, 0xF0, 0x20, 0xD8, 0x36, 0x0D, 0x83, 0x60, 0x98, 0x64, 0x1B, 0x06,
  0x41, 0x99, 0xC3, 0xE0, 0xC0, 0xF0, 0x6C, 0x11, 0x0C, 0x62, 0x19, 0x86,
  0x61, 0xB0, 0x6C, 0x0E, 0x03, 0x80, 0x8C, 0xE7, 0x39, 0x4A, 0x52, 0x95,
  0xA9, 0x4A, 0x52, 0x9C, 0xC6, 0x31, 0x8C, 0x60, 0x38, 0x71, 0x8C, 0x19,
  0xC0, 0xD8, 0x07, 0x00, 0x60, 0x0F, 0x01, 0xB0, 0x31, 0x87, 0x18, 0xE0,
  0xC0, 0x30, 0xD8, 0x36, 0x0D, 0x83, 0x60, 0x98, 0x64, 0x19, 0x86, 0x63,
  0x8F, 0x60, 0x10, 0x0C, 0x03, 0x1F, 0x87, 0x80, 0x3F, 0xCF, 0xF0, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x3F, 0xEF, 0xF0, 0x00, 0xC0,
  0xF0, 0x60, 0x18, 0x06, 0x01, 0x80, 0x40, 0x10, 0x0C, 0x3E, 0x0F, 0x80,
  0x30, 0x0C, 0x02, 0x01, 0x80, 0x60, 0x18, 0x07, 0x00, 0xE0, 0x18, 0x84,
  0x63, 0x18, 0xC6, 0x23, 0x18, 0xC6, 0x31, 0x18, 0xC6, 0x30, 0x18, 0x03,
  0xC0, 0x0C, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x7C,
  0x1F, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x08, 0x07, 0x03, 0xC0,
  0x00, 0x38, 0xDB, 0x3C, 0x7F, 0x1E,
};

const GFXglyph JetBrainsMono_Italic20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 5, 15, 12, 4, -15 },
  { 11, 6, 6, 12, 4, -15 },
  { 16, 12, 15, 12, 0, -15 },
  { 39, 10, 20, 12, 1, -17 },
  { 64, 14, 15, 12, -1, -15 },
  { 91, 12, 15, 12, 0, -15 },
  { 114, 2, 6, 12, 6, -15 },
  { 116, 9, 20, 12, 3, -17 },
  { 139, 8, 20, 12, 1, -17 },
  { 159, 11, 10, 12, 1, -12 },
  { 173, 10, 9, 12, 1, -11 },
  { 185, 5, 6, 12, 2, -3 },
  { 189, 7, 1, 12, 3, -7 },
  { 190, 3, 3, 12, 4, -3 },
  { 192, 12, 19, 12, 0, -17 },
  { 221, 10, 15, 12, 1, -15 },
  { 240, 9, 15, 12, 1, -15 },
  { 257, 10, 15, 12, 1, -15 },
  { 276, 10, 15, 12, 1, -15 },
  { 295, 10, 15, 12, 1, -15 },
  { 314, 10, 15, 12, 1, -15 },
  { 333, 10, 15, 12, 1, -15 },
  { 352, 10, 15, 12, 2, -15 },
  { 371, 10, 15, 12, 1, -15 },
  { 390, 10, 15, 12, 2, -15 },
  { 409, 4, 11, 12, 4, -11 },
  { 415, 6, 14, 12, 2, -11 },
  { 426, 9, 11, 12, 2, -12 },
  { 439, 10, 7, 12, 1, -10 },
  { 448, 10, 11, 12, 1, -12 },
  { 462, 8, 15, 12, 3, -15 },
  { 477, 12, 19, 12, 0, -15 },
  { 506, 10, 15, 12, 0, -15 },
  { 525, 10, 15, 12, 1, -15 },
  { 544, 10, 15, 12, 1, -15 },
  { 563, 10, 15, 12, 1, -15 },
  { 582, 11, 15, 12, 1, -15 },
  { 603, 11, 15, 12, 1, -15 },
  { 624, 10, 15, 12, 1, -15 },
  { 643, 11, 15, 12, 1, -15 },
  { 664, 10, 15, 12, 1, -15 },
  { 683, 11, 15, 12, 0, -15 },
  { 704, 11, 15, 12, 1, -15 },
  { 725, 9, 15, 12, 1, -15 },
  { 742, 11, 15, 12, 1, -15 },
  { 763, 11, 15, 12, 1, -15 },
  { 784, 10, 15, 12, 1, -15 },
  { 803, 11, 15, 12, 1, -15 },
  { 824, 10, 19, 12, 1, -15 },
  { 848, 11, 15, 12, 1, -15 },
  { 869, 10, 15, 12, 1, -15 },
  { 888, 10, 15, 12, 2, -15 },
  { 907, 11, 15, 12, 1, -15 },
  { 928, 10, 15, 12, 2, -15 },
  { 947, 12, 15, 12, 1, -15 },
  { 970, 12, 15, 12, 0, -15 },
  { 993, 11, 15, 12, 2, -15 },
  { 1014, 11, 15, 12, 1, -15 },
  { 1035, 8, 19, 12, 3, -17 },
  { 1054, 6, 19, 12, 3, -17 },
  { 1069, 8, 19, 12, 2, -17 },
  { 1088, 9, 8, 12, 2, -15 },
  { 1097, 10, 2, 12, 0, 0 },
  { 1100, 4, 3, 12, 5, -16 },
  { 1102, 10, 11, 12, 1, -11 },
  { 1116, 10, 15, 12, 1, -15 },
  { 1135, 10, 11, 12, 1, -11 },
  { 1149, 11, 15, 12, 1, -15 },
  { 1170, 10, 11, 12, 1, -11 },
  { 1184, 14, 19, 12, -1, -15 },
  { 1218, 10, 15, 12, 1, -11 },
  { 1237, 10, 15, 12, 1, -15 },
  { 1256, 9, 16, 12, 1, -16 },
  { 1274, 11, 20, 12, 0, -16 },
  { 1302, 11, 15, 12, 1, -15 },
  { 1323, 8, 15, 12, 2, -15 },
  { 1338, 11, 11, 12, 0, -11 },
  { 1354, 10, 11, 12, 1, -11 },
  { 1368, 10, 11, 12, 1, -11 },
  { 1382, 11, 15, 12, 0, -11 },
  { 1403, 10, 15, 12, 1, -11 },
  { 1422, 10, 11, 12, 1, -11 },
  { 1436, 10, 11, 12, 1, -11 },
  { 1450, 9, 14, 12, 2, -14 },
  { 1466, 10, 11, 12, 1, -11 },
  { 1480, 10, 11, 12, 2, -11 },
  { 1494, 10, 11, 12, 2, -11 },
  { 1508, 12, 11, 12, 0, -11 },
  { 1525, 10, 15, 12, 1, -11 },
  { 1544, 10, 11, 12, 1, -11 },
  { 1558, 10, 19, 12, 2, -17 },
  { 1582, 5, 19, 12, 4, -17 },
  { 1594, 11, 19, 12, 0, -17 },
  { 1621, 10, 4, 12, 1, -9 },
};

const GFXfont JetBrainsMono_Italic20pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Italic20pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Italic20pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _JETBRAINSMONO_ITALIC20PT7B_H_
