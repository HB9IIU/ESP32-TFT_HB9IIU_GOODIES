#ifndef _JETBRAINSMONO_ITALIC43PT7B_H_
#define _JETBRAINSMONO_ITALIC43PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Italic.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Italic43pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xE0, 0x78, 0x1E, 0x0F,
  0x83, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x81,
  0xE0, 0x70, 0x1C, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC1, 0xF8,
  0xFE, 0x3F, 0x07, 0xC0, 0x7C, 0x3D, 0xE0, 0xF7, 0x83, 0xDE, 0x0F, 0x78,
  0x3D, 0xE1, 0xE7, 0x07, 0xBC, 0x1E, 0xF0, 0x7B, 0xC1, 0xEF, 0x07, 0x38,
  0x1C, 0xE0, 0x70, 0x00, 0x1E, 0x07, 0x00, 0x0E, 0x03, 0x80, 0x0F, 0x03,
  0x80, 0x07, 0x01, 0xC0, 0x03, 0x80, 0xE0, 0x03, 0xC0, 0xE0, 0x01, 0xC0,
  0x70, 0x00, 0xE0, 0x38, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xE0, 0x38, 0x0E, 0x00, 0x1C, 0x07, 0x00, 0x0E, 0x07, 0x80, 0x0E,
  0x03, 0x80, 0x07, 0x01, 0xC0, 0x03, 0x81, 0xE0, 0x03, 0x80, 0xE0, 0x01,
  0xC0, 0x70, 0x00, 0xE0, 0x78, 0x0F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xC0,
  0x38, 0x1E, 0x00, 0x38, 0x0E, 0x00, 0x1C, 0x07, 0x00, 0x0E, 0x07, 0x80,
  0x0E, 0x03, 0x80, 0x07, 0x01, 0xC0, 0x07, 0x81, 0xE0, 0x03, 0x80, 0xE0,
  0x01, 0xC0, 0xF0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x0F, 0x9C, 0xF8, 0x1E, 0x38, 0xF0,
  0x78, 0x71, 0xE0, 0xF0, 0xC3, 0xC1, 0xE1, 0x87, 0x83, 0xC7, 0x00, 0x07,
  0x8E, 0x00, 0x0F, 0x1C, 0x00, 0x1F, 0x38, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x39, 0xF0, 0x00, 0x61, 0xE0, 0x00, 0xC3, 0xC0, 0x03, 0x87,
  0x80, 0x07, 0x0F, 0x1E, 0x0E, 0x1E, 0x3C, 0x1C, 0x3C, 0x7C, 0x30, 0xF0,
  0x78, 0x63, 0xE0, 0xFD, 0xDF, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00,
  0xFF, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0F, 0xE0, 0x03, 0xC0, 0xFF, 0x80, 0x3C, 0x0F, 0x3E, 0x01, 0xC0, 0xF0,
  0x70, 0x1C, 0x07, 0x03, 0x81, 0xC0, 0x38, 0x1C, 0x1C, 0x01, 0xC1, 0xE1,
  0xE0, 0x0E, 0x0E, 0x1E, 0x00, 0xF0, 0x70, 0xE0, 0x07, 0x83, 0x8E, 0x00,
  0x3C, 0x3C, 0xE0, 0x00, 0xFF, 0xCE, 0x00, 0x03, 0xFC, 0xF0, 0x00, 0x07,
  0x8F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x1F, 0x80, 0x00, 0x71, 0xFF, 0x00, 0x07, 0x9F, 0xF8,
  0x00, 0x79, 0xE1, 0xE0, 0x03, 0x8E, 0x0F, 0x00, 0x38, 0x70, 0x78, 0x03,
  0x87, 0x83, 0x80, 0x38, 0x38, 0x1C, 0x03, 0xC1, 0xC0, 0xE0, 0x3C, 0x0E,
  0x07, 0x01, 0xC0, 0x78, 0x78, 0x1C, 0x03, 0xFF, 0x81, 0xC0, 0x0F, 0xF8,
  0x1C, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xC0, 0xF8, 0x03, 0xC0, 0x78, 0x07, 0x80,
  0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF8, 0x01, 0x3E, 0x78, 0x1E, 0x3C, 0x3C,
  0x3C, 0x78, 0x3C, 0x3C, 0x78, 0x1E, 0x78, 0x78, 0x1E, 0xF0, 0x78, 0x0F,
  0xE0, 0x78, 0x0F, 0xE0, 0x78, 0x07, 0xC0, 0xF0, 0x07, 0xC0, 0xF0, 0x0F,
  0xC0, 0xF8, 0x1F, 0xE0, 0x7C, 0x3F, 0xE0, 0x7F, 0xFC, 0xF0, 0x3F, 0xF8,
  0xF8, 0x1F, 0xE0, 0x78, 0x3D, 0xF7, 0x9E, 0x79, 0xE7, 0x9C, 0xF3, 0xCF,
  0x3C, 0xE0, 0x00, 0x01, 0xC0, 0x01, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F,
  0x80, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x01,
  0x80, 0x00, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x1F, 0xC0,
  0x07, 0xE0, 0x03, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x80, 0x0C, 0x0F, 0x03, 0x3E, 0x1C, 0x3F, 0x7F, 0x19, 0xFF, 0xFF, 0xB7,
  0xFC, 0x7F, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x77, 0x80, 0x01, 0xE7, 0x80, 0x07, 0x8F, 0x00, 0x1E, 0x1F, 0x00,
  0x78, 0x1E, 0x01, 0xF0, 0x3E, 0x01, 0xC0, 0x38, 0x01, 0x00, 0x40, 0x00,
  0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xE0, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0xFC, 0x1F, 0x07, 0xE0, 0xF8,
  0x1E, 0x07, 0xC0, 0xF0, 0x3E, 0x07, 0x81, 0xF0, 0x3C, 0x07, 0x01, 0xE0,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x18, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x1F, 0xDF, 0xC0,
  0x7C, 0x07, 0xC1, 0xF0, 0x07, 0x83, 0xC0, 0x0F, 0x07, 0x00, 0x1E, 0x1E,
  0x00, 0x3C, 0x3C, 0x00, 0x78, 0x78, 0x00, 0xF0, 0xF0, 0x01, 0xE1, 0xC0,
  0x03, 0xC7, 0x80, 0x07, 0x0F, 0x1F, 0x1E, 0x1E, 0x3E, 0x3C, 0x3C, 0x7C,
  0x78, 0x78, 0xF8, 0xF0, 0xE0, 0xE1, 0xE3, 0xC0, 0x03, 0x87, 0x80, 0x07,
  0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x78, 0x00, 0xF0,
  0xF0, 0x03, 0xC1, 0xE0, 0x07, 0x83, 0xE0, 0x1E, 0x07, 0xE0, 0xFC, 0x07,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x07,
  0xF8, 0x00, 0xFF, 0x80, 0x3F, 0x78, 0x07, 0xC7, 0x80, 0xF8, 0x70, 0x0E,
  0x0F, 0x00, 0xC0, 0xF0, 0x18, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF,
  0xFE, 0x07, 0xC0, 0x78, 0x3E, 0x01, 0xF0, 0xF0, 0x03, 0xC7, 0x80, 0x0F,
  0x1E, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xCF, 0x00, 0x0E, 0x3C, 0x00, 0x78,
  0xF0, 0x01, 0xE3, 0xE0, 0x0F, 0x07, 0x80, 0x7C, 0x1F, 0x83, 0xE0, 0x3F,
  0xFF, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x0E, 0x0F, 0x01, 0xE1, 0xE0, 0x1E,
  0x3C, 0x01, 0xE7, 0xC0, 0x1E, 0x78, 0x01, 0xEF, 0x00, 0x1C, 0xF0, 0x03,
  0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x00, 0x03, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x87, 0x00, 0x39, 0xFF, 0x03, 0xDF, 0xFC,
  0x1F, 0xFF, 0xF0, 0xFC, 0x0F, 0x87, 0xC0, 0x3C, 0x3C, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x01,
  0xE1, 0xF8, 0x3F, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFB, 0xFC, 0x07, 0xFF,
  0xF0, 0x7F, 0xFF, 0xC3, 0xE0, 0x3E, 0x3E, 0x00, 0xF1, 0xE0, 0x07, 0xDE,
  0x00, 0x1E, 0xF0, 0x00, 0xF7, 0x80, 0x07, 0xB8, 0x00, 0x3F, 0xC0, 0x03,
  0xDE, 0x00, 0x1E, 0xF8, 0x00, 0xF3, 0xC0, 0x0F, 0x1F, 0x00, 0xF8, 0xFC,
  0x1F, 0x83, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x7F, 0xFF,
  0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xF0, 0x01, 0xE7, 0x80, 0x0F, 0x38,
  0x00, 0xF3, 0xC0, 0x07, 0x9E, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x03,
  0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xC0, 0x78, 0x1E, 0x01,
  0xF0, 0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x0F, 0x00, 0x3C, 0x3C, 0x01, 0xE0,
  0xF0, 0x07, 0x83, 0xC0, 0x3C, 0x07, 0x81, 0xE0, 0x1F, 0x9F, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0x00, 0x1F, 0xBE, 0x00, 0xF8, 0x7C,
  0x07, 0x80, 0x78, 0x3C, 0x01, 0xF0, 0xE0, 0x03, 0xC7, 0x80, 0x0F, 0x1E,
  0x00, 0x3C, 0x78, 0x00, 0xF1, 0xE0, 0x07, 0x87, 0x80, 0x1E, 0x1E, 0x00,
  0xF8, 0x7E, 0x0F, 0xC0, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0x00,
  0x00, 0x7E, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0xC1, 0xF0,
  0x1F, 0x1F, 0x00, 0x78, 0xF0, 0x03, 0xCF, 0x00, 0x0F, 0x78, 0x00, 0x7B,
  0x80, 0x03, 0xFC, 0x00, 0x3D, 0xE0, 0x01, 0xEF, 0x00, 0x0F, 0x78, 0x00,
  0xFB, 0xE0, 0x07, 0x8F, 0x80, 0x7C, 0x7E, 0x0F, 0xC1, 0xFF, 0xFE, 0x07,
  0xFD, 0xE0, 0x1F, 0x9E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0x87, 0xF1, 0xFC, 0x7F, 0x1F, 0x87, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC1,
  0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF0, 0x00, 0xF8, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xC0,
  0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0xF0, 0x00, 0x3F, 0x00,
  0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07,
  0xF8, 0x00, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x38, 0x00, 0x01, 0x80, 0x3F,
  0xFF, 0xF9, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xE0,
  0x10, 0x00, 0x00, 0x60, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x03,
  0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x0F, 0xFE, 0x0F, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0xF0,
  0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03,
  0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x3F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xE0, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0xC0,
  0x0F, 0xE0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xF0, 0x7C, 0x01, 0xE0, 0x07, 0x80,
  0xF0, 0x01, 0xE0, 0x78, 0x00, 0x3C, 0x1C, 0x00, 0x0F, 0x0F, 0x00, 0x03,
  0xC3, 0x80, 0x00, 0xF0, 0xE0, 0x00, 0x3C, 0x78, 0x07, 0xCE, 0x1E, 0x07,
  0xFB, 0x87, 0x03, 0xFE, 0xE1, 0xC0, 0xF0, 0xF8, 0x70, 0x78, 0x1E, 0x3C,
  0x1C, 0x07, 0x8F, 0x07, 0x01, 0xC3, 0xC1, 0xC0, 0x70, 0xE0, 0xF0, 0x1C,
  0x38, 0x3C, 0x07, 0x0E, 0x0F, 0x03, 0xC3, 0x83, 0x80, 0xF1, 0xE0, 0xE0,
  0x3C, 0x78, 0x38, 0x0E, 0x1E, 0x0E, 0x07, 0x87, 0x03, 0xC3, 0xE1, 0xC0,
  0xFF, 0xB8, 0x70, 0x1F, 0xCE, 0x1C, 0x00, 0xC0, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xB8, 0x00, 0x1E, 0xE0, 0x00, 0x7B, 0x80, 0x01, 0xCE,
  0x00, 0x0F, 0x38, 0x00, 0x38, 0xF0, 0x01, 0xE3, 0xC0, 0x07, 0x8F, 0x00,
  0x3C, 0x3C, 0x00, 0xF0, 0xF0, 0x03, 0x83, 0xC0, 0x1E, 0x0F, 0x00, 0x78,
  0x1C, 0x03, 0xC0, 0x70, 0x0F, 0x01, 0xC0, 0x78, 0x07, 0x81, 0xFF, 0xFE,
  0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x87, 0x80, 0x1E, 0x1E,
  0x00, 0x78, 0x78, 0x01, 0xE3, 0xC0, 0x03, 0x8F, 0x00, 0x0E, 0x78, 0x00,
  0x3D, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xC0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x83, 0xC0, 0x3F, 0x0F, 0x00, 0x7C, 0x3C, 0x00, 0xF0,
  0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x0E, 0x00, 0x3C, 0x38, 0x00, 0xE1, 0xE0,
  0x07, 0x87, 0x80, 0x3C, 0x1E, 0x03, 0xE0, 0x7F, 0xFF, 0x01, 0xFF, 0xF0,
  0x07, 0xFF, 0xF0, 0x3C, 0x0F, 0xE0, 0xF0, 0x07, 0xC3, 0xC0, 0x0F, 0x0F,
  0x00, 0x3C, 0x3C, 0x00, 0x70, 0xE0, 0x01, 0xC7, 0x80, 0x0F, 0x1E, 0x00,
  0x3C, 0x78, 0x00, 0xF1, 0xE0, 0x07, 0x87, 0x80, 0x3E, 0x1C, 0x0F, 0xF0,
  0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x07, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xF8, 0x0F, 0x87, 0x80,
  0x3C, 0x78, 0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x79, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x3C,
  0xF0, 0x01, 0xE7, 0x80, 0x1E, 0x3C, 0x00, 0xF1, 0xF0, 0x0F, 0x07, 0xC1,
  0xF8, 0x3F, 0xFF, 0x80, 0xFF, 0xF8, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0xC0,
  0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x03, 0xC0, 0x7E, 0x0F, 0x00, 0x78, 0x3C,
  0x01, 0xF0, 0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x0F, 0x00, 0x3C, 0x78, 0x00,
  0xF1, 0xE0, 0x07, 0x87, 0x80, 0x1E, 0x1E, 0x00, 0x78, 0x78, 0x01, 0xE1,
  0xE0, 0x07, 0x87, 0x00, 0x1E, 0x3C, 0x00, 0x70, 0xF0, 0x03, 0xC3, 0xC0,
  0x0F, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0xF0, 0xE0, 0x03, 0xC7, 0x80, 0x0E,
  0x1E, 0x00, 0x78, 0x78, 0x01, 0xE1, 0xE0, 0x0F, 0x07, 0x80, 0x7C, 0x1E,
  0x1F, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x07,
  0xFF, 0xFE, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0xF8, 0x0F, 0x87, 0x80, 0x3C, 0x78, 0x01, 0xE3, 0xC0, 0x0F, 0x1E,
  0x00, 0x79, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x3F, 0xF3, 0xC3,
  0xFF, 0x9E, 0x1F, 0xFC, 0xF0, 0xFF, 0xC7, 0x80, 0x1E, 0x38, 0x00, 0xF3,
  0xC0, 0x07, 0x9E, 0x00, 0x3C, 0xF0, 0x01, 0xE7, 0x80, 0x1E, 0x3C, 0x00,
  0xF1, 0xF0, 0x0F, 0x07, 0xC1, 0xF8, 0x3F, 0xFF, 0x80, 0xFF, 0xF8, 0x01,
  0xFF, 0x00, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0x3C, 0x1E, 0x00, 0x70, 0x78,
  0x01, 0xE0, 0xF0, 0x03, 0xC1, 0xE0, 0x07, 0x83, 0xC0, 0x0F, 0x07, 0x80,
  0x1E, 0x0F, 0x00, 0x38, 0x1C, 0x00, 0xF0, 0x78, 0x01, 0xE0, 0xF0, 0x03,
  0xC1, 0xE0, 0x07, 0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF0, 0x78, 0x01, 0xE0, 0xF0, 0x03, 0xC1, 0xE0, 0x07, 0x83,
  0xC0, 0x0F, 0x07, 0x00, 0x1C, 0x1E, 0x00, 0x78, 0x3C, 0x00, 0xF0, 0x78,
  0x01, 0xE0, 0xF0, 0x03, 0xC1, 0xE0, 0x07, 0x83, 0xC0, 0x0E, 0x0F, 0x00,
  0x3C, 0x1E, 0x00, 0x78, 0x3C, 0x00, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xC3, 0xFF, 0xFE, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x01, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xC3, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x3C,
  0x78, 0x00, 0x70, 0xF0, 0x01, 0xE1, 0xF0, 0x03, 0xC1, 0xE0, 0x0F, 0x03,
  0xF0, 0x7C, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x00,
  0x07, 0x80, 0x0F, 0x83, 0xC0, 0x0F, 0x81, 0xC0, 0x0F, 0x81, 0xE0, 0x07,
  0x80, 0xF0, 0x07, 0x80, 0x78, 0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x1E, 0x03,
  0xC0, 0x0F, 0x03, 0xE0, 0x0F, 0x01, 0xE0, 0x07, 0x81, 0xE0, 0x03, 0xC1,
  0xF0, 0x01, 0xE0, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F,
  0xFC, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x03, 0xC0, 0x07,
  0x81, 0xE0, 0x03, 0xC0, 0xF8, 0x01, 0xC0, 0x3C, 0x01, 0xE0, 0x1E, 0x00,
  0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF8,
  0x0F, 0x00, 0x3C, 0x0F, 0x00, 0x1E, 0x07, 0x80, 0x0F, 0x83, 0xC0, 0x03,
  0xC0, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xF0, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0x81, 0xF8, 0x0E,
  0xC0, 0xDC, 0x07, 0xE0, 0x6E, 0x07, 0x70, 0x77, 0x03, 0xB8, 0x3B, 0x83,
  0x9C, 0x1C, 0xE1, 0xDC, 0x0E, 0x71, 0xEE, 0x07, 0x38, 0xE7, 0x03, 0x9C,
  0xF3, 0x83, 0xCE, 0x73, 0xC1, 0xE7, 0x39, 0xE0, 0xF1, 0xF8, 0xE0, 0x78,
  0xFC, 0x70, 0x3C, 0x7C, 0x78, 0x1C, 0x3E, 0x3C, 0x0E, 0x00, 0x1E, 0x0F,
  0x00, 0x0F, 0x07, 0x80, 0x07, 0x03, 0xC0, 0x07, 0x81, 0xE0, 0x03, 0xC0,
  0xF0, 0x01, 0xE0, 0x70, 0x00, 0xF0, 0x78, 0x00, 0x78, 0x3C, 0x00, 0x3C,
  0x1E, 0x00, 0x1C, 0x0F, 0x00, 0x1E, 0x07, 0x80, 0x0F, 0x03, 0x80, 0x07,
  0x83, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x1E, 0x0F, 0x80, 0x3C, 0x3F, 0x80,
  0x78, 0x7F, 0x00, 0xE0, 0xFE, 0x03, 0xC1, 0xDC, 0x07, 0x83, 0xB8, 0x0F,
  0x07, 0x78, 0x1E, 0x0E, 0xF0, 0x3C, 0x3C, 0xE0, 0x70, 0x79, 0xC0, 0xE0,
  0xF3, 0x83, 0xC1, 0xE7, 0x87, 0x83, 0xCF, 0x0F, 0x07, 0x0E, 0x1E, 0x1E,
  0x1C, 0x3C, 0x3C, 0x38, 0x70, 0x78, 0x79, 0xE0, 0xF0, 0xF3, 0xC1, 0xE0,
  0xE7, 0x83, 0x81, 0xCF, 0x0F, 0x03, 0x9E, 0x1E, 0x07, 0xB8, 0x3C, 0x0F,
  0x70, 0x78, 0x0E, 0xE0, 0xF0, 0x1D, 0xC1, 0xC0, 0x3F, 0x83, 0x80, 0x7F,
  0x0F, 0x00, 0xFC, 0x1E, 0x00, 0xF8, 0x3C, 0x01, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x07, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xF8, 0x0F, 0x07,
  0x80, 0x7C, 0x78, 0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x79, 0xE0, 0x03,
  0xCF, 0x00, 0x1E, 0x78, 0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x78, 0xF0,
  0x03, 0xCF, 0x00, 0x1E, 0x78, 0x00, 0xF3, 0xC0, 0x07, 0x1E, 0x00, 0x78,
  0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x38, 0x00, 0xF3, 0xC0, 0x07, 0x9E, 0x00,
  0x38, 0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x01, 0xF1, 0xF0, 0x0F, 0x07,
  0xC1, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x07, 0xFF,
  0xF0, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x0F, 0x00, 0x7E, 0x0F, 0x00,
  0x3E, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x0F, 0x00,
  0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x3E, 0x1E, 0x00,
  0x3C, 0x1E, 0x00, 0xFC, 0x1E, 0x07, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC0, 0x3F, 0xFF, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xFF,
  0xC0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7C, 0x07, 0xC1, 0xF0, 0x07,
  0x83, 0xC0, 0x0F, 0x07, 0x80, 0x1E, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x78,
  0x78, 0x00, 0xF0, 0xF0, 0x01, 0xE1, 0xE0, 0x03, 0xC7, 0x80, 0x07, 0x0F,
  0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x78, 0x00, 0xF0, 0xF0,
  0x01, 0xE3, 0xC0, 0x03, 0x87, 0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x1E, 0x00,
  0x3C, 0x3C, 0x00, 0x78, 0x78, 0x00, 0xF0, 0xF0, 0x03, 0xC1, 0xE0, 0x07,
  0x83, 0xE0, 0x1E, 0x07, 0xE0, 0xFC, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x78,
  0x07, 0xE0, 0xF0, 0x03, 0xC1, 0xE0, 0x07, 0xC3, 0xC0, 0x07, 0x87, 0x80,
  0x0F, 0x0F, 0x00, 0x1E, 0x3C, 0x00, 0x78, 0x78, 0x00, 0xF0, 0xF0, 0x01,
  0xE1, 0xE0, 0x07, 0x83, 0xC0, 0x3F, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0,
  0x3F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0xF0, 0x78, 0x01, 0xE0, 0x78, 0x03,
  0xC0, 0xF0, 0x07, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x78,
  0x07, 0x80, 0xF0, 0x0F, 0x81, 0xE0, 0x0F, 0x03, 0xC0, 0x1E, 0x0F, 0x00,
  0x3E, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7C, 0x07, 0xC0, 0xF0,
  0x07, 0x83, 0xC0, 0x0F, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0x3C, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0xF0, 0x00, 0xF1, 0xE0, 0x01, 0xE3, 0xE0,
  0x07, 0x83, 0xC0, 0x1F, 0x07, 0xE0, 0xFC, 0x07, 0xFF, 0xF0, 0x07, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0x80, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0xF1,
  0xE0, 0x03, 0xC7, 0x80, 0x0E, 0x1E, 0x00, 0x78, 0x78, 0x01, 0xE1, 0xE0,
  0x07, 0x87, 0x80, 0x1E, 0x1C, 0x00, 0x78, 0xF0, 0x01, 0xC3, 0xC0, 0x0F,
  0x0F, 0x00, 0x3C, 0x3C, 0x00, 0xF0, 0xF0, 0x03, 0xC3, 0x80, 0x0F, 0x1E,
  0x00, 0x3C, 0x78, 0x01, 0xE1, 0xE0, 0x07, 0x87, 0x80, 0x1E, 0x1E, 0x00,
  0x78, 0x78, 0x01, 0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x1C, 0x3C, 0x00, 0xF0,
  0xF0, 0x03, 0xC3, 0xC0, 0x1F, 0x0F, 0x80, 0x78, 0x1F, 0x07, 0xC0, 0x7F,
  0xFF, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x00, 0xF0, 0x00, 0x7F, 0xC0,
  0x01, 0xE7, 0x00, 0x07, 0x9E, 0x00, 0x3C, 0x78, 0x00, 0xF1, 0xE0, 0x07,
  0x87, 0x80, 0x1E, 0x1E, 0x00, 0x70, 0x78, 0x03, 0xC1, 0xE0, 0x0F, 0x07,
  0x80, 0x78, 0x1E, 0x01, 0xE0, 0x38, 0x0F, 0x00, 0xE0, 0x3C, 0x03, 0xC0,
  0xF0, 0x0F, 0x07, 0x80, 0x3C, 0x1E, 0x00, 0xF0, 0xF0, 0x03, 0xC3, 0xC0,
  0x0F, 0x0E, 0x00, 0x3C, 0x78, 0x00, 0xF1, 0xE0, 0x01, 0xCF, 0x00, 0x07,
  0x3C, 0x00, 0x1C, 0xE0, 0x00, 0x77, 0x80, 0x01, 0xDE, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x78, 0x1E,
  0x07, 0xBC, 0x1F, 0x03, 0x9E, 0x0F, 0x81, 0xCF, 0x06, 0xC1, 0xE7, 0x83,
  0xE0, 0xE3, 0x83, 0xF0, 0x71, 0xC1, 0xF8, 0x78, 0xE0, 0xDC, 0x3C, 0x70,
  0xEE, 0x1C, 0x38, 0x77, 0x0E, 0x1C, 0x33, 0x8F, 0x0E, 0x19, 0xC7, 0x87,
  0x1C, 0xE3, 0x83, 0x8E, 0x71, 0xC3, 0xC6, 0x31, 0xE1, 0xE7, 0x18, 0xE0,
  0xF3, 0x8C, 0x70, 0x79, 0x86, 0x38, 0x3C, 0xC3, 0x3C, 0x1E, 0xE1, 0x9C,
  0x0F, 0x70, 0xCE, 0x07, 0xB0, 0x6F, 0x03, 0xB8, 0x37, 0x81, 0xDC, 0x1B,
  0x80, 0xEC, 0x0D, 0xC0, 0x76, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x1F, 0x83,
  0xF0, 0x0F, 0x81, 0xF8, 0x07, 0xC0, 0xFC, 0x03, 0xE0, 0x7C, 0x00, 0x07,
  0xC0, 0x03, 0xE0, 0x78, 0x00, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x07,
  0x80, 0x1E, 0x01, 0xE0, 0x01, 0xE0, 0x7C, 0x00, 0x3C, 0x1F, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0x78, 0xF0, 0x00, 0x0F, 0x3E, 0x00, 0x00, 0xF7, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x1F, 0x3C, 0x00, 0x03, 0xC7,
  0x80, 0x00, 0xF0, 0x78, 0x00, 0x3E, 0x0F, 0x00, 0x0F, 0x81, 0xF0, 0x01,
  0xE0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0x00, 0x3C, 0x03, 0xC0, 0x07,
  0x80, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x3F, 0xC0,
  0x01, 0xE7, 0x00, 0x0F, 0x9E, 0x00, 0x3C, 0x78, 0x01, 0xE1, 0xE0, 0x07,
  0x83, 0xC0, 0x3C, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0x78, 0x3C, 0x01,
  0xE1, 0xE0, 0x07, 0x87, 0x80, 0x0F, 0x3C, 0x00, 0x3C, 0xE0, 0x00, 0xF7,
  0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F,
  0xF0, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xFF,
  0x01, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x0E, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x01, 0xC0,
  0x0F, 0x00, 0x78, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x07, 0xFF, 0x03,
  0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x0F, 0x80,
  0x03, 0xF8, 0x00, 0x77, 0x00, 0x1E, 0xE0, 0x03, 0x9E, 0x00, 0xE1, 0xC0,
  0x3C, 0x38, 0x07, 0x07, 0x01, 0xE0, 0x70, 0x78, 0x0E, 0x0E, 0x01, 0xC3,
  0xC0, 0x3C, 0x70, 0x03, 0x9E, 0x00, 0x77, 0x80, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF8, 0x78, 0x3C, 0x1C, 0x1E, 0x0F, 0x01,
  0xFC, 0x78, 0x3F, 0xF3, 0xC3, 0xFF, 0xDC, 0x3F, 0x9F, 0xE1, 0xE0, 0x1F,
  0x1F, 0x00, 0xF8, 0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x78, 0x00, 0xE3, 0xC0,
  0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x38, 0x00, 0xF3,
  0xC0, 0x07, 0x9E, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x01,
  0xF1, 0xF0, 0x0F, 0x87, 0xC1, 0xBC, 0x3F, 0xFD, 0xC0, 0xFF, 0xDE, 0x03,
  0xFC, 0xF0, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE3, 0xF0, 0x0E,
  0x7F, 0xE0, 0xF7, 0xFF, 0x87, 0xB8, 0xFC, 0x3F, 0x01, 0xE1, 0xF0, 0x0F,
  0x8F, 0x00, 0x3C, 0x78, 0x01, 0xE3, 0x80, 0x0F, 0x3C, 0x00, 0x71, 0xE0,
  0x07, 0x8F, 0x00, 0x3C, 0x78, 0x01, 0xE3, 0xC0, 0x0F, 0x1C, 0x00, 0x79,
  0xE0, 0x03, 0x8F, 0x00, 0x3C, 0x78, 0x01, 0xE3, 0xC0, 0x0F, 0x1F, 0x00,
  0xF0, 0xFC, 0x1F, 0x8F, 0x7F, 0xF8, 0x79, 0xFF, 0x83, 0xC7, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xE0, 0xFE, 0xFE, 0x1F, 0x01,
  0xF3, 0xE0, 0x0F, 0x3C, 0x00, 0xF3, 0xC0, 0x0F, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x01, 0xEF, 0x00, 0x3C, 0xF0, 0x03, 0xCF,
  0x80, 0x78, 0x7C, 0x1F, 0x87, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x7F, 0x1E, 0x07, 0xFE,
  0x78, 0x3F, 0xFD, 0xC1, 0xFC, 0xFF, 0x07, 0x80, 0x7C, 0x3E, 0x01, 0xF0,
  0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x1E, 0x00, 0x38, 0x78, 0x01, 0xE1, 0xE0,
  0x07, 0x87, 0x80, 0x1E, 0x1E, 0x00, 0x78, 0x70, 0x01, 0xE3, 0xC0, 0x07,
  0x8F, 0x00, 0x3C, 0x3C, 0x00, 0xF0, 0xF0, 0x03, 0xC3, 0xC0, 0x1F, 0x0F,
  0x80, 0x7C, 0x1F, 0x06, 0xF0, 0x7F, 0xFB, 0x80, 0xFF, 0xDE, 0x01, 0xFE,
  0x78, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0xF8, 0x7E,
  0x1E, 0x01, 0xE3, 0xC0, 0x0F, 0x3C, 0x00, 0xF3, 0x80, 0x0F, 0x78, 0x00,
  0xF7, 0x80, 0x0E, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x03, 0xCF, 0x80, 0x78, 0x7C, 0x0F, 0x87, 0xFF, 0xF0, 0x3F, 0xFE, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFC, 0x02, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x78, 0x3F, 0xF3, 0xC3, 0xFF, 0xDC, 0x3F, 0x8F, 0xE1, 0xF0,
  0x1F, 0x1F, 0x00, 0xF8, 0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x78, 0x00, 0xE3,
  0xC0, 0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x00,
  0xF3, 0xC0, 0x07, 0x9E, 0x00, 0x78, 0xF8, 0x03, 0xC3, 0xC0, 0x3E, 0x1F,
  0x03, 0xF0, 0xFF, 0xF7, 0x83, 0xFF, 0x3C, 0x0F, 0xF1, 0xC0, 0x0C, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xE0, 0x0F, 0xF8, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE3, 0xF0, 0x0E, 0x7F, 0xE0,
  0xF7, 0xFF, 0x87, 0xB8, 0xFC, 0x3F, 0x01, 0xF1, 0xF0, 0x0F, 0x8F, 0x00,
  0x3C, 0x78, 0x01, 0xE3, 0x80, 0x0F, 0x3C, 0x00, 0xF1, 0xE0, 0x07, 0x8F,
  0x00, 0x3C, 0x78, 0x01, 0xE3, 0xC0, 0x0F, 0x1C, 0x00, 0x79, 0xE0, 0x03,
  0x8F, 0x00, 0x3C, 0x78, 0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x78, 0xF0,
  0x03, 0xCF, 0x00, 0x1C, 0x78, 0x01, 0xE3, 0xC0, 0x0F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x0F,
  0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x0F, 0x0F, 0x00, 0x3C, 0x1C, 0x00, 0xF0, 0x78, 0x03, 0xE0, 0xF0, 0x0F,
  0x81, 0xE0, 0x3E, 0x03, 0xC0, 0xF8, 0x07, 0x81, 0xE0, 0x0F, 0x07, 0x80,
  0x3C, 0x1E, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03,
  0xC3, 0xC0, 0x07, 0x83, 0xC0, 0x0E, 0x07, 0x80, 0x3C, 0x0F, 0x80, 0x78,
  0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x3E, 0x07, 0x00,
  0x3C, 0x1E, 0x00, 0x7C, 0x3C, 0x00, 0x7C, 0x00, 0x7F, 0xF0, 0x1F, 0xF8,
  0x0F, 0xFE, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3F, 0xFF, 0x07,
  0xFF, 0xC1, 0xFF, 0xF0, 0x1F, 0xFC, 0x0E, 0x78, 0x78, 0x3D, 0xF9, 0xF8,
  0x7F, 0xF7, 0xF8, 0xF8, 0xF8, 0xF1, 0xE1, 0xE1, 0xE3, 0x83, 0xC3, 0xC7,
  0x07, 0x07, 0x8E, 0x0E, 0x0F, 0x3C, 0x1C, 0x1E, 0x78, 0x38, 0x38, 0xF0,
  0x70, 0x71, 0xE1, 0xE1, 0xE3, 0x83, 0x83, 0xC7, 0x07, 0x07, 0x9E, 0x0E,
  0x0F, 0x3C, 0x1C, 0x1C, 0x78, 0x38, 0x38, 0xF0, 0xF0, 0x71, 0xC1, 0xC1,
  0xE3, 0x83, 0x83, 0xCF, 0x07, 0x07, 0x9E, 0x0E, 0x0E, 0x3C, 0x1C, 0x1C,
  0x78, 0x78, 0x78, 0x0F, 0x1F, 0x80, 0x73, 0xFF, 0x07, 0xBF, 0xFC, 0x3D,
  0xC7, 0xE1, 0xF8, 0x0F, 0x8F, 0x80, 0x7C, 0x78, 0x01, 0xE3, 0xC0, 0x0F,
  0x1C, 0x00, 0x79, 0xE0, 0x07, 0x8F, 0x00, 0x3C, 0x78, 0x01, 0xE3, 0xC0,
  0x0F, 0x1E, 0x00, 0x78, 0xE0, 0x03, 0xCF, 0x00, 0x1C, 0x78, 0x01, 0xE3,
  0xC0, 0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x78, 0x00,
  0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x78, 0x00, 0xFE, 0x00, 0x3F, 0xF8, 0x07,
  0xFF, 0xC0, 0xFC, 0xFE, 0x1F, 0x01, 0xE3, 0xE0, 0x1F, 0x3C, 0x00, 0xF3,
  0xC0, 0x0F, 0x78, 0x00, 0xF7, 0x80, 0x0E, 0x78, 0x01, 0xE7, 0x80, 0x1E,
  0x78, 0x01, 0xE7, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x1C, 0xF0, 0x03,
  0xCF, 0x00, 0x3C, 0xF0, 0x03, 0xCF, 0x80, 0x78, 0x7C, 0x1F, 0x07, 0xFF,
  0xF0, 0x3F, 0xFC, 0x01, 0xFF, 0x80, 0x07, 0x8F, 0xC0, 0x1C, 0xFF, 0xC0,
  0xF7, 0xFF, 0x83, 0xDC, 0x7E, 0x0F, 0xC0, 0x78, 0x3E, 0x01, 0xF0, 0xF0,
  0x03, 0xC3, 0xC0, 0x0F, 0x1E, 0x00, 0x3C, 0x78, 0x00, 0xE1, 0xE0, 0x07,
  0x87, 0x80, 0x1E, 0x1E, 0x00, 0x78, 0x78, 0x01, 0xE1, 0xC0, 0x07, 0x8F,
  0x00, 0x1C, 0x3C, 0x00, 0xF0, 0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x0F, 0x80,
  0x78, 0x3B, 0x07, 0xE1, 0xEF, 0xFF, 0x07, 0x9F, 0xF8, 0x1E, 0x3F, 0x80,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF8,
  0x78, 0x3F, 0xF3, 0xC3, 0xFF, 0xFC, 0x3F, 0x9F, 0xE1, 0xE0, 0x3F, 0x1F,
  0x00, 0xF8, 0xF0, 0x07, 0xC7, 0x80, 0x1E, 0x78, 0x01, 0xE3, 0xC0, 0x0F,
  0x1E, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x38, 0x00, 0xF3, 0xC0,
  0x07, 0x1E, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x01, 0xF1,
  0xF0, 0x1F, 0x8F, 0xC1, 0xB8, 0x3F, 0xFD, 0xC0, 0xFF, 0xDE, 0x03, 0xF8,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x0E, 0x1F,
  0x80, 0xF3, 0xFF, 0x07, 0xBF, 0xF8, 0x3F, 0x87, 0xE1, 0xF0, 0x0F, 0x0F,
  0x80, 0x7C, 0x78, 0x01, 0xE7, 0x80, 0x0F, 0x3C, 0x00, 0x79, 0xE0, 0x07,
  0x8F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0xE1, 0xF8, 0x7E, 0x1E,
  0x01, 0xF3, 0xC0, 0x0F, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0xF0, 0x03,
  0xCF, 0x00, 0x7C, 0xF8, 0x0F, 0x8F, 0xFF, 0xF0, 0x7F, 0xFE, 0x03, 0xFF,
  0xC0, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x07,
  0xFF, 0x00, 0x1F, 0xF0, 0x1E, 0x00, 0x78, 0xE0, 0x03, 0xCF, 0x00, 0x1C,
  0x78, 0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x00,
  0x1E, 0x78, 0x00, 0xF3, 0xC0, 0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x03, 0xC7,
  0x80, 0x1E, 0x3C, 0x00, 0xF3, 0xC0, 0x07, 0x9E, 0x00, 0x38, 0xF0, 0x03,
  0xC7, 0x80, 0x1E, 0x3C, 0x01, 0xE1, 0xF0, 0x0F, 0x07, 0xC1, 0xF0, 0x3F,
  0xFF, 0x00, 0xFF, 0xF0, 0x01, 0xFE, 0x00, 0xF0, 0x00, 0x7B, 0x80, 0x07,
  0xDE, 0x00, 0x3C, 0xF0, 0x01, 0xE7, 0x80, 0x1E, 0x3C, 0x00, 0xF1, 0xE0,
  0x0F, 0x07, 0x00, 0x78, 0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x0F, 0x03, 0xC0,
  0x78, 0x1E, 0x03, 0xC1, 0xE0, 0x0E, 0x0F, 0x00, 0x78, 0xF0, 0x03, 0xC7,
  0x80, 0x1E, 0x78, 0x00, 0xF3, 0xC0, 0x07, 0x9C, 0x00, 0x1D, 0xE0, 0x00,
  0xEE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0xF0, 0x3C,
  0x0F, 0xE0, 0xF8, 0x1F, 0xC1, 0xF0, 0x77, 0x83, 0xE0, 0xEF, 0x0F, 0xC1,
  0xDE, 0x1F, 0x87, 0x3C, 0x37, 0x0E, 0x78, 0x6E, 0x1C, 0xF1, 0xDC, 0x79,
  0xE3, 0x38, 0xE3, 0xC6, 0x71, 0xC7, 0x1C, 0xE7, 0x8E, 0x31, 0xCE, 0x1C,
  0x63, 0x9C, 0x39, 0xC7, 0x38, 0x73, 0x0E, 0xE0, 0xE6, 0x1D, 0xC1, 0xDC,
  0x3B, 0x83, 0xB0, 0x7E, 0x07, 0x60, 0xFC, 0x0F, 0xC1, 0xF8, 0x1F, 0x03,
  0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0x07, 0x80, 0x0F, 0x83, 0xE0,
  0x0F, 0x80, 0xF0, 0x07, 0x80, 0x7C, 0x07, 0x80, 0x1E, 0x07, 0x80, 0x0F,
  0x87, 0xC0, 0x03, 0xC7, 0xC0, 0x01, 0xF3, 0xC0, 0x00, 0x7B, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xDE, 0x00, 0x03, 0xEF, 0x00, 0x01, 0xE3, 0xC0,
  0x01, 0xE1, 0xE0, 0x01, 0xE0, 0xF8, 0x01, 0xF0, 0x3C, 0x01, 0xF0, 0x1F,
  0x00, 0xF0, 0x07, 0x80, 0xF0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x1E, 0x00,
  0x78, 0xE0, 0x03, 0xCF, 0x00, 0x1C, 0x78, 0x01, 0xE3, 0xC0, 0x0F, 0x1E,
  0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x78, 0x00, 0xE3, 0xC0, 0x0F,
  0x1E, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x00, 0xF1, 0xC0,
  0x07, 0x9E, 0x00, 0x78, 0xF8, 0x03, 0xC3, 0xC0, 0x3E, 0x1F, 0x07, 0xF0,
  0xFF, 0xF7, 0x83, 0xFF, 0x3C, 0x0F, 0xF1, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x07,
  0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x0F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x1F, 0xFF,
  0xF8, 0x00, 0x00, 0x3C, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFE,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0x80, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x7F, 0xF0, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x03, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x03, 0x00, 0x00, 0xFE,
  0x03, 0xCF, 0xF8, 0x1E, 0xFF, 0xE0, 0xFF, 0x0F, 0x07, 0xF8, 0x3C, 0x7B,
  0xC1, 0xFF, 0xDE, 0x07, 0xFC, 0xE0, 0x1F, 0x80,
};

const GFXglyph JetBrainsMono_Italic43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 26, 0, -1 },
  { 1, 10, 31, 26, 8, -31 },
  { 40, 14, 13, 26, 8, -31 },
  { 63, 25, 31, 26, 1, -31 },
  { 160, 23, 43, 26, 2, -37 },
  { 284, 29, 32, 26, -1, -32 },
  { 400, 24, 32, 26, 1, -32 },
  { 496, 6, 13, 26, 12, -31 },
  { 506, 18, 41, 26, 7, -36 },
  { 599, 18, 41, 26, 2, -36 },
  { 692, 23, 22, 26, 2, -26 },
  { 756, 21, 20, 26, 3, -24 },
  { 809, 11, 14, 26, 4, -7 },
  { 829, 14, 4, 26, 6, -16 },
  { 836, 7, 7, 26, 8, -7 },
  { 843, 25, 41, 26, 1, -36 },
  { 972, 23, 32, 26, 2, -32 },
  { 1064, 20, 31, 26, 2, -31 },
  { 1142, 22, 32, 26, 2, -32 },
  { 1230, 22, 31, 26, 2, -31 },
  { 1316, 20, 31, 26, 3, -31 },
  { 1394, 21, 31, 26, 3, -31 },
  { 1476, 21, 31, 26, 2, -31 },
  { 1558, 21, 31, 26, 5, -31 },
  { 1640, 22, 32, 26, 2, -32 },
  { 1728, 21, 32, 26, 4, -32 },
  { 1812, 10, 24, 26, 8, -24 },
  { 1842, 14, 31, 26, 4, -24 },
  { 1897, 20, 23, 26, 4, -26 },
  { 1955, 21, 14, 26, 3, -21 },
  { 1992, 21, 23, 26, 2, -26 },
  { 2053, 17, 31, 26, 6, -31 },
  { 2119, 26, 40, 26, 0, -32 },
  { 2249, 22, 31, 26, 0, -31 },
  { 2335, 22, 31, 26, 2, -31 },
  { 2421, 21, 32, 26, 3, -32 },
  { 2505, 22, 31, 26, 2, -31 },
  { 2591, 23, 31, 26, 2, -31 },
  { 2681, 24, 31, 26, 2, -31 },
  { 2774, 21, 32, 26, 3, -32 },
  { 2858, 23, 31, 26, 2, -31 },
  { 2948, 21, 31, 26, 3, -31 },
  { 3030, 23, 31, 26, 1, -31 },
  { 3120, 25, 31, 26, 2, -31 },
  { 3217, 19, 31, 26, 3, -31 },
  { 3291, 25, 31, 26, 1, -31 },
  { 3388, 23, 31, 26, 2, -31 },
  { 3478, 21, 32, 26, 3, -32 },
  { 3562, 24, 31, 26, 2, -31 },
  { 3655, 23, 40, 26, 2, -32 },
  { 3770, 23, 31, 26, 2, -31 },
  { 3860, 23, 32, 26, 2, -32 },
  { 3952, 22, 31, 26, 5, -31 },
  { 4038, 22, 31, 26, 3, -31 },
  { 4124, 22, 31, 26, 5, -31 },
  { 4210, 25, 31, 26, 3, -31 },
  { 4307, 27, 31, 26, 0, -31 },
  { 4412, 22, 31, 26, 5, -31 },
  { 4498, 23, 31, 26, 2, -31 },
  { 4588, 17, 41, 26, 6, -36 },
  { 4676, 13, 41, 26, 7, -36 },
  { 4743, 17, 41, 26, 4, -36 },
  { 4831, 19, 16, 26, 4, -31 },
  { 4869, 21, 3, 26, 0, 1 },
  { 4877, 8, 6, 26, 11, -34 },
  { 4883, 21, 24, 26, 3, -24 },
  { 4946, 21, 31, 26, 2, -31 },
  { 5028, 20, 24, 26, 3, -24 },
  { 5088, 22, 31, 26, 3, -31 },
  { 5174, 20, 24, 26, 3, -24 },
  { 5234, 29, 39, 26, -2, -31 },
  { 5376, 21, 32, 26, 3, -24 },
  { 5460, 21, 31, 26, 2, -31 },
  { 5542, 20, 33, 26, 2, -33 },
  { 5625, 22, 41, 26, 1, -33 },
  { 5738, 23, 31, 26, 2, -31 },
  { 5828, 18, 31, 26, 4, -31 },
  { 5898, 23, 24, 26, 1, -24 },
  { 5967, 21, 24, 26, 2, -24 },
  { 6030, 20, 24, 26, 3, -24 },
  { 6090, 22, 32, 26, 1, -24 },
  { 6178, 21, 32, 26, 3, -24 },
  { 6262, 21, 24, 26, 3, -24 },
  { 6325, 20, 24, 26, 3, -24 },
  { 6385, 20, 30, 26, 4, -30 },
  { 6460, 21, 24, 26, 3, -24 },
  { 6523, 21, 24, 26, 4, -24 },
  { 6586, 23, 24, 26, 3, -24 },
  { 6655, 25, 24, 26, 0, -24 },
  { 6730, 21, 32, 26, 3, -24 },
  { 6814, 21, 24, 26, 2, -24 },
  { 6877, 22, 41, 26, 4, -36 },
  { 6990, 11, 41, 26, 8, -36 },
  { 7047, 22, 41, 26, 1, -36 },
  { 7160, 21, 9, 26, 3, -20 },
};

const GFXfont JetBrainsMono_Italic43pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Italic43pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Italic43pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _JETBRAINSMONO_ITALIC43PT7B_H_
