#ifndef _JETBRAINSMONO_ITALIC41PT7B_H_
#define _JETBRAINSMONO_ITALIC41PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Italic.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Italic41pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0xF8, 0x7C, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0x81, 0xC1, 0xE0, 0xF0, 0x78, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x3F, 0x1F, 0x8F, 0xC7, 0xC0, 0x78,
  0x7B, 0xC3, 0xDE, 0x1E, 0xF0, 0xFF, 0x07, 0xF8, 0x3B, 0xC1, 0xDE, 0x1E,
  0xE0, 0xF7, 0x07, 0xB8, 0x39, 0xC1, 0xC0, 0x00, 0x1C, 0x0E, 0x00, 0x38,
  0x0E, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x70, 0x1C, 0x00, 0x70,
  0x38, 0x00, 0x70, 0x38, 0x00, 0xE0, 0x38, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFE, 0x01, 0xC0, 0xE0, 0x01, 0xC0, 0xE0, 0x03, 0x80,
  0xE0, 0x03, 0x81, 0xC0, 0x03, 0x81, 0xC0, 0x07, 0x01, 0xC0, 0x07, 0x03,
  0x80, 0x0F, 0x03, 0x80, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF0, 0x1C, 0x07, 0x00, 0x1C, 0x0E, 0x00, 0x38, 0x0E, 0x00, 0x38, 0x1C,
  0x00, 0x38, 0x1C, 0x00, 0x70, 0x1C, 0x00, 0x70, 0x38, 0x00, 0x70, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xF8, 0x03,
  0xFF, 0xF0, 0x1F, 0x33, 0xE0, 0x79, 0xC7, 0x83, 0xC7, 0x1E, 0x0E, 0x1C,
  0x78, 0x38, 0x61, 0xE1, 0xE1, 0x80, 0x07, 0x86, 0x00, 0x1F, 0x18, 0x00,
  0x3E, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x1D, 0xF8, 0x00, 0x73, 0xE0, 0x01, 0xC7,
  0x80, 0x06, 0x1E, 0x00, 0x18, 0x78, 0xF0, 0x61, 0xE3, 0xC3, 0x87, 0x8F,
  0x0E, 0x1C, 0x3E, 0x38, 0xF0, 0x7C, 0xCF, 0x81, 0xFF, 0xFC, 0x03, 0xFF,
  0xE0, 0x03, 0xFE, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0xF0, 0x3F, 0xC0, 0x0E, 0x07, 0xFE, 0x01, 0xC0, 0xF0, 0xE0, 0x38, 0x0E,
  0x0E, 0x07, 0x00, 0xE0, 0xE0, 0xE0, 0x0E, 0x0E, 0x1E, 0x01, 0xC0, 0xE1,
  0xC0, 0x1C, 0x0E, 0x38, 0x01, 0xC1, 0xC7, 0x00, 0x1E, 0x3C, 0xE0, 0x00,
  0xFF, 0x9C, 0x00, 0x07, 0xF3, 0xC0, 0x00, 0x08, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x10, 0x00, 0x03, 0x8F, 0xE0,
  0x00, 0x79, 0xFF, 0x00, 0x07, 0x3C, 0xF0, 0x00, 0xE7, 0x87, 0x80, 0x1C,
  0x70, 0x70, 0x03, 0x87, 0x07, 0x00, 0x70, 0x70, 0x70, 0x0F, 0x07, 0x07,
  0x00, 0xE0, 0xF0, 0x70, 0x1C, 0x07, 0x0E, 0x03, 0x80, 0x7F, 0xE0, 0x70,
  0x07, 0xFC, 0x0E, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0x80, 0x1E, 0x0F, 0x80, 0x78, 0x0F, 0x00, 0xF0, 0x1E, 0x01,
  0xE0, 0x3C, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0x78, 0x0F, 0x3C, 0x78, 0x3C, 0xF0, 0xF0, 0xF1, 0xE0, 0xF3,
  0xC3, 0xC1, 0xE7, 0x07, 0x81, 0xFE, 0x0F, 0x01, 0xF8, 0x1C, 0x03, 0xE0,
  0x78, 0x03, 0xC0, 0xF0, 0x0F, 0x81, 0xE0, 0x3F, 0x83, 0xE0, 0xFF, 0x03,
  0xFF, 0xCF, 0x07, 0xFF, 0x1F, 0x03, 0xF8, 0x1E, 0x00, 0x7B, 0xDF, 0xEF,
  0x7B, 0xDE, 0xF7, 0x39, 0xC0, 0x00, 0x00, 0x80, 0x03, 0x80, 0x07, 0xC0,
  0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFE, 0x00,
  0x3F, 0x00, 0x0F, 0x80, 0x01, 0x80, 0x02, 0x00, 0x01, 0xC0, 0x00, 0xF8,
  0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x07, 0xF0,
  0x07, 0xE0, 0x03, 0xE0, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x07,
  0x03, 0x81, 0x9F, 0x0E, 0x3F, 0xFF, 0x33, 0xFD, 0xFE, 0xDF, 0xE0, 0xFF,
  0xFC, 0x00, 0x1C, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x70, 0x00, 0x39, 0xE0,
  0x01, 0xE7, 0x80, 0x0F, 0x0F, 0x00, 0x78, 0x3C, 0x03, 0xC0, 0xF8, 0x0F,
  0x01, 0xE0, 0x18, 0x02, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x01, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xE1, 0xF8, 0x3E, 0x07, 0xC1, 0xF0,
  0x3C, 0x0F, 0x81, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x78, 0x0E, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x3E, 0x7E, 0x7E, 0xFE, 0x7E, 0x7C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFF,
  0x00, 0xFF, 0xFC, 0x0F, 0x83, 0xE0, 0xF0, 0x07, 0x87, 0x80, 0x3C, 0x78,
  0x01, 0xE3, 0xC0, 0x0F, 0x1C, 0x00, 0x78, 0xE0, 0x03, 0xC7, 0x00, 0x1E,
  0x78, 0x00, 0xE3, 0xC2, 0x07, 0x1E, 0x3C, 0x38, 0xF3, 0xE3, 0xC7, 0x1F,
  0x1E, 0x38, 0x78, 0xF3, 0xC0, 0x07, 0x9E, 0x00, 0x38, 0xF0, 0x01, 0xC7,
  0x80, 0x1E, 0x38, 0x00, 0xF1, 0xC0, 0x07, 0x8E, 0x00, 0x38, 0x78, 0x03,
  0xC3, 0xC0, 0x3C, 0x1F, 0x03, 0xE0, 0x7F, 0xFE, 0x01, 0xFF, 0xE0, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x01, 0xFF, 0x80,
  0x7C, 0xF0, 0x1F, 0x1E, 0x03, 0x83, 0x80, 0xE0, 0x70, 0x10, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0x83,
  0xE0, 0xF0, 0x0F, 0x8F, 0x00, 0x3C, 0x78, 0x01, 0xE3, 0x80, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8,
  0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00,
  0x3C, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE3, 0xC0, 0x07, 0x1E, 0x00, 0x78,
  0xF0, 0x03, 0xC7, 0xC0, 0x3C, 0x1F, 0x07, 0xC0, 0xFF, 0xFE, 0x03, 0xFF,
  0xC0, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x0E, 0x0F, 0x01, 0xE1, 0xE0, 0x1E, 0x3E, 0x01, 0xE3, 0xC0,
  0x1E, 0x78, 0x01, 0xE7, 0x80, 0x1C, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F,
  0xFF, 0xC8, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF0, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x3C, 0x03, 0xDF,
  0xF0, 0x3F, 0xFF, 0x83, 0xFF, 0xFC, 0x3E, 0x07, 0xC3, 0xC0, 0x3C, 0x78,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0x8E, 0x00, 0x78, 0xF0, 0x07, 0x8F, 0x00, 0xF0,
  0xF8, 0x1F, 0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0xC0, 0x0F, 0x7F, 0x81, 0xEF, 0xFC, 0x1F, 0xFF, 0xE3,
  0xE0, 0x3E, 0x3C, 0x01, 0xE7, 0x80, 0x0F, 0x78, 0x00, 0xF7, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0E, 0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x03,
  0xC7, 0x80, 0x7C, 0x7C, 0x0F, 0x83, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0xFF,
  0x80, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0x00, 0x0E, 0x70,
  0x01, 0xEF, 0x00, 0x3C, 0xF0, 0x03, 0xCF, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0x00, 0xFF, 0xFC,
  0x0F, 0x83, 0xE0, 0x78, 0x0F, 0x87, 0x80, 0x3C, 0x3C, 0x01, 0xE1, 0xC0,
  0x0E, 0x0E, 0x00, 0x70, 0x70, 0x07, 0x83, 0xC0, 0x78, 0x1F, 0x07, 0x80,
  0x7C, 0xF8, 0x01, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0xE0, 0x0F, 0xCF,
  0x80, 0xF8, 0x3E, 0x0F, 0x00, 0xF0, 0x70, 0x03, 0xC7, 0x80, 0x1E, 0x38,
  0x00, 0xF1, 0xC0, 0x07, 0x8E, 0x00, 0x38, 0x70, 0x03, 0xC3, 0xC0, 0x3E,
  0x1F, 0x03, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0xC1, 0xF0, 0x7E, 0x3E, 0x01, 0xE7,
  0xC0, 0x1E, 0x78, 0x00, 0xE7, 0x00, 0x0E, 0xF0, 0x00, 0xEF, 0x00, 0x0E,
  0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x03, 0xCF, 0x80, 0x3C, 0x78, 0x07,
  0xC7, 0xF3, 0xF8, 0x3F, 0xFF, 0x01, 0xFE, 0xF0, 0x03, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x83, 0xF1, 0xFC, 0x7F, 0x1F, 0xC3, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x07, 0xE1, 0xF8, 0xFE, 0x1F, 0x87, 0xC0, 0x00, 0xF0, 0x0F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x80, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x3C, 0x01,
  0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x70, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x0F, 0x00, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07,
  0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x07, 0xC0, 0x00, 0x70, 0x00, 0x07,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x78, 0x00, 0x01,
  0x80, 0x3F, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xC0, 0x18, 0x00,
  0x01, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x00,
  0x00, 0x60, 0x00, 0x3E, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x3F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFE, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x1F, 0xF8, 0x1F, 0xF0, 0x1F,
  0xC0, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF,
  0x80, 0x3C, 0x03, 0xE0, 0x3C, 0x00, 0xF0, 0x3C, 0x00, 0x38, 0x1C, 0x00,
  0x1C, 0x1E, 0x00, 0x0F, 0x0E, 0x00, 0x07, 0x0F, 0x00, 0x03, 0x87, 0x00,
  0xF9, 0xC3, 0x80, 0xFE, 0xE1, 0xC0, 0xFF, 0x70, 0xE0, 0xF0, 0x78, 0xF0,
  0x70, 0x3C, 0x78, 0x78, 0x1C, 0x38, 0x38, 0x0E, 0x1C, 0x1C, 0x07, 0x0E,
  0x0E, 0x03, 0x87, 0x07, 0x01, 0xC3, 0x83, 0x81, 0xE3, 0xC3, 0xC0, 0xF1,
  0xE1, 0xE0, 0x70, 0xE0, 0xF0, 0x78, 0x70, 0x78, 0x3C, 0x38, 0x1F, 0xEE,
  0x1C, 0x0F, 0xF7, 0x1E, 0x01, 0xE0, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xDC,
  0x00, 0x1E, 0xE0, 0x00, 0xF7, 0x00, 0x07, 0x38, 0x00, 0x79, 0xE0, 0x03,
  0x8F, 0x00, 0x3C, 0x78, 0x01, 0xE3, 0xC0, 0x0E, 0x0E, 0x00, 0xF0, 0x70,
  0x07, 0x03, 0x80, 0x78, 0x1C, 0x03, 0xC0, 0xE0, 0x3C, 0x07, 0x81, 0xE0,
  0x3C, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x78, 0x03, 0xC3,
  0xC0, 0x0E, 0x1C, 0x00, 0x71, 0xE0, 0x03, 0x8F, 0x00, 0x1C, 0xF0, 0x00,
  0xF7, 0x80, 0x07, 0xF8, 0x00, 0x3C, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x03,
  0xFF, 0xFC, 0x1E, 0x0F, 0xE0, 0xF0, 0x0F, 0x87, 0x80, 0x3C, 0x38, 0x01,
  0xE1, 0xC0, 0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x03, 0x87, 0x80, 0x3C, 0x3C,
  0x03, 0xC1, 0xC0, 0x7C, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x07, 0xFF, 0xF8,
  0x3C, 0x07, 0xC1, 0xE0, 0x0F, 0x0E, 0x00, 0x78, 0x70, 0x01, 0xC3, 0x80,
  0x0E, 0x3C, 0x00, 0x71, 0xE0, 0x07, 0x8F, 0x00, 0x3C, 0x78, 0x03, 0xC3,
  0x80, 0x3E, 0x1C, 0x0F, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x3F, 0xFC, 0x07, 0xFF, 0xE0, 0xF8, 0x3E, 0x0F,
  0x00, 0xF1, 0xE0, 0x0F, 0x1C, 0x00, 0xF3, 0xC0, 0x0F, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x03, 0xCF, 0x00,
  0x38, 0xF0, 0x07, 0x8F, 0x00, 0xF8, 0xFC, 0x1F, 0x07, 0xFF, 0xE0, 0x3F,
  0xFC, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xF8,
  0x1E, 0x0F, 0xE0, 0xF0, 0x0F, 0x07, 0x80, 0x78, 0x38, 0x01, 0xE1, 0xC0,
  0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x03, 0x87, 0x80, 0x1C, 0x3C, 0x01, 0xE1,
  0xC0, 0x0F, 0x0E, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x00,
  0xE1, 0xE0, 0x0F, 0x0E, 0x00, 0x78, 0x70, 0x03, 0xC7, 0x80, 0x1E, 0x3C,
  0x00, 0xF1, 0xE0, 0x07, 0x0F, 0x00, 0x78, 0x78, 0x07, 0xC3, 0x80, 0x7C,
  0x1C, 0x0F, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0x07,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7F,
  0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x7F, 0xFF,
  0x81, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x3F, 0xFC, 0x07, 0xFF, 0xE0, 0xF8, 0x3E, 0x0F, 0x00, 0xF1, 0xE0, 0x0F,
  0x1C, 0x00, 0xF3, 0xC0, 0x0F, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x87,
  0xFE, 0x78, 0x7F, 0xE7, 0x07, 0xFC, 0x70, 0x01, 0xCF, 0x00, 0x3C, 0xF0,
  0x03, 0xCF, 0x00, 0x3C, 0xF0, 0x03, 0xCF, 0x00, 0x38, 0xF0, 0x07, 0x8F,
  0x00, 0xF8, 0xFC, 0x1F, 0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0x00,
  0x07, 0x00, 0x3C, 0x1C, 0x00, 0xF0, 0xF0, 0x03, 0x83, 0xC0, 0x1E, 0x0F,
  0x00, 0x78, 0x3C, 0x01, 0xE0, 0xE0, 0x07, 0x83, 0x80, 0x1E, 0x1E, 0x00,
  0x70, 0x78, 0x01, 0xC1, 0xE0, 0x0F, 0x07, 0x80, 0x3C, 0x1C, 0x00, 0xF0,
  0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3C, 0x01, 0xE0, 0xF0,
  0x07, 0x83, 0xC0, 0x1E, 0x0E, 0x00, 0x78, 0x38, 0x01, 0xE1, 0xE0, 0x07,
  0x07, 0x80, 0x3C, 0x1E, 0x00, 0xF0, 0x78, 0x03, 0xC1, 0xC0, 0x0F, 0x07,
  0x00, 0x3C, 0x3C, 0x00, 0xE0, 0xF0, 0x03, 0x83, 0xC0, 0x1E, 0x00, 0x07,
  0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x00, 0x3C, 0x00, 0x01, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0xFF, 0xFF,
  0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x1E, 0x3C, 0x00, 0x70,
  0xF0, 0x03, 0xC3, 0xE0, 0x1E, 0x07, 0xC0, 0xF8, 0x1F, 0xFF, 0xC0, 0x3F,
  0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0x00, 0x1F, 0x0F, 0x00, 0x3E, 0x0F,
  0x00, 0x3C, 0x0F, 0x00, 0x78, 0x0F, 0x00, 0xF8, 0x0F, 0x00, 0xF0, 0x0E,
  0x01, 0xE0, 0x0E, 0x03, 0xE0, 0x1E, 0x03, 0xC0, 0x1E, 0x07, 0x80, 0x1E,
  0x0F, 0x80, 0x1E, 0x0F, 0x00, 0x1C, 0x1E, 0x00, 0x1F, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x3C,
  0x1E, 0x00, 0x38, 0x1F, 0x00, 0x78, 0x0F, 0x00, 0x78, 0x0F, 0x00, 0x78,
  0x0F, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x70, 0x03, 0xC0, 0x70,
  0x03, 0xC0, 0xF0, 0x03, 0xC0, 0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0x07,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xE0, 0x07, 0xC0, 0x3E, 0x0F, 0x80,
  0x7C, 0x1F, 0x01, 0xD8, 0x3E, 0x03, 0xF0, 0xEE, 0x0F, 0xE1, 0xDC, 0x1D,
  0xC3, 0xB8, 0x7B, 0x07, 0x70, 0xEE, 0x0E, 0xE1, 0xDC, 0x1D, 0xC7, 0x38,
  0x79, 0x8E, 0x70, 0xF3, 0xB9, 0xE1, 0xC7, 0x73, 0x83, 0x8F, 0xC7, 0x07,
  0x1F, 0x8E, 0x0E, 0x3E, 0x3C, 0x3C, 0x3C, 0x78, 0x78, 0x00, 0xF0, 0xF0,
  0x01, 0xE1, 0xE0, 0x03, 0x83, 0x80, 0x07, 0x07, 0x00, 0x1E, 0x1E, 0x00,
  0x3C, 0x3C, 0x00, 0x78, 0x78, 0x00, 0xF0, 0xF0, 0x01, 0xC1, 0xC0, 0x03,
  0x83, 0x80, 0x0F, 0x07, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x00, 0x07, 0xC0,
  0x3C, 0x3F, 0x00, 0xF0, 0xFC, 0x03, 0x83, 0xF0, 0x0E, 0x0F, 0xC0, 0x38,
  0x3F, 0x81, 0xE0, 0xEE, 0x07, 0x87, 0xB8, 0x1E, 0x1E, 0xE0, 0x78, 0x7B,
  0x81, 0xC1, 0xEF, 0x07, 0x07, 0x1C, 0x3C, 0x1C, 0x70, 0xF0, 0xF1, 0xC3,
  0xC3, 0xC7, 0x0F, 0x0F, 0x1E, 0x38, 0x3C, 0x38, 0xE0, 0xE0, 0xE3, 0x83,
  0x83, 0x9E, 0x0E, 0x0E, 0x78, 0x78, 0x3D, 0xE1, 0xE0, 0x77, 0x07, 0x81,
  0xDC, 0x1E, 0x07, 0x70, 0x70, 0x1D, 0xC1, 0xC0, 0x7F, 0x0F, 0x00, 0xFC,
  0x3C, 0x03, 0xF0, 0xF0, 0x0F, 0x83, 0xC0, 0x3E, 0x00, 0x00, 0xFF, 0x00,
  0x3F, 0xFC, 0x07, 0xFF, 0xE0, 0xF8, 0x3E, 0x1F, 0x01, 0xF1, 0xE0, 0x0F,
  0x1C, 0x00, 0xF3, 0xC0, 0x0F, 0x3C, 0x00, 0xF3, 0xC0, 0x0E, 0x3C, 0x00,
  0xE3, 0x80, 0x1E, 0x38, 0x01, 0xE7, 0x80, 0x1E, 0x78, 0x01, 0xE7, 0x80,
  0x1C, 0x78, 0x01, 0xC7, 0x80, 0x3C, 0x70, 0x03, 0xCF, 0x00, 0x3C, 0xF0,
  0x03, 0xCF, 0x00, 0x3C, 0xF0, 0x03, 0x8F, 0x00, 0x78, 0xF0, 0x07, 0x8F,
  0x00, 0xF0, 0xF8, 0x1F, 0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0x00,
  0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x78, 0x1F, 0xC0,
  0xF0, 0x07, 0xC1, 0xE0, 0x07, 0x83, 0x80, 0x0F, 0x07, 0x00, 0x1E, 0x1E,
  0x00, 0x3C, 0x3C, 0x00, 0x78, 0x78, 0x00, 0xF0, 0xF0, 0x03, 0xC1, 0xC0,
  0x07, 0x83, 0x80, 0x3E, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF,
  0x80, 0x7F, 0xF0, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0x0F,
  0x83, 0xE0, 0xF8, 0x0F, 0x87, 0x80, 0x3C, 0x78, 0x01, 0xE3, 0xC0, 0x0F,
  0x1E, 0x00, 0x78, 0xE0, 0x03, 0xC7, 0x00, 0x1E, 0x78, 0x00, 0xE3, 0xC0,
  0x07, 0x1E, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x00, 0x1E, 0x38, 0x00, 0xF3,
  0xC0, 0x07, 0x9E, 0x00, 0x38, 0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x00,
  0xF1, 0xC0, 0x07, 0x8E, 0x00, 0x38, 0x78, 0x03, 0xC3, 0xC0, 0x3C, 0x1F,
  0x03, 0xE0, 0x7F, 0xFE, 0x01, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF,
  0xFF, 0x03, 0xC0, 0xFE, 0x0F, 0x00, 0x78, 0x3C, 0x01, 0xE0, 0xE0, 0x03,
  0xC3, 0x80, 0x0F, 0x1E, 0x00, 0x3C, 0x78, 0x01, 0xE1, 0xE0, 0x07, 0x87,
  0x80, 0x1E, 0x1C, 0x00, 0xF0, 0x70, 0x0F, 0x83, 0xFF, 0xFE, 0x0F, 0xFF,
  0xE0, 0x3F, 0xFE, 0x00, 0xF0, 0x70, 0x03, 0x81, 0xE0, 0x0E, 0x07, 0x80,
  0x78, 0x1E, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x07, 0x81, 0xC0, 0x1E, 0x07, 0x00, 0x78, 0x3C, 0x00, 0xF0, 0xF0, 0x03,
  0xC3, 0xC0, 0x0F, 0x80, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0x80, 0x3F, 0xFF,
  0x01, 0xF0, 0x3E, 0x07, 0x80, 0x78, 0x3C, 0x01, 0xE0, 0xE0, 0x07, 0x83,
  0x80, 0x1E, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x8F, 0x00, 0x1E, 0x3C, 0x00, 0x78, 0xF0, 0x01,
  0xC3, 0xE0, 0x0F, 0x07, 0xC0, 0xF8, 0x1F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x78, 0xF0, 0x03, 0xC7,
  0x80, 0x1C, 0x3C, 0x00, 0xE1, 0xE0, 0x0F, 0x0E, 0x00, 0x78, 0x70, 0x03,
  0xC7, 0x80, 0x1E, 0x3C, 0x00, 0xF1, 0xE0, 0x07, 0x0F, 0x00, 0x38, 0x78,
  0x03, 0xC3, 0x80, 0x1E, 0x3C, 0x00, 0xF1, 0xE0, 0x07, 0x8F, 0x00, 0x38,
  0x78, 0x01, 0xC3, 0xC0, 0x1E, 0x1C, 0x00, 0xF0, 0xE0, 0x07, 0x8F, 0x00,
  0x3C, 0x78, 0x01, 0xC3, 0xC0, 0x0E, 0x1E, 0x00, 0xF0, 0xF0, 0x07, 0x87,
  0x80, 0x78, 0x3E, 0x07, 0xC0, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x0F, 0xF8,
  0x00, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xBC, 0x00, 0x39, 0xE0, 0x03, 0xCF,
  0x00, 0x1E, 0x38, 0x01, 0xE1, 0xC0, 0x0F, 0x0E, 0x00, 0x70, 0x78, 0x07,
  0x83, 0xC0, 0x3C, 0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x07, 0x80, 0xE0, 0x3C,
  0x0F, 0x01, 0xE0, 0x70, 0x07, 0x07, 0x80, 0x38, 0x3C, 0x01, 0xC1, 0xC0,
  0x0E, 0x1E, 0x00, 0x78, 0xE0, 0x03, 0xCF, 0x00, 0x1E, 0x78, 0x00, 0xF3,
  0x80, 0x07, 0xBC, 0x00, 0x3D, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x70, 0x3C, 0x0F, 0x70,
  0x3C, 0x0E, 0x70, 0x3C, 0x0E, 0x70, 0x7C, 0x1E, 0x70, 0x6C, 0x1C, 0x70,
  0x6C, 0x1C, 0x70, 0x6C, 0x3C, 0x70, 0xEC, 0x38, 0x70, 0xCC, 0x38, 0x70,
  0xCC, 0x38, 0x71, 0xDC, 0x78, 0xF1, 0x9C, 0x70, 0xF1, 0x9C, 0x70, 0xF1,
  0x9C, 0x70, 0xF3, 0x9C, 0xF0, 0xF3, 0x1C, 0xE0, 0xE3, 0x1C, 0xE0, 0xE7,
  0x1C, 0xE0, 0xE7, 0x19, 0xC0, 0xE6, 0x19, 0xC0, 0xE6, 0x19, 0xC0, 0xEE,
  0x1B, 0xC0, 0xEC, 0x1B, 0x80, 0xEC, 0x1B, 0x80, 0xFC, 0x1B, 0x80, 0xFC,
  0x1F, 0x80, 0xF8, 0x1F, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x1F, 0x00, 0xF0,
  0x1E, 0x00, 0x07, 0x80, 0x07, 0x81, 0xE0, 0x07, 0x80, 0xF0, 0x03, 0xC0,
  0x78, 0x03, 0xC0, 0x1E, 0x03, 0xC0, 0x0F, 0x03, 0xE0, 0x03, 0x81, 0xE0,
  0x01, 0xE1, 0xE0, 0x00, 0xF1, 0xE0, 0x00, 0x3C, 0xF0, 0x00, 0x1E, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3D,
  0xE0, 0x00, 0x3C, 0xF0, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x1E, 0x00, 0x1E,
  0x0F, 0x00, 0x0F, 0x03, 0xC0, 0x0F, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x0F,
  0x80, 0x3C, 0x07, 0x80, 0x1E, 0x07, 0x80, 0x07, 0x87, 0x80, 0x03, 0xC0,
  0xF0, 0x00, 0x3D, 0xE0, 0x01, 0xE7, 0x80, 0x07, 0x9E, 0x00, 0x3C, 0x3C,
  0x01, 0xE0, 0xF0, 0x07, 0x83, 0xC0, 0x3C, 0x07, 0x81, 0xE0, 0x1E, 0x07,
  0x80, 0x78, 0x3C, 0x00, 0xE0, 0xE0, 0x03, 0xC7, 0x80, 0x0F, 0x3C, 0x00,
  0x1C, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0x03, 0xFF, 0x03, 0xFF, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0xFF, 0xC0, 0xFF, 0xC0,
  0xFF, 0xC0, 0xFF, 0xC0, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x70, 0x07,
  0x80, 0x78, 0x07, 0x80, 0x38, 0x03, 0x80, 0x3C, 0x03, 0xC0, 0x3C, 0x01,
  0xC0, 0x1E, 0x01, 0xE0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x07, 0x00, 0x78, 0x07, 0x80, 0x78, 0x03, 0x80, 0x3C, 0x03, 0xC0,
  0x3C, 0x01, 0xC0, 0x1C, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x0E, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x03, 0xFF, 0x07, 0xFF, 0x07, 0xFE, 0x00, 0x0E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x00,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01,
  0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xDC, 0x00, 0xF3, 0x80, 0x38,
  0xE0, 0x1C, 0x38, 0x0F, 0x0F, 0x03, 0x81, 0xC1, 0xE0, 0x70, 0xF0, 0x1C,
  0x38, 0x03, 0x9E, 0x00, 0xE7, 0x00, 0x3B, 0x80, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0xF0, 0xE1, 0xE1, 0xE1, 0xC0, 0x00,
  0xF8, 0x78, 0x1F, 0xF3, 0x81, 0xFF, 0xDC, 0x1F, 0x8F, 0xE1, 0xF0, 0x1F,
  0x0F, 0x00, 0xF8, 0x70, 0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x00, 0xE1, 0xE0,
  0x0F, 0x0F, 0x00, 0x78, 0x70, 0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x00, 0xF1,
  0xE0, 0x07, 0x0F, 0x00, 0x38, 0x78, 0x03, 0xC3, 0xC0, 0x1E, 0x1E, 0x01,
  0xF0, 0xF8, 0x1F, 0x83, 0xFF, 0xB8, 0x1F, 0xF9, 0xC0, 0x3F, 0x9E, 0x00,
  0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE1, 0xF0, 0x1E, 0x7F, 0xC1, 0xEF,
  0xFE, 0x1F, 0xC7, 0xE1, 0xF0, 0x1E, 0x1E, 0x00, 0xF1, 0xE0, 0x0F, 0x3C,
  0x00, 0xF3, 0xC0, 0x0E, 0x3C, 0x00, 0xE3, 0xC0, 0x1E, 0x38, 0x01, 0xE3,
  0x80, 0x1E, 0x78, 0x01, 0xE7, 0x80, 0x1E, 0x78, 0x01, 0xC7, 0x80, 0x3C,
  0x78, 0x03, 0xC7, 0x80, 0x78, 0x7C, 0x0F, 0x8F, 0x7F, 0xF0, 0xF7, 0xFE,
  0x0F, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x7F, 0xF0, 0x3F, 0xFF, 0x0F, 0xE7,
  0xE1, 0xE0, 0x3E, 0x78, 0x03, 0xCE, 0x00, 0x7B, 0xC0, 0x0F, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x02, 0xF0, 0x03, 0x9E, 0x00, 0xF3, 0xC0, 0x3E,
  0x7E, 0x0F, 0x87, 0xFF, 0xE0, 0x7F, 0xF8, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x3E, 0x1E, 0x03, 0xFE, 0x78, 0x1F,
  0xFD, 0xC0, 0xFC, 0x7F, 0x07, 0xC0, 0x7C, 0x1E, 0x01, 0xF0, 0x70, 0x03,
  0xC3, 0xC0, 0x0F, 0x0F, 0x00, 0x38, 0x3C, 0x01, 0xE0, 0xF0, 0x07, 0x83,
  0x80, 0x1E, 0x1E, 0x00, 0x78, 0x78, 0x01, 0xE1, 0xE0, 0x07, 0x07, 0x80,
  0x1C, 0x1E, 0x00, 0xF0, 0x78, 0x03, 0xC1, 0xE0, 0x1F, 0x07, 0xC0, 0xFC,
  0x0F, 0xFE, 0xE0, 0x3F, 0xF3, 0x80, 0x3F, 0x9E, 0x00, 0x00, 0xFC, 0x00,
  0x7F, 0xE0, 0x3F, 0xFE, 0x0F, 0x83, 0xE1, 0xE0, 0x3C, 0x78, 0x03, 0x8E,
  0x00, 0x7B, 0xC0, 0x0F, 0x78, 0x01, 0xCF, 0x00, 0x39, 0xFF, 0xFF, 0x3F,
  0xFF, 0xEF, 0xFF, 0xFD, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0xF3, 0xC0, 0x1E, 0x3C, 0x0F, 0x87, 0xFF, 0xE0, 0x7F,
  0xF8, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFF, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x01, 0xF8, 0xF0, 0x7F, 0xCE, 0x0F, 0xFE, 0xE1, 0xF8, 0xFE,
  0x3E, 0x03, 0xE3, 0xC0, 0x3E, 0x38, 0x01, 0xE7, 0x80, 0x1E, 0x78, 0x01,
  0xC7, 0x80, 0x1C, 0x78, 0x03, 0xC7, 0x00, 0x3C, 0x70, 0x03, 0xCF, 0x00,
  0x3C, 0xF0, 0x03, 0x8F, 0x00, 0x78, 0xF8, 0x0F, 0x87, 0x81, 0xF8, 0x7F,
  0xFF, 0x83, 0xFF, 0x78, 0x1F, 0xE7, 0x00, 0x20, 0x70, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x07, 0xFF, 0xC0,
  0x7F, 0xF8, 0x07, 0xFF, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE1,
  0xF0, 0x1E, 0x7F, 0xC1, 0xEF, 0xFE, 0x1F, 0xC3, 0xE1, 0xF0, 0x1F, 0x1E,
  0x00, 0xF1, 0xE0, 0x0F, 0x3C, 0x00, 0xF3, 0xC0, 0x0E, 0x3C, 0x00, 0xE3,
  0xC0, 0x1E, 0x38, 0x01, 0xE3, 0x80, 0x1E, 0x78, 0x01, 0xE7, 0x80, 0x1C,
  0x78, 0x01, 0xC7, 0x80, 0x3C, 0x78, 0x03, 0xC7, 0x00, 0x3C, 0x70, 0x03,
  0xCF, 0x00, 0x3C, 0xF0, 0x03, 0x8F, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00,
  0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x07, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0xFF,
  0xF8, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0x80, 0x0F, 0x1E, 0x00, 0x78, 0x78, 0x03, 0xC1, 0xE0, 0x1E, 0x07, 0x80,
  0xF8, 0x1E, 0x07, 0xC0, 0x70, 0x1E, 0x01, 0xC0, 0xF0, 0x0F, 0x07, 0x80,
  0x3C, 0x3C, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x38,
  0x3C, 0x01, 0xE0, 0xF0, 0x07, 0x81, 0xE0, 0x1E, 0x07, 0x80, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x00, 0x78, 0x3C, 0x01, 0xE0, 0xF0, 0x03, 0xC3,
  0xC0, 0x0F, 0x80, 0x7F, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x00, 0x3C, 0x00,
  0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0,
  0x01, 0xFF, 0xF0, 0x7F, 0xF8, 0x1F, 0xFC, 0x1E, 0x70, 0xF0, 0x7F, 0xE7,
  0xE1, 0xDF, 0xFF, 0xC7, 0x8F, 0x8F, 0x1C, 0x1C, 0x3C, 0x70, 0x70, 0xF3,
  0xC1, 0xC3, 0xCF, 0x0E, 0x0F, 0x3C, 0x38, 0x38, 0xE0, 0xE0, 0xE3, 0x83,
  0x83, 0x8E, 0x0E, 0x1E, 0x38, 0x38, 0x79, 0xE1, 0xE1, 0xE7, 0x87, 0x07,
  0x1E, 0x1C, 0x1C, 0x70, 0x70, 0x71, 0xC1, 0xC1, 0xC7, 0x07, 0x0F, 0x3C,
  0x1C, 0x3C, 0xF0, 0xE0, 0xF3, 0xC3, 0x83, 0x8E, 0x0E, 0x0E, 0x00, 0x0E,
  0x1F, 0x01, 0xE7, 0xFC, 0x1E, 0xFF, 0xE1, 0xFC, 0x3E, 0x1F, 0x01, 0xF1,
  0xE0, 0x0F, 0x1E, 0x00, 0xF3, 0xC0, 0x0F, 0x3C, 0x00, 0xE3, 0xC0, 0x0E,
  0x3C, 0x01, 0xE3, 0x80, 0x1E, 0x38, 0x01, 0xE7, 0x80, 0x1E, 0x78, 0x01,
  0xC7, 0x80, 0x1C, 0x78, 0x03, 0xC7, 0x80, 0x3C, 0x70, 0x03, 0xC7, 0x00,
  0x3C, 0xF0, 0x03, 0xCF, 0x00, 0x38, 0xF0, 0x07, 0x80, 0x00, 0xFC, 0x00,
  0x7F, 0xE0, 0x3F, 0xFE, 0x0F, 0xC7, 0xE1, 0xE0, 0x3C, 0x78, 0x03, 0xCE,
  0x00, 0x7B, 0xC0, 0x0F, 0x78, 0x01, 0xEF, 0x00, 0x39, 0xC0, 0x0F, 0x38,
  0x01, 0xEF, 0x00, 0x3D, 0xE0, 0x07, 0xBC, 0x00, 0xF7, 0x80, 0x1C, 0xF0,
  0x07, 0x9E, 0x00, 0xF3, 0xC0, 0x3C, 0x7C, 0x0F, 0x87, 0xFF, 0xE0, 0x7F,
  0xF8, 0x07, 0xFC, 0x00, 0x07, 0x0F, 0x80, 0x79, 0xFF, 0x03, 0xDF, 0xFC,
  0x1F, 0xC7, 0xE0, 0xF8, 0x0F, 0x07, 0x80, 0x3C, 0x3C, 0x01, 0xE3, 0xC0,
  0x0F, 0x1E, 0x00, 0x70, 0xF0, 0x03, 0x87, 0x80, 0x3C, 0x38, 0x01, 0xE1,
  0xC0, 0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x1C, 0x3C, 0x01,
  0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0xF0, 0xFC, 0x0F, 0x87, 0xBF, 0xF8, 0x3D,
  0xFF, 0x81, 0xE7, 0xF8, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF8, 0x78, 0x1F, 0xF3, 0x81, 0xFF, 0xDC, 0x1F, 0x8F, 0xE1, 0xF0, 0x1F,
  0x0F, 0x00, 0xF8, 0x70, 0x03, 0xC7, 0x80, 0x1C, 0x3C, 0x00, 0xE1, 0xE0,
  0x0F, 0x0E, 0x00, 0x78, 0x70, 0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x00, 0xF1,
  0xE0, 0x07, 0x0F, 0x00, 0x78, 0x78, 0x03, 0xC3, 0xC0, 0x1E, 0x1E, 0x01,
  0xF0, 0xF8, 0x1F, 0x83, 0xFF, 0xB8, 0x1F, 0xF9, 0xC0, 0x7F, 0x9E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x1E, 0x3F, 0x01, 0xEF, 0xF8, 0x1F,
  0xFF, 0xC1, 0xDC, 0x3E, 0x1F, 0x01, 0xE3, 0xE0, 0x1E, 0x3C, 0x00, 0xF3,
  0xC0, 0x0F, 0x3C, 0x00, 0xE3, 0xC0, 0x1E, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xE0,
  0xF8, 0x3E, 0x1E, 0x00, 0xF1, 0xE0, 0x0F, 0x1E, 0x00, 0x01, 0xC0, 0x00,
  0x1E, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0xC0, 0x00, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC7, 0x00,
  0x3C, 0x78, 0x03, 0xC7, 0x80, 0x78, 0x7F, 0xFF, 0x83, 0xFF, 0xF0, 0x1F,
  0xFC, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0xF0,
  0x01, 0xFF, 0x00, 0x3C, 0x00, 0xF3, 0xC0, 0x0F, 0x3C, 0x00, 0xE3, 0xC0,
  0x1E, 0x3C, 0x01, 0xE3, 0x80, 0x1E, 0x78, 0x01, 0xE7, 0x80, 0x1E, 0x78,
  0x01, 0xC7, 0x80, 0x1C, 0x78, 0x03, 0xC7, 0x00, 0x3C, 0x70, 0x03, 0xCF,
  0x00, 0x3C, 0xF0, 0x03, 0x8F, 0x00, 0x38, 0xF0, 0x07, 0x8F, 0x00, 0x78,
  0xF0, 0x0F, 0x07, 0x81, 0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0x1F, 0xF0,
  0x00, 0xF0, 0x00, 0xFF, 0x00, 0x0E, 0x70, 0x01, 0xE7, 0x00, 0x1C, 0x78,
  0x03, 0xC7, 0x80, 0x38, 0x78, 0x07, 0x87, 0x80, 0x78, 0x38, 0x0F, 0x03,
  0x80, 0xF0, 0x38, 0x1E, 0x03, 0xC1, 0xE0, 0x3C, 0x3C, 0x03, 0xC3, 0xC0,
  0x1C, 0x38, 0x01, 0xC7, 0x80, 0x1C, 0x70, 0x01, 0xEF, 0x00, 0x1E, 0xE0,
  0x01, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xE0,
  0x78, 0x1F, 0x81, 0xE0, 0xFE, 0x07, 0x83, 0xB8, 0x3E, 0x0E, 0xE0, 0xD8,
  0x3B, 0x83, 0x61, 0xCE, 0x1D, 0x87, 0x38, 0x66, 0x1C, 0xE1, 0x98, 0xE3,
  0x8E, 0x63, 0x8E, 0x31, 0x8E, 0x38, 0xC6, 0x70, 0xE7, 0x19, 0xC3, 0x98,
  0x67, 0x0E, 0x61, 0x98, 0x3B, 0x86, 0xE0, 0xEC, 0x1B, 0x83, 0xB0, 0x6C,
  0x0F, 0xC1, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1E, 0x03, 0xE0, 0x78, 0x0F,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x1F, 0x07, 0x80, 0x3E, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x78, 0x01, 0xE0, 0xF0, 0x01, 0xE1, 0xF0, 0x00, 0xF1, 0xE0,
  0x00, 0xF3, 0xC0, 0x00, 0x77, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xEF, 0x00,
  0x01, 0xE7, 0x80, 0x03, 0xC7, 0x80, 0x07, 0x83, 0xC0, 0x0F, 0x03, 0xC0,
  0x1F, 0x01, 0xE0, 0x3E, 0x01, 0xE0, 0x3C, 0x00, 0xF0, 0xF8, 0x00, 0xF8,
  0x1C, 0x00, 0xF3, 0xC0, 0x0F, 0x3C, 0x00, 0xE3, 0xC0, 0x0E, 0x3C, 0x01,
  0xE3, 0x80, 0x1E, 0x38, 0x01, 0xE7, 0x80, 0x1E, 0x78, 0x01, 0xC7, 0x80,
  0x1C, 0x78, 0x03, 0xC7, 0x80, 0x3C, 0x70, 0x03, 0xCF, 0x00, 0x3C, 0xF0,
  0x03, 0x8F, 0x00, 0x78, 0xF8, 0x0F, 0x87, 0xC1, 0xF8, 0x7F, 0xFF, 0x83,
  0xFF, 0x78, 0x1F, 0xC7, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x07, 0xFF, 0xC0, 0x7F, 0xF8,
  0x07, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x1F, 0xFF, 0xF1, 0xFF,
  0xFF, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x80,
  0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0x18, 0x00, 0x03, 0xC0, 0xE0, 0x38,
  0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xE0, 0x38, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xE0, 0x38, 0x1E, 0x07, 0x81, 0xE0,
  0x78, 0x1C, 0x07, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00,
  0x1E, 0x00, 0x01, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0xFF, 0x03, 0xCF, 0xF8, 0x1E,
  0x7B, 0xE0, 0xF7, 0x87, 0x87, 0x38, 0x3E, 0x79, 0xC0, 0xFF, 0x8E, 0x03,
  0xF8, 0xF0, 0x07, 0x00,
};

const GFXglyph JetBrainsMono_Italic41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 9, 30, 25, 8, -30 },
  { 35, 13, 12, 25, 8, -30 },
  { 55, 24, 30, 25, 1, -30 },
  { 145, 22, 42, 25, 2, -36 },
  { 261, 28, 30, 25, -1, -30 },
  { 366, 23, 30, 25, 1, -30 },
  { 453, 5, 12, 25, 12, -30 },
  { 461, 17, 40, 25, 7, -35 },
  { 546, 17, 40, 25, 2, -35 },
  { 631, 22, 21, 25, 2, -25 },
  { 689, 20, 19, 25, 3, -23 },
  { 737, 11, 13, 25, 4, -6 },
  { 755, 13, 3, 25, 6, -15 },
  { 760, 8, 6, 25, 7, -6 },
  { 766, 24, 39, 25, 1, -34 },
  { 883, 21, 30, 25, 2, -30 },
  { 962, 19, 30, 25, 2, -30 },
  { 1034, 21, 30, 25, 2, -30 },
  { 1113, 21, 30, 25, 2, -30 },
  { 1192, 20, 30, 25, 2, -30 },
  { 1267, 20, 30, 25, 3, -30 },
  { 1342, 20, 30, 25, 2, -30 },
  { 1417, 20, 30, 25, 5, -30 },
  { 1492, 21, 30, 25, 2, -30 },
  { 1571, 20, 30, 25, 4, -30 },
  { 1646, 10, 23, 25, 7, -23 },
  { 1675, 13, 30, 25, 4, -23 },
  { 1724, 20, 21, 25, 3, -24 },
  { 1777, 20, 13, 25, 3, -20 },
  { 1810, 20, 21, 25, 2, -24 },
  { 1863, 16, 30, 25, 6, -30 },
  { 1923, 25, 37, 25, 0, -30 },
  { 2039, 21, 30, 25, 0, -30 },
  { 2118, 21, 30, 25, 2, -30 },
  { 2197, 20, 30, 25, 3, -30 },
  { 2272, 21, 30, 25, 2, -30 },
  { 2351, 22, 30, 25, 2, -30 },
  { 2434, 22, 30, 25, 2, -30 },
  { 2517, 20, 30, 25, 3, -30 },
  { 2592, 22, 30, 25, 2, -30 },
  { 2675, 21, 30, 25, 2, -30 },
  { 2754, 22, 30, 25, 1, -30 },
  { 2837, 24, 30, 25, 2, -30 },
  { 2927, 18, 30, 25, 3, -30 },
  { 2995, 23, 30, 25, 1, -30 },
  { 3082, 22, 30, 25, 2, -30 },
  { 3165, 20, 30, 25, 3, -30 },
  { 3240, 23, 30, 25, 2, -30 },
  { 3327, 21, 37, 25, 2, -30 },
  { 3425, 22, 30, 25, 2, -30 },
  { 3508, 22, 30, 25, 2, -30 },
  { 3591, 20, 30, 25, 5, -30 },
  { 3666, 21, 30, 25, 3, -30 },
  { 3745, 21, 30, 25, 5, -30 },
  { 3824, 24, 30, 25, 3, -30 },
  { 3914, 25, 30, 25, 0, -30 },
  { 4008, 22, 30, 25, 4, -30 },
  { 4091, 22, 30, 25, 2, -30 },
  { 4174, 16, 39, 25, 6, -34 },
  { 4252, 12, 39, 25, 7, -34 },
  { 4311, 16, 39, 25, 4, -34 },
  { 4389, 18, 16, 25, 4, -30 },
  { 4425, 20, 3, 25, 0, 1 },
  { 4433, 7, 6, 25, 11, -32 },
  { 4439, 21, 23, 25, 2, -23 },
  { 4500, 20, 30, 25, 2, -30 },
  { 4575, 19, 23, 25, 3, -23 },
  { 4630, 22, 30, 25, 2, -30 },
  { 4713, 19, 23, 25, 3, -23 },
  { 4768, 28, 37, 25, -2, -30 },
  { 4898, 20, 30, 25, 3, -23 },
  { 4973, 20, 30, 25, 2, -30 },
  { 5048, 20, 32, 25, 1, -32 },
  { 5128, 22, 39, 25, 0, -32 },
  { 5236, 22, 30, 25, 2, -30 },
  { 5319, 17, 30, 25, 4, -30 },
  { 5383, 22, 23, 25, 1, -23 },
  { 5447, 20, 23, 25, 2, -23 },
  { 5505, 19, 23, 25, 3, -23 },
  { 5560, 21, 30, 25, 1, -23 },
  { 5639, 21, 30, 25, 2, -23 },
  { 5718, 20, 23, 25, 3, -23 },
  { 5776, 20, 23, 25, 2, -23 },
  { 5834, 20, 29, 25, 3, -29 },
  { 5907, 20, 23, 25, 3, -23 },
  { 5965, 20, 23, 25, 4, -23 },
  { 6023, 22, 23, 25, 3, -23 },
  { 6087, 24, 23, 25, 0, -23 },
  { 6156, 20, 30, 25, 3, -23 },
  { 6231, 20, 23, 25, 2, -23 },
  { 6289, 21, 39, 25, 4, -34 },
  { 6392, 10, 39, 25, 8, -34 },
  { 6441, 21, 39, 25, 1, -34 },
  { 6544, 21, 9, 25, 2, -19 },
};

const GFXfont JetBrainsMono_Italic41pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Italic41pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Italic41pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _JETBRAINSMONO_ITALIC41PT7B_H_
