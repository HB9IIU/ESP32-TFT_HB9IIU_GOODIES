#ifndef _JETBRAINSMONO_ITALIC15PT7B_H_
#define _JETBRAINSMONO_ITALIC15PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Italic.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Italic15pt7bBitmaps[] PROGMEM = {
  0x00, 0x25, 0xB6, 0x92, 0x1B, 0x00, 0xDE, 0xE5, 0x29, 0x00, 0x08, 0x84,
  0x86, 0x47, 0xF5, 0x21, 0x90, 0x89, 0xFE, 0x64, 0x22, 0x12, 0x00, 0x08,
  0x08, 0x3E, 0x6A, 0x4A, 0x48, 0x70, 0x3C, 0x16, 0x16, 0x96, 0xD4, 0x78,
  0x20, 0x20, 0x38, 0xD2, 0x24, 0x91, 0x28, 0x74, 0x02, 0x01, 0x70, 0xD6,
  0x29, 0x92, 0x48, 0x70, 0x1E, 0x19, 0x88, 0x06, 0x01, 0x03, 0xC5, 0x24,
  0x9C, 0x46, 0x67, 0x1E, 0xC0, 0x5F, 0x80, 0x02, 0x18, 0x61, 0x82, 0x0C,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x06, 0x07, 0x04, 0x00, 0x20, 0xC1, 0x83,
  0x0C, 0x30, 0xC2, 0x08, 0x21, 0x84, 0x33, 0x88, 0x00, 0x08, 0x18, 0xD3,
  0x7E, 0x10, 0x68, 0xCC, 0x48, 0x18, 0x33, 0xFF, 0xF1, 0x02, 0x0C, 0x00,
  0x32, 0x6C, 0xFF, 0xC0, 0xF0, 0x01, 0x80, 0x80, 0xC0, 0x40, 0x60, 0x20,
  0x20, 0x30, 0x10, 0x18, 0x08, 0x0C, 0x04, 0x06, 0x00, 0x3E, 0x62, 0x42,
  0x42, 0x42, 0xDA, 0xC2, 0x86, 0x84, 0xCC, 0x78, 0x1C, 0x79, 0x20, 0x40,
  0x81, 0x06, 0x0C, 0x10, 0x23, 0xF8, 0x3E, 0xC5, 0x08, 0x10, 0x61, 0x86,
  0x18, 0x61, 0x83, 0xF0, 0x7E, 0x04, 0x30, 0xC1, 0xC4, 0x81, 0x83, 0x85,
  0x99, 0xE0, 0x06, 0x18, 0x20, 0x82, 0x0C, 0xF1, 0xFE, 0xFC, 0x08, 0x30,
  0x3E, 0xC1, 0x82, 0x07, 0xC8, 0xC1, 0x83, 0x05, 0x99, 0xE0, 0x0C, 0x10,
  0x41, 0x87, 0xCC, 0xF1, 0xC1, 0x87, 0x99, 0xE0, 0xFF, 0x0E, 0x10, 0x60,
  0x83, 0x04, 0x18, 0x20, 0x83, 0x00, 0x3E, 0xC5, 0x0A, 0x12, 0xC7, 0x11,
  0x63, 0x87, 0x99, 0xE0, 0x3E, 0x62, 0x43, 0x43, 0xC2, 0x66, 0x3C, 0x08,
  0x18, 0x30, 0x60, 0x6C, 0x00, 0x36, 0x33, 0x00, 0x00, 0x64, 0xC8, 0x02,
  0x1C, 0xE7, 0x0C, 0x06, 0x07, 0x02, 0x7E, 0x00, 0x07, 0xF0, 0x40, 0xE0,
  0x60, 0x30, 0x63, 0x38, 0x40, 0x78, 0x30, 0x41, 0x0D, 0xE6, 0x10, 0x01,
  0x0C, 0x00, 0x1F, 0x18, 0xC8, 0x28, 0x14, 0xEA, 0x4D, 0x24, 0xB2, 0xD9,
  0x47, 0xA0, 0x18, 0x06, 0x01, 0xC0, 0x0E, 0x0E, 0x0A, 0x1A, 0x12, 0x32,
  0x22, 0x3E, 0x62, 0x42, 0xC3, 0x7C, 0x66, 0x42, 0x42, 0x46, 0x7C, 0xC6,
  0xC6, 0x86, 0x8C, 0xF8, 0x3E, 0x62, 0x42, 0x40, 0x40, 0x40, 0xC0, 0xC0,
  0x86, 0xCC, 0x78, 0x7C, 0xCD, 0x0A, 0x14, 0x28, 0x71, 0xE3, 0x85, 0x1B,
  0xE0, 0x3F, 0x60, 0x60, 0x40, 0x40, 0x7E, 0x40, 0xC0, 0xC0, 0x80, 0xFC,
  0x7F, 0x60, 0x40, 0x40, 0x40, 0x7E, 0xC0, 0xC0, 0xC0, 0x80, 0x80, 0x3E,
  0x62, 0x42, 0x40, 0x40, 0x5E, 0xDE, 0xC6, 0x84, 0xCC, 0x78, 0x63, 0x62,
  0x42, 0x42, 0x42, 0x7E, 0xC6, 0xC4, 0x84, 0x84, 0x84, 0x3F, 0x48, 0x18,
  0x18, 0x18, 0x10, 0x10, 0x10, 0x10, 0x30, 0xFC, 0x0F, 0x80, 0x80, 0x40,
  0x20, 0x30, 0x18, 0x08, 0x04, 0xC2, 0x23, 0x1F, 0x00, 0x61, 0x62, 0x46,
  0x4C, 0x48, 0x78, 0xC8, 0xCC, 0x8C, 0x84, 0x86, 0x20, 0x41, 0x83, 0x04,
  0x08, 0x10, 0x20, 0xC1, 0x87, 0xF0, 0x31, 0x99, 0xCC, 0xE7, 0x62, 0xD3,
  0x69, 0x84, 0x86, 0x43, 0x21, 0x30, 0x80, 0x63, 0x73, 0x52, 0x52, 0x52,
  0x52, 0xDE, 0xCE, 0x8C, 0x8C, 0x8C, 0x3E, 0xC5, 0x0A, 0x14, 0x28, 0x71,
  0xE3, 0x85, 0x99, 0xE0, 0x7E, 0x63, 0x43, 0x43, 0x42, 0x7E, 0xF0, 0xC0,
  0x80, 0x80, 0x80, 0x3E, 0x62, 0x42, 0x42, 0x42, 0xC2, 0xC6, 0x86, 0x84,
  0xCC, 0x78, 0x18, 0x08, 0x0C, 0x7E, 0x62, 0x43, 0x43, 0x42, 0x7C, 0xC8,
  0xC8, 0x8C, 0x84, 0x86, 0x3E, 0x62, 0x42, 0x40, 0x60, 0x3C, 0x06, 0x06,
  0x86, 0xC4, 0x78, 0xFE, 0x20, 0x41, 0x83, 0x04, 0x08, 0x10, 0x20, 0xC1,
  0x80, 0x63, 0x63, 0x42, 0x42, 0x42, 0x42, 0xC6, 0xC6, 0x84, 0xCC, 0x78,
  0x83, 0x0E, 0x16, 0x2C, 0x99, 0x36, 0x28, 0x50, 0xC1, 0x80, 0xC9, 0xEC,
  0xB6, 0x5B, 0x29, 0xA5, 0x52, 0xA9, 0x54, 0xCC, 0x66, 0x33, 0x00, 0x31,
  0x98, 0x84, 0xC3, 0xC0, 0xC0, 0x60, 0x70, 0x68, 0x26, 0x31, 0x30, 0xC0,
  0x83, 0x86, 0xC4, 0x48, 0x58, 0x70, 0x20, 0x20, 0x20, 0x60, 0x60, 0x7F,
  0x02, 0x06, 0x0C, 0x08, 0x10, 0x30, 0x60, 0x40, 0x80, 0xFC, 0x3C, 0x82,
  0x08, 0x21, 0x86, 0x10, 0x41, 0x04, 0x30, 0xF3, 0xC0, 0xC2, 0x10, 0xC2,
  0x10, 0x86, 0x30, 0x84, 0x21, 0x84, 0x3C, 0x10, 0xC3, 0x08, 0x20, 0x82,
  0x18, 0x61, 0x84, 0x73, 0xC0, 0x08, 0x28, 0xD1, 0x24, 0x78, 0x40, 0xFF,
  0xFC, 0xCC, 0x3E, 0x8D, 0x1E, 0x3C, 0x70, 0xB3, 0x3A, 0x60, 0xC1, 0x02,
  0xF6, 0x68, 0x71, 0xE3, 0xC5, 0x9A, 0xE0, 0x3E, 0x8D, 0x06, 0x0C, 0x10,
  0xF3, 0x3C, 0x03, 0x02, 0x02, 0x3E, 0x46, 0x46, 0xC6, 0xC6, 0x84, 0xCC,
  0x74, 0x3C, 0x8D, 0x0F, 0xFC, 0x10, 0x31, 0x3C, 0x03, 0xE0, 0xC0, 0x10,
  0x02, 0x23, 0xF8, 0x08, 0x03, 0x00, 0x60, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x0F, 0x01, 0xC0, 0x00, 0x3E, 0x8D, 0x0E, 0x3C, 0x78, 0x9F, 0x02, 0x04,
  0xF3, 0xC0, 0x60, 0xC1, 0x03, 0xF4, 0x68, 0x71, 0xE3, 0x85, 0x0A, 0x10,
  0x0C, 0x18, 0x00, 0x07, 0x83, 0x06, 0x0C, 0x10, 0x20, 0x47, 0xF0, 0x03,
  0x03, 0x00, 0x00, 0x3E, 0x02, 0x06, 0x06, 0x04, 0x04, 0x04, 0x04, 0x0C,
  0xF8, 0xE0, 0x60, 0x60, 0x41, 0x42, 0x44, 0x48, 0xF8, 0xD8, 0xC8, 0x8C,
  0x86, 0x79, 0x20, 0x40, 0x83, 0x06, 0x08, 0x10, 0x20, 0x40, 0xF8, 0x3B,
  0x36, 0x92, 0x49, 0x24, 0x92, 0x49, 0x2D, 0xA4, 0x7E, 0x8D, 0x0E, 0x3C,
  0x70, 0xA1, 0x42, 0x3C, 0x8D, 0x0E, 0x3C, 0x70, 0xB3, 0x3C, 0x2F, 0x33,
  0x21, 0x63, 0x63, 0x62, 0x66, 0x5C, 0x40, 0xC0, 0xC0, 0x7A, 0x8D, 0x1E,
  0x3C, 0x70, 0xB3, 0x3A, 0x04, 0x18, 0x30, 0x7E, 0xC5, 0x0A, 0x04, 0x18,
  0x30, 0x40, 0x7E, 0x85, 0x03, 0xC0, 0xC0, 0xA1, 0x7C, 0x18, 0x20, 0x47,
  0xF1, 0x06, 0x0C, 0x10, 0x20, 0x40, 0xF0, 0x42, 0x85, 0x0E, 0x3C, 0x70,
  0xB3, 0x3C, 0x87, 0x0A, 0x24, 0x4D, 0x0A, 0x18, 0x30, 0x99, 0x9B, 0x9A,
  0xAA, 0xAA, 0xAC, 0xCC, 0xCC, 0x33, 0x89, 0x05, 0x01, 0x81, 0xC1, 0xA1,
  0x99, 0x86, 0x42, 0x85, 0x0E, 0x3C, 0x78, 0x9F, 0x02, 0x04, 0xF3, 0xC0,
  0x7E, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0x7E, 0x07, 0x0C, 0x0C, 0x08, 0x08,
  0x08, 0xF0, 0x18, 0x18, 0x10, 0x10, 0x10, 0x1C, 0x0C, 0x24, 0x96, 0xD2,
  0x4B, 0x69, 0x00, 0x38, 0x0C, 0x0C, 0x08, 0x08, 0x08, 0x07, 0x18, 0x10,
  0x10, 0x10, 0x10, 0x70, 0xC0, 0x63, 0xA6, 0x78,
};

const GFXglyph JetBrainsMono_Italic15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 3, 11, 9, 3, -11 },
  { 6, 5, 5, 9, 3, -11 },
  { 10, 9, 11, 9, 0, -11 },
  { 23, 8, 15, 9, 1, -13 },
  { 38, 10, 11, 9, 0, -11 },
  { 52, 9, 11, 9, 0, -11 },
  { 65, 2, 5, 9, 4, -11 },
  { 67, 7, 15, 9, 2, -13 },
  { 81, 6, 15, 9, 1, -13 },
  { 93, 8, 8, 9, 1, -9 },
  { 101, 7, 7, 9, 1, -8 },
  { 108, 4, 4, 9, 1, -2 },
  { 110, 5, 2, 9, 2, -6 },
  { 112, 2, 2, 9, 3, -2 },
  { 113, 9, 14, 9, 0, -12 },
  { 129, 8, 11, 9, 1, -11 },
  { 140, 7, 11, 9, 1, -11 },
  { 150, 7, 11, 9, 1, -11 },
  { 160, 7, 11, 9, 1, -11 },
  { 170, 7, 11, 9, 1, -11 },
  { 180, 7, 11, 9, 1, -11 },
  { 190, 7, 11, 9, 1, -11 },
  { 200, 7, 11, 9, 2, -11 },
  { 210, 7, 11, 9, 1, -11 },
  { 220, 8, 11, 9, 1, -11 },
  { 231, 3, 8, 9, 3, -8 },
  { 234, 4, 10, 9, 2, -8 },
  { 239, 7, 8, 9, 1, -9 },
  { 246, 7, 4, 9, 1, -7 },
  { 250, 7, 8, 9, 1, -9 },
  { 257, 6, 11, 9, 2, -11 },
  { 266, 9, 14, 9, 0, -11 },
  { 282, 8, 11, 9, 0, -11 },
  { 293, 8, 11, 9, 1, -11 },
  { 304, 8, 11, 9, 1, -11 },
  { 315, 7, 11, 9, 1, -11 },
  { 325, 8, 11, 9, 1, -11 },
  { 336, 8, 11, 9, 1, -11 },
  { 347, 8, 11, 9, 1, -11 },
  { 358, 8, 11, 9, 1, -11 },
  { 369, 8, 11, 9, 1, -11 },
  { 380, 9, 11, 9, 0, -11 },
  { 393, 8, 11, 9, 1, -11 },
  { 404, 7, 11, 9, 1, -11 },
  { 414, 9, 11, 9, 0, -11 },
  { 427, 8, 11, 9, 1, -11 },
  { 438, 7, 11, 9, 1, -11 },
  { 448, 8, 11, 9, 1, -11 },
  { 459, 8, 14, 9, 1, -11 },
  { 473, 8, 11, 9, 1, -11 },
  { 484, 8, 11, 9, 1, -11 },
  { 495, 7, 11, 9, 2, -11 },
  { 505, 8, 11, 9, 1, -11 },
  { 516, 7, 11, 9, 2, -11 },
  { 526, 9, 11, 9, 1, -11 },
  { 539, 9, 11, 9, 0, -11 },
  { 552, 8, 11, 9, 2, -11 },
  { 563, 8, 11, 9, 1, -11 },
  { 574, 6, 14, 9, 2, -12 },
  { 585, 5, 14, 9, 2, -12 },
  { 594, 6, 14, 9, 1, -12 },
  { 605, 7, 6, 9, 1, -11 },
  { 611, 7, 2, 9, 0, 0 },
  { 613, 3, 2, 9, 4, -12 },
  { 614, 7, 8, 9, 1, -8 },
  { 621, 7, 11, 9, 1, -11 },
  { 631, 7, 8, 9, 1, -8 },
  { 638, 8, 11, 9, 1, -11 },
  { 649, 7, 8, 9, 1, -8 },
  { 656, 11, 14, 9, -1, -11 },
  { 676, 7, 11, 9, 1, -8 },
  { 686, 7, 11, 9, 1, -11 },
  { 696, 7, 12, 9, 1, -12 },
  { 707, 8, 15, 9, 0, -12 },
  { 722, 8, 11, 9, 1, -11 },
  { 733, 7, 11, 9, 1, -11 },
  { 743, 9, 8, 9, 0, -8 },
  { 752, 7, 8, 9, 1, -8 },
  { 759, 7, 8, 9, 1, -8 },
  { 766, 8, 11, 9, 0, -8 },
  { 777, 7, 11, 9, 1, -8 },
  { 787, 7, 8, 9, 1, -8 },
  { 794, 7, 8, 9, 1, -8 },
  { 801, 7, 11, 9, 1, -11 },
  { 811, 7, 8, 9, 1, -8 },
  { 818, 7, 8, 9, 2, -8 },
  { 825, 8, 8, 9, 1, -8 },
  { 833, 9, 8, 9, 0, -8 },
  { 842, 7, 11, 9, 1, -8 },
  { 852, 7, 8, 9, 1, -8 },
  { 859, 8, 14, 9, 1, -12 },
  { 873, 3, 14, 9, 3, -12 },
  { 879, 8, 14, 9, 0, -12 },
  { 893, 7, 3, 9, 1, -7 },
};

const GFXfont JetBrainsMono_Italic15pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Italic15pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Italic15pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _JETBRAINSMONO_ITALIC15PT7B_H_
