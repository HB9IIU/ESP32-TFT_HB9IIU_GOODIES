#ifndef _JETBRAINSMONO_ITALIC51PT7B_H_
#define _JETBRAINSMONO_ITALIC51PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Italic.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Italic51pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0xE0, 0x00, 0x3E, 0x07, 0xCF, 0x83, 0xE3, 0xE0, 0xF8, 0xF8, 0x3E, 0x3C,
  0x0F, 0x9F, 0x03, 0xE7, 0xC0, 0xF1, 0xF0, 0x3C, 0x7C, 0x1F, 0x1E, 0x07,
  0xC7, 0x81, 0xF1, 0xE0, 0x78, 0x78, 0x1E, 0x1E, 0x07, 0x8F, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x78, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x70, 0x0F, 0x00,
  0x03, 0xC0, 0x3C, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x38, 0x07, 0x80, 0x01,
  0xE0, 0x1E, 0x00, 0x07, 0x80, 0x70, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0xF0,
  0x0F, 0x00, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xF8, 0x01, 0xE0, 0x1C, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x3C, 0x03, 0xC0,
  0x00, 0xF0, 0x0E, 0x00, 0x03, 0x80, 0x78, 0x00, 0x1E, 0x01, 0xE0, 0x00,
  0x78, 0x07, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x3C,
  0x03, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xC0, 0x3C, 0x00, 0x0F, 0x00, 0xE0,
  0x00, 0x38, 0x07, 0x80, 0x01, 0xE0, 0x1E, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x3C, 0x03, 0xC0, 0x00, 0xF0, 0x0F, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x1E,
  0x01, 0xE0, 0x00, 0x78, 0x07, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0xF8, 0xE3, 0xE0,
  0x3E, 0x1C, 0x7E, 0x07, 0x83, 0x87, 0xC1, 0xF0, 0xF0, 0xF8, 0x3E, 0x1C,
  0x1F, 0x07, 0x83, 0x80, 0x00, 0xF0, 0x70, 0x00, 0x1F, 0x0E, 0x00, 0x03,
  0xE1, 0xC0, 0x00, 0x7E, 0x78, 0x00, 0x0F, 0xEE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xE7, 0xF0, 0x00, 0x1C, 0x7E,
  0x00, 0x03, 0x87, 0xC0, 0x00, 0x70, 0xF8, 0x00, 0x0E, 0x0F, 0x00, 0x03,
  0xC1, 0xE1, 0xF0, 0x70, 0x3C, 0x3C, 0x0E, 0x0F, 0x87, 0xC1, 0xC1, 0xF0,
  0xF8, 0x38, 0x7C, 0x1F, 0x87, 0x1F, 0x83, 0xF9, 0xE7, 0xE0, 0x3F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x01, 0xF0, 0x0F, 0xFE, 0x00, 0x3C, 0x01, 0xFF, 0xE0,
  0x07, 0x80, 0x3E, 0x1F, 0x00, 0x70, 0x03, 0xC0, 0xF0, 0x0F, 0x00, 0x38,
  0x0F, 0x01, 0xE0, 0x07, 0x80, 0xF0, 0x3C, 0x00, 0x78, 0x0E, 0x07, 0x80,
  0x07, 0x81, 0xE0, 0xF0, 0x00, 0x78, 0x1E, 0x0E, 0x00, 0x07, 0x81, 0xE1,
  0xE0, 0x00, 0x78, 0x1E, 0x3C, 0x00, 0x07, 0x83, 0xC7, 0x80, 0x00, 0x7F,
  0xFC, 0xF0, 0x00, 0x03, 0xFF, 0x9E, 0x00, 0x00, 0x1F, 0xE3, 0xC0, 0x00,
  0x00, 0x30, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x00,
  0x78, 0xFF, 0x80, 0x00, 0x07, 0x9F, 0xFC, 0x00, 0x00, 0xF3, 0xFF, 0xE0,
  0x00, 0x1E, 0x3C, 0x1E, 0x00, 0x03, 0xC7, 0x81, 0xE0, 0x00, 0x78, 0x78,
  0x1E, 0x00, 0x0F, 0x07, 0x81, 0xE0, 0x00, 0xE0, 0x78, 0x1E, 0x00, 0x1E,
  0x07, 0x01, 0xE0, 0x03, 0xC0, 0xF0, 0x1E, 0x00, 0x78, 0x0F, 0x01, 0xC0,
  0x0F, 0x00, 0xF0, 0x3C, 0x01, 0xE0, 0x07, 0xC7, 0xC0, 0x1C, 0x00, 0x7F,
  0xF8, 0x03, 0xC0, 0x03, 0xFF, 0x00, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0xFC, 0x3F, 0x80, 0x1F, 0x00, 0xF8, 0x01, 0xF0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0x1F, 0x01,
  0xF3, 0xE1, 0xF0, 0x3E, 0x3E, 0x0F, 0x87, 0xC3, 0xC0, 0xF8, 0x7C, 0x3C,
  0x07, 0xCF, 0x83, 0xC0, 0x7F, 0xF0, 0x7C, 0x03, 0xFE, 0x07, 0xC0, 0x1F,
  0xE0, 0x7C, 0x01, 0xFC, 0x07, 0xC0, 0x0F, 0x80, 0x78, 0x00, 0xF8, 0x07,
  0x80, 0x1F, 0xC0, 0x7C, 0x03, 0xFC, 0x07, 0xC0, 0x7F, 0xE0, 0x7F, 0xFF,
  0x9F, 0x03, 0xFF, 0xF1, 0xF0, 0x3F, 0xFE, 0x0F, 0x80, 0xFF, 0x80, 0xFC,
  0x01, 0x80, 0x00, 0x00, 0x3E, 0x7C, 0xF9, 0xF7, 0xCF, 0x9F, 0x3E, 0x7C,
  0xF1, 0xE3, 0xC7, 0x9F, 0x3C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x03, 0xC0,
  0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0xFE, 0x00,
  0x0F, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x01, 0x00, 0x78, 0x06, 0x7C, 0x0E, 0x07,
  0xCF, 0xE1, 0xC3, 0xFB, 0xFE, 0x39, 0xFF, 0xFF, 0xF6, 0xFF, 0xE1, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xF7, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xE1,
  0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x3F, 0x07, 0xE0, 0x0F, 0xC0, 0x7C, 0x03,
  0xF0, 0x0F, 0xC0, 0x1C, 0x00, 0xF0, 0x01, 0x00, 0x18, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x00, 0x1F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x3F,
  0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x03,
  0xE0, 0x1E, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1E, 0x1F, 0x9F, 0xEF, 0xFF, 0xFF, 0xFD, 0xFC, 0xFC, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC,
  0x03, 0xFC, 0x7F, 0x81, 0xF8, 0x07, 0xE0, 0x7C, 0x00, 0xF8, 0x3E, 0x00,
  0x1F, 0x0F, 0x00, 0x07, 0xC7, 0xC0, 0x01, 0xF1, 0xF0, 0x00, 0x7C, 0x78,
  0x00, 0x1E, 0x1E, 0x00, 0x07, 0x87, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0x78,
  0xF8, 0x00, 0x3E, 0x3E, 0x0E, 0x0F, 0x8F, 0x8F, 0xC3, 0xE3, 0xC3, 0xF0,
  0xF0, 0xF0, 0xFC, 0x3C, 0x3C, 0x3F, 0x0F, 0x1F, 0x07, 0x87, 0xC7, 0xC0,
  0x01, 0xF1, 0xF0, 0x00, 0x7C, 0x78, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0x87,
  0x80, 0x01, 0xE3, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x0F,
  0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x1F, 0x80,
  0x7E, 0x07, 0xFD, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFC, 0xF0, 0x03, 0xF9, 0xF0,
  0x07, 0xE1, 0xF0, 0x07, 0xC1, 0xF0, 0x07, 0x01, 0xF0, 0x06, 0x01, 0xE0,
  0x08, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x7F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x1F,
  0xE7, 0xF8, 0x07, 0xE0, 0x1F, 0x81, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x3E,
  0x0F, 0x80, 0x03, 0xC1, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x78, 0x3E, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x1F,
  0x00, 0x1F, 0x03, 0xE0, 0x07, 0xE0, 0x7E, 0x01, 0xF8, 0x07, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x1F, 0x03, 0xE0, 0x0F, 0x03,
  0xE0, 0x07, 0x83, 0xE0, 0x07, 0xC3, 0xE0, 0x03, 0xE3, 0xF0, 0x01, 0xF1,
  0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x78, 0x78, 0x00, 0x3C, 0x3F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC7, 0xFC, 0x00, 0xF7, 0xFF, 0x80,
  0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x07, 0xF0, 0x1F, 0x81, 0xF8, 0x03,
  0xE0, 0x7C, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x3E, 0x00, 0x1F,
  0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x03, 0xE0, 0x7E, 0x01, 0xF0, 0x1F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x9F, 0xC0, 0x0F, 0xBF, 0xF8, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x87,
  0xF0, 0x0F, 0xC3, 0xF0, 0x03, 0xF3, 0xF0, 0x01, 0xF9, 0xF0, 0x00, 0x7C,
  0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xBE, 0x00, 0x07,
  0xDF, 0x00, 0x03, 0xEF, 0x80, 0x01, 0xE7, 0xC0, 0x01, 0xF3, 0xE0, 0x00,
  0xF9, 0xF0, 0x00, 0xF8, 0xFC, 0x00, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xE7, 0xC0, 0x01, 0xF3, 0xC0, 0x00, 0xF9, 0xE0, 0x00, 0xF8,
  0xF0, 0x00, 0x78, 0xF8, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03,
  0xFC, 0x7F, 0x80, 0xF8, 0x07, 0xE0, 0x7C, 0x00, 0xF8, 0x1E, 0x00, 0x3E,
  0x0F, 0x80, 0x07, 0x83, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0xF8, 0x3E, 0x00,
  0x3E, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x1F,
  0x83, 0xF0, 0x03, 0xFB, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x01, 0xF8, 0xFE, 0x01, 0xF8, 0x0F,
  0xC0, 0x7C, 0x01, 0xF0, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x87, 0x80,
  0x03, 0xE1, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x8F,
  0x80, 0x03, 0xC3, 0xE0, 0x01, 0xF0, 0xFC, 0x00, 0xF8, 0x1F, 0x80, 0x7E,
  0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x03, 0xFF,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0x1F, 0xE0, 0xFC, 0x03, 0xF0,
  0xFC, 0x00, 0xFC, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x0F,
  0x9E, 0x00, 0x03, 0xDF, 0x00, 0x03, 0xEF, 0x80, 0x01, 0xF7, 0xC0, 0x00,
  0xFB, 0xE0, 0x00, 0x79, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x3E, 0x7E, 0x00,
  0x3E, 0x1F, 0x00, 0x3F, 0x0F, 0xE0, 0x7F, 0x03, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x07, 0xC7, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x80, 0x7F, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xE0, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x07, 0xF0, 0x7F, 0x8F, 0xF8, 0xFF, 0x8F, 0xF0, 0x7E, 0x01,
  0x00, 0x00, 0x18, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8,
  0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1E,
  0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x02, 0x00, 0x1F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFC, 0x08,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0xFF,
  0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x1F, 0x80, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xF8,
  0x00, 0xFF, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x07, 0xE0, 0x1F, 0x80, 0x1F, 0x00, 0x0F, 0x80, 0x7C, 0x00,
  0x1F, 0x01, 0xF0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x3C, 0x0F, 0x80, 0x00,
  0x78, 0x1E, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x03,
  0xC1, 0xE0, 0x03, 0x87, 0x83, 0xC0, 0x3F, 0xEF, 0x07, 0x80, 0xFF, 0xDE,
  0x1F, 0x03, 0xFB, 0xBC, 0x3C, 0x07, 0x81, 0xF8, 0x78, 0x1F, 0x01, 0xE0,
  0xF0, 0x3C, 0x03, 0xC1, 0xE0, 0x78, 0x07, 0x83, 0xC0, 0xF0, 0x0F, 0x0F,
  0x83, 0xE0, 0x1E, 0x1E, 0x07, 0x80, 0x3C, 0x3C, 0x0F, 0x00, 0xF0, 0x78,
  0x1E, 0x01, 0xE0, 0xF0, 0x3C, 0x03, 0xC1, 0xE0, 0x78, 0x07, 0x83, 0xC0,
  0xF0, 0x0F, 0x0F, 0x03, 0xE0, 0x3E, 0x1E, 0x03, 0xC0, 0x78, 0x3C, 0x07,
  0xC3, 0xF0, 0x78, 0x0F, 0xFE, 0xE0, 0xF0, 0x0F, 0xFB, 0xC1, 0xE0, 0x0F,
  0xE7, 0x83, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x79, 0xE0,
  0x00, 0x1E, 0x78, 0x00, 0x0F, 0x9E, 0x00, 0x03, 0xC7, 0x80, 0x01, 0xF1,
  0xE0, 0x00, 0x78, 0x78, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x87, 0x80, 0x03,
  0xC1, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x78, 0x1F, 0x00, 0x3E, 0x03, 0xC0,
  0x0F, 0x80, 0xF0, 0x03, 0xC0, 0x3C, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x3E, 0x00, 0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0x87,
  0xC0, 0x01, 0xE1, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x1E, 0x3E, 0x00, 0x07,
  0x8F, 0x80, 0x01, 0xE7, 0xC0, 0x00, 0x7D, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xC0, 0x3C, 0x01, 0xFC, 0x0F, 0x80, 0x0F, 0x81, 0xF0,
  0x01, 0xF0, 0x3E, 0x00, 0x1E, 0x07, 0xC0, 0x03, 0xC0, 0xF0, 0x00, 0x78,
  0x1E, 0x00, 0x0F, 0x03, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x78, 0x1F, 0x00,
  0x1F, 0x03, 0xE0, 0x07, 0xC0, 0x78, 0x0F, 0xF0, 0x0F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x01, 0xF0, 0x03,
  0xF0, 0x3C, 0x00, 0x3E, 0x07, 0x80, 0x07, 0xC0, 0xF0, 0x00, 0x7C, 0x3E,
  0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x3C, 0x1F, 0x00, 0x07,
  0x83, 0xC0, 0x01, 0xF0, 0x78, 0x00, 0x3E, 0x0F, 0x00, 0x0F, 0x83, 0xE0,
  0x03, 0xF0, 0x7C, 0x01, 0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xFE, 0xFF, 0x80,
  0xF8, 0x07, 0xE0, 0x7C, 0x00, 0xF8, 0x1E, 0x00, 0x1F, 0x0F, 0x80, 0x07,
  0xC3, 0xC0, 0x01, 0xF0, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x3E, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x07, 0xC1,
  0xF0, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x1F, 0x80, 0x7E, 0x03, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x02,
  0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xC0, 0x3C, 0x01, 0xF8, 0x0F, 0x80, 0x1F, 0x81, 0xF0,
  0x01, 0xF0, 0x3E, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0xC0, 0xF0, 0x00, 0x78,
  0x1E, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x1F, 0x00,
  0x0F, 0x83, 0xE0, 0x01, 0xE0, 0x78, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x81,
  0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x00,
  0xF8, 0x3E, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xC0, 0xF0, 0x00, 0xF8, 0x3E,
  0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x0F,
  0x03, 0xC0, 0x03, 0xE0, 0x78, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x03, 0xE0,
  0x07, 0xC0, 0x7C, 0x07, 0xF8, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFE, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xF0, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xFF, 0x00,
  0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xFE, 0xFF, 0x80, 0xF8, 0x07,
  0xE0, 0x7C, 0x00, 0xF8, 0x1E, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC3, 0xC0,
  0x01, 0xF0, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x3F, 0xFC, 0x3E, 0x0F,
  0xFF, 0x0F, 0x03, 0xFF, 0xC3, 0xC1, 0xFF, 0xF0, 0xF0, 0x00, 0x78, 0x7C,
  0x00, 0x1E, 0x1F, 0x00, 0x07, 0x87, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xF8,
  0x78, 0x00, 0x3E, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x07, 0xC1, 0xF0, 0x01,
  0xF0, 0x7C, 0x00, 0xF8, 0x1F, 0x80, 0x7E, 0x03, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x02, 0x00, 0x00,
  0x03, 0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x1E, 0x03, 0xE0, 0x03, 0xE0, 0x3C,
  0x00, 0x3E, 0x03, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x03,
  0xC0, 0x7C, 0x00, 0x3C, 0x07, 0xC0, 0x03, 0xC0, 0x78, 0x00, 0x7C, 0x07,
  0x80, 0x07, 0xC0, 0x78, 0x00, 0x7C, 0x0F, 0x80, 0x07, 0xC0, 0xF8, 0x00,
  0x78, 0x0F, 0x80, 0x07, 0x80, 0xF0, 0x00, 0xF8, 0x0F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x1F, 0x00,
  0x0F, 0x01, 0xF0, 0x01, 0xF0, 0x1E, 0x00, 0x1F, 0x01, 0xE0, 0x01, 0xF0,
  0x3E, 0x00, 0x1F, 0x03, 0xE0, 0x01, 0xE0, 0x3E, 0x00, 0x1E, 0x03, 0xE0,
  0x03, 0xE0, 0x3C, 0x00, 0x3E, 0x03, 0xC0, 0x03, 0xE0, 0x3C, 0x00, 0x3E,
  0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x3C, 0x07, 0xC0, 0x03, 0xC0, 0x7C,
  0x00, 0x7C, 0x07, 0x80, 0x07, 0xC0, 0xF8, 0x00, 0x7C, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x1F, 0x07, 0x80, 0x01,
  0xE0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x07,
  0xC0, 0x07, 0xC0, 0x7E, 0x01, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0xFC, 0x0F, 0x80, 0x07, 0xE0, 0x3E, 0x00, 0x1F, 0x00,
  0xF0, 0x00, 0xF8, 0x03, 0xC0, 0x07, 0xE0, 0x1F, 0x00, 0x1F, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x1E, 0x00,
  0xF8, 0x00, 0x78, 0x07, 0xE0, 0x03, 0xE0, 0x1F, 0x00, 0x0F, 0x80, 0xF8,
  0x00, 0x3E, 0x07, 0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x03, 0xC0, 0xF8, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xE0,
  0x3E, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0xF8, 0x07,
  0xC0, 0x03, 0xE0, 0x0F, 0x80, 0x0F, 0x80, 0x3E, 0x00, 0x3C, 0x00, 0xF8,
  0x00, 0xF0, 0x01, 0xF0, 0x07, 0xC0, 0x07, 0xC0, 0x1F, 0x00, 0x1F, 0x00,
  0x7C, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0xF8, 0x07, 0x80, 0x03, 0xE0, 0x1E,
  0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xF8, 0x07, 0xF0, 0x03, 0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF0,
  0x7F, 0x00, 0x77, 0x07, 0x70, 0x0F, 0xF0, 0x77, 0x00, 0xEF, 0x0F, 0x78,
  0x1E, 0xE0, 0xF7, 0x81, 0xCE, 0x0F, 0x78, 0x3D, 0xE0, 0xF7, 0x83, 0xDE,
  0x0F, 0x38, 0x79, 0xE0, 0xF3, 0x87, 0x9E, 0x0E, 0x38, 0xF3, 0xC1, 0xE3,
  0xCF, 0x3C, 0x1E, 0x3D, 0xE3, 0xC1, 0xE3, 0xDE, 0x3C, 0x1E, 0x1D, 0xC7,
  0xC1, 0xE1, 0xFC, 0x7C, 0x1E, 0x1F, 0x87, 0x83, 0xE1, 0xF8, 0x78, 0x3E,
  0x1F, 0x07, 0x83, 0xE0, 0x00, 0xF8, 0x3C, 0x00, 0x0F, 0x83, 0xC0, 0x00,
  0xF8, 0x3C, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0xF0, 0x7C, 0x00, 0x0F, 0x07,
  0xC0, 0x01, 0xF0, 0x78, 0x00, 0x1F, 0x07, 0x80, 0x01, 0xF0, 0x78, 0x00,
  0x1F, 0x0F, 0x80, 0x01, 0xE0, 0xF8, 0x00, 0x1E, 0x0F, 0x80, 0x01, 0xE0,
  0xF8, 0x00, 0x3E, 0x0F, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x3E, 0x00, 0x03,
  0xF0, 0x01, 0xF0, 0x3F, 0x80, 0x1E, 0x03, 0xF8, 0x01, 0xE0, 0x3F, 0x80,
  0x1E, 0x07, 0xF8, 0x03, 0xE0, 0x7F, 0x80, 0x3E, 0x07, 0xBC, 0x03, 0xE0,
  0x7B, 0xC0, 0x3C, 0x07, 0xBC, 0x03, 0xC0, 0x7B, 0xC0, 0x3C, 0x07, 0xBC,
  0x03, 0xC0, 0xF9, 0xE0, 0x7C, 0x0F, 0x9E, 0x07, 0xC0, 0xF1, 0xE0, 0x7C,
  0x0F, 0x1E, 0x07, 0x80, 0xF1, 0xE0, 0x78, 0x0F, 0x0F, 0x07, 0x81, 0xF0,
  0xF0, 0xF8, 0x1F, 0x0F, 0x0F, 0x81, 0xF0, 0xF0, 0xF8, 0x1E, 0x0F, 0x0F,
  0x01, 0xE0, 0x78, 0xF0, 0x1E, 0x07, 0x8F, 0x03, 0xE0, 0x79, 0xF0, 0x3E,
  0x07, 0x9F, 0x03, 0xE0, 0x79, 0xF0, 0x3C, 0x03, 0xDE, 0x03, 0xC0, 0x3D,
  0xE0, 0x3C, 0x03, 0xDE, 0x03, 0xC0, 0x3D, 0xE0, 0x7C, 0x03, 0xDE, 0x07,
  0xC0, 0x1F, 0xE0, 0x7C, 0x01, 0xFE, 0x07, 0x80, 0x1F, 0xC0, 0x78, 0x01,
  0xFC, 0x07, 0x80, 0x1F, 0xC0, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xFE,
  0xFF, 0x00, 0xF8, 0x07, 0xE0, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x0F,
  0x80, 0x07, 0x83, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0x7C, 0x00, 0x3E,
  0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x78, 0x00,
  0x3C, 0x1E, 0x00, 0x0F, 0x0F, 0x80, 0x03, 0xC3, 0xE0, 0x01, 0xF0, 0xF8,
  0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x0F, 0x00, 0x07, 0xC3, 0xC0, 0x01, 0xE0,
  0xF0, 0x00, 0x78, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x03,
  0xE1, 0xF0, 0x00, 0xF8, 0x78, 0x00, 0x3C, 0x1E, 0x00, 0x1F, 0x07, 0x80,
  0x07, 0xC1, 0xF0, 0x01, 0xE0, 0x7C, 0x00, 0xF8, 0x1F, 0x80, 0xFC, 0x03,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x3C, 0x00, 0x7E, 0x03, 0xE0,
  0x01, 0xF8, 0x1F, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x01,
  0xF0, 0x3C, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xE0,
  0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x0F, 0x81, 0xE0,
  0x00, 0xF8, 0x0F, 0x00, 0x0F, 0xC0, 0x78, 0x07, 0xFC, 0x07, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xFC, 0xFF, 0x81,
  0xF8, 0x07, 0xE0, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x07,
  0xC7, 0xC0, 0x01, 0xF1, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x1E, 0x1E, 0x00,
  0x07, 0x87, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x3E, 0x3E,
  0x00, 0x0F, 0x8F, 0x80, 0x03, 0xE3, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x3C,
  0x3C, 0x00, 0x1F, 0x1F, 0x00, 0x07, 0xC7, 0xC0, 0x01, 0xF1, 0xF0, 0x00,
  0x7C, 0x7C, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0x87, 0x80, 0x03, 0xE3, 0xE0,
  0x00, 0xF8, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x0F, 0x80, 0x07, 0xC3,
  0xE0, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x03, 0xC0, 0x0F, 0xE0, 0x7C, 0x00,
  0x7E, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xE0,
  0x78, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x0F, 0x80,
  0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x0F, 0x80, 0x07, 0xC0, 0xF0, 0x00, 0xF8,
  0x0F, 0x00, 0x3F, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x01, 0xE0, 0x3C, 0x00, 0x1E, 0x03, 0xE0,
  0x01, 0xE0, 0x3E, 0x00, 0x3E, 0x01, 0xE0, 0x03, 0xE0, 0x1F, 0x00, 0x3E,
  0x01, 0xF0, 0x03, 0xE0, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0xC0, 0x0F,
  0x80, 0x7C, 0x00, 0xF8, 0x07, 0xC0, 0x07, 0xC0, 0x7C, 0x00, 0x7C, 0x07,
  0xC0, 0x07, 0xC0, 0x78, 0x00, 0x3E, 0x07, 0x80, 0x03, 0xE0, 0xF8, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xF3, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0xF8,
  0x01, 0xF8, 0x1E, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x7C,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x87, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0xC3, 0xE0,
  0x01, 0xF0, 0x7E, 0x00, 0x7E, 0x0F, 0xE0, 0x1F, 0x80, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x04,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0,
  0x03, 0xE0, 0xF8, 0x00, 0x78, 0x1E, 0x00, 0x0F, 0x03, 0xC0, 0x03, 0xE0,
  0x78, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x01, 0xF0, 0x7C, 0x00,
  0x3C, 0x0F, 0x00, 0x07, 0x81, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x3E, 0x0F,
  0x80, 0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x03,
  0xC0, 0xF0, 0x00, 0x78, 0x1E, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE0, 0xF8,
  0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x01, 0xE0, 0x78, 0x00, 0x3C,
  0x0F, 0x00, 0x0F, 0x83, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x0F, 0x80,
  0x07, 0xC1, 0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x1E, 0x07, 0x80, 0x07, 0xC0,
  0xF0, 0x00, 0xF8, 0x1F, 0x00, 0x3E, 0x03, 0xE0, 0x07, 0xC0, 0x7E, 0x03,
  0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0xF9, 0xE0, 0x00, 0x7C, 0x78, 0x00, 0x1F, 0x1E,
  0x00, 0x07, 0x87, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0xF0, 0x7C, 0x00, 0x7C,
  0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x07, 0x81, 0xF0, 0x03, 0xE0, 0x7C, 0x00,
  0xF0, 0x0F, 0x00, 0x7C, 0x03, 0xC0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x03, 0xE0, 0x0F, 0x00, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x1E, 0x00,
  0x3E, 0x07, 0x80, 0x0F, 0x83, 0xE0, 0x03, 0xE0, 0xF0, 0x00, 0x78, 0x7C,
  0x00, 0x1E, 0x1E, 0x00, 0x07, 0x8F, 0x80, 0x01, 0xE3, 0xE0, 0x00, 0x78,
  0xF0, 0x00, 0x1E, 0x7C, 0x00, 0x07, 0x9E, 0x00, 0x01, 0xF7, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3C, 0x07, 0xC0, 0x3C,
  0xF0, 0x1F, 0x01, 0xF3, 0xC0, 0x7C, 0x07, 0x8F, 0x01, 0xB0, 0x1E, 0x3C,
  0x0F, 0xC0, 0x78, 0xF0, 0x3F, 0x03, 0xC3, 0xC0, 0xFC, 0x0F, 0x0F, 0x07,
  0x70, 0x3C, 0x3C, 0x1D, 0xC1, 0xF0, 0xF0, 0x77, 0x07, 0x87, 0xC1, 0xDC,
  0x1E, 0x1F, 0x0E, 0x70, 0x78, 0x7C, 0x39, 0xC3, 0xC1, 0xE0, 0xE7, 0x0F,
  0x07, 0x87, 0x1C, 0x3C, 0x1E, 0x1C, 0x70, 0xF0, 0x78, 0x71, 0xC7, 0x81,
  0xE1, 0xC7, 0x1E, 0x07, 0x8E, 0x1C, 0x78, 0x1E, 0x38, 0x71, 0xE0, 0x78,
  0xE1, 0xCF, 0x01, 0xE7, 0x07, 0x3C, 0x07, 0x9C, 0x18, 0xF0, 0x1E, 0x70,
  0x63, 0x80, 0x79, 0xC3, 0x9E, 0x01, 0xEE, 0x0E, 0x78, 0x07, 0xB8, 0x39,
  0xE0, 0x1E, 0xE0, 0xEF, 0x00, 0x7F, 0x03, 0xBC, 0x01, 0xFC, 0x0E, 0xF0,
  0x07, 0x70, 0x3B, 0xC0, 0x1D, 0xC0, 0xFE, 0x00, 0xFE, 0x03, 0xF8, 0x03,
  0xF8, 0x0F, 0xE0, 0x0F, 0xE0, 0x3F, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0xFC,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x7C, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x00,
  0x78, 0x03, 0xF0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x7C, 0x07, 0xC0, 0x00,
  0x3E, 0x0F, 0x80, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x1E, 0x1F, 0x00, 0x00,
  0x1F, 0x3E, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x0F, 0x7C, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00,
  0x3C, 0xF8, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x01,
  0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x07,
  0xC0, 0x3E, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x3F, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x0F, 0x80, 0x7C,
  0x00, 0x07, 0xC0, 0xF8, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x03, 0xEF, 0x80,
  0x00, 0x79, 0xF0, 0x00, 0x1F, 0x1E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0xF0,
  0x7C, 0x00, 0x3E, 0x07, 0x80, 0x0F, 0x80, 0xF8, 0x01, 0xF0, 0x1F, 0x00,
  0x7C, 0x01, 0xE0, 0x1F, 0x00, 0x3E, 0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x00,
  0x78, 0x1E, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF1, 0xF0, 0x00, 0x1E, 0x3C,
  0x00, 0x03, 0xCF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x01, 0xFF,
  0xF0, 0x1F, 0xFF, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0x80,
  0x7F, 0xF8, 0x0F, 0xFF, 0x80, 0xF8, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x01, 0xFF, 0xF0, 0x1F, 0xFE, 0x01, 0xFF,
  0xE0, 0x3F, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x00,
  0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x03,
  0xF8, 0x00, 0x0E, 0xE0, 0x00, 0x7B, 0xC0, 0x03, 0xCF, 0x00, 0x0F, 0x3C,
  0x00, 0x78, 0x70, 0x03, 0xE1, 0xE0, 0x0F, 0x07, 0x80, 0x78, 0x0E, 0x01,
  0xE0, 0x3C, 0x0F, 0x00, 0xF0, 0x7C, 0x03, 0xC1, 0xE0, 0x07, 0x8F, 0x00,
  0x1E, 0x3C, 0x00, 0x79, 0xE0, 0x01, 0xEF, 0x80, 0x03, 0xFC, 0x00, 0x0F,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xF8, 0x3C, 0x1F, 0x07, 0xC1, 0xE0, 0xF8, 0x3E, 0x00, 0x08, 0x00,
  0x00, 0x7F, 0xC7, 0xC0, 0x7F, 0xF3, 0xE0, 0x7F, 0xFD, 0xF0, 0x7F, 0xBE,
  0xF8, 0x7E, 0x03, 0xF8, 0x7E, 0x00, 0xFC, 0x3E, 0x00, 0x3E, 0x1E, 0x00,
  0x1F, 0x1F, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0xC7, 0xC0, 0x03, 0xC3, 0xE0,
  0x01, 0xE1, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x7C, 0x7C,
  0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x87,
  0x80, 0x07, 0xC3, 0xC0, 0x03, 0xE1, 0xF0, 0x03, 0xF0, 0xF8, 0x01, 0xF8,
  0x7E, 0x03, 0xF8, 0x3F, 0xEF, 0xBC, 0x0F, 0xFF, 0x9E, 0x03, 0xFF, 0x9F,
  0x00, 0xFF, 0x8F, 0x80, 0x0C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x40, 0x03,
  0xC3, 0xFE, 0x01, 0xE7, 0xFF, 0x81, 0xF7, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0,
  0x7F, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x0F,
  0x87, 0x80, 0x07, 0xC7, 0xC0, 0x03, 0xE3, 0xE0, 0x01, 0xF1, 0xF0, 0x00,
  0xF0, 0xF8, 0x00, 0x78, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x3E, 0x3E, 0x00,
  0x1F, 0x1F, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0xC7, 0xC0, 0x03, 0xC3, 0xE0,
  0x03, 0xE1, 0xF0, 0x01, 0xF1, 0xF8, 0x00, 0xF8, 0xFC, 0x00, 0xF8, 0x7F,
  0x00, 0xFC, 0x3F, 0xFF, 0xFC, 0x1E, 0xFF, 0xFC, 0x0F, 0x3F, 0xFC, 0x0F,
  0x8F, 0xF8, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x7E, 0x01,
  0xF8, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x1E, 0x00, 0x0F, 0x1F, 0x00,
  0x07, 0x8F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x03, 0xE3,
  0xC0, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0x7E, 0x01, 0xF8,
  0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xF0,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x08, 0x07, 0x80, 0x1F,
  0xF1, 0xF0, 0x07, 0xFF, 0x3E, 0x01, 0xFF, 0xF7, 0xC0, 0x7F, 0xBE, 0xF8,
  0x1F, 0x80, 0xFE, 0x07, 0xE0, 0x0F, 0xC0, 0xF8, 0x00, 0xF8, 0x1E, 0x00,
  0x1F, 0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x83,
  0xE0, 0x01, 0xE0, 0x78, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x83, 0xE0, 0x01,
  0xF0, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x00, 0xF0, 0x3C,
  0x00, 0x1E, 0x07, 0x80, 0x07, 0xC0, 0xF0, 0x00, 0xF8, 0x1F, 0x00, 0x3F,
  0x03, 0xE0, 0x07, 0xE0, 0x7E, 0x03, 0xF8, 0x0F, 0xFB, 0xEF, 0x00, 0xFF,
  0xF9, 0xE0, 0x0F, 0xFE, 0x7C, 0x00, 0xFF, 0x8F, 0x80, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xFF,
  0xFC, 0x07, 0xF1, 0xFE, 0x0F, 0xC0, 0x3E, 0x0F, 0x80, 0x1F, 0x1F, 0x00,
  0x1F, 0x1E, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x3C, 0x00,
  0x1F, 0x3C, 0x00, 0x1E, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFE, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x7C, 0x7C, 0x00,
  0xF8, 0x7E, 0x01, 0xF8, 0x3F, 0xCF, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x01, 0xFF, 0x0F, 0x03,
  0xFF, 0xDF, 0x07, 0xFF, 0xDF, 0x0F, 0xF7, 0xFF, 0x1F, 0x80, 0xFE, 0x1F,
  0x00, 0x7E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C,
  0x00, 0x3E, 0x7C, 0x00, 0x3C, 0x7C, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78,
  0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8,
  0x00, 0x78, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xFC, 0x01, 0xF8, 0x7E,
  0x07, 0xF8, 0x7F, 0xFE, 0xF8, 0x3F, 0xFE, 0xF0, 0x1F, 0xFC, 0xF0, 0x0F,
  0xF0, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x7F,
  0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x40, 0x03, 0xC7, 0xFE, 0x01, 0xE7, 0xFF, 0x81, 0xF7, 0xFF,
  0xE0, 0xFF, 0xCF, 0xF0, 0x7F, 0x00, 0xFC, 0x3F, 0x00, 0x3E, 0x1F, 0x00,
  0x1F, 0x0F, 0x80, 0x0F, 0x87, 0x80, 0x07, 0xC7, 0xC0, 0x03, 0xE3, 0xE0,
  0x01, 0xF1, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x7C, 0x3C,
  0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0x87,
  0xC0, 0x03, 0xC3, 0xC0, 0x01, 0xE1, 0xE0, 0x01, 0xF1, 0xF0, 0x00, 0xF8,
  0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x3C, 0x3E, 0x00, 0x1E, 0x1E, 0x00, 0x0F,
  0x0F, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x07, 0xFF,
  0xE0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0xFC, 0x3C, 0x00, 0x3F,
  0x07, 0x80, 0x0F, 0xC1, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x7C, 0x07, 0xC0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x1E, 0x01, 0xF8, 0x03, 0xC0, 0x7E, 0x00,
  0x78, 0x1F, 0x80, 0x1F, 0x07, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x0F,
  0x81, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x3E, 0x03, 0xE0, 0x07, 0xC0, 0x7C,
  0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x07, 0xC0, 0x0F, 0x80, 0xF8,
  0x01, 0xF0, 0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x03, 0xE0, 0x78, 0x00, 0x3E,
  0x0F, 0x00, 0x07, 0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01,
  0xFF, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE,
  0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x00, 0x04, 0x01, 0x00, 0xFB, 0xF0,
  0xFC, 0x0F, 0x7F, 0x9F, 0xE0, 0xF7, 0xFB, 0xFE, 0x0F, 0x87, 0xE3, 0xE0,
  0xF0, 0x3C, 0x1F, 0x0F, 0x03, 0xC1, 0xF0, 0xF0, 0x38, 0x1E, 0x1F, 0x07,
  0x81, 0xE1, 0xE0, 0x78, 0x1E, 0x1E, 0x07, 0x81, 0xE1, 0xE0, 0x78, 0x3E,
  0x1E, 0x07, 0x83, 0xE1, 0xE0, 0x70, 0x3C, 0x3E, 0x0F, 0x03, 0xC3, 0xE0,
  0xF0, 0x3C, 0x3C, 0x0F, 0x03, 0xC3, 0xC0, 0xF0, 0x3C, 0x3C, 0x0F, 0x07,
  0xC3, 0xC0, 0xE0, 0x7C, 0x7C, 0x0E, 0x07, 0x87, 0xC1, 0xE0, 0x78, 0x78,
  0x1E, 0x07, 0x87, 0x81, 0xE0, 0x78, 0x78, 0x1E, 0x0F, 0x87, 0x81, 0xC0,
  0xF8, 0x78, 0x1C, 0x0F, 0x0F, 0x83, 0xC0, 0xF0, 0xF0, 0x3C, 0x0F, 0x00,
  0x00, 0x00, 0x40, 0x03, 0xC7, 0xFE, 0x01, 0xE7, 0xFF, 0x81, 0xF7, 0xFF,
  0xE0, 0xFF, 0xCF, 0xF0, 0x7F, 0x00, 0xFC, 0x3F, 0x00, 0x3E, 0x1F, 0x00,
  0x1F, 0x0F, 0x80, 0x0F, 0x87, 0x80, 0x07, 0xC7, 0xC0, 0x03, 0xE3, 0xE0,
  0x01, 0xF1, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x7C, 0x3C,
  0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0x87,
  0xC0, 0x03, 0xC3, 0xC0, 0x01, 0xE1, 0xE0, 0x01, 0xF1, 0xF0, 0x00, 0xF8,
  0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x3C, 0x3E, 0x00, 0x1E, 0x1E, 0x00, 0x0F,
  0x0F, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x0F, 0xC0,
  0x3E, 0x0F, 0x80, 0x3F, 0x1F, 0x00, 0x1F, 0x1E, 0x00, 0x1F, 0x3E, 0x00,
  0x1F, 0x3E, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x3C, 0x00, 0x1F, 0x3C, 0x00,
  0x1E, 0x3C, 0x00, 0x1E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00,
  0x3E, 0x7C, 0x00, 0x3E, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x7C, 0x78, 0x00,
  0x7C, 0x7C, 0x00, 0x78, 0x7C, 0x00, 0xF8, 0x7E, 0x03, 0xF0, 0x3F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x30, 0x00, 0xF0, 0xFF, 0x80, 0x3C, 0xFF, 0xF0, 0x1F,
  0x7F, 0xFE, 0x07, 0xFF, 0x7F, 0x81, 0xFC, 0x03, 0xF0, 0x7E, 0x00, 0x7C,
  0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x07, 0xC1, 0xE0, 0x01, 0xF0, 0xF8, 0x00,
  0x7C, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0x83, 0xE0, 0x01, 0xE0, 0xF0,
  0x00, 0x78, 0x3C, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xE1,
  0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x3C, 0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x07,
  0xC3, 0xF0, 0x01, 0xF0, 0xFC, 0x00, 0xF8, 0x3F, 0x80, 0x7E, 0x0F, 0xFF,
  0xFF, 0x03, 0xCF, 0xFF, 0x80, 0xF3, 0xFF, 0xC0, 0x7C, 0x7F, 0xC0, 0x1F,
  0x01, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x7F, 0xC7, 0xC0,
  0x7F, 0xF3, 0xE0, 0x7F, 0xFD, 0xF0, 0x7F, 0xBE, 0xF8, 0x7E, 0x03, 0xF8,
  0x7E, 0x00, 0xFC, 0x3E, 0x00, 0x3E, 0x1E, 0x00, 0x1F, 0x1F, 0x00, 0x0F,
  0x8F, 0x80, 0x07, 0xC7, 0xC0, 0x03, 0xC3, 0xC0, 0x01, 0xE1, 0xE0, 0x00,
  0xF0, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x3E, 0x00,
  0x1E, 0x1F, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x07, 0xC3, 0xC0,
  0x03, 0xE1, 0xF0, 0x03, 0xF0, 0xF8, 0x01, 0xF8, 0x7E, 0x03, 0xF8, 0x3F,
  0xEF, 0xBC, 0x0F, 0xFF, 0x9E, 0x03, 0xFF, 0x9F, 0x00, 0xFF, 0x8F, 0x80,
  0x0C, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xC0, 0x01, 0xE3, 0xFE, 0x00, 0x79,
  0xFF, 0xE0, 0x3E, 0xFF, 0xFC, 0x0F, 0xFC, 0xFF, 0x03, 0xF8, 0x07, 0xE0,
  0xFC, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x03,
  0xE1, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xFC,
  0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x0F, 0x80, 0x3F, 0x1F, 0x00, 0x1F,
  0x1F, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xF0,
  0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0xF8, 0x00, 0x7C,
  0xF8, 0x00, 0x7C, 0xFC, 0x00, 0xF8, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x00, 0x60, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xE0, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x0F,
  0xFE, 0x00, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x07, 0xC7, 0xC0, 0x03, 0xE3,
  0xE0, 0x01, 0xF1, 0xF0, 0x00, 0xF0, 0xF8, 0x00, 0x78, 0x78, 0x00, 0x3C,
  0x3C, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x8F, 0x80, 0x07,
  0xC7, 0xC0, 0x03, 0xC3, 0xC0, 0x01, 0xE1, 0xE0, 0x01, 0xF1, 0xF0, 0x00,
  0xF8, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x1E, 0x1E, 0x00,
  0x0F, 0x0F, 0x00, 0x0F, 0x87, 0xC0, 0x07, 0xC3, 0xE0, 0x07, 0xC1, 0xF0,
  0x03, 0xE0, 0xFC, 0x07, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x07,
  0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x06, 0x00, 0x00, 0xF8, 0x00, 0x0F,
  0xBC, 0x00, 0x0F, 0x9E, 0x00, 0x07, 0xCF, 0x00, 0x07, 0xC7, 0xC0, 0x03,
  0xE3, 0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0x78, 0x01, 0xF0, 0x3C, 0x00,
  0xF8, 0x1E, 0x00, 0xF8, 0x0F, 0x00, 0x7C, 0x07, 0xC0, 0x3C, 0x03, 0xE0,
  0x3E, 0x00, 0xF0, 0x1E, 0x00, 0x78, 0x1F, 0x00, 0x3C, 0x0F, 0x00, 0x1E,
  0x0F, 0x80, 0x0F, 0x87, 0x80, 0x07, 0xC7, 0xC0, 0x01, 0xE3, 0xC0, 0x00,
  0xF3, 0xE0, 0x00, 0x79, 0xE0, 0x00, 0x3D, 0xF0, 0x00, 0x1E, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF0, 0x1F, 0x01, 0xFE, 0x03, 0xE0, 0x3F, 0xC0, 0xFC, 0x0F, 0x78,
  0x1F, 0x81, 0xEF, 0x03, 0xF0, 0x3D, 0xE0, 0xEE, 0x0F, 0x3C, 0x1D, 0xC1,
  0xE7, 0x83, 0xB8, 0x3C, 0xF0, 0xE7, 0x07, 0x1E, 0x1C, 0xE1, 0xE3, 0xC3,
  0x9C, 0x3C, 0x78, 0x63, 0x87, 0x0F, 0x1C, 0x71, 0xE1, 0xE3, 0x8E, 0x3C,
  0x3C, 0x61, 0xC7, 0x07, 0x9C, 0x39, 0xE0, 0xF3, 0x87, 0x3C, 0x1E, 0x60,
  0xE7, 0x03, 0xDC, 0x1D, 0xE0, 0x7B, 0x83, 0xBC, 0x0F, 0x70, 0x77, 0x01,
  0xFC, 0x0E, 0xE0, 0x3F, 0x81, 0xFC, 0x07, 0x70, 0x3F, 0x00, 0xFC, 0x07,
  0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x7E, 0x00, 0x3E, 0x03, 0xE0, 0x07, 0xC0, 0x3F,
  0x00, 0xFC, 0x01, 0xF0, 0x1F, 0x80, 0x1F, 0x01, 0xF0, 0x00, 0xF8, 0x3E,
  0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7C, 0xFC, 0x00, 0x03, 0xCF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xBE, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x1F, 0x1F, 0x00, 0x03, 0xE0,
  0xF8, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x80, 0x7C, 0x01, 0xF8, 0x07, 0xC0,
  0x3F, 0x00, 0x3E, 0x03, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x1F, 0x0F, 0x80,
  0x01, 0xF8, 0x1E, 0x00, 0x0F, 0x1E, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x3E,
  0x00, 0x1F, 0x3E, 0x00, 0x1E, 0x3E, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C,
  0x00, 0x3E, 0x3C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C,
  0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x7C, 0x78, 0x00, 0x7C, 0xF8,
  0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x78, 0xF8, 0x00, 0xF8, 0xF8,
  0x01, 0xF8, 0xFC, 0x03, 0xF8, 0x7E, 0x07, 0xF8, 0x7F, 0xFE, 0xF8, 0x3F,
  0xFE, 0xF0, 0x1F, 0xF8, 0xF0, 0x07, 0xE0, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x7F,
  0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xFE, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0x00, 0x0F,
  0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0x00,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C,
  0x07, 0x80, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0xF0,
  0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0x7C, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF,
  0xF0, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x07, 0xC7, 0xFE, 0x01, 0xE3, 0xFF, 0xC0, 0x78, 0xFF, 0xF0,
  0x1E, 0x7C, 0x3E, 0x07, 0x9E, 0x07, 0xC3, 0xE7, 0x81, 0xFF, 0xF3, 0xE0,
  0x3F, 0xF8, 0xF8, 0x07, 0xFC, 0x3E, 0x00, 0xFE, 0x00,
};

const GFXglyph JetBrainsMono_Italic51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 31, 0, -1 },
  { 1, 13, 37, 31, 9, -37 },
  { 62, 18, 15, 31, 9, -37 },
  { 96, 30, 37, 31, 1, -37 },
  { 235, 27, 51, 31, 2, -44 },
  { 408, 36, 37, 31, -2, -37 },
  { 575, 28, 39, 31, 1, -38 },
  { 712, 7, 15, 31, 14, -37 },
  { 726, 21, 49, 31, 8, -43 },
  { 855, 20, 49, 31, 3, -43 },
  { 978, 27, 26, 31, 3, -31 },
  { 1066, 25, 24, 31, 3, -29 },
  { 1141, 13, 16, 31, 5, -8 },
  { 1167, 17, 4, 31, 7, -19 },
  { 1176, 9, 9, 31, 9, -8 },
  { 1187, 30, 48, 31, 1, -42 },
  { 1367, 26, 39, 31, 3, -38 },
  { 1494, 24, 37, 31, 2, -37 },
  { 1605, 27, 38, 31, 2, -38 },
  { 1734, 27, 38, 31, 2, -37 },
  { 1863, 25, 37, 31, 3, -37 },
  { 1979, 26, 38, 31, 3, -37 },
  { 2103, 25, 38, 31, 2, -37 },
  { 2222, 25, 37, 31, 6, -37 },
  { 2338, 26, 39, 31, 3, -38 },
  { 2465, 25, 38, 31, 5, -38 },
  { 2584, 12, 30, 31, 9, -29 },
  { 2629, 17, 37, 31, 5, -29 },
  { 2708, 25, 27, 31, 4, -30 },
  { 2793, 25, 16, 31, 3, -25 },
  { 2843, 24, 27, 31, 3, -30 },
  { 2924, 21, 37, 31, 7, -37 },
  { 3022, 31, 47, 31, 0, -38 },
  { 3205, 26, 37, 31, 0, -37 },
  { 3326, 27, 37, 31, 2, -37 },
  { 3451, 26, 39, 31, 3, -38 },
  { 3578, 27, 37, 31, 2, -37 },
  { 3703, 27, 37, 31, 3, -37 },
  { 3828, 27, 37, 31, 3, -37 },
  { 3953, 26, 39, 31, 3, -38 },
  { 4080, 28, 37, 31, 2, -37 },
  { 4210, 26, 37, 31, 3, -37 },
  { 4331, 28, 38, 31, 1, -37 },
  { 4464, 30, 37, 31, 2, -37 },
  { 4603, 22, 37, 31, 4, -37 },
  { 4705, 28, 37, 31, 2, -37 },
  { 4835, 28, 37, 31, 2, -37 },
  { 4965, 26, 39, 31, 3, -38 },
  { 5092, 29, 37, 31, 2, -37 },
  { 5227, 26, 47, 31, 3, -38 },
  { 5380, 28, 37, 31, 2, -37 },
  { 5510, 27, 39, 31, 2, -38 },
  { 5642, 25, 37, 31, 6, -37 },
  { 5758, 27, 38, 31, 3, -37 },
  { 5887, 26, 37, 31, 6, -37 },
  { 6008, 30, 37, 31, 3, -37 },
  { 6147, 32, 37, 31, 0, -37 },
  { 6295, 27, 37, 31, 5, -37 },
  { 6420, 27, 37, 31, 2, -37 },
  { 6545, 20, 48, 31, 7, -42 },
  { 6665, 16, 48, 31, 8, -42 },
  { 6761, 20, 48, 31, 5, -42 },
  { 6881, 22, 20, 31, 5, -37 },
  { 6936, 25, 4, 31, 0, 1 },
  { 6949, 9, 7, 31, 14, -40 },
  { 6957, 25, 30, 31, 3, -29 },
  { 7051, 25, 38, 31, 2, -37 },
  { 7170, 25, 30, 31, 3, -29 },
  { 7264, 27, 38, 31, 3, -37 },
  { 7393, 24, 30, 31, 3, -29 },
  { 7483, 35, 46, 31, -2, -37 },
  { 7685, 24, 38, 31, 4, -29 },
  { 7799, 25, 37, 31, 2, -37 },
  { 7915, 24, 40, 31, 2, -40 },
  { 8035, 26, 49, 31, 1, -40 },
  { 8195, 27, 37, 31, 3, -37 },
  { 8320, 21, 37, 31, 5, -37 },
  { 8418, 28, 29, 31, 1, -29 },
  { 8520, 25, 29, 31, 2, -29 },
  { 8611, 24, 30, 31, 3, -29 },
  { 8701, 26, 38, 31, 1, -29 },
  { 8825, 25, 38, 31, 3, -29 },
  { 8944, 26, 29, 31, 3, -29 },
  { 9039, 24, 30, 31, 3, -29 },
  { 9129, 25, 36, 31, 4, -36 },
  { 9242, 25, 29, 31, 3, -28 },
  { 9333, 25, 28, 31, 5, -28 },
  { 9421, 27, 28, 31, 4, -28 },
  { 9516, 28, 28, 31, 1, -28 },
  { 9614, 24, 37, 31, 4, -28 },
  { 9725, 26, 28, 31, 2, -28 },
  { 9816, 26, 48, 31, 5, -42 },
  { 9972, 12, 48, 31, 10, -42 },
  { 10044, 26, 48, 31, 1, -42 },
  { 10200, 26, 10, 31, 3, -23 },
};

const GFXfont JetBrainsMono_Italic51pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Italic51pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Italic51pt7bGlyphs,
  0x20, 0x7E, 67
};

#endif // _JETBRAINSMONO_ITALIC51PT7B_H_
