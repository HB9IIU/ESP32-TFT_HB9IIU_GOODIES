#ifndef _JETBRAINSMONO_ITALIC45PT7B_H_
#define _JETBRAINSMONO_ITALIC45PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Italic.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Italic45pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0xFC, 0x1F, 0x87, 0xF0, 0x7C, 0x00, 0x3C,
  0x1E, 0x78, 0x3C, 0xF0, 0x7B, 0xE0, 0xF7, 0xC3, 0xEF, 0x07, 0xDE, 0x0F,
  0x3C, 0x1E, 0x78, 0x3C, 0xF0, 0x79, 0xC0, 0xF3, 0x81, 0xCF, 0x03, 0x9E,
  0x0F, 0x00, 0x00, 0x0E, 0x03, 0xC0, 0x07, 0x80, 0xE0, 0x01, 0xC0, 0x78,
  0x00, 0x70, 0x1C, 0x00, 0x3C, 0x07, 0x00, 0x0E, 0x03, 0xC0, 0x03, 0x80,
  0xE0, 0x01, 0xE0, 0x38, 0x00, 0x70, 0x1E, 0x03, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x10, 0xE0, 0x38, 0x00, 0x78, 0x0E, 0x00,
  0x1C, 0x07, 0x80, 0x07, 0x01, 0xC0, 0x03, 0xC0, 0x70, 0x00, 0xE0, 0x3C,
  0x00, 0x38, 0x0E, 0x00, 0x1E, 0x03, 0x80, 0x07, 0x01, 0xE0, 0x3F, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0x0E, 0x03, 0x80, 0x07,
  0x80, 0xE0, 0x01, 0xC0, 0x78, 0x00, 0x70, 0x1C, 0x00, 0x3C, 0x07, 0x00,
  0x0E, 0x03, 0xC0, 0x03, 0x80, 0xE0, 0x01, 0xE0, 0x38, 0x00, 0x70, 0x1C,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xC7, 0x3E, 0x07,
  0x86, 0x1E, 0x0F, 0x86, 0x1E, 0x0F, 0x0E, 0x1E, 0x0F, 0x0E, 0x00, 0x0F,
  0x0E, 0x00, 0x0F, 0x0E, 0x00, 0x0F, 0x8E, 0x00, 0x0F, 0x8C, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x19, 0xF8, 0x00, 0x38, 0xF8, 0x00,
  0x38, 0x78, 0x00, 0x38, 0x78, 0x00, 0x38, 0x78, 0x78, 0x30, 0x78, 0xF8,
  0x30, 0x78, 0xF8, 0x70, 0xF8, 0x78, 0x70, 0xF0, 0x7C, 0x71, 0xF0, 0x7F,
  0x77, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x1E, 0x07, 0xFC, 0x00,
  0x78, 0x1F, 0xFC, 0x01, 0xE0, 0x3C, 0x38, 0x07, 0x80, 0xF0, 0x78, 0x0E,
  0x01, 0xC0, 0xF0, 0x38, 0x03, 0x81, 0xC0, 0xE0, 0x07, 0x03, 0x83, 0x80,
  0x0E, 0x07, 0x0F, 0x00, 0x3C, 0x0E, 0x3C, 0x00, 0x78, 0x3C, 0x70, 0x00,
  0x78, 0xF1, 0xC0, 0x00, 0xFF, 0xE7, 0x00, 0x00, 0xFF, 0x9C, 0x00, 0x00,
  0xFC, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x78, 0x00, 0x00, 0xE3, 0xFC, 0x00, 0x03,
  0xCF, 0xFC, 0x00, 0x0F, 0x3C, 0x7C, 0x00, 0x3C, 0x70, 0x78, 0x00, 0x71,
  0xE0, 0xF0, 0x01, 0xC3, 0x81, 0xE0, 0x07, 0x07, 0x03, 0xC0, 0x1E, 0x0E,
  0x07, 0x00, 0x78, 0x1C, 0x0E, 0x01, 0xE0, 0x38, 0x3C, 0x03, 0x80, 0x78,
  0x78, 0x0E, 0x00, 0xFF, 0xE0, 0x38, 0x00, 0xFF, 0x80, 0xF0, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0x1F, 0x80, 0x3E, 0x07, 0xC0, 0x1E, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x3E, 0x07, 0xCF, 0x0F, 0x07,
  0xC7, 0x87, 0xC3, 0xC7, 0xC1, 0xE3, 0xC3, 0xC0, 0x7B, 0xC1, 0xE0, 0x3F,
  0xE0, 0xF0, 0x0F, 0xE0, 0x78, 0x07, 0xE0, 0x3C, 0x01, 0xF0, 0x1E, 0x00,
  0xF8, 0x1F, 0x00, 0xFC, 0x07, 0x80, 0xFF, 0x03, 0xE1, 0xF7, 0x81, 0xFF,
  0xF1, 0xE0, 0x7F, 0xF0, 0xF8, 0x1F, 0xE0, 0x3C, 0x00, 0x7D, 0xE7, 0x9E,
  0x7B, 0xEF, 0xBC, 0xF3, 0xCF, 0x3C, 0xE3, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x3C, 0x00, 0x1F, 0x00, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0xC0,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xC0, 0x03, 0xF0, 0x00, 0x3E, 0x00,
  0x01, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x3C, 0x00, 0x07, 0xE0,
  0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03,
  0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x30, 0x1C, 0x03, 0x7C,
  0x1C, 0x1F, 0x7F, 0x1C, 0xFF, 0xFF, 0xD9, 0xFF, 0x1F, 0xFF, 0xFC, 0x03,
  0xFF, 0xC0, 0x00, 0x38, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xEE, 0x00, 0x03,
  0xCF, 0x00, 0x07, 0xCF, 0x80, 0x07, 0x87, 0x80, 0x0F, 0x07, 0xC0, 0x1F,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x1C, 0x01, 0xC0, 0x08, 0x01, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0x00, 0x70, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xF0, 0x7E,
  0x07, 0xE0, 0x7C, 0x0F, 0xC0, 0xF8, 0x1F, 0x01, 0xF0, 0x1E, 0x03, 0xE0,
  0x3C, 0x07, 0xC0, 0x78, 0x0F, 0x00, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1E, 0x7E, 0x7F, 0xFF, 0xFF, 0xFE, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0xFF,
  0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0x0F, 0xC0, 0xF8, 0x07, 0xC1, 0xE0, 0x07,
  0x87, 0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x1C, 0x00, 0x3C, 0x78, 0x00, 0x78,
  0xF0, 0x00, 0xF1, 0xE0, 0x01, 0xE3, 0xC0, 0x03, 0xC7, 0x80, 0x07, 0x8E,
  0x1E, 0x1E, 0x3C, 0x3E, 0x3C, 0x78, 0xFC, 0x78, 0xF0, 0xF8, 0xF1, 0xE1,
  0xE1, 0xE3, 0xC0, 0x03, 0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x1E, 0x3C, 0x00,
  0x3C, 0x78, 0x00, 0x78, 0xF0, 0x00, 0xF1, 0xE0, 0x03, 0xC3, 0xC0, 0x07,
  0x87, 0x80, 0x1F, 0x0F, 0x80, 0x7C, 0x0F, 0xC1, 0xF0, 0x1F, 0xFF, 0xC0,
  0x1F, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x3F, 0x7C, 0x03, 0xF3, 0xC0, 0x3E, 0x1E,
  0x01, 0xE0, 0xF0, 0x0C, 0x07, 0x80, 0x40, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x1F, 0xCF, 0xE0, 0x7C, 0x03, 0xE1,
  0xF0, 0x07, 0xC3, 0xC0, 0x07, 0x8F, 0x80, 0x0F, 0x1E, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x07,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x7C, 0x78, 0x00, 0xF1, 0xF0, 0x01, 0xE3, 0xE0,
  0x03, 0xC3, 0xC0, 0x0F, 0x07, 0xC0, 0x3E, 0x0F, 0xC1, 0xF8, 0x0F, 0xFF,
  0xE0, 0x0F, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x03, 0xE1, 0xF0,
  0x1E, 0x1F, 0x00, 0xF1, 0xF0, 0x07, 0x8F, 0x00, 0x3C, 0xF0, 0x01, 0xE7,
  0x80, 0x1F, 0x78, 0x00, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x07, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x83, 0x00, 0x1E, 0x7F, 0xC0, 0x7F, 0xFF,
  0x83, 0xDF, 0xFE, 0x0F, 0xE0, 0xFC, 0x3E, 0x01, 0xF0, 0xF0, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x8F, 0x00, 0x1E,
  0x3C, 0x00, 0xF8, 0xF8, 0x07, 0xC1, 0xF8, 0x7E, 0x07, 0xFF, 0xF0, 0x0F,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x7F, 0x00, 0xFF, 0xFF, 0x07, 0xFF,
  0xFC, 0x1F, 0x81, 0xF8, 0xFC, 0x03, 0xE3, 0xE0, 0x07, 0xCF, 0x00, 0x1F,
  0x78, 0x00, 0x3D, 0xE0, 0x00, 0xF7, 0x80, 0x03, 0xDE, 0x00, 0x1E, 0x78,
  0x00, 0x79, 0xE0, 0x01, 0xE7, 0x80, 0x0F, 0x1E, 0x00, 0x7C, 0x7C, 0x03,
  0xE0, 0xFC, 0x3F, 0x83, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x07, 0xFC, 0x00,
  0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x78,
  0x00, 0x79, 0xE0, 0x01, 0xE7, 0x80, 0x0F, 0x1E, 0x00, 0x3C, 0xF8, 0x01,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0xF0, 0x07, 0xFF, 0xF0, 0x1F, 0x87, 0xE0, 0x7C, 0x03, 0xE0, 0xF0, 0x03,
  0xC1, 0xE0, 0x07, 0x87, 0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x78,
  0x3C, 0x00, 0xF0, 0x3C, 0x03, 0xC0, 0x7C, 0x0F, 0x80, 0x7C, 0x7C, 0x00,
  0x7F, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x1F,
  0x0F, 0x80, 0xF8, 0x0F, 0x81, 0xE0, 0x0F, 0x07, 0x80, 0x1F, 0x0F, 0x00,
  0x1E, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x78, 0xF0, 0x00, 0xF1, 0xE0, 0x03,
  0xC3, 0xC0, 0x07, 0x87, 0xC0, 0x3E, 0x0F, 0xE0, 0xFC, 0x0F, 0xFF, 0xF0,
  0x0F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0x80,
  0x7F, 0xFF, 0x03, 0xF9, 0xFE, 0x1F, 0x00, 0xF8, 0xF8, 0x01, 0xE3, 0xC0,
  0x07, 0xDF, 0x00, 0x0F, 0x78, 0x00, 0x3D, 0xE0, 0x00, 0xF7, 0x80, 0x07,
  0xDE, 0x00, 0x1E, 0xF8, 0x00, 0x7B, 0xE0, 0x03, 0xE7, 0x80, 0x0F, 0x1F,
  0x00, 0x7C, 0x7E, 0x07, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xBC, 0x03, 0xFD,
  0xE0, 0x01, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC1, 0xFC, 0x7F, 0x8F, 0xF1, 0xFC, 0x1F, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x07, 0xF1, 0xFE, 0x3F, 0xC7, 0xF0, 0x7C, 0x00,
  0x00, 0xF8, 0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xF8, 0x07, 0xE0, 0x04,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x01, 0xF0, 0x0F,
  0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xC0, 0x1F,
  0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0xC0, 0x00, 0x3E, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x80, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0x80,
  0x01, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x08, 0x3F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xC0, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x38, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1F, 0xF0, 0x07, 0xFF,
  0x01, 0xFF, 0xF0, 0x7F, 0xFE, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x03, 0xF8, 0x0F, 0xFC, 0x03, 0xFE,
  0x00, 0xFE, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x7C, 0x07,
  0xE0, 0x1E, 0x00, 0x3C, 0x07, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0x78, 0x3C,
  0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x3C, 0x38, 0x00, 0x07,
  0x8F, 0x00, 0x78, 0xF1, 0xE0, 0x3F, 0xDC, 0x3C, 0x0F, 0xFB, 0x87, 0x83,
  0xE1, 0xF0, 0xE0, 0x78, 0x1E, 0x1C, 0x0E, 0x03, 0xC7, 0x83, 0xC0, 0x78,
  0xF0, 0x78, 0x0F, 0x1E, 0x0F, 0x01, 0xC3, 0xC1, 0xC0, 0x38, 0x70, 0x38,
  0x0F, 0x0E, 0x0F, 0x01, 0xE1, 0xC1, 0xE0, 0x3C, 0x78, 0x3C, 0x07, 0x8F,
  0x07, 0x81, 0xE1, 0xE0, 0xF0, 0x3C, 0x3C, 0x1F, 0x9F, 0x87, 0x01, 0xFF,
  0x70, 0xE0, 0x1F, 0xDE, 0x1C, 0x00, 0x40, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x07, 0xBC, 0x00, 0x0F, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x78, 0xE0, 0x00,
  0xF1, 0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x87, 0x80, 0x1E, 0x0F, 0x00, 0x3C,
  0x1E, 0x00, 0x78, 0x3C, 0x01, 0xE0, 0x78, 0x03, 0xC0, 0xF0, 0x0F, 0x00,
  0xE0, 0x1E, 0x01, 0xC0, 0x7C, 0x03, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0x07, 0xFF, 0xFE, 0x0F, 0x00, 0x3C, 0x3E, 0x00, 0x78, 0x78, 0x00, 0xF0,
  0xF0, 0x01, 0xE3, 0xC0, 0x03, 0xC7, 0x80, 0x03, 0x9F, 0x00, 0x07, 0xBC,
  0x00, 0x0F, 0xF8, 0x00, 0x1E, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x07,
  0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x07, 0x80, 0x7E, 0x07, 0x80, 0x3E, 0x0F,
  0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x0F,
  0x00, 0x3C, 0x0F, 0x00, 0x3C, 0x1E, 0x00, 0x78, 0x1E, 0x00, 0xF8, 0x1F,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x3C,
  0x01, 0xF8, 0x3C, 0x00, 0xF8, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0x78, 0x3C,
  0x00, 0x78, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0x78, 0x78, 0x00, 0x78, 0x78,
  0x00, 0xF8, 0x78, 0x01, 0xF0, 0x78, 0x03, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x03,
  0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0x9F, 0xC0, 0xF8, 0x07, 0xC1, 0xE0,
  0x07, 0x87, 0xC0, 0x0F, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0xF1, 0xE0, 0x03, 0xC3, 0xC0,
  0x07, 0x87, 0xC0, 0x1F, 0x07, 0x80, 0x7C, 0x0F, 0xC3, 0xF0, 0x0F, 0xFF,
  0xC0, 0x1F, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x0F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x78, 0x07, 0xC0, 0xF0, 0x07,
  0xC3, 0xC0, 0x0F, 0x87, 0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x3C,
  0x3C, 0x00, 0x78, 0x78, 0x01, 0xE1, 0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x87,
  0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0xF8, 0xF8,
  0x01, 0xE1, 0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x0F, 0x00,
  0x1E, 0x1E, 0x00, 0x7C, 0x7C, 0x00, 0xF0, 0xF0, 0x01, 0xE1, 0xE0, 0x07,
  0xC3, 0xC0, 0x1F, 0x07, 0x80, 0x7C, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0,
  0x7F, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0xE0, 0x0F,
  0xFF, 0xE0, 0x3F, 0x9F, 0xC0, 0xF8, 0x07, 0xC1, 0xE0, 0x07, 0x87, 0xC0,
  0x0F, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x3F, 0xF8, 0xF8, 0x7F, 0xF1, 0xE0, 0xFF, 0xE3,
  0xC1, 0xFF, 0x87, 0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x7C,
  0x00, 0x78, 0xF0, 0x00, 0xF1, 0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x87, 0xC0,
  0x1F, 0x07, 0x80, 0x7C, 0x0F, 0xC3, 0xF0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0x80, 0x0F, 0x07, 0x80, 0x0F, 0x07, 0x80,
  0x0F, 0x07, 0x80, 0x1F, 0x07, 0x80, 0x1E, 0x07, 0x80, 0x1E, 0x0F, 0x00,
  0x1E, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x3E, 0x0F, 0x00,
  0x3C, 0x0F, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x1F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x3E, 0x00,
  0x78, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0x78, 0x3C, 0x00,
  0xF8, 0x3C, 0x00, 0xF0, 0x3C, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0x78, 0x00,
  0xF0, 0x78, 0x00, 0xF0, 0x78, 0x01, 0xF0, 0x78, 0x01, 0xE0, 0x78, 0x01,
  0xE0, 0xF8, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0x07, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x10, 0x00, 0xF0, 0xF0, 0x00, 0x78,
  0x7C, 0x00, 0x78, 0x3E, 0x00, 0x3C, 0x0F, 0x00, 0x3E, 0x07, 0xC0, 0x3E,
  0x03, 0xF8, 0x7E, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x07, 0x80, 0x07, 0xC1, 0xE0, 0x01, 0xE0, 0x78, 0x00, 0xF0,
  0x1E, 0x00, 0x7C, 0x07, 0x80, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07,
  0xC0, 0x3C, 0x03, 0xE0, 0x0F, 0x00, 0xF0, 0x03, 0xC0, 0x7C, 0x00, 0xF0,
  0x3E, 0x00, 0x3C, 0x0F, 0x00, 0x1E, 0x07, 0xC0, 0x07, 0x83, 0xE0, 0x01,
  0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0xC0,
  0x03, 0xE0, 0xF0, 0x00, 0xF0, 0x3E, 0x00, 0x3C, 0x0F, 0x80, 0x0F, 0x01,
  0xE0, 0x03, 0xC0, 0x7C, 0x00, 0xF0, 0x1F, 0x00, 0x7C, 0x03, 0xC0, 0x1E,
  0x00, 0xF8, 0x07, 0x80, 0x3E, 0x01, 0xE0, 0x07, 0x80, 0x78, 0x01, 0xF0,
  0x1E, 0x00, 0x3C, 0x07, 0x80, 0x0F, 0x03, 0xC0, 0x03, 0xE0, 0xF0, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xE0, 0x03, 0xE0, 0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x1F,
  0x80, 0x76, 0x07, 0xF0, 0x3F, 0x81, 0xDC, 0x0E, 0xE0, 0x77, 0x07, 0xB8,
  0x3D, 0xC1, 0xDE, 0x0F, 0x70, 0x77, 0x83, 0xDC, 0x39, 0xC0, 0xE7, 0x8E,
  0x70, 0x38, 0xE7, 0x3C, 0x0E, 0x39, 0xCF, 0x03, 0x8E, 0xE3, 0xC1, 0xE3,
  0xB8, 0xF0, 0x78, 0xFE, 0x38, 0x1E, 0x3F, 0x1E, 0x07, 0x87, 0xC7, 0x81,
  0xE1, 0xE1, 0xE0, 0x78, 0x00, 0x78, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x0F,
  0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x3C, 0x0F, 0x00,
  0x0F, 0x07, 0x80, 0x03, 0xC1, 0xE0, 0x01, 0xE0, 0x78, 0x00, 0x78, 0x1E,
  0x00, 0x1E, 0x07, 0x80, 0x07, 0x81, 0xE0, 0x01, 0xE0, 0xF8, 0x00, 0x78,
  0x00, 0x07, 0xE0, 0x0F, 0x07, 0xE0, 0x0F, 0x07, 0xE0, 0x0F, 0x07, 0xE0,
  0x0F, 0x07, 0xF0, 0x0F, 0x0F, 0xF0, 0x1E, 0x0F, 0xF0, 0x1E, 0x0F, 0x70,
  0x1E, 0x0F, 0x70, 0x1E, 0x0F, 0x78, 0x1E, 0x0E, 0x78, 0x1E, 0x1E, 0x78,
  0x3C, 0x1E, 0x38, 0x3C, 0x1E, 0x38, 0x3C, 0x1E, 0x3C, 0x3C, 0x1E, 0x3C,
  0x3C, 0x1E, 0x3C, 0x3C, 0x1C, 0x1C, 0x38, 0x3C, 0x1C, 0x78, 0x3C, 0x1E,
  0x78, 0x3C, 0x1E, 0x78, 0x3C, 0x1E, 0x78, 0x3C, 0x0E, 0x78, 0x38, 0x0E,
  0x78, 0x78, 0x0F, 0x70, 0x78, 0x0F, 0xF0, 0x78, 0x0F, 0xF0, 0x78, 0x07,
  0xF0, 0x78, 0x07, 0xF0, 0x78, 0x07, 0xF0, 0xF0, 0x07, 0xE0, 0xF0, 0x07,
  0xE0, 0xF0, 0x03, 0xE0, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF,
  0x81, 0xFC, 0xFE, 0x0F, 0x80, 0x7C, 0x3C, 0x01, 0xF1, 0xF0, 0x03, 0xC7,
  0x80, 0x0F, 0x1E, 0x00, 0x3C, 0x78, 0x00, 0xF1, 0xE0, 0x03, 0xCF, 0x00,
  0x1E, 0x3C, 0x00, 0x78, 0xF0, 0x01, 0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x1E,
  0x3C, 0x00, 0x79, 0xF0, 0x03, 0xE7, 0x80, 0x0F, 0x1E, 0x00, 0x3C, 0x78,
  0x00, 0xF1, 0xE0, 0x03, 0xC7, 0x80, 0x0F, 0x3E, 0x00, 0x3C, 0xF0, 0x01,
  0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x1E, 0x3E, 0x00, 0xF0, 0x78, 0x07, 0xC1,
  0xF8, 0x7E, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x07,
  0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0,
  0x78, 0x03, 0xF0, 0x3C, 0x00, 0xF8, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x1F,
  0x0F, 0x00, 0x0F, 0x87, 0x80, 0x07, 0x83, 0xC0, 0x03, 0xC1, 0xE0, 0x01,
  0xE1, 0xE0, 0x01, 0xF0, 0xF0, 0x00, 0xF0, 0x78, 0x00, 0xF8, 0x3C, 0x01,
  0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0xFF,
  0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0x9F, 0xC0, 0xF8, 0x07, 0xC1, 0xE0, 0x07,
  0x87, 0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x78, 0x00, 0x78,
  0xF0, 0x00, 0xF1, 0xE0, 0x01, 0xE3, 0xC0, 0x03, 0xC7, 0x80, 0x0F, 0x8F,
  0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x78, 0xF0, 0x00, 0xF1, 0xE0,
  0x01, 0xE3, 0xC0, 0x07, 0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x1E, 0x3C, 0x00,
  0x3C, 0x78, 0x00, 0x78, 0xF0, 0x00, 0xF1, 0xE0, 0x03, 0xC3, 0xC0, 0x07,
  0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x7C, 0x0F, 0xC3, 0xF0, 0x1F, 0xFF, 0xC0,
  0x1F, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0x80, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x07,
  0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0x80, 0x3E, 0x07, 0x80, 0x1F, 0x0F,
  0x00, 0x1F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0F,
  0x00, 0x1F, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x3E, 0x1E, 0x00, 0x3C, 0x1E,
  0x00, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x3F,
  0xFF, 0x00, 0x3C, 0x0F, 0x00, 0x3C, 0x0F, 0x00, 0x3C, 0x0F, 0x80, 0x3C,
  0x07, 0x80, 0x3C, 0x07, 0x80, 0x7C, 0x07, 0xC0, 0x78, 0x03, 0xC0, 0x78,
  0x03, 0xC0, 0x78, 0x03, 0xE0, 0x78, 0x01, 0xE0, 0x78, 0x01, 0xE0, 0x78,
  0x01, 0xF0, 0xF0, 0x01, 0xF0, 0xF0, 0x00, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xF8, 0xFE, 0x07, 0xC0, 0x3E, 0x07,
  0x80, 0x1E, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x78, 0x00, 0x78, 0xF8,
  0x00, 0x78, 0x78, 0x00, 0xF8, 0x78, 0x00, 0xF0, 0x7C, 0x01, 0xF0, 0x7F,
  0x07, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xE0, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00,
  0x1E, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x78, 0x00, 0xF0, 0xF0, 0x03,
  0xE3, 0xE0, 0x07, 0x87, 0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x3C,
  0x3C, 0x00, 0x78, 0x78, 0x01, 0xF1, 0xF0, 0x03, 0xC3, 0xC0, 0x07, 0x87,
  0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x78,
  0x01, 0xE1, 0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x0F, 0x00,
  0x1E, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0xF8, 0xF0, 0x01, 0xE1, 0xE0, 0x03,
  0xC3, 0xC0, 0x07, 0x87, 0xC0, 0x1E, 0x07, 0x80, 0x7C, 0x0F, 0xC3, 0xF0,
  0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xF8, 0x00, 0x1E,
  0xF0, 0x00, 0x79, 0xE0, 0x00, 0xF3, 0xC0, 0x03, 0xE7, 0x80, 0x07, 0x8F,
  0x00, 0x0F, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x78, 0x01, 0xF0, 0xF0,
  0x03, 0xC0, 0xF0, 0x07, 0x81, 0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x07, 0x80,
  0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x0F, 0x00, 0x78, 0x1E,
  0x00, 0xF0, 0x78, 0x01, 0xE0, 0xF0, 0x01, 0xC1, 0xE0, 0x03, 0xC7, 0x80,
  0x07, 0x8F, 0x00, 0x0F, 0x3C, 0x00, 0x1E, 0x78, 0x00, 0x3C, 0xE0, 0x00,
  0x7B, 0xC0, 0x00, 0xF7, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x0F, 0x03, 0xDE,
  0x07, 0xC0, 0xF7, 0x81, 0xF0, 0x39, 0xE0, 0x7C, 0x0E, 0x78, 0x3F, 0x07,
  0x9E, 0x0F, 0xC1, 0xE7, 0x83, 0x70, 0x71, 0xE0, 0xDC, 0x3C, 0x78, 0x77,
  0x0F, 0x1E, 0x1D, 0xC3, 0xC7, 0x86, 0x60, 0xE1, 0xE3, 0x98, 0x78, 0x70,
  0xE6, 0x1E, 0x1C, 0x31, 0x87, 0x07, 0x0C, 0x61, 0xC1, 0xC7, 0x18, 0xF0,
  0x71, 0xC6, 0x3C, 0x1C, 0x61, 0x8E, 0x07, 0x38, 0x63, 0x83, 0xCE, 0x19,
  0xE0, 0xF3, 0x8E, 0x78, 0x3C, 0xC3, 0x9C, 0x0F, 0x70, 0xEF, 0x03, 0xDC,
  0x3B, 0xC0, 0xF6, 0x0E, 0xE0, 0x3F, 0x83, 0xB8, 0x0F, 0xE0, 0xFE, 0x03,
  0xF8, 0x3F, 0x80, 0xEC, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0xFC,
  0x03, 0xE0, 0x3E, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x01, 0xF0,
  0x3E, 0x00, 0x3E, 0x03, 0xE0, 0x03, 0xC0, 0x1E, 0x00, 0x7C, 0x01, 0xF0,
  0x0F, 0x80, 0x0F, 0x00, 0xF0, 0x00, 0xF0, 0x1E, 0x00, 0x0F, 0x83, 0xE0,
  0x00, 0x78, 0x3C, 0x00, 0x07, 0x87, 0x80, 0x00, 0x3C, 0xF8, 0x00, 0x03,
  0xCF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x0F, 0x3E,
  0x00, 0x01, 0xF1, 0xE0, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x7C, 0x0F, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0xF0, 0x07, 0x80, 0x1F, 0x00,
  0x78, 0x03, 0xE0, 0x07, 0xC0, 0x3C, 0x00, 0x3C, 0x07, 0xC0, 0x03, 0xE0,
  0xF8, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1E, 0x78, 0x00,
  0x3C, 0x78, 0x00, 0x7C, 0x78, 0x00, 0x78, 0x3C, 0x00, 0xF0, 0x3C, 0x01,
  0xF0, 0x3C, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x1E, 0x07, 0xC0, 0x1E, 0x07,
  0x80, 0x1F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0xBC,
  0x00, 0x07, 0xBC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xFC, 0x00, 0xF8, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x01,
  0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x07, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x00, 0x1E,
  0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0x70, 0x00, 0xF7, 0x00, 0x0E,
  0x70, 0x01, 0xE7, 0x80, 0x3C, 0x38, 0x03, 0x83, 0x80, 0x78, 0x38, 0x0F,
  0x03, 0xC0, 0xF0, 0x1C, 0x1E, 0x01, 0xC1, 0xC0, 0x1E, 0x3C, 0x01, 0xE7,
  0x80, 0x0E, 0x78, 0x00, 0xEF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x78, 0x3C, 0x3E, 0x1E, 0x0F,
  0x00, 0xFC, 0x3C, 0x0F, 0xFC, 0xF0, 0x7F, 0xF7, 0x83, 0xF9, 0xFE, 0x1F,
  0x01, 0xF8, 0x78, 0x03, 0xE3, 0xC0, 0x0F, 0x8F, 0x00, 0x3E, 0x3C, 0x00,
  0xF9, 0xF0, 0x03, 0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x3C, 0x78, 0x00, 0xF1,
  0xE0, 0x03, 0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x01, 0xE3, 0xC0,
  0x07, 0x8F, 0x00, 0x1E, 0x3E, 0x00, 0xF8, 0xF8, 0x07, 0xE1, 0xF8, 0x7F,
  0x07, 0xFF, 0xBC, 0x0F, 0xFE, 0xF0, 0x1F, 0xE3, 0xC0, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x1F, 0xC0, 0x3C, 0xFF,
  0xC0, 0xF7, 0xFF, 0x83, 0xFC, 0xFE, 0x1E, 0x80, 0xF8, 0x7C, 0x01, 0xF1,
  0xF0, 0x07, 0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x3C, 0x78, 0x01, 0xF3, 0xE0,
  0x07, 0x8F, 0x00, 0x1E, 0x3C, 0x00, 0x78, 0xF0, 0x01, 0xE3, 0xC0, 0x07,
  0x8F, 0x00, 0x1E, 0x7C, 0x00, 0xF1, 0xF0, 0x03, 0xC7, 0xC0, 0x0F, 0x1F,
  0x00, 0x7C, 0x7E, 0x03, 0xE1, 0xFC, 0x1F, 0x07, 0xFF, 0xFC, 0x3C, 0xFF,
  0xE0, 0xF1, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0xFF, 0x01, 0xFF, 0xFC,
  0x1F, 0xEF, 0xE1, 0xF0, 0x0F, 0x8F, 0x00, 0x7C, 0xF0, 0x01, 0xE7, 0x80,
  0x0F, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x0F, 0xBC, 0x00, 0x79, 0xF0, 0x07, 0xC7, 0x80, 0x7C, 0x3F,
  0x07, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0xFC, 0x3C,
  0x07, 0xFE, 0x78, 0x1F, 0xFD, 0xF0, 0x7F, 0x3F, 0xC1, 0xF0, 0x1F, 0x83,
  0xC0, 0x1F, 0x0F, 0x00, 0x3E, 0x1E, 0x00, 0x7C, 0x3C, 0x00, 0xF8, 0xF8,
  0x01, 0xE1, 0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x0F, 0x00,
  0x1E, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0xF0, 0xF0, 0x01, 0xE1, 0xE0, 0x03,
  0xC3, 0xC0, 0x07, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x7E, 0x0F, 0xC3, 0xFC,
  0x1F, 0xFE, 0xF0, 0x1F, 0xFD, 0xE0, 0x1F, 0xE3, 0xC0, 0x00, 0xFF, 0x00,
  0x1F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0x87, 0xE1, 0xF0, 0x0F, 0x0F, 0x00,
  0x7C, 0xF0, 0x01, 0xE7, 0x80, 0x0F, 0x3C, 0x00, 0x7B, 0xC0, 0x03, 0xDE,
  0x00, 0x3C, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xE0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0,
  0x03, 0xC7, 0x80, 0x3C, 0x3E, 0x07, 0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0xC0,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x3C, 0x0F, 0xFC, 0xF0,
  0x7F, 0xFF, 0x83, 0xF9, 0xFE, 0x1F, 0x01, 0xF8, 0x78, 0x03, 0xE3, 0xC0,
  0x0F, 0x8F, 0x00, 0x1E, 0x3C, 0x00, 0xF9, 0xF0, 0x03, 0xC7, 0x80, 0x0F,
  0x1E, 0x00, 0x3C, 0x78, 0x00, 0xF1, 0xE0, 0x03, 0xC7, 0x80, 0x0F, 0x1E,
  0x00, 0x78, 0x78, 0x01, 0xE1, 0xE0, 0x0F, 0x87, 0xC0, 0x7E, 0x1F, 0x83,
  0x78, 0x3F, 0xFD, 0xE0, 0xFF, 0xEF, 0x80, 0xFF, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x7F, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x1F, 0xC0, 0x3C, 0xFF, 0xC0, 0xF7, 0xFF, 0x83, 0xF8, 0x7E, 0x1E, 0x80,
  0x7C, 0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x7C,
  0x78, 0x01, 0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x1E, 0x3C, 0x00, 0x78, 0xF0,
  0x01, 0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x3C, 0x7C, 0x00, 0xF1, 0xE0, 0x03,
  0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x3C, 0x78, 0x00, 0xF1, 0xE0, 0x07, 0xC7,
  0x80, 0x1E, 0x3C, 0x00, 0x78, 0xF0, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x3E, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x00, 0x3C, 0x00,
  0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x7F, 0xFE, 0x00, 0xFF,
  0xF8, 0x01, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x1F, 0x0F,
  0x00, 0x1E, 0x0F, 0x00, 0x3E, 0x0F, 0x00, 0x7C, 0x0F, 0x00, 0xF8, 0x1E,
  0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x1E, 0x07, 0xC0, 0x1E, 0x07, 0x80, 0x1E,
  0x0F, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x1F, 0x00, 0x3C, 0x0F, 0x00, 0x7C,
  0x0F, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0xC0, 0x78, 0x03, 0xC0, 0x78,
  0x03, 0xE0, 0x78, 0x01, 0xE0, 0x78, 0x01, 0xF0, 0xF0, 0x00, 0xF8, 0x7F,
  0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xFF, 0xC1, 0xFF,
  0xF8, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x0E, 0x7C, 0x3E, 0x07, 0x7F, 0x7F,
  0x03, 0xBF, 0xBF, 0xC3, 0xE3, 0xF1, 0xE1, 0xE0, 0xF0, 0xF0, 0xF0, 0x70,
  0x78, 0x78, 0x38, 0x3C, 0x3C, 0x1C, 0x1E, 0x1C, 0x1E, 0x0F, 0x1E, 0x0F,
  0x07, 0x8F, 0x07, 0x03, 0x87, 0x83, 0x83, 0xC3, 0xC1, 0xC1, 0xE1, 0xE0,
  0xE0, 0xF0, 0xE0, 0x70, 0x78, 0xF0, 0x78, 0x3C, 0x78, 0x3C, 0x1C, 0x3C,
  0x1C, 0x1E, 0x1E, 0x0E, 0x0F, 0x0F, 0x07, 0x07, 0x87, 0x03, 0x83, 0xC3,
  0x83, 0xC1, 0xE3, 0xC1, 0xE0, 0xE1, 0xE0, 0xE0, 0x70, 0xF0, 0x70, 0x78,
  0x00, 0x0F, 0x1F, 0xC0, 0x3C, 0xFF, 0xC0, 0xF7, 0xFF, 0x83, 0xF8, 0x7E,
  0x1E, 0x80, 0x7C, 0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0x80, 0x0F, 0x1E,
  0x00, 0x7C, 0x78, 0x01, 0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x1E, 0x3C, 0x00,
  0x78, 0xF0, 0x01, 0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x3C, 0x7C, 0x00, 0xF1,
  0xE0, 0x03, 0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x3C, 0x78, 0x00, 0xF1, 0xE0,
  0x07, 0xC7, 0x80, 0x1E, 0x3C, 0x00, 0x78, 0xF0, 0x01, 0xE0, 0x00, 0xFF,
  0x80, 0x1F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0xCF, 0xE1, 0xF0, 0x1F, 0x0F,
  0x00, 0x7C, 0xF0, 0x03, 0xE7, 0x80, 0x0F, 0x3C, 0x00, 0x7B, 0xC0, 0x07,
  0xDE, 0x00, 0x3C, 0xF0, 0x01, 0xE7, 0x80, 0x0F, 0x3C, 0x00, 0x79, 0xE0,
  0x03, 0xDF, 0x00, 0x1E, 0xF0, 0x01, 0xE7, 0x80, 0x0F, 0x3C, 0x00, 0x79,
  0xF0, 0x07, 0x87, 0x80, 0x7C, 0x3F, 0x0F, 0xC0, 0xFF, 0xFC, 0x07, 0xFF,
  0xC0, 0x0F, 0xF8, 0x00, 0x07, 0x8F, 0xE0, 0x0F, 0x3F, 0xF0, 0x1E, 0xFF,
  0xF0, 0x3F, 0xCF, 0xE0, 0xF4, 0x07, 0xC1, 0xF0, 0x07, 0xC3, 0xE0, 0x07,
  0x87, 0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x7C, 0x7C, 0x00, 0xF0,
  0xF0, 0x01, 0xE1, 0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x0F,
  0x00, 0x1E, 0x3E, 0x00, 0x78, 0x7C, 0x00, 0xF0, 0xF8, 0x01, 0xE1, 0xF0,
  0x07, 0xC3, 0xF0, 0x1F, 0x07, 0xF0, 0x7C, 0x0F, 0xFF, 0xF8, 0x3C, 0xFF,
  0xE0, 0x78, 0xFF, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x3C, 0x0F, 0xFC, 0xF0, 0x7F, 0xF7, 0x83,
  0xF9, 0xFE, 0x1F, 0x01, 0xF8, 0xF8, 0x03, 0xE3, 0xC0, 0x0F, 0x8F, 0x00,
  0x3E, 0x3C, 0x00, 0xF1, 0xE0, 0x03, 0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x3C,
  0x78, 0x00, 0xF1, 0xE0, 0x03, 0xC7, 0x80, 0x1F, 0x3E, 0x00, 0x78, 0xF0,
  0x01, 0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x3E, 0x3E, 0x00, 0xF8, 0xF8, 0x05,
  0xE1, 0xF8, 0x7F, 0x07, 0xFF, 0xBC, 0x0F, 0xFC, 0xF0, 0x1F, 0xE3, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x0F, 0x1F,
  0xC0, 0x3D, 0xFF, 0xC0, 0xFF, 0xFF, 0x87, 0xB8, 0x7E, 0x1F, 0x80, 0x78,
  0x7C, 0x01, 0xF1, 0xE0, 0x07, 0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x3C, 0xF8,
  0x01, 0xF3, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x3F, 0xFF,
  0x03, 0xFF, 0xFC, 0x1F, 0x87, 0xE1, 0xF0, 0x0F, 0x8F, 0x00, 0x3C, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0x80, 0x00,
  0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x79, 0xE0, 0x03, 0xCF,
  0x00, 0x3E, 0x7E, 0x07, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x1F, 0xFC,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F,
  0xF0, 0x1E, 0x00, 0x3C, 0x78, 0x00, 0xF1, 0xE0, 0x07, 0xCF, 0x80, 0x1E,
  0x3C, 0x00, 0x78, 0xF0, 0x01, 0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x1E, 0x3C,
  0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x3C, 0x78, 0x00,
  0xF1, 0xE0, 0x03, 0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x01, 0xE3,
  0xC0, 0x07, 0x8F, 0x80, 0x1E, 0x3E, 0x00, 0xF0, 0x78, 0x07, 0xC1, 0xF8,
  0x7E, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xF0, 0x00,
  0x7F, 0x80, 0x07, 0xFC, 0x00, 0x3D, 0xE0, 0x03, 0xEF, 0x00, 0x1E, 0x38,
  0x00, 0xF1, 0xE0, 0x0F, 0x0F, 0x00, 0x78, 0x78, 0x07, 0x83, 0xC0, 0x3C,
  0x1E, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0xC1, 0xE0, 0x1E, 0x0F, 0x00, 0xF0,
  0xF0, 0x07, 0x87, 0x80, 0x3C, 0x78, 0x00, 0xE3, 0xC0, 0x07, 0xBC, 0x00,
  0x3D, 0xE0, 0x01, 0xEE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0xE0, 0x78, 0x0F, 0xC0, 0xF0, 0x1F, 0x81, 0xE0,
  0x7F, 0x07, 0xC0, 0xEE, 0x0F, 0x81, 0xDC, 0x1B, 0x07, 0xB8, 0x76, 0x0E,
  0x70, 0xEC, 0x1C, 0xE1, 0x98, 0x79, 0xC7, 0x30, 0xE3, 0x8E, 0x61, 0xC7,
  0x18, 0xC7, 0x8E, 0x71, 0x8E, 0x1C, 0xE3, 0x1C, 0x39, 0x86, 0x38, 0x73,
  0x0C, 0xE0, 0xEE, 0x19, 0xC1, 0xD8, 0x33, 0x83, 0xB0, 0x6E, 0x07, 0xE0,
  0xDC, 0x0F, 0x81, 0xB8, 0x1F, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x0F,
  0x80, 0xF0, 0x1E, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0xF0, 0x03, 0xE0, 0x3E,
  0x01, 0xF0, 0x07, 0x80, 0x78, 0x01, 0xF0, 0x3E, 0x00, 0x3C, 0x1F, 0x00,
  0x0F, 0x8F, 0x80, 0x01, 0xE3, 0xC0, 0x00, 0x79, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xF3, 0xC0, 0x00,
  0x78, 0xF8, 0x00, 0x3C, 0x1E, 0x00, 0x1F, 0x07, 0xC0, 0x0F, 0x80, 0xF0,
  0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x07, 0x80, 0xF8, 0x01, 0xF0, 0xFC, 0x00,
  0x3E, 0x00, 0x1E, 0x00, 0x3C, 0x78, 0x00, 0xF1, 0xE0, 0x07, 0xC7, 0x80,
  0x1E, 0x3C, 0x00, 0x78, 0xF0, 0x01, 0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x1E,
  0x3C, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0xC0, 0x0F, 0x1E, 0x00, 0x3C, 0x78,
  0x00, 0xF1, 0xE0, 0x03, 0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x78, 0x78, 0x01,
  0xE1, 0xE0, 0x0F, 0x87, 0xC0, 0x7E, 0x1F, 0xC7, 0x78, 0x3F, 0xFD, 0xE0,
  0x7F, 0xEF, 0x80, 0xFE, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0xFF, 0xFC,
  0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x00, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x00, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC1, 0xF0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0,
  0x78, 0x3E, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC1, 0xE0, 0x78,
  0x1E, 0x07, 0x81, 0xE0, 0x78, 0x3E, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x3E, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x3C, 0xFF, 0x80, 0xF7, 0xFF, 0x03, 0xDE, 0x3E, 0x0F,
  0xF0, 0x7C, 0x7B, 0xC0, 0xFF, 0xEF, 0x03, 0xFF, 0x3C, 0x07, 0xF8, 0xF0,
  0x07, 0x80,
};

const GFXglyph JetBrainsMono_Italic45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 27, 0, -1 },
  { 1, 11, 33, 27, 8, -33 },
  { 47, 15, 14, 27, 8, -33 },
  { 74, 26, 33, 27, 1, -33 },
  { 182, 24, 45, 27, 2, -39 },
  { 317, 31, 33, 27, -1, -33 },
  { 445, 25, 33, 27, 1, -33 },
  { 549, 6, 14, 27, 13, -33 },
  { 560, 19, 44, 27, 7, -38 },
  { 665, 19, 44, 27, 2, -38 },
  { 770, 24, 23, 27, 2, -27 },
  { 839, 22, 21, 27, 3, -25 },
  { 897, 12, 14, 27, 4, -7 },
  { 918, 15, 4, 27, 6, -17 },
  { 926, 8, 7, 27, 8, -7 },
  { 933, 27, 42, 27, 1, -37 },
  { 1075, 23, 33, 27, 3, -33 },
  { 1170, 21, 33, 27, 2, -33 },
  { 1257, 23, 33, 27, 2, -33 },
  { 1352, 23, 33, 27, 2, -33 },
  { 1447, 21, 33, 27, 3, -33 },
  { 1534, 22, 33, 27, 3, -33 },
  { 1625, 22, 33, 27, 2, -33 },
  { 1716, 22, 33, 27, 5, -33 },
  { 1807, 23, 33, 27, 2, -33 },
  { 1902, 22, 33, 27, 4, -33 },
  { 1993, 11, 25, 27, 8, -25 },
  { 2028, 14, 32, 27, 5, -25 },
  { 2084, 21, 24, 27, 4, -27 },
  { 2147, 22, 14, 27, 3, -22 },
  { 2186, 22, 24, 27, 2, -27 },
  { 2252, 18, 33, 27, 6, -33 },
  { 2327, 27, 41, 27, 0, -33 },
  { 2466, 23, 33, 27, 0, -33 },
  { 2561, 24, 33, 27, 2, -33 },
  { 2660, 23, 33, 27, 3, -33 },
  { 2755, 23, 33, 27, 2, -33 },
  { 2850, 24, 33, 27, 3, -33 },
  { 2949, 25, 33, 27, 2, -33 },
  { 3053, 23, 33, 27, 3, -33 },
  { 3148, 24, 33, 27, 2, -33 },
  { 3247, 23, 33, 27, 3, -33 },
  { 3342, 25, 33, 27, 1, -33 },
  { 3446, 26, 33, 27, 2, -33 },
  { 3554, 20, 33, 27, 3, -33 },
  { 3637, 26, 33, 27, 1, -33 },
  { 3745, 24, 33, 27, 2, -33 },
  { 3844, 22, 33, 27, 3, -33 },
  { 3935, 25, 33, 27, 2, -33 },
  { 4039, 23, 41, 27, 3, -33 },
  { 4157, 24, 33, 27, 2, -33 },
  { 4256, 24, 33, 27, 2, -33 },
  { 4355, 23, 33, 27, 5, -33 },
  { 4450, 23, 33, 27, 3, -33 },
  { 4545, 23, 33, 27, 5, -33 },
  { 4640, 26, 33, 27, 3, -33 },
  { 4748, 28, 33, 27, 0, -33 },
  { 4864, 24, 33, 27, 5, -33 },
  { 4963, 24, 33, 27, 2, -33 },
  { 5062, 18, 42, 27, 6, -37 },
  { 5157, 14, 42, 27, 7, -37 },
  { 5231, 18, 42, 27, 4, -37 },
  { 5326, 20, 18, 27, 4, -33 },
  { 5371, 22, 4, 27, 0, 1 },
  { 5382, 8, 6, 27, 12, -35 },
  { 5388, 22, 25, 27, 3, -25 },
  { 5457, 22, 33, 27, 2, -33 },
  { 5548, 21, 25, 27, 3, -25 },
  { 5614, 23, 33, 27, 3, -33 },
  { 5709, 21, 25, 27, 3, -25 },
  { 5775, 31, 41, 27, -2, -33 },
  { 5934, 22, 33, 27, 3, -25 },
  { 6025, 22, 33, 27, 2, -33 },
  { 6116, 21, 35, 27, 2, -35 },
  { 6208, 23, 43, 27, 1, -35 },
  { 6332, 24, 33, 27, 2, -33 },
  { 6431, 19, 33, 27, 4, -33 },
  { 6510, 25, 25, 27, 1, -25 },
  { 6589, 22, 25, 27, 2, -25 },
  { 6658, 21, 25, 27, 3, -25 },
  { 6724, 23, 33, 27, 1, -25 },
  { 6819, 22, 33, 27, 3, -25 },
  { 6910, 22, 25, 27, 3, -25 },
  { 6979, 21, 25, 27, 3, -25 },
  { 7045, 21, 32, 27, 4, -32 },
  { 7129, 22, 25, 27, 3, -25 },
  { 7198, 21, 25, 27, 5, -25 },
  { 7264, 23, 25, 27, 4, -25 },
  { 7336, 26, 25, 27, 0, -25 },
  { 7418, 22, 33, 27, 3, -25 },
  { 7509, 22, 25, 27, 2, -25 },
  { 7578, 23, 42, 27, 4, -37 },
  { 7699, 10, 42, 27, 9, -37 },
  { 7752, 23, 42, 27, 1, -37 },
  { 7873, 22, 9, 27, 3, -20 },
};

const GFXfont JetBrainsMono_Italic45pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Italic45pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Italic45pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _JETBRAINSMONO_ITALIC45PT7B_H_
