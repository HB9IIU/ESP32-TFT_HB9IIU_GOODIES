#ifndef _JETBRAINSMONO_ITALIC37PT7B_H_
#define _JETBRAINSMONO_ITALIC37PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Italic.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Italic37pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x83, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1C, 0x0E, 0x07,
  0x07, 0x83, 0xC1, 0xC0, 0xE0, 0x70, 0x38, 0x18, 0x0C, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0xFC, 0x7C, 0x3E, 0x00, 0x78, 0x77, 0x8F, 0x70,
  0xF7, 0x0F, 0x70, 0xFF, 0x0E, 0xF0, 0xEE, 0x0E, 0xE0, 0xEE, 0x0C, 0xE1,
  0xC0, 0x00, 0x70, 0x38, 0x03, 0x81, 0x80, 0x1C, 0x1C, 0x01, 0xC0, 0xE0,
  0x0E, 0x06, 0x00, 0x60, 0x70, 0x07, 0x03, 0x83, 0xFF, 0xFF, 0x1F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xC0, 0xE0, 0x60, 0x06, 0x07, 0x00, 0x70, 0x38, 0x03,
  0x83, 0x80, 0x18, 0x1C, 0x01, 0xC0, 0xE0, 0x0E, 0x0E, 0x07, 0xFF, 0xFF,
  0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x81, 0x81, 0xC0, 0x1C, 0x0C, 0x00, 0xE0,
  0xE0, 0x06, 0x07, 0x00, 0x70, 0x30, 0x03, 0x83, 0x80, 0x38, 0x1C, 0x00,
  0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x01, 0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0x31, 0xE1, 0xC6, 0x3C,
  0x78, 0xC7, 0x8E, 0x18, 0xF1, 0xC3, 0x00, 0x38, 0xE0, 0x07, 0x9C, 0x00,
  0xFB, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x01, 0x8F, 0x00, 0x31, 0xE0, 0x06, 0x1C, 0x00, 0xC3, 0x9C,
  0x18, 0x73, 0x87, 0x1E, 0x78, 0xC3, 0x8F, 0x99, 0xF0, 0xFF, 0xFC, 0x0F,
  0xFF, 0x00, 0xFF, 0x80, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x03, 0xF0, 0x03, 0x83, 0xFC, 0x03, 0x83, 0xCF,
  0x03, 0x81, 0xC3, 0x81, 0x80, 0xC1, 0xC1, 0xC0, 0xE0, 0xE1, 0xC0, 0x70,
  0x71, 0xC0, 0x38, 0x31, 0xC0, 0x1C, 0x39, 0xC0, 0x0F, 0x3C, 0xC0, 0x03,
  0xFC, 0xE0, 0x00, 0xF8, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x63, 0xF0, 0x00, 0x77, 0xFC, 0x00, 0x73, 0x9E,
  0x00, 0x73, 0x87, 0x00, 0x71, 0xC3, 0x80, 0x70, 0xC1, 0xC0, 0x70, 0x60,
  0xE0, 0x30, 0x70, 0x70, 0x38, 0x38, 0x30, 0x38, 0x0E, 0x78, 0x38, 0x07,
  0xF8, 0x38, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFF,
  0xC0, 0x78, 0x3C, 0x07, 0x01, 0xC0, 0xF0, 0x1C, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x0F,
  0xC0, 0x03, 0xFE, 0x00, 0x38, 0xE0, 0xF7, 0x8F, 0x1E, 0x70, 0x71, 0xC7,
  0x07, 0xBC, 0x70, 0x3F, 0x87, 0x03, 0xF0, 0xF0, 0x1E, 0x0F, 0x01, 0xE0,
  0xF0, 0x3F, 0x0F, 0x07, 0xF0, 0x7F, 0xF7, 0x87, 0xFE, 0x38, 0x3F, 0x83,
  0xC0, 0x3B, 0xDE, 0xF7, 0xB9, 0xCE, 0x73, 0xB8, 0x00, 0x06, 0x00, 0x3C,
  0x01, 0xF8, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x0E,
  0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0xC0,
  0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0x80,
  0x07, 0x00, 0x02, 0x00, 0x07, 0x00, 0x0F, 0x80, 0x1F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x3C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x78,
  0x01, 0xE0, 0x0F, 0x80, 0xFE, 0x01, 0xF0, 0x03, 0x80, 0x04, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x70, 0x60, 0xE7, 0xC6, 0x3E, 0xFF, 0x6F, 0xF3, 0xFF,
  0xF8, 0x03, 0xFC, 0x00, 0x1E, 0x00, 0x03, 0xF0, 0x00, 0x73, 0x80, 0x0F,
  0x3C, 0x01, 0xE3, 0xC0, 0x3C, 0x1E, 0x07, 0x81, 0xE0, 0x30, 0x0C, 0x01,
  0x00, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x01, 0xFF, 0xFF, 0x7F, 0xFF, 0xDF, 0xFF,
  0xF8, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC1, 0xF0, 0xF8, 0x3C, 0x0F, 0x07,
  0x81, 0xE0, 0xF0, 0x3C, 0x1E, 0x07, 0x03, 0xC0, 0x7F, 0xFB, 0xFF, 0xBF,
  0xFC, 0x39, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xF0,
  0x1F, 0xBF, 0x07, 0x81, 0xE1, 0xE0, 0x1E, 0x38, 0x03, 0xC7, 0x00, 0x39,
  0xE0, 0x0F, 0x38, 0x01, 0xE7, 0x00, 0x38, 0xE0, 0x07, 0x1C, 0x70, 0xE3,
  0x8F, 0x1C, 0xF3, 0xE3, 0x9E, 0x3C, 0xF3, 0x83, 0x1C, 0x70, 0x03, 0x8E,
  0x00, 0x71, 0xC0, 0x0E, 0x78, 0x01, 0xCF, 0x00, 0x79, 0xE0, 0x0E, 0x1C,
  0x03, 0xC3, 0xC0, 0xF0, 0x7F, 0xFC, 0x07, 0xFF, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFF, 0x00, 0xFB, 0x81, 0xF1, 0xC0, 0xF1,
  0xE0, 0x60, 0xF0, 0x20, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x07, 0x81, 0xE1, 0xE0, 0x1E, 0x38, 0x03,
  0xCF, 0x00, 0x79, 0xC0, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0x1F, 0xFF, 0xE3,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0xFF, 0x00, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0x8E, 0x00, 0x71, 0xC0, 0x1E, 0x3C, 0x03, 0xC7, 0xC0, 0xF0,
  0x7F, 0xFC, 0x07, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x0E, 0x0F,
  0x03, 0x87, 0x80, 0xE3, 0xC0, 0x39, 0xE0, 0x1E, 0x70, 0x07, 0x9C, 0x01,
  0xC7, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x0F, 0xFF, 0xE1,
  0xFF, 0xFC, 0x3F, 0xFF, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x8F, 0x00, 0x77, 0xF8, 0x0F,
  0xFF, 0x83, 0xF0, 0xF8, 0x78, 0x0F, 0x0F, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x71, 0xE0,
  0x0E, 0x1C, 0x03, 0xC3, 0xC0, 0xF0, 0x7F, 0xFC, 0x07, 0xFF, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0x70, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0,
  0x00, 0xF3, 0xC0, 0x7F, 0xF8, 0x1F, 0xFF, 0x0F, 0x83, 0xE7, 0xC0, 0x79,
  0xE0, 0x0E, 0x70, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3B, 0x80, 0x0E, 0xE0,
  0x03, 0xBC, 0x01, 0xEF, 0x00, 0xF1, 0xE0, 0x78, 0x7F, 0xFE, 0x0F, 0xFE,
  0x01, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFE,
  0x00, 0x77, 0x00, 0x7B, 0x80, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03,
  0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xE0, 0x00,
  0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x07, 0x81, 0xE0, 0xE0,
  0x1C, 0x3C, 0x03, 0x87, 0x00, 0x70, 0xE0, 0x0E, 0x1E, 0x03, 0xC3, 0xC0,
  0xF0, 0x3C, 0x3C, 0x03, 0xFF, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x03, 0xEF,
  0x80, 0xF0, 0xF8, 0x3C, 0x07, 0x0F, 0x00, 0xF1, 0xC0, 0x1E, 0x38, 0x03,
  0xCF, 0x00, 0x79, 0xE0, 0x0E, 0x3C, 0x03, 0xC3, 0xC0, 0xF0, 0x7F, 0xFE,
  0x07, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x01, 0xFF, 0xC0, 0xFF,
  0xF8, 0x78, 0x1F, 0x3C, 0x03, 0xCE, 0x00, 0x77, 0x80, 0x1D, 0xC0, 0x07,
  0x70, 0x01, 0xDC, 0x00, 0xF7, 0x00, 0x3D, 0xC0, 0x1E, 0x78, 0x07, 0x9F,
  0x07, 0xC3, 0xFF, 0xF0, 0x7F, 0xF8, 0x07, 0xBC, 0x00, 0x0E, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x0E, 0x0F, 0x8F, 0xC7, 0xE3,
  0xF0, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x7E, 0x3F, 0x1F, 0x8F, 0x80, 0x01, 0xC0, 0x3E, 0x07, 0xF0,
  0x7E, 0x07, 0xE0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0xF0, 0x1F, 0x01,
  0xE0, 0x3C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x70, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7E, 0x00, 0x07, 0x80, 0x00, 0x60, 0x00, 0x08, 0x7F, 0xFF, 0xBF,
  0xFF, 0xDF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xC0, 0x10,
  0x00, 0x07, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xE0, 0x00, 0x78,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0x3C, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x1F, 0xE0, 0x7F, 0xE0,
  0xFF, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x03, 0xFC, 0x07, 0xF0,
  0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xE0, 0x00, 0x00,
  0x3F, 0xE0, 0x03, 0xFF, 0xC0, 0x1F, 0x0F, 0x80, 0xF0, 0x0E, 0x07, 0x00,
  0x1C, 0x38, 0x00, 0x70, 0xE0, 0x01, 0xC7, 0x00, 0x07, 0x1C, 0x00, 0x1C,
  0x70, 0x1E, 0x71, 0xC1, 0xFD, 0xCE, 0x0F, 0xBF, 0x38, 0x38, 0x38, 0xE1,
  0xC0, 0xE3, 0x87, 0x03, 0x8E, 0x1C, 0x0E, 0x38, 0x70, 0x38, 0xC1, 0xC0,
  0xE7, 0x07, 0x07, 0x1C, 0x38, 0x1C, 0x70, 0xE0, 0x71, 0xC3, 0xC3, 0xC7,
  0x07, 0x9F, 0x1C, 0x1F, 0xDC, 0xE0, 0x3E, 0x73, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xE7, 0x00,
  0x1C, 0xE0, 0x07, 0x9C, 0x00, 0xE3, 0x80, 0x1C, 0x70, 0x07, 0x0E, 0x00,
  0xE1, 0xC0, 0x3C, 0x38, 0x07, 0x07, 0x01, 0xE0, 0xE0, 0x38, 0x1E, 0x07,
  0x01, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x0F, 0xFF, 0xE1, 0xC0, 0x1C, 0x38,
  0x03, 0x8F, 0x00, 0x71, 0xC0, 0x0E, 0x78, 0x01, 0xCE, 0x00, 0x3F, 0xC0,
  0x07, 0x80, 0x0F, 0xFE, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0x01, 0xE1,
  0xE0, 0x1E, 0x38, 0x03, 0xC7, 0x00, 0x78, 0xE0, 0x0E, 0x1C, 0x01, 0xC3,
  0x80, 0x78, 0xF0, 0x1E, 0x1F, 0xFF, 0x83, 0xFF, 0xC0, 0x7F, 0xFC, 0x0E,
  0x0F, 0xC1, 0xC0, 0x3C, 0x78, 0x03, 0x8F, 0x00, 0x71, 0xC0, 0x0E, 0x38,
  0x01, 0xC7, 0x00, 0x38, 0xE0, 0x0F, 0x1C, 0x03, 0xC7, 0x80, 0xF8, 0xFF,
  0xFE, 0x1F, 0xFF, 0x83, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xF0,
  0x1F, 0xFF, 0x07, 0x81, 0xE0, 0xE0, 0x1E, 0x3C, 0x03, 0xC7, 0x00, 0x78,
  0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x78, 0xE0, 0x0E, 0x1C,
  0x03, 0xC3, 0xC0, 0xF0, 0x7F, 0xFC, 0x07, 0xFF, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xFC, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0x03, 0xE1, 0xE0, 0x3C,
  0x3C, 0x03, 0x87, 0x00, 0x70, 0xE0, 0x0E, 0x1C, 0x01, 0xC3, 0x80, 0x38,
  0xF0, 0x07, 0x1E, 0x01, 0xE3, 0x80, 0x3C, 0x70, 0x07, 0x0E, 0x00, 0xE1,
  0xC0, 0x1C, 0x78, 0x03, 0x8F, 0x00, 0xF1, 0xC0, 0x1E, 0x38, 0x03, 0xC7,
  0x00, 0x70, 0xE0, 0x1E, 0x3C, 0x07, 0x87, 0x81, 0xF0, 0xFF, 0xFC, 0x1F,
  0xFE, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF0, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xFF, 0xF8, 0x3F,
  0xFF, 0x83, 0xFF, 0xF0, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0xFF, 0x83, 0xFF, 0xF8,
  0x3F, 0xFF, 0x83, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x7F, 0xF0, 0x1F, 0xFF, 0x07, 0x81, 0xE0, 0xE0, 0x1E, 0x3C, 0x03, 0xC7,
  0x00, 0x78, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0xFF, 0x8E, 0x1F, 0xF3, 0xC3, 0xFC, 0x78,
  0x83, 0x8E, 0x00, 0x71, 0xC0, 0x0E, 0x38, 0x03, 0xC7, 0x00, 0x78, 0xE0,
  0x0E, 0x1C, 0x03, 0xC3, 0xC0, 0xF0, 0x7F, 0xFC, 0x07, 0xFF, 0x00, 0x3F,
  0xC0, 0x00, 0x0E, 0x00, 0xE1, 0xC0, 0x1C, 0x38, 0x03, 0x87, 0x00, 0x71,
  0xE0, 0x1E, 0x3C, 0x03, 0xC7, 0x00, 0x70, 0xE0, 0x0E, 0x1C, 0x01, 0xC3,
  0x80, 0x38, 0xF0, 0x0F, 0x1E, 0x01, 0xE3, 0xFF, 0xF8, 0x7F, 0xFF, 0x0F,
  0xFF, 0xE1, 0xC0, 0x1C, 0x78, 0x07, 0x8F, 0x00, 0xF1, 0xE0, 0x1C, 0x38,
  0x03, 0x87, 0x00, 0x70, 0xE0, 0x0E, 0x1C, 0x03, 0xC7, 0x80, 0x78, 0xF0,
  0x0F, 0x1C, 0x01, 0xC3, 0x80, 0x38, 0x00, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC,
  0x3F, 0xFF, 0x80, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x7F, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x8F,
  0x00, 0x38, 0xE0, 0x07, 0x8F, 0x00, 0x70, 0xF0, 0x0F, 0x07, 0x81, 0xE0,
  0x7F, 0xFC, 0x03, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x0E, 0x00, 0x78, 0x70,
  0x07, 0x83, 0x80, 0x38, 0x3C, 0x03, 0xC1, 0xE0, 0x3C, 0x0F, 0x01, 0xC0,
  0x70, 0x1E, 0x03, 0x81, 0xE0, 0x1C, 0x0E, 0x00, 0xE0, 0xF0, 0x0F, 0x0F,
  0x00, 0x78, 0x70, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x07,
  0x0F, 0x00, 0x78, 0x38, 0x03, 0xC1, 0xE0, 0x1C, 0x0F, 0x00, 0xE0, 0x38,
  0x07, 0x01, 0xE0, 0x38, 0x0F, 0x03, 0xC0, 0x3C, 0x1E, 0x01, 0xE0, 0xF0,
  0x07, 0x07, 0x00, 0x3C, 0x38, 0x01, 0xE0, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFE, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xC3, 0x60, 0x7E, 0x1B, 0x03, 0xF0,
  0xD8, 0x3B, 0x06, 0xE1, 0xD8, 0x77, 0x0D, 0xC3, 0xB8, 0xEE, 0x1C, 0xC6,
  0x70, 0xE6, 0x73, 0x87, 0x33, 0x38, 0x39, 0xF9, 0xC3, 0xCF, 0x8E, 0x1E,
  0x7C, 0x70, 0xE1, 0xC3, 0x87, 0x00, 0x3C, 0x38, 0x01, 0xC1, 0xC0, 0x0E,
  0x0E, 0x00, 0x70, 0xF0, 0x03, 0x87, 0x00, 0x1C, 0x38, 0x01, 0xE1, 0xC0,
  0x0E, 0x0E, 0x00, 0x70, 0x70, 0x03, 0x87, 0x80, 0x1C, 0x3C, 0x01, 0xE0,
  0x0F, 0x80, 0xF0, 0xF8, 0x0E, 0x0F, 0x80, 0xE1, 0xF8, 0x0E, 0x1F, 0x80,
  0xE1, 0xDC, 0x1E, 0x1D, 0xC1, 0xE1, 0xDC, 0x1C, 0x1D, 0xC1, 0xC3, 0xDC,
  0x1C, 0x3C, 0xE1, 0xC3, 0x8E, 0x3C, 0x38, 0xE3, 0xC3, 0x8E, 0x38, 0x38,
  0xE3, 0x83, 0x87, 0x38, 0x78, 0x73, 0x87, 0x07, 0x38, 0x70, 0x77, 0x87,
  0x07, 0x70, 0x70, 0x3F, 0x07, 0x03, 0xF0, 0xF0, 0x3F, 0x0E, 0x03, 0xF0,
  0xE0, 0x3F, 0x0E, 0x01, 0xE0, 0xE0, 0x1E, 0x00, 0x00, 0xFF, 0x00, 0x7F,
  0xF0, 0x1F, 0xFF, 0x07, 0x81, 0xE0, 0xE0, 0x1C, 0x3C, 0x03, 0xC7, 0x00,
  0x78, 0xE0, 0x0E, 0x1C, 0x01, 0xC7, 0x80, 0x38, 0xF0, 0x07, 0x1C, 0x01,
  0xE3, 0x80, 0x3C, 0x70, 0x07, 0x0E, 0x00, 0xE3, 0xC0, 0x1C, 0x78, 0x03,
  0x8E, 0x00, 0xF1, 0xC0, 0x1E, 0x38, 0x03, 0xC7, 0x00, 0x70, 0xE0, 0x0E,
  0x1C, 0x03, 0xC3, 0xC0, 0xF0, 0x7F, 0xFC, 0x07, 0xFF, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xE1, 0xE0, 0x3E, 0x1E,
  0x00, 0xF1, 0xE0, 0x0F, 0x1C, 0x00, 0xF1, 0xC0, 0x0F, 0x1C, 0x00, 0xF1,
  0xC0, 0x0E, 0x3C, 0x01, 0xE3, 0xC0, 0x3E, 0x38, 0x07, 0xC3, 0xFF, 0xF8,
  0x3F, 0xFF, 0x03, 0xFF, 0x80, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x7F, 0xF0, 0x1F, 0xFF, 0x07, 0x81, 0xE1, 0xE0, 0x1E, 0x38, 0x03, 0xC7,
  0x00, 0x79, 0xE0, 0x0F, 0x3C, 0x01, 0xE7, 0x00, 0x38, 0xE0, 0x07, 0x1C,
  0x00, 0xE3, 0x80, 0x1C, 0xF0, 0x07, 0x9E, 0x00, 0xF3, 0x80, 0x1C, 0x70,
  0x03, 0x8E, 0x00, 0x71, 0xC0, 0x0E, 0x78, 0x03, 0xCF, 0x00, 0x79, 0xE0,
  0x0E, 0x1C, 0x03, 0xC3, 0xC0, 0xF0, 0x7F, 0xFC, 0x07, 0xFF, 0x00, 0x7F,
  0xC0, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC1, 0xE0, 0x3E, 0x1E, 0x01, 0xE1, 0xE0, 0x0E, 0x1C, 0x00, 0xE1,
  0xC0, 0x0E, 0x1C, 0x00, 0xE1, 0xC0, 0x1E, 0x3C, 0x01, 0xC3, 0xC0, 0x3C,
  0x38, 0x1F, 0x83, 0xFF, 0xF0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x78, 0x38,
  0x07, 0x83, 0x80, 0x70, 0x3C, 0x07, 0x03, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xE0, 0xF0, 0x1E, 0x0F, 0x00, 0xE0, 0xF0, 0x0F, 0x0E, 0x00, 0xF0, 0xE0,
  0x07, 0x80, 0x00, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x07, 0x81, 0xF0,
  0xE0, 0x1E, 0x3C, 0x03, 0xC7, 0x00, 0x78, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00,
  0x3F, 0xC0, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0E, 0x00,
  0x01, 0xCE, 0x00, 0x39, 0xC0, 0x0F, 0x3C, 0x01, 0xC7, 0xC0, 0xF8, 0x7F,
  0xFE, 0x07, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0xF0, 0xE0, 0x0E, 0x0E, 0x00, 0xE1, 0xE0, 0x0E, 0x1E, 0x01,
  0xE1, 0xC0, 0x1E, 0x1C, 0x01, 0xE1, 0xC0, 0x1C, 0x1C, 0x01, 0xC3, 0xC0,
  0x1C, 0x3C, 0x01, 0xC3, 0xC0, 0x3C, 0x38, 0x03, 0xC3, 0x80, 0x38, 0x38,
  0x03, 0x83, 0x80, 0x38, 0x78, 0x03, 0x87, 0x80, 0x78, 0x70, 0x07, 0x87,
  0x00, 0x70, 0x70, 0x07, 0x07, 0x00, 0x70, 0x70, 0x0F, 0x07, 0x81, 0xE0,
  0x7F, 0xFC, 0x03, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0xE0, 0x03, 0xF8, 0x00,
  0xEE, 0x00, 0x3B, 0x80, 0x1E, 0xE0, 0x07, 0x38, 0x03, 0xCE, 0x00, 0xE3,
  0xC0, 0x78, 0xF0, 0x1C, 0x3C, 0x07, 0x07, 0x03, 0xC1, 0xC0, 0xE0, 0x70,
  0x78, 0x1C, 0x1C, 0x07, 0x07, 0x01, 0xC3, 0xC0, 0x70, 0xE0, 0x1C, 0x78,
  0x07, 0x9C, 0x01, 0xE7, 0x00, 0x3B, 0x80, 0x0E, 0xE0, 0x03, 0xB8, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x38, 0x3C, 0x1C,
  0xE0, 0xF0, 0xF7, 0x87, 0x83, 0x9E, 0x1E, 0x0E, 0x70, 0x78, 0x39, 0xC3,
  0xE1, 0xC7, 0x0D, 0x87, 0x1C, 0x36, 0x1C, 0x70, 0xD8, 0x71, 0xC7, 0x63,
  0x87, 0x19, 0x8E, 0x1C, 0x66, 0x38, 0x73, 0x98, 0xC1, 0xCC, 0x67, 0x07,
  0x31, 0x9C, 0x1C, 0xC6, 0x70, 0x77, 0x19, 0x81, 0xD8, 0x6E, 0x07, 0x61,
  0xB8, 0x1F, 0x86, 0xE0, 0x7C, 0x1F, 0x01, 0xB0, 0x7C, 0x06, 0xC3, 0xF0,
  0x1F, 0x0F, 0x80, 0xF8, 0x3E, 0x03, 0xE0, 0xF8, 0x0F, 0x83, 0xE0, 0x00,
  0x07, 0x00, 0x1E, 0x0F, 0x00, 0x78, 0x0E, 0x01, 0xE0, 0x1E, 0x03, 0x80,
  0x3C, 0x0F, 0x00, 0x38, 0x3C, 0x00, 0x78, 0x70, 0x00, 0xF1, 0xE0, 0x00,
  0xE7, 0x80, 0x01, 0xEE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0x9C, 0x00, 0x0F, 0x3C, 0x00, 0x3C, 0x38, 0x00, 0x70, 0x78,
  0x01, 0xE0, 0xF0, 0x07, 0x80, 0xE0, 0x1E, 0x01, 0xE0, 0x38, 0x03, 0xC0,
  0xF0, 0x03, 0xC3, 0xC0, 0x07, 0x80, 0xF0, 0x00, 0xFF, 0x00, 0x1E, 0x70,
  0x03, 0xC7, 0x00, 0x38, 0x78, 0x07, 0x83, 0x80, 0x70, 0x38, 0x0E, 0x03,
  0xC1, 0xE0, 0x1C, 0x1C, 0x01, 0xC3, 0x80, 0x1E, 0x78, 0x00, 0xE7, 0x00,
  0x0E, 0xF0, 0x00, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x80, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xFF,
  0xFF, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x1F,
  0xF8, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x7F, 0xC0, 0xFF, 0x83, 0xFE,
  0x00, 0xE0, 0x1E, 0x03, 0xC0, 0x38, 0x07, 0x00, 0xF0, 0x1E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x80, 0xF0, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x3C, 0x07, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xE0, 0x3C,
  0x03, 0x80, 0x03, 0xFE, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x7F, 0xC0, 0xFF, 0x83, 0xFE, 0x00, 0x00, 0x78, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x3B, 0x00, 0x39, 0xC0, 0x1C, 0xE0, 0x1C, 0x30, 0x0E,
  0x1C, 0x0E, 0x0E, 0x0E, 0x07, 0x07, 0x01, 0x87, 0x00, 0xE7, 0x80, 0x77,
  0x80, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0xE0, 0xE1,
  0xE1, 0xE0, 0x00, 0xE0, 0x01, 0xFE, 0x70, 0xFF, 0xDC, 0x7C, 0x37, 0x1E,
  0x05, 0xCF, 0x00, 0xF3, 0x80, 0x3C, 0xE0, 0x0E, 0x38, 0x03, 0x9E, 0x00,
  0xE7, 0x80, 0x39, 0xE0, 0x1E, 0x70, 0x07, 0x9C, 0x01, 0xC7, 0x00, 0x71,
  0xC0, 0x3C, 0x70, 0x0F, 0x1E, 0x07, 0xC7, 0xFF, 0xF0, 0xFF, 0xB8, 0x1F,
  0xCE, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xC3, 0xC0, 0x73, 0xFC, 0x1D, 0xFF, 0x87, 0xE3,
  0xE3, 0xE0, 0x78, 0xF0, 0x0F, 0x3C, 0x03, 0xCE, 0x00, 0xE3, 0x80, 0x38,
  0xE0, 0x0E, 0x78, 0x03, 0x9E, 0x01, 0xE7, 0x00, 0x79, 0xC0, 0x1E, 0x70,
  0x07, 0x1C, 0x01, 0xCF, 0x80, 0xF3, 0xE0, 0x78, 0xFF, 0xFE, 0x3B, 0xFF,
  0x0E, 0x7F, 0x00, 0x00, 0x70, 0x00, 0xFF, 0x80, 0x7F, 0xF8, 0x3E, 0x3E,
  0x1E, 0x03, 0xCF, 0x00, 0xF3, 0x80, 0x3C, 0xE0, 0x00, 0x38, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x79, 0xC0, 0x1C, 0x70, 0x0F, 0x1E, 0x07, 0x87, 0xFF, 0xE0, 0xFF, 0xF0,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0xE1, 0xC0, 0x7F, 0x9C, 0x0F,
  0xFD, 0xC1, 0xF0, 0xDC, 0x1E, 0x05, 0xC3, 0xC0, 0x3C, 0x38, 0x03, 0xC3,
  0x80, 0x38, 0x38, 0x03, 0x87, 0x80, 0x38, 0x78, 0x03, 0x87, 0x80, 0x78,
  0x70, 0x07, 0x87, 0x00, 0x70, 0x70, 0x07, 0x07, 0x00, 0xF0, 0x70, 0x0F,
  0x07, 0x81, 0xF0, 0x7F, 0xFF, 0x03, 0xFE, 0xE0, 0x1F, 0xCE, 0x00, 0x00,
  0x78, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x3C, 0x3E, 0x1E, 0x03, 0x8F, 0x00,
  0xE3, 0x80, 0x38, 0xE0, 0x0E, 0x38, 0x03, 0x9F, 0xFF, 0xE7, 0xFF, 0xF9,
  0xFF, 0xFE, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x0F, 0x1E, 0x03, 0x87, 0xEF, 0xE0, 0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1E, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF8, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x3E, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x07, 0xF9, 0xC7, 0xFE, 0xE7, 0xC3, 0x73, 0xC0,
  0xFB, 0xC0, 0x3D, 0xE0, 0x1E, 0xE0, 0x0E, 0x70, 0x07, 0x38, 0x03, 0xBC,
  0x01, 0xDE, 0x01, 0xEE, 0x00, 0xF7, 0x00, 0x73, 0xC0, 0x79, 0xE0, 0x3C,
  0xF8, 0x6E, 0x3F, 0xFF, 0x0F, 0xF7, 0x81, 0xC3, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0xF8, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xE0, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xC3, 0x80, 0x73, 0xFC, 0x1D, 0xFF, 0x87, 0xC3,
  0xE3, 0xE0, 0x38, 0xF0, 0x0F, 0x3C, 0x03, 0xCE, 0x00, 0xE3, 0x80, 0x38,
  0xE0, 0x0E, 0x78, 0x03, 0x9E, 0x01, 0xE7, 0x00, 0x79, 0xC0, 0x1C, 0x70,
  0x07, 0x1C, 0x01, 0xCF, 0x00, 0x73, 0xC0, 0x3C, 0xF0, 0x0F, 0x38, 0x03,
  0x8E, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x38, 0x07, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x03, 0xFF,
  0x80, 0x7F, 0xF8, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x03, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xC0,
  0x0F, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x11, 0xC0, 0x1E, 0x1C,
  0x03, 0xC1, 0xC0, 0x78, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x1E, 0x03,
  0x83, 0xC0, 0x38, 0x78, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0x00,
  0x78, 0x70, 0x07, 0x07, 0x80, 0x70, 0x38, 0x07, 0x03, 0xC0, 0x70, 0x1C,
  0x0F, 0x01, 0xE0, 0xF0, 0x0E, 0x0E, 0x00, 0xF0, 0xE0, 0x07, 0x80, 0xFF,
  0xC1, 0xFF, 0x03, 0xFE, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x1F, 0xFE, 0x1F, 0xFC,
  0x1F, 0xF8, 0x00, 0xE1, 0x81, 0xDF, 0x3E, 0x1F, 0xF7, 0xE1, 0xC7, 0x8F,
  0x3C, 0x38, 0x73, 0x83, 0x0F, 0x38, 0x70, 0xE3, 0x87, 0x0E, 0x38, 0x70,
  0xE3, 0x87, 0x0E, 0x78, 0x60, 0xE7, 0x06, 0x0E, 0x70, 0xE1, 0xC7, 0x0E,
  0x1C, 0x70, 0xE1, 0xC7, 0x0E, 0x1C, 0x70, 0xE1, 0xCE, 0x0C, 0x1C, 0xE0,
  0xC3, 0xCE, 0x1C, 0x38, 0xE1, 0xC3, 0x80, 0x00, 0x38, 0x07, 0x3F, 0xC1,
  0xDF, 0xF8, 0x7C, 0x3E, 0x3E, 0x03, 0x8F, 0x00, 0xF3, 0xC0, 0x3C, 0xE0,
  0x0E, 0x38, 0x03, 0x8E, 0x00, 0xE7, 0x80, 0x39, 0xE0, 0x1E, 0x70, 0x07,
  0x9C, 0x01, 0xC7, 0x00, 0x71, 0xC0, 0x1C, 0xF0, 0x07, 0x3C, 0x03, 0xCF,
  0x00, 0xF3, 0x80, 0x38, 0xE0, 0x0E, 0x00, 0x00, 0x78, 0x00, 0xFF, 0x80,
  0xFF, 0xF0, 0x3E, 0x3E, 0x1E, 0x07, 0x8F, 0x00, 0xE3, 0x80, 0x3C, 0xE0,
  0x0E, 0x38, 0x03, 0x9E, 0x00, 0xE7, 0x80, 0x39, 0xC0, 0x1E, 0x70, 0x07,
  0x9C, 0x01, 0xE7, 0x00, 0x71, 0xC0, 0x1C, 0x70, 0x0F, 0x1E, 0x07, 0x87,
  0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xF0, 0x00, 0x00, 0x1E, 0x01, 0xCF, 0xF0,
  0x3B, 0xFF, 0x07, 0xE3, 0xE1, 0xF0, 0x3C, 0x3C, 0x03, 0xC7, 0x80, 0x78,
  0xE0, 0x0E, 0x1C, 0x01, 0xC3, 0x80, 0x38, 0xF0, 0x07, 0x1E, 0x01, 0xE3,
  0x80, 0x3C, 0x70, 0x07, 0x8E, 0x00, 0xE1, 0xC0, 0x1C, 0x7C, 0x07, 0x8F,
  0x81, 0xE1, 0xDF, 0xFC, 0x3B, 0xFF, 0x07, 0x3F, 0x80, 0xE0, 0x00, 0x1C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xE0, 0x01, 0xFE, 0x70, 0xFF, 0xDC, 0x7C, 0x37, 0x1E,
  0x07, 0xCF, 0x00, 0xF3, 0x80, 0x38, 0xE0, 0x0E, 0x38, 0x03, 0x9E, 0x00,
  0xE7, 0x80, 0x79, 0xC0, 0x1E, 0x70, 0x07, 0x9C, 0x01, 0xC7, 0x00, 0x71,
  0xC0, 0x3C, 0x70, 0x0F, 0x1E, 0x07, 0xC7, 0xFF, 0xF0, 0xFF, 0xB8, 0x1F,
  0xCE, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x01, 0xDF, 0xE0, 0x7F, 0xFE,
  0x0F, 0xC3, 0xE1, 0xF0, 0x3C, 0x3C, 0x03, 0x87, 0x00, 0x70, 0xE0, 0x0E,
  0x3C, 0x01, 0xC7, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x01, 0xFF, 0xC0,
  0xFF, 0xF8, 0x7C, 0x1E, 0x1C, 0x03, 0xCF, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x1F,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0xF0, 0x07, 0x3C, 0x03, 0xC7,
  0xFF, 0xE1, 0xFF, 0xF0, 0x1F, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x3F,
  0xF8, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x1C, 0x01, 0xC7, 0x00, 0x73, 0xC0,
  0x1C, 0xF0, 0x07, 0x3C, 0x03, 0xCE, 0x00, 0xF3, 0x80, 0x38, 0xE0, 0x0E,
  0x38, 0x03, 0x9E, 0x00, 0xE7, 0x80, 0x79, 0xC0, 0x1E, 0x70, 0x07, 0x1C,
  0x01, 0xC7, 0x00, 0x71, 0xC0, 0x3C, 0x78, 0x1E, 0x1F, 0xFF, 0x03, 0xFF,
  0x80, 0x3F, 0xC0, 0xE0, 0x03, 0xF8, 0x01, 0xEF, 0x00, 0x73, 0xC0, 0x3C,
  0x70, 0x0E, 0x1C, 0x07, 0x87, 0x01, 0xC1, 0xC0, 0xF0, 0x78, 0x38, 0x1E,
  0x0E, 0x03, 0x87, 0x00, 0xE1, 0xC0, 0x38, 0xE0, 0x0E, 0x38, 0x03, 0x9C,
  0x00, 0xF7, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0xE0, 0xE0, 0xFE, 0x1E, 0x0E, 0xE1, 0xE0, 0xEE, 0x1E, 0x1C, 0xE3, 0xE1,
  0xCE, 0x36, 0x1C, 0xE3, 0x61, 0x8E, 0x36, 0x38, 0xE6, 0x63, 0x8E, 0x66,
  0x30, 0xE6, 0x67, 0x0E, 0xC6, 0x70, 0xEC, 0x66, 0x0C, 0xC6, 0xE0, 0xD8,
  0x6E, 0x0D, 0x86, 0xC0, 0xD8, 0x6C, 0x0F, 0x07, 0xC0, 0xF0, 0x78, 0x0F,
  0x07, 0x80, 0x07, 0x00, 0x78, 0x3C, 0x07, 0x80, 0xE0, 0x78, 0x07, 0x87,
  0x80, 0x1C, 0x38, 0x00, 0xF3, 0xC0, 0x03, 0xBC, 0x00, 0x1D, 0xC0, 0x00,
  0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1D, 0xE0,
  0x01, 0xE7, 0x00, 0x1E, 0x3C, 0x01, 0xE0, 0xE0, 0x1E, 0x07, 0x81, 0xE0,
  0x3C, 0x0F, 0x00, 0xF1, 0xF0, 0x07, 0xC0, 0x38, 0x03, 0x9C, 0x01, 0xCE,
  0x00, 0xEF, 0x00, 0x77, 0x80, 0x7B, 0x80, 0x3D, 0xC0, 0x1C, 0xE0, 0x0E,
  0x70, 0x07, 0x78, 0x03, 0xBC, 0x03, 0xDC, 0x01, 0xEE, 0x00, 0xE7, 0x80,
  0xF3, 0xC0, 0xF9, 0xF9, 0xDC, 0x7F, 0xFE, 0x1F, 0xEF, 0x01, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x01, 0xF0, 0x7F, 0xF0,
  0x3F, 0xF0, 0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0xC7, 0xFF, 0xF1, 0xFF, 0xFC,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3F, 0xFF, 0xCF, 0xFF, 0xE3,
  0xFF, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x7F, 0xE0, 0x0F, 0xE0, 0x03, 0xFF, 0x00, 0x00,
  0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x01,
  0xF0, 0x00, 0x03, 0x83, 0xC1, 0xE0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x0F,
  0x07, 0x83, 0x81, 0xC0, 0xE0, 0x70, 0x78, 0x3C, 0x1C, 0x0E, 0x07, 0x03,
  0x83, 0xC1, 0xE0, 0xF0, 0x70, 0x38, 0x1C, 0x0E, 0x0F, 0x07, 0x83, 0x81,
  0xC0, 0xE0, 0x70, 0x78, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xFC, 0x00, 0x1F,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03,
  0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x7F, 0xE0, 0x03,
  0xFC, 0x01, 0xFF, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x7C, 0x00, 0xFF, 0x00,
  0x1F, 0xC0, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0xE3, 0xF8, 0x3C, 0xFF,
  0x07, 0x3C, 0xF0, 0xE7, 0x0F, 0x3C, 0xE0, 0xFF, 0x3C, 0x1F, 0xC7, 0x00,
  0x60,
};

const GFXglyph JetBrainsMono_Italic37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 9, 27, 22, 7, -27 },
  { 32, 12, 11, 22, 7, -27 },
  { 49, 21, 27, 22, 1, -27 },
  { 120, 19, 37, 22, 2, -32 },
  { 208, 25, 27, 22, -1, -27 },
  { 293, 20, 27, 22, 1, -27 },
  { 361, 5, 11, 22, 10, -27 },
  { 368, 15, 36, 22, 6, -31 },
  { 436, 15, 36, 22, 2, -31 },
  { 504, 20, 20, 22, 2, -23 },
  { 554, 18, 17, 22, 2, -21 },
  { 593, 10, 12, 22, 3, -6 },
  { 608, 13, 3, 22, 5, -14 },
  { 613, 6, 6, 22, 7, -6 },
  { 618, 22, 35, 22, 1, -31 },
  { 715, 19, 27, 22, 2, -27 },
  { 780, 17, 27, 22, 2, -27 },
  { 838, 19, 27, 22, 2, -27 },
  { 903, 19, 27, 22, 2, -27 },
  { 968, 18, 27, 22, 2, -27 },
  { 1029, 19, 27, 22, 2, -27 },
  { 1094, 18, 27, 22, 2, -27 },
  { 1155, 17, 27, 22, 5, -27 },
  { 1213, 19, 27, 22, 2, -27 },
  { 1278, 18, 27, 22, 3, -27 },
  { 1339, 9, 21, 22, 7, -21 },
  { 1363, 12, 27, 22, 4, -21 },
  { 1404, 18, 20, 22, 3, -22 },
  { 1449, 17, 12, 22, 3, -18 },
  { 1475, 18, 20, 22, 2, -22 },
  { 1520, 15, 27, 22, 5, -27 },
  { 1571, 22, 34, 22, 0, -27 },
  { 1665, 19, 27, 22, 0, -27 },
  { 1730, 19, 27, 22, 2, -27 },
  { 1795, 19, 27, 22, 2, -27 },
  { 1860, 19, 27, 22, 2, -27 },
  { 1925, 20, 27, 22, 2, -27 },
  { 1993, 20, 27, 22, 2, -27 },
  { 2061, 19, 27, 22, 2, -27 },
  { 2126, 19, 27, 22, 2, -27 },
  { 2191, 19, 27, 22, 2, -27 },
  { 2256, 20, 27, 22, 1, -27 },
  { 2324, 21, 27, 22, 2, -27 },
  { 2395, 16, 27, 22, 3, -27 },
  { 2449, 21, 27, 22, 1, -27 },
  { 2520, 20, 27, 22, 2, -27 },
  { 2588, 19, 27, 22, 2, -27 },
  { 2653, 20, 27, 22, 2, -27 },
  { 2721, 19, 34, 22, 2, -27 },
  { 2802, 20, 27, 22, 2, -27 },
  { 2870, 19, 27, 22, 2, -27 },
  { 2935, 19, 27, 22, 4, -27 },
  { 3000, 20, 27, 22, 2, -27 },
  { 3068, 18, 27, 22, 5, -27 },
  { 3129, 22, 27, 22, 2, -27 },
  { 3204, 23, 27, 22, 0, -27 },
  { 3282, 20, 27, 22, 4, -27 },
  { 3350, 19, 27, 22, 2, -27 },
  { 3415, 15, 35, 22, 5, -31 },
  { 3481, 11, 35, 22, 6, -31 },
  { 3530, 15, 35, 22, 3, -31 },
  { 3596, 17, 14, 22, 3, -27 },
  { 3626, 18, 3, 22, 0, 1 },
  { 3633, 7, 5, 22, 10, -29 },
  { 3638, 18, 21, 22, 2, -21 },
  { 3686, 18, 27, 22, 2, -27 },
  { 3747, 18, 21, 22, 2, -21 },
  { 3795, 20, 27, 22, 2, -27 },
  { 3863, 18, 21, 22, 2, -21 },
  { 3911, 26, 34, 22, -2, -27 },
  { 4022, 17, 28, 22, 3, -21 },
  { 4082, 18, 27, 22, 2, -27 },
  { 4143, 18, 29, 22, 1, -29 },
  { 4209, 20, 36, 22, 0, -29 },
  { 4299, 20, 27, 22, 2, -27 },
  { 4367, 15, 27, 22, 4, -27 },
  { 4418, 20, 21, 22, 1, -21 },
  { 4471, 18, 21, 22, 2, -21 },
  { 4519, 18, 21, 22, 2, -21 },
  { 4567, 19, 28, 22, 1, -21 },
  { 4634, 18, 28, 22, 2, -21 },
  { 4697, 19, 21, 22, 2, -21 },
  { 4747, 18, 21, 22, 2, -21 },
  { 4795, 18, 26, 22, 3, -26 },
  { 4854, 18, 20, 22, 2, -20 },
  { 4899, 18, 20, 22, 4, -20 },
  { 4944, 20, 20, 22, 3, -20 },
  { 4994, 21, 20, 22, 0, -20 },
  { 5047, 17, 27, 22, 3, -20 },
  { 5105, 18, 20, 22, 2, -20 },
  { 5150, 19, 35, 22, 3, -31 },
  { 5234, 9, 35, 22, 7, -31 },
  { 5274, 19, 35, 22, 1, -31 },
  { 5358, 19, 8, 22, 2, -17 },
};

const GFXfont JetBrainsMono_Italic37pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Italic37pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Italic37pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _JETBRAINSMONO_ITALIC37PT7B_H_
