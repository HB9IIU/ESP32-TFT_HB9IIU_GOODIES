#ifndef _JETBRAINSMONO_ITALIC71PT7B_H_
#define _JETBRAINSMONO_ITALIC71PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Italic.ttf
// Size: 71pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Italic71pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x01, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F,
  0xF0, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x7F, 0x1F, 0x80, 0x7F, 0x3F, 0x80,
  0x7F, 0x3F, 0x80, 0x7F, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x80,
  0xFE, 0x3F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFC, 0x7F, 0x00,
  0xFC, 0x7F, 0x00, 0xFC, 0x7E, 0x01, 0xFC, 0x7E, 0x01, 0xFC, 0x7E, 0x01,
  0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7C, 0x01, 0xF8, 0xFC, 0x01,
  0xF8, 0xFC, 0x01, 0xF0, 0xFC, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xF0, 0x01,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0xFC, 0x00,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x00,
  0x07, 0xE0, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x03, 0xF0, 0x00, 0x01, 0xF0,
  0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x80,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x07, 0xC0,
  0x00, 0x07, 0xE0, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x7E, 0x00,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFD,
  0xEF, 0xFC, 0x00, 0x7F, 0x87, 0x8F, 0xF0, 0x01, 0xFC, 0x3E, 0x1F, 0xE0,
  0x0F, 0xE0, 0xF8, 0x3F, 0x80, 0x3F, 0x03, 0xC0, 0xFE, 0x01, 0xFC, 0x0F,
  0x01, 0xF8, 0x07, 0xE0, 0x3C, 0x07, 0xE0, 0x1F, 0x80, 0xF0, 0x1F, 0x80,
  0xFE, 0x07, 0xC0, 0x80, 0x03, 0xF8, 0x1F, 0x00, 0x00, 0x0F, 0xE0, 0x78,
  0x00, 0x00, 0x3F, 0x81, 0xE0, 0x00, 0x00, 0xFF, 0x07, 0x80, 0x00, 0x01,
  0xFC, 0x1E, 0x00, 0x00, 0x07, 0xF8, 0x78, 0x00, 0x00, 0x1F, 0xF3, 0xE0,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x79, 0xFF,
  0x80, 0x00, 0x01, 0xE1, 0xFE, 0x00, 0x00, 0x0F, 0x83, 0xF8, 0x00, 0x00,
  0x3E, 0x0F, 0xF0, 0x00, 0x00, 0xF0, 0x1F, 0xC0, 0x00, 0x03, 0xC0, 0x7F,
  0x00, 0x00, 0x0F, 0x01, 0xFC, 0x00, 0x00, 0x3C, 0x07, 0xF0, 0x01, 0x00,
  0xF0, 0x1F, 0xC1, 0xF8, 0x07, 0xC0, 0x7E, 0x07, 0xE0, 0x1E, 0x01, 0xF8,
  0x1F, 0xC0, 0x78, 0x0F, 0xE0, 0x7F, 0x01, 0xE0, 0x3F, 0x01, 0xFC, 0x07,
  0x81, 0xFC, 0x07, 0xF8, 0x1E, 0x0F, 0xE0, 0x0F, 0xF0, 0xF8, 0xFF, 0x80,
  0x3F, 0xF3, 0xEF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x07,
  0xFF, 0x80, 0x00, 0x1F, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0x80, 0x0F,
  0xFF, 0xF8, 0x00, 0x0F, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0x80, 0x07,
  0xE0, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x1F, 0x80, 0x0F, 0x80, 0x03,
  0xF0, 0x0F, 0xC0, 0x0F, 0xC0, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x00,
  0x7E, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x7C, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x3F, 0x07, 0xE0, 0x00,
  0x07, 0xC0, 0x1F, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x0F, 0x83, 0xE0, 0x00,
  0x01, 0xF8, 0x0F, 0xC3, 0xE0, 0x00, 0x00, 0xFE, 0x1F, 0xC3, 0xE0, 0x00,
  0x00, 0x3F, 0xFF, 0xC3, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xE3, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0xC3, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC1, 0xF0, 0x00,
  0x00, 0x00, 0x0C, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x7F,
  0xFC, 0x00, 0x00, 0x00, 0xF8, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0xFC, 0x7F,
  0xFF, 0xC0, 0x00, 0x00, 0xFC, 0x7F, 0xDF, 0xE0, 0x00, 0x00, 0x7C, 0x3F,
  0x01, 0xF8, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x1F,
  0x00, 0x7E, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x3F, 0x00, 0x00, 0x7E, 0x07,
  0xC0, 0x1F, 0x80, 0x00, 0x7E, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x3E, 0x03,
  0xF0, 0x07, 0xC0, 0x00, 0x3E, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0xF8, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x3E, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0xFE, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x1F, 0xC0,
  0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x07, 0xF0, 0xFE, 0x3F, 0x80, 0x1F, 0xC3, 0xF8, 0x3F, 0x80,
  0x3F, 0x07, 0xE0, 0x7F, 0x00, 0xFE, 0x1F, 0xC0, 0x7F, 0x03, 0xF8, 0x3F,
  0x00, 0xFE, 0x07, 0xE0, 0x7E, 0x00, 0xFE, 0x1F, 0x80, 0xFC, 0x00, 0xFE,
  0x7F, 0x01, 0xF8, 0x01, 0xFD, 0xFC, 0x07, 0xF0, 0x01, 0xFF, 0xF0, 0x0F,
  0xE0, 0x03, 0xFF, 0xE0, 0x1F, 0x80, 0x03, 0xFF, 0x80, 0x3F, 0x00, 0x07,
  0xFE, 0x00, 0x7E, 0x00, 0x07, 0xF8, 0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x03,
  0xF8, 0x00, 0x1F, 0xE0, 0x07, 0xF0, 0x00, 0x3F, 0xE0, 0x0F, 0xE0, 0x00,
  0xFF, 0xC0, 0x1F, 0xC0, 0x03, 0xFF, 0xC0, 0x3F, 0xC0, 0x1F, 0xFF, 0x80,
  0x3F, 0xC0, 0xFF, 0xBF, 0x80, 0x7F, 0xFF, 0xFE, 0x7F, 0x00, 0x7F, 0xFF,
  0xF8, 0x7F, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0x00, 0xFF, 0xFF, 0x00, 0xFE,
  0x00, 0x7F, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF,
  0xE7, 0xE3, 0xF1, 0xF9, 0xFC, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC0, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x0E, 0x00, 0x1F, 0x00, 0x0C, 0x7E, 0x00, 0xF8, 0x03,
  0xF7, 0xFC, 0x07, 0x80, 0xFF, 0xBF, 0xF8, 0x3C, 0x1F, 0xFF, 0xFF, 0xE1,
  0xE3, 0xFF, 0xFF, 0xFF, 0xCE, 0x7F, 0xFF, 0x3F, 0xFF, 0x77, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x3E, 0xF8, 0x00, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x00, 0x3F, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x03, 0xF8,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x0F, 0xC3, 0xFE, 0x7F, 0xF7, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xE7, 0xFC, 0x7F, 0x80, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xE0,
  0x0F, 0xF0, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00,
  0x7F, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x00, 0x7F, 0x07, 0xF0,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0xFE, 0x00, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x00,
  0x7E, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x7E, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x0F, 0xE1,
  0xF8, 0x0F, 0x80, 0xFC, 0x1F, 0x81, 0xFC, 0x0F, 0xC1, 0xF8, 0x3F, 0xC0,
  0xFC, 0x1F, 0x83, 0xFE, 0x0F, 0xC1, 0xF8, 0x3F, 0xE0, 0xFC, 0x3F, 0x83,
  0xFC, 0x1F, 0xC3, 0xF0, 0x1F, 0xC1, 0xFC, 0x3F, 0x00, 0xF8, 0x1F, 0x83,
  0xF0, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x01,
  0xF8, 0x7F, 0x00, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x03, 0xF8, 0x7E, 0x00,
  0x00, 0x3F, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x7E, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x7F, 0x00,
  0x01, 0xFC, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x07, 0xF8, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xCF, 0xC0,
  0x00, 0xFF, 0xCF, 0xE0, 0x00, 0xFF, 0x87, 0xF0, 0x00, 0xFF, 0x83, 0xF0,
  0x00, 0x7F, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x7E,
  0x00, 0x1E, 0x00, 0x7F, 0x00, 0x0C, 0x00, 0x3F, 0x80, 0x04, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xC1, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x00, 0xFC, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x3F, 0x00, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x01, 0xFC, 0x1F,
  0xC0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x80, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0xFC,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x7F, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x03, 0xFC, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0xC0, 0x7F,
  0xC0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x01, 0xF8, 0x03, 0xF8, 0x00, 0x7E,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x03,
  0xF0, 0x1F, 0xC0, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x3F, 0x07, 0xF0, 0x00,
  0x0F, 0xC3, 0xF8, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x01, 0xFC, 0x3F, 0x00,
  0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x07, 0xE1, 0xFF,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x01,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x83, 0xFE, 0x00, 0x07, 0xF1,
  0xFF, 0xF0, 0x00, 0xFC, 0xFF, 0xFF, 0x80, 0x1F, 0xBF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xF8, 0x03, 0xFE,
  0x03, 0xFE, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x03, 0xFC, 0x0F, 0xE0, 0x00,
  0x3F, 0x81, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x1F, 0x80,
  0x00, 0x3F, 0x83, 0xF0, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x01, 0xFC, 0x0F,
  0xE0, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x01,
  0xFD, 0xFF, 0xF0, 0x00, 0x7F, 0x7F, 0xFF, 0x80, 0x1F, 0xDF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x3F, 0xF0, 0x01,
  0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x01, 0xFC, 0x3F, 0x80,
  0x00, 0x3F, 0x87, 0xF0, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x00, 0x7F, 0x3F,
  0x80, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x3F,
  0x3F, 0x80, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00,
  0x3F, 0x9F, 0x80, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x00, 0xFC, 0x7F, 0x00,
  0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x01, 0xFC, 0x1F,
  0xC0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x07, 0xF8,
  0x07, 0xFE, 0x07, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xE7, 0xE0, 0x00, 0x03,
  0xF9, 0xF8, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00,
  0x1F, 0x8F, 0xE0, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x03, 0xF0, 0xFC, 0x00,
  0x01, 0xFC, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x0F, 0xF0, 0x01, 0xFE,
  0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0xFE, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x3F, 0x80, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x3F,
  0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x00, 0xFE,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x3F, 0x80, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x0F,
  0xE0, 0x1F, 0xE0, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F,
  0xF1, 0xFF, 0x80, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x0F, 0xE0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x00,
  0x7F, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x00, 0x3F, 0x07, 0xF0,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x7E, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00,
  0x7E, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x01, 0xFC, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x07, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xE0, 0x03,
  0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0x0F, 0xE3, 0xFC, 0x00,
  0x03, 0xF8, 0xFE, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x1F, 0xDF, 0xC0,
  0x00, 0x07, 0xF7, 0xE0, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x01, 0xFB,
  0xF8, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x0F,
  0xCF, 0xE0, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00,
  0xFE, 0x1F, 0xE0, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x7F, 0xC1, 0xFF, 0x80,
  0x7F, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0xFC, 0x00, 0xFF,
  0xFF, 0x7F, 0x00, 0x1F, 0xFF, 0xBF, 0x80, 0x01, 0xFF, 0x9F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF8,
  0x3F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFE, 0x01, 0xFE, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x3F,
  0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x00,
  0xFF, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x06, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xBF, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0x00,
  0x3E, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x00, 0x00, 0xF8,
  0x0F, 0x80, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x7F, 0xC7, 0xE0, 0x7E,
  0x00, 0x3F, 0xFC, 0xFC, 0x0F, 0xC0, 0x0F, 0xFF, 0xDF, 0x81, 0xF8, 0x03,
  0xFF, 0xFB, 0xE0, 0x3E, 0x00, 0x7F, 0x03, 0xFC, 0x07, 0xC0, 0x1F, 0xC0,
  0x3F, 0x81, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x00, 0x7E,
  0x07, 0xE0, 0x1F, 0x80, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x01, 0xF8, 0x1F,
  0x00, 0x7C, 0x00, 0x3E, 0x03, 0xE0, 0x1F, 0x80, 0x0F, 0xC0, 0xFC, 0x03,
  0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x7E, 0x00, 0x3F, 0x03, 0xF0, 0x0F, 0xC0,
  0x07, 0xE0, 0x7E, 0x01, 0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x3E, 0x00, 0x1F,
  0x01, 0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x7E, 0x01, 0xF8, 0x00, 0xFC, 0x0F,
  0xC0, 0x3F, 0x00, 0x1F, 0x81, 0xF8, 0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x00,
  0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x1F, 0x80, 0x1F, 0x80, 0xF8, 0x03, 0xF0,
  0x07, 0xF0, 0x1F, 0x00, 0x7F, 0x01, 0xFE, 0x07, 0xE0, 0x0F, 0xFD, 0xF7,
  0xC0, 0xFC, 0x00, 0xFF, 0xFE, 0xF8, 0x1F, 0x80, 0x0F, 0xFF, 0x9F, 0x03,
  0xF0, 0x00, 0xFF, 0xE7, 0xE0, 0x7E, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xBE, 0x00, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00,
  0x03, 0xF3, 0xF0, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x07, 0xF3, 0xF0,
  0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00, 0xFC,
  0x3F, 0x00, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x00,
  0x1F, 0x81, 0xF0, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x00, 0x3F, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x1F, 0x80, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00,
  0xFC, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x01, 0xF8, 0x01, 0xF8,
  0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00,
  0x0F, 0xC0, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x3F, 0x00, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x7E,
  0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00,
  0x07, 0xE3, 0xF8, 0x00, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0x07, 0xF7, 0xF0,
  0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xF0, 0x00, 0xFF, 0xC0, 0x1F, 0x80, 0x01,
  0xFE, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0x3F, 0xC0, 0x7E,
  0x00, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0x3F,
  0x80, 0xFC, 0x00, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x7F, 0x00,
  0x00, 0x7E, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0xFC, 0x00, 0x03, 0xF8, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x03,
  0xF8, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFC, 0x00,
  0x1F, 0xF0, 0x07, 0xE0, 0x00, 0x3F, 0xC0, 0x3F, 0x00, 0x00, 0xFE, 0x01,
  0xF8, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00,
  0xFE, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x00, 0x7F,
  0x07, 0xF0, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x01, 0xFE, 0x03,
  0xF0, 0x00, 0x1F, 0xE0, 0x1F, 0x80, 0x03, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xF0, 0x7F, 0xF0, 0x0F, 0xF0, 0x01, 0xFE,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00,
  0x3F, 0x83, 0xF8, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x00, 0xFE, 0x1F, 0xC0,
  0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0xFE,
  0x1F, 0xC0, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00,
  0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x0F, 0xF0, 0x1F, 0xE0,
  0x03, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3D, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x03, 0xF0, 0x01, 0xFF, 0x80, 0x3F, 0x80, 0x03, 0xFC, 0x01,
  0xFC, 0x00, 0x0F, 0xF0, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x01,
  0xFC, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x00, 0x7E,
  0x03, 0xF0, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0xFC, 0x00,
  0x01, 0xFC, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x00, 0x7E, 0x03,
  0xF8, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x01,
  0xFC, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x00, 0x7E, 0x03, 0xF8,
  0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x00, 0xFC,
  0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x00, 0x7F, 0x01, 0xF8, 0x00,
  0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x00, 0xFC, 0x07,
  0xF0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x03,
  0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x00, 0xFC, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x07, 0xF0,
  0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x03, 0xF8, 0x03, 0xF0, 0x00,
  0x7F, 0xC0, 0x3F, 0x80, 0x0F, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xF0, 0x7F, 0xF0, 0x0F, 0xF0, 0x01, 0xFE,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00,
  0x3F, 0x83, 0xF8, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x00, 0xFE, 0x1F, 0xC0,
  0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x7F, 0xFF, 0xC3, 0xF0, 0x0F, 0xFF, 0xF8, 0x7E, 0x03, 0xFF, 0xFE,
  0x0F, 0xC0, 0x7F, 0xFF, 0xC1, 0xF8, 0x0F, 0xFF, 0xF8, 0x7F, 0x00, 0x00,
  0x3F, 0x0F, 0xE0, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x01, 0xFC, 0x3F, 0x00,
  0x00, 0x3F, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0xFC, 0x3F,
  0x80, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0xFE,
  0x1F, 0xC0, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00,
  0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x0F, 0xF0, 0x1F, 0xE0,
  0x03, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3D, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x7E,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x7F, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x7F,
  0x00, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x07, 0xE0, 0x00, 0x0F,
  0xE0, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x03, 0xF8,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x7E, 0x00,
  0x00, 0xFC, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x0F,
  0xE0, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0x7E, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00,
  0x1F, 0xE0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xFC, 0x03, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x00, 0x1F,
  0xE0, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8,
  0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x01,
  0xFE, 0x00, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x01, 0xF8,
  0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x1F, 0x80, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x7E, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x1F, 0x80,
  0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x07,
  0xFE, 0x01, 0xF7, 0xC0, 0x07, 0xDE, 0x01, 0xF7, 0xC0, 0x0F, 0xDE, 0x01,
  0xF7, 0xC0, 0x0F, 0xBE, 0x01, 0xF7, 0xC0, 0x1F, 0xBE, 0x01, 0xF7, 0xC0,
  0x1F, 0x3E, 0x01, 0xF3, 0xE0, 0x3F, 0x3E, 0x01, 0xF3, 0xE0, 0x3E, 0x7C,
  0x03, 0xF3, 0xE0, 0x3E, 0x7C, 0x03, 0xE3, 0xE0, 0x7C, 0x7C, 0x03, 0xE3,
  0xE0, 0x7C, 0x7C, 0x03, 0xE3, 0xE0, 0xF8, 0xFC, 0x03, 0xE1, 0xF0, 0xF8,
  0xFC, 0x03, 0xE1, 0xF1, 0xF0, 0xF8, 0x07, 0xE1, 0xF1, 0xF0, 0xF8, 0x07,
  0xE1, 0xF3, 0xF1, 0xF8, 0x07, 0xE1, 0xF3, 0xE1, 0xF8, 0x07, 0xE1, 0xF3,
  0xE1, 0xF8, 0x07, 0xE0, 0xF7, 0xC1, 0xF8, 0x07, 0xE0, 0xFF, 0xC3, 0xF0,
  0x0F, 0xE0, 0xFF, 0x83, 0xF0, 0x0F, 0xC0, 0xFF, 0x83, 0xF0, 0x0F, 0xC0,
  0xFF, 0x03, 0xF0, 0x0F, 0xC0, 0xFF, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x07,
  0xF0, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x1F,
  0xC0, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x00, 0x0F, 0xE0,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x3F, 0x80,
  0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x1F,
  0xC0, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x7F,
  0x00, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x3F, 0x80,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFC, 0x03, 0xFE, 0x00, 0x03,
  0xF0, 0x0F, 0xF8, 0x00, 0x0F, 0xC0, 0x3F, 0xF0, 0x00, 0x3F, 0x00, 0xFF,
  0xC0, 0x01, 0xFC, 0x03, 0xFF, 0x00, 0x07, 0xF0, 0x1F, 0xFC, 0x00, 0x1F,
  0x80, 0x7F, 0xF0, 0x00, 0x7E, 0x01, 0xFF, 0xE0, 0x01, 0xF8, 0x07, 0xFF,
  0x80, 0x07, 0xE0, 0x1F, 0xFE, 0x00, 0x3F, 0x80, 0x7C, 0xF8, 0x00, 0xFE,
  0x01, 0xF3, 0xE0, 0x03, 0xF0, 0x0F, 0xCF, 0xC0, 0x0F, 0xC0, 0x3F, 0x3F,
  0x00, 0x3F, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0x03, 0xF1, 0xF0, 0x03, 0xF0,
  0x0F, 0xC7, 0xC0, 0x1F, 0xC0, 0x3F, 0x1F, 0x80, 0x7E, 0x01, 0xFC, 0x7E,
  0x01, 0xF8, 0x07, 0xE1, 0xF8, 0x07, 0xE0, 0x1F, 0x83, 0xE0, 0x1F, 0x80,
  0x7E, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x3F, 0x03, 0xF8, 0x07, 0xE0, 0xFC,
  0x0F, 0xC0, 0x3F, 0x83, 0xF0, 0x3F, 0x00, 0xFE, 0x07, 0xC0, 0xFC, 0x03,
  0xF0, 0x1F, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x3F, 0x01, 0xF8,
  0x7F, 0x00, 0xFC, 0x07, 0xE1, 0xFC, 0x03, 0xF0, 0x0F, 0x87, 0xE0, 0x1F,
  0xC0, 0x3E, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x7E, 0x01, 0xF8, 0x03, 0xF1,
  0xF8, 0x07, 0xE0, 0x0F, 0xC7, 0xE0, 0x1F, 0x80, 0x1F, 0x1F, 0x80, 0x7E,
  0x00, 0x7C, 0xFC, 0x03, 0xF8, 0x01, 0xFB, 0xF0, 0x0F, 0xC0, 0x07, 0xEF,
  0xC0, 0x3F, 0x00, 0x1F, 0xBF, 0x00, 0xFC, 0x00, 0x3E, 0xFC, 0x03, 0xF0,
  0x00, 0xFB, 0xF0, 0x0F, 0xC0, 0x03, 0xFF, 0x80, 0x7F, 0x00, 0x0F, 0xFE,
  0x01, 0xF8, 0x00, 0x3F, 0xF8, 0x07, 0xE0, 0x00, 0x7F, 0xE0, 0x1F, 0x80,
  0x01, 0xFF, 0x80, 0x7E, 0x00, 0x07, 0xFE, 0x01, 0xF8, 0x00, 0x1F, 0xF8,
  0x0F, 0xE0, 0x00, 0x7F, 0xC0, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x0F, 0xF0, 0x03, 0xFE, 0x03, 0xFC, 0x00,
  0x1F, 0xC0, 0x7F, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x3F, 0x03, 0xF8,
  0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x1F, 0x83,
  0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00,
  0x0F, 0xE1, 0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x87,
  0xF0, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x1F,
  0x83, 0xF0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00,
  0x1F, 0xC1, 0xF8, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0x7F, 0x0F, 0xE0,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x3F,
  0x87, 0xF0, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x00,
  0x3F, 0x83, 0xF8, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x01, 0xFC, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0xFE, 0x00, 0x0F, 0xE0, 0x1F, 0xE0, 0x03, 0xFC, 0x03,
  0xFF, 0x03, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0x00, 0x03, 0xFF, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x07, 0xE0, 0x00, 0x03,
  0xF8, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x3F,
  0x00, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x00,
  0x7F, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x0F,
  0xC0, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0xFE, 0x00, 0x00, 0xFF, 0x01, 0xF8, 0x00, 0x03, 0xFC, 0x03,
  0xF0, 0x00, 0x0F, 0xF8, 0x07, 0xE0, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x0F, 0xF0, 0x01, 0xFE, 0x01, 0xFE, 0x00,
  0x0F, 0xE0, 0x3F, 0xC0, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x3F,
  0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x00, 0x7F,
  0x07, 0xE0, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0xFE, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0xFE,
  0x1F, 0xC0, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x01, 0xFC,
  0x3F, 0x80, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00,
  0x1F, 0x83, 0xF0, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0x3F, 0x87, 0xF0,
  0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x7E, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x00,
  0x7F, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0xFE, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x7F, 0xC0, 0x07, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xC0, 0x01, 0xFF, 0x80, 0x7F, 0x00, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x7E,
  0x00, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x07,
  0xF0, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x7F, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x00, 0x3F,
  0x80, 0xFC, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x7E, 0x00, 0x01, 0xFE, 0x01, 0xF8, 0x00, 0x1F, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x0F,
  0xE0, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x3F,
  0x00, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x00, 0xFE, 0x01, 0xF8,
  0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x00, 0x7E, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x00, 0x20,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x40, 0x00, 0x07, 0xF0, 0x7E,
  0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x03,
  0xF8, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x00, 0x7F, 0x01, 0xFE,
  0x00, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x0F, 0xFE, 0x03, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x7F, 0x00,
  0x00, 0x7E, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0x3F, 0x80,
  0xFC, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x00,
  0x7E, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0xFC,
  0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x00, 0x7E,
  0x03, 0xF8, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0x01, 0xFC, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x00, 0x7F, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x00,
  0xFC, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x7F, 0x01, 0xF8,
  0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x00, 0xFC,
  0x07, 0xF0, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x00, 0x3F, 0x01, 0xF8, 0x00,
  0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x00, 0xFE, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x01,
  0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x00, 0xFE, 0x03, 0xF0,
  0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x01, 0xF8,
  0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00,
  0x07, 0xE0, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0xC0, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x0F, 0xEF,
  0xE0, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x0F,
  0xE7, 0xF0, 0x00, 0x01, 0xF8, 0xFE, 0x00, 0x00, 0x7F, 0x0F, 0xC0, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x00, 0x7E, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x00, 0x7E, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x03, 0xF0, 0x0F, 0xE0, 0x00, 0xFE,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x1F, 0x80, 0x03, 0xF0, 0x03, 0xF0, 0x00,
  0xFE, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x03, 0xF8, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0xFC, 0x07,
  0xE0, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x7E,
  0x07, 0xE0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00,
  0x3F, 0x0F, 0xE0, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x00, 0x7E, 0x3F, 0x00,
  0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x3F, 0x3E,
  0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0x9F,
  0x80, 0x1F, 0xC0, 0x0F, 0xCF, 0xC0, 0x1F, 0xE0, 0x0F, 0xC7, 0xE0, 0x0F,
  0xF0, 0x07, 0xE3, 0xF0, 0x07, 0xF8, 0x03, 0xF1, 0xF8, 0x03, 0xFC, 0x01,
  0xF0, 0xFC, 0x03, 0xDE, 0x01, 0xF8, 0x7C, 0x01, 0xEF, 0x00, 0xFC, 0x3E,
  0x00, 0xF7, 0x80, 0x7E, 0x3F, 0x00, 0xFB, 0x80, 0x3E, 0x1F, 0x80, 0x7B,
  0xC0, 0x3F, 0x0F, 0xC0, 0x3D, 0xE0, 0x1F, 0x87, 0xE0, 0x1E, 0xF0, 0x0F,
  0xC3, 0xF0, 0x1E, 0x78, 0x07, 0xC1, 0xF8, 0x0F, 0x3C, 0x07, 0xE0, 0xFC,
  0x07, 0x9E, 0x03, 0xF0, 0x7E, 0x07, 0xCF, 0x01, 0xF0, 0x3F, 0x03, 0xC7,
  0x80, 0xF8, 0x1F, 0x81, 0xE3, 0xC0, 0xFC, 0x0F, 0xC0, 0xF1, 0xE0, 0x7E,
  0x07, 0xE0, 0xF0, 0xF0, 0x3E, 0x03, 0xF0, 0x78, 0x78, 0x3F, 0x01, 0xF8,
  0x3C, 0x3C, 0x1F, 0x80, 0xFC, 0x3E, 0x1E, 0x0F, 0x80, 0x7C, 0x1E, 0x0F,
  0x07, 0xC0, 0x3E, 0x0F, 0x07, 0x87, 0xE0, 0x1F, 0x07, 0x83, 0xC3, 0xF0,
  0x0F, 0x87, 0xC1, 0xE1, 0xF0, 0x07, 0xC3, 0xC0, 0xF0, 0xF8, 0x03, 0xE1,
  0xE0, 0x78, 0xFC, 0x01, 0xF1, 0xF0, 0x3C, 0x7E, 0x01, 0xF8, 0xF0, 0x3E,
  0x3E, 0x00, 0xFC, 0x78, 0x1E, 0x1F, 0x00, 0x7E, 0x3C, 0x0F, 0x1F, 0x80,
  0x3F, 0x3E, 0x07, 0x8F, 0x80, 0x1F, 0x9E, 0x03, 0xC7, 0xC0, 0x0F, 0xCF,
  0x01, 0xE7, 0xE0, 0x07, 0xEF, 0x80, 0xF3, 0xF0, 0x03, 0xF7, 0x80, 0x79,
  0xF0, 0x01, 0xFB, 0xC0, 0x3C, 0xF8, 0x00, 0xFD, 0xE0, 0x1E, 0xFC, 0x00,
  0x7D, 0xF0, 0x0F, 0x7E, 0x00, 0x3E, 0xF0, 0x07, 0xBE, 0x00, 0x1F, 0x78,
  0x03, 0xDF, 0x00, 0x0F, 0xBC, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x83, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC7, 0xF0, 0x00,
  0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xBF, 0x00, 0x00, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x00,
  0x1F, 0xC7, 0xE0, 0x00, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0xFC,
  0x00, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x7F, 0x00, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x01, 0xFC, 0x3F, 0x80,
  0x00, 0x07, 0xE3, 0xF8, 0x00, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x01, 0xFD,
  0xFC, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFE, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03,
  0xEF, 0x80, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x0F,
  0x87, 0xC0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x3F,
  0x03, 0xE0, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0xFC,
  0x01, 0xF0, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0,
  0x00, 0xF8, 0x03, 0xE0, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0xF8, 0x0F, 0xC0,
  0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x7C, 0x3F, 0x00,
  0x00, 0x7E, 0x3F, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x3E, 0xFE, 0x00,
  0x00, 0x3F, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFE, 0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x00,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0xFC, 0x00, 0xFF, 0xFE, 0x1F, 0x80, 0x3F, 0xFF, 0xE7, 0xF0, 0x0F,
  0xFF, 0xFE, 0xFE, 0x03, 0xFF, 0xFF, 0xDF, 0x80, 0xFF, 0xC0, 0x7B, 0xF0,
  0x1F, 0xE0, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x07,
  0xF8, 0x3F, 0x80, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0xFC, 0x00,
  0x01, 0xF8, 0x3F, 0x80, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x07, 0xF0,
  0x7E, 0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x03,
  0xF0, 0x7F, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x1F, 0xC1, 0xF8, 0x00,
  0x03, 0xF8, 0x3F, 0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x0F, 0xC1, 0xFC,
  0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0xFE, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x0F,
  0xE0, 0x7F, 0x80, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0xDF, 0x80, 0xFF, 0x80,
  0x7F, 0xF0, 0x1F, 0xFF, 0xFE, 0xFE, 0x01, 0xFF, 0xFF, 0xDF, 0xC0, 0x1F,
  0xFF, 0xF3, 0xF0, 0x01, 0xFF, 0xFC, 0x7E, 0x00, 0x1F, 0xFE, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x7E, 0x00, 0x03, 0xF0, 0x7F, 0xF0, 0x00, 0xFE, 0x3F, 0xFF, 0x80, 0x1F,
  0xCF, 0xFF, 0xF8, 0x03, 0xF3, 0xFF, 0xFF, 0x80, 0x7E, 0xFF, 0xFF, 0xF0,
  0x0F, 0xDE, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x01,
  0xFC, 0x0F, 0xF0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x03, 0xF0, 0x3F, 0x80,
  0x00, 0x7E, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x01, 0xF8, 0x3F,
  0x80, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x00, 0xFC,
  0x1F, 0x80, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x00,
  0xFC, 0x1F, 0xC0, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x03, 0xF0, 0x7F, 0x00,
  0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x03, 0xF8, 0x3F,
  0x00, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x01, 0xF8,
  0x3F, 0x80, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x01,
  0xF8, 0x1F, 0xE0, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0xFF, 0xC0,
  0x07, 0xF8, 0x1F, 0xFE, 0x03, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7E,
  0x7F, 0xFF, 0xF0, 0x0F, 0xCF, 0xFF, 0xF8, 0x01, 0xF8, 0xFF, 0xFE, 0x00,
  0x7F, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F,
  0xE0, 0x3F, 0xF0, 0x1F, 0xE0, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0x83,
  0xF8, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0xFE,
  0x1F, 0x80, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00, 0xFC,
  0x3F, 0x80, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x0F,
  0xE0, 0x7F, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x03, 0xFC, 0x07, 0xFE, 0x03,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x7E, 0x00, 0x07, 0xFF, 0x83, 0xF0, 0x00, 0xFF, 0xFE,
  0x1F, 0x80, 0x0F, 0xFF, 0xF9, 0xFC, 0x00, 0xFF, 0xFF, 0xEF, 0xE0, 0x0F,
  0xFF, 0xFF, 0x7F, 0x00, 0xFF, 0xC0, 0x7B, 0xF0, 0x07, 0xF8, 0x00, 0xFF,
  0x80, 0x7F, 0x80, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x3F, 0x80,
  0x00, 0xFF, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0xFE, 0x00, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00,
  0x7F, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x7E,
  0x00, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x00, 0x3F,
  0x01, 0xFC, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x7E, 0x00,
  0x00, 0xFE, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x00, 0x3F, 0x01,
  0xFC, 0x00, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00,
  0xFE, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0xFE,
  0x00, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x03, 0x7E,
  0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFF, 0xFF, 0xBF, 0x80, 0x1F, 0xFF,
  0xFD, 0xFC, 0x00, 0x7F, 0xFF, 0xCF, 0xC0, 0x01, 0xFF, 0xFC, 0x7E, 0x00,
  0x07, 0xFF, 0x83, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xF0, 0x07, 0xF8, 0x0F, 0xE0, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0x07,
  0xE0, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x07, 0xE1,
  0xF8, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0xFC,
  0x7E, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x3F, 0x1F, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFF, 0xF1, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00,
  0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x1F, 0xF0, 0x07, 0xF8, 0x07, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0x83, 0xF0, 0x03, 0xFF, 0xF8, 0xFC, 0x03, 0xFF, 0xFE, 0x7F, 0x01,
  0xFF, 0xFF, 0xDF, 0xC0, 0xFF, 0xFF, 0xF7, 0xE0, 0x7F, 0xE0, 0x3F, 0xF8,
  0x1F, 0xE0, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x1F,
  0xE1, 0xFC, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0xFE, 0x1F, 0x80, 0x00,
  0x3F, 0x0F, 0xE0, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x03, 0xF0, 0xFE, 0x00,
  0x00, 0xFC, 0x3F, 0x00, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x1F, 0xC3, 0xF0,
  0x00, 0x07, 0xE1, 0xFC, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x00, 0x7E, 0x1F,
  0xC0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x03, 0xF8,
  0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1F,
  0xC1, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x01,
  0xFF, 0x07, 0xF8, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFD, 0xF8, 0x07, 0xFF, 0xFE, 0x7E, 0x00, 0xFF, 0xFF, 0x1F, 0x80, 0x1F,
  0xFF, 0x8F, 0xE0, 0x03, 0xFF, 0x83, 0xF8, 0x00, 0x0E, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x7E,
  0x00, 0x03, 0xF0, 0x7F, 0xF0, 0x00, 0xFE, 0x3F, 0xFF, 0x80, 0x1F, 0xCF,
  0xFF, 0xF8, 0x03, 0xF3, 0xFF, 0xFF, 0x80, 0x7E, 0xFF, 0xFF, 0xF0, 0x0F,
  0xDE, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x01, 0xFC,
  0x0F, 0xF0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00,
  0x7F, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x80,
  0x00, 0x3F, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x01, 0xFC, 0x1F,
  0x80, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x00, 0xFC,
  0x1F, 0xC0, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x00,
  0xFE, 0x0F, 0xC0, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x03, 0xF8, 0x3F, 0x00,
  0x00, 0x7E, 0x07, 0xE0, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x01, 0xF8, 0x3F,
  0x80, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x01, 0xFC,
  0x1F, 0x80, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x00,
  0xFC, 0x1F, 0xC0, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x07, 0xF0, 0x7E, 0x00,
  0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x03, 0xF0, 0x7F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xF0, 0x3F, 0x00, 0x00, 0x7F,
  0x01, 0xFC, 0x00, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x1F, 0x80,
  0x00, 0xFF, 0x00, 0x7E, 0x00, 0x07, 0xF8, 0x01, 0xF8, 0x00, 0x1F, 0xC0,
  0x07, 0xE0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x3F, 0xC0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x0F, 0xC0, 0x0F, 0xF0, 0x00,
  0x3F, 0x00, 0x7F, 0x80, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x0F,
  0xE0, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x01, 0xFC,
  0x00, 0x03, 0xF0, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x01, 0xF8,
  0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x0F, 0xC0,
  0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x00, 0x3F, 0xC0, 0x7F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x70, 0x03, 0x80, 0x0F, 0x8F, 0xF0, 0x7F, 0x80, 0x7E, 0x7F, 0xE3,
  0xFF, 0x01, 0xFB, 0xFF, 0x9F, 0xFE, 0x07, 0xEF, 0xFF, 0x7F, 0xF8, 0x1F,
  0xE1, 0xFF, 0x8F, 0xF0, 0x7F, 0x03, 0xF8, 0x1F, 0xC1, 0xF8, 0x0F, 0xC0,
  0x3F, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0xFC,
  0x03, 0xE0, 0x0F, 0x83, 0xF0, 0x0F, 0x80, 0x7E, 0x0F, 0xC0, 0x3E, 0x01,
  0xF8, 0x3F, 0x00, 0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xE0, 0x1F, 0x87, 0xE0,
  0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7C, 0x01, 0xF8, 0x7E, 0x01, 0xF0, 0x0F,
  0xC1, 0xF8, 0x07, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x1F, 0x80,
  0x7C, 0x03, 0xF0, 0xFC, 0x01, 0xF0, 0x0F, 0xC3, 0xF0, 0x0F, 0xC0, 0x3F,
  0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x3F, 0x00, 0xF8, 0x07, 0xE0, 0xFC, 0x03,
  0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0x80, 0x7E, 0x0F, 0x80, 0x3E, 0x01, 0xF8,
  0x7E, 0x01, 0xF8, 0x07, 0xE1, 0xF8, 0x07, 0xC0, 0x1F, 0x07, 0xE0, 0x1F,
  0x00, 0xFC, 0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x7E, 0x01, 0xF0, 0x0F, 0xC1,
  0xF8, 0x07, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xF8,
  0x03, 0xF0, 0xFC, 0x03, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0x80, 0x7E, 0x0F,
  0xC0, 0x3E, 0x01, 0xF8, 0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x7F, 0x07, 0xFF, 0x00, 0x0F, 0xE3, 0xFF, 0xF8, 0x01, 0xFC,
  0xFF, 0xFF, 0x80, 0x3F, 0x3F, 0xFF, 0xF8, 0x07, 0xEF, 0xFF, 0xFF, 0x00,
  0xFD, 0xE0, 0x1F, 0xF0, 0x1F, 0xF0, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x1F,
  0xC0, 0xFF, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x3F, 0x83, 0xF8, 0x00,
  0x07, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF8,
  0x00, 0x03, 0xF0, 0x7F, 0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x1F, 0xC1,
  0xF8, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x0F,
  0xC1, 0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00, 0x3F, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0xFC, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x83, 0xF0,
  0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x1F, 0x83,
  0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x1F,
  0xC1, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x00,
  0x0F, 0xC1, 0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00, 0x7F, 0x07, 0xE0,
  0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x07,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x01,
  0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x3F, 0x87, 0xF0, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x03, 0xF1, 0xFC, 0x00,
  0x01, 0xF8, 0xFE, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x7E, 0x3F, 0x00,
  0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0x1F, 0xCF, 0xE0,
  0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x03, 0xF1, 0xF8,
  0x00, 0x01, 0xF8, 0xFC, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x00, 0xFE, 0x7F,
  0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x1F, 0x8F,
  0xE0, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x07, 0xE1,
  0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x07, 0xF8,
  0x1F, 0xF8, 0x0F, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xF0, 0x7F, 0xF8, 0x00, 0x3F, 0x8F, 0xFF, 0xE0, 0x01, 0xFC, 0xFF, 0xFF,
  0x80, 0x0F, 0xCF, 0xFF, 0xFE, 0x00, 0x7E, 0xFF, 0xFF, 0xF0, 0x03, 0xF7,
  0x80, 0xFF, 0xC0, 0x1F, 0xF0, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0x07, 0xF0,
  0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x00, 0xFC, 0x03, 0xF8, 0x00,
  0x07, 0xE0, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x0F,
  0xE0, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x03,
  0xF0, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x01, 0xFC, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x03, 0xF0,
  0x1F, 0xC0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00,
  0x0F, 0xE0, 0x3F, 0x00, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x1F,
  0xC0, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x3F, 0x80, 0x00, 0x7E, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x0F, 0xF0,
  0x00, 0x7F, 0x00, 0xFF, 0xC0, 0x07, 0xF8, 0x07, 0xFF, 0x80, 0xFF, 0x80,
  0x3F, 0x7F, 0xFF, 0xF8, 0x01, 0xF9, 0xFF, 0xFF, 0xC0, 0x0F, 0xC7, 0xFF,
  0xFC, 0x00, 0x7E, 0x3F, 0xFF, 0x80, 0x07, 0xF0, 0x7F, 0xF0, 0x00, 0x3F,
  0x80, 0x78, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0xFC, 0x00, 0xFF, 0xFE,
  0x3F, 0x80, 0x3F, 0xFF, 0xE7, 0xF0, 0x0F, 0xFF, 0xFE, 0xFE, 0x03, 0xFF,
  0xFF, 0xDF, 0x80, 0xFF, 0xC0, 0x7B, 0xF0, 0x1F, 0xE0, 0x03, 0x7E, 0x07,
  0xF0, 0x00, 0x7F, 0xC0, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x00, 0xFF,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00,
  0x3F, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x01, 0xFC, 0x1F, 0x80,
  0x00, 0x3F, 0x83, 0xF0, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0xFC, 0x1F,
  0xC0, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0xFE,
  0x0F, 0xC0, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x00,
  0x7E, 0x0F, 0xE0, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x80,
  0x00, 0x7F, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x01, 0xFC, 0x1F,
  0xC0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x03, 0xFC,
  0x0F, 0xF8, 0x01, 0xDF, 0x80, 0xFF, 0x80, 0x7B, 0xF0, 0x1F, 0xFF, 0xFE,
  0xFE, 0x01, 0xFF, 0xFF, 0xDF, 0x80, 0x1F, 0xFF, 0xF3, 0xF0, 0x01, 0xFF,
  0xF8, 0x7E, 0x00, 0x1F, 0xFE, 0x0F, 0xC0, 0x00, 0x7C, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0xFF,
  0x00, 0x0F, 0xC7, 0xFF, 0xF0, 0x01, 0xF9, 0xFF, 0xFF, 0x00, 0x7F, 0x7F,
  0xFF, 0xF0, 0x0F, 0xDF, 0xFF, 0xFF, 0x01, 0xFB, 0xC0, 0x3F, 0xE0, 0x3F,
  0xE0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x03, 0xF8,
  0x3F, 0xC0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00,
  0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x07, 0xF0, 0x7E, 0x00,
  0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0xFE, 0x07, 0xF0, 0x00,
  0x1F, 0xC1, 0xF8, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x0F, 0xE3, 0xF8,
  0x00, 0x03, 0xF8, 0xFE, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0xFF, 0x07,
  0xFC, 0x00, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xE0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x00, 0xFC,
  0x1F, 0x80, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x00,
  0xFE, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x03, 0xF0, 0x7F, 0x00,
  0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xF8, 0x3F,
  0x00, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x01, 0xF8,
  0x3F, 0x80, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x01,
  0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x07, 0xF0, 0x7E, 0x00,
  0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x03, 0xF0, 0x7E,
  0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x03, 0xF8,
  0x3F, 0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x01,
  0xF8, 0x3F, 0x80, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0xFE, 0x00,
  0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x3F,
  0xC0, 0x0F, 0xF0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xDF, 0x80, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x01, 0xF9, 0xF8,
  0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x1F, 0xC7,
  0xF0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x00, 0xFC,
  0x0F, 0xC0, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x0F,
  0xE0, 0x3F, 0x80, 0x03, 0xF0, 0x07, 0xE0, 0x01, 0xFC, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x3F, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0xFC, 0x07, 0xE0, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x01, 0xF8, 0x3F, 0x00,
  0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x07, 0xE3, 0xF8,
  0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x0F, 0xDF,
  0x80, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xF8, 0x01, 0xF8, 0x00,
  0xFF, 0xC0, 0x0F, 0xC0, 0x0F, 0xFE, 0x00, 0xFE, 0x00, 0x7D, 0xF0, 0x07,
  0xF0, 0x03, 0xEF, 0x80, 0x3F, 0x80, 0x3F, 0x7C, 0x03, 0xFC, 0x01, 0xF3,
  0xE0, 0x1F, 0xE0, 0x0F, 0x9F, 0x00, 0xFF, 0x00, 0xFC, 0xF8, 0x0F, 0x78,
  0x07, 0xC7, 0xC0, 0x7B, 0xC0, 0x3E, 0x3E, 0x03, 0xDE, 0x01, 0xF1, 0xF0,
  0x3C, 0xF0, 0x1F, 0x0F, 0x81, 0xE7, 0x80, 0xF8, 0x7C, 0x0F, 0x3C, 0x07,
  0xC3, 0xE0, 0x79, 0xE0, 0x7C, 0x1F, 0x07, 0x8F, 0x03, 0xE0, 0xF8, 0x3C,
  0x78, 0x1F, 0x07, 0xC1, 0xE3, 0xC1, 0xF0, 0x3E, 0x1E, 0x1E, 0x0F, 0x81,
  0xF0, 0xF0, 0xF0, 0x7C, 0x0F, 0x87, 0x87, 0x87, 0xE0, 0x7C, 0x78, 0x3C,
  0x3E, 0x03, 0xE3, 0xC1, 0xE1, 0xF0, 0x1F, 0x1E, 0x0F, 0x0F, 0x80, 0xF9,
  0xE0, 0x78, 0xF8, 0x07, 0xCF, 0x03, 0xC7, 0xC0, 0x3E, 0x78, 0x1E, 0x3E,
  0x01, 0xF7, 0x80, 0xF3, 0xE0, 0x0F, 0x3C, 0x07, 0x9F, 0x00, 0x79, 0xE0,
  0x3C, 0xF8, 0x03, 0xDE, 0x01, 0xEF, 0x80, 0x1E, 0xF0, 0x0F, 0x7C, 0x00,
  0xF7, 0x80, 0x7B, 0xE0, 0x07, 0xB8, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x1F,
  0xF0, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x07, 0xF8, 0x00, 0x7F,
  0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0xFE, 0x00, 0x00, 0x07, 0xE1, 0xFE, 0x00, 0x00, 0x07, 0xF1,
  0xFC, 0x00, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x00, 0x0F, 0xEF,
  0xE0, 0x00, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x00, 0x3F, 0x87, 0xF0, 0x00,
  0x00, 0x7F, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x0F, 0xE0, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x01,
  0xFC, 0x3F, 0x00, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x1F, 0xC3, 0xF0, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x00, 0x7E, 0x1F, 0xC0,
  0x00, 0x1F, 0x87, 0xE0, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x03, 0xF8, 0x7E,
  0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x0F, 0xC3,
  0xF8, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x00, 0x7F,
  0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x01,
  0xF8, 0x7F, 0x00, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x3F, 0x87, 0xE0, 0x00,
  0x0F, 0xE1, 0xF8, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x80,
  0x00, 0x7F, 0x07, 0xF0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x0F, 0xF0, 0x7F,
  0x80, 0x07, 0xFC, 0x1F, 0xF0, 0x07, 0xFF, 0x03, 0xFF, 0x07, 0xDF, 0x80,
  0xFF, 0xFF, 0xF7, 0xE0, 0x1F, 0xFF, 0xF9, 0xF8, 0x03, 0xFF, 0xFC, 0x7E,
  0x00, 0x7F, 0xFC, 0x3F, 0x80, 0x07, 0xFC, 0x0F, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x03, 0xF0, 0x3F, 0xFC, 0x00, 0x3F, 0x0F, 0xFF, 0xE0, 0x07,
  0xF1, 0xFF, 0xFE, 0x00, 0x7E, 0x1F, 0xFF, 0xF0, 0x07, 0xE3, 0xF8, 0x7F,
  0x80, 0x7E, 0x3F, 0x03, 0xF8, 0x07, 0xE7, 0xF0, 0x1F, 0xC0, 0xFC, 0x7E,
  0x00, 0xFE, 0x1F, 0xC7, 0xE0, 0x0F, 0xFF, 0xF8, 0x7E, 0x00, 0x7F, 0xFF,
  0x87, 0xE0, 0x03, 0xFF, 0xF0, 0x7E, 0x00, 0x1F, 0xFC, 0x0F, 0xC0, 0x00,
  0x7F, 0x80,
};

const GFXglyph JetBrainsMono_Italic71pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 43, 0, -1 },
  { 1, 17, 52, 43, 13, -52 },
  { 112, 24, 21, 43, 13, -52 },
  { 175, 41, 52, 43, 2, -52 },
  { 442, 38, 72, 43, 3, -62 },
  { 784, 49, 52, 43, -2, -52 },
  { 1103, 39, 54, 43, 2, -53 },
  { 1367, 9, 21, 43, 20, -52 },
  { 1391, 30, 69, 43, 11, -60 },
  { 1650, 29, 69, 43, 4, -60 },
  { 1901, 37, 36, 43, 4, -43 },
  { 2068, 34, 33, 43, 5, -40 },
  { 2209, 18, 22, 43, 7, -11 },
  { 2259, 24, 5, 43, 10, -26 },
  { 2274, 12, 12, 43, 13, -11 },
  { 2292, 42, 67, 43, 1, -59 },
  { 2644, 36, 54, 43, 4, -53 },
  { 2887, 33, 52, 43, 3, -52 },
  { 3102, 37, 53, 43, 3, -53 },
  { 3348, 37, 53, 43, 3, -52 },
  { 3594, 34, 52, 43, 4, -52 },
  { 3815, 35, 53, 43, 5, -52 },
  { 4047, 35, 53, 43, 3, -52 },
  { 4279, 34, 52, 43, 9, -52 },
  { 4500, 36, 54, 43, 4, -53 },
  { 4743, 34, 53, 43, 7, -53 },
  { 4969, 17, 41, 43, 13, -40 },
  { 5057, 23, 51, 43, 7, -40 },
  { 5204, 34, 37, 43, 6, -42 },
  { 5362, 34, 23, 43, 5, -35 },
  { 5460, 34, 37, 43, 4, -42 },
  { 5618, 29, 52, 43, 10, -52 },
  { 5807, 43, 66, 43, 0, -53 },
  { 6162, 36, 52, 43, 0, -52 },
  { 6396, 37, 52, 43, 3, -52 },
  { 6637, 35, 54, 43, 5, -53 },
  { 6874, 37, 52, 43, 3, -52 },
  { 7115, 38, 52, 43, 4, -52 },
  { 7362, 38, 52, 43, 4, -52 },
  { 7609, 35, 54, 43, 5, -53 },
  { 7846, 38, 52, 43, 3, -52 },
  { 8093, 36, 52, 43, 4, -52 },
  { 8327, 39, 53, 43, 1, -52 },
  { 8586, 41, 52, 43, 3, -52 },
  { 8853, 31, 52, 43, 5, -52 },
  { 9055, 40, 52, 43, 2, -52 },
  { 9315, 38, 52, 43, 3, -52 },
  { 9562, 35, 54, 43, 5, -53 },
  { 9799, 39, 52, 43, 3, -52 },
  { 10053, 36, 66, 43, 4, -53 },
  { 10350, 38, 52, 43, 3, -52 },
  { 10597, 38, 54, 43, 3, -53 },
  { 10854, 36, 52, 43, 8, -52 },
  { 11088, 37, 53, 43, 4, -52 },
  { 11334, 35, 52, 43, 9, -52 },
  { 11562, 41, 52, 43, 5, -52 },
  { 11829, 44, 52, 43, 0, -52 },
  { 12115, 37, 52, 43, 8, -52 },
  { 12356, 38, 52, 43, 3, -52 },
  { 12603, 28, 67, 43, 10, -59 },
  { 12838, 22, 67, 43, 11, -59 },
  { 13023, 28, 67, 43, 6, -59 },
  { 13258, 32, 28, 43, 6, -52 },
  { 13370, 35, 5, 43, 0, 2 },
  { 13392, 13, 10, 43, 19, -56 },
  { 13409, 35, 41, 43, 4, -40 },
  { 13589, 35, 53, 43, 3, -52 },
  { 13821, 34, 41, 43, 5, -40 },
  { 13996, 37, 53, 43, 4, -52 },
  { 14242, 33, 41, 43, 5, -40 },
  { 14412, 48, 65, 43, -3, -52 },
  { 14802, 34, 53, 43, 5, -40 },
  { 15028, 35, 52, 43, 3, -52 },
  { 15256, 34, 55, 43, 3, -55 },
  { 15490, 37, 68, 43, 1, -55 },
  { 15805, 38, 52, 43, 4, -52 },
  { 16052, 30, 52, 43, 7, -52 },
  { 16247, 38, 40, 43, 2, -40 },
  { 16437, 35, 40, 43, 3, -40 },
  { 16612, 33, 41, 43, 5, -40 },
  { 16782, 37, 53, 43, 1, -40 },
  { 17028, 35, 53, 43, 4, -40 },
  { 17260, 35, 40, 43, 5, -40 },
  { 17435, 34, 41, 43, 4, -40 },
  { 17610, 34, 50, 43, 6, -50 },
  { 17823, 35, 40, 43, 4, -39 },
  { 17998, 34, 39, 43, 7, -39 },
  { 18164, 37, 39, 43, 6, -39 },
  { 18345, 40, 39, 43, 1, -39 },
  { 18540, 34, 52, 43, 5, -39 },
  { 18761, 35, 39, 43, 3, -39 },
  { 18932, 36, 67, 43, 7, -59 },
  { 19234, 17, 67, 43, 14, -59 },
  { 19377, 36, 67, 43, 2, -59 },
  { 19679, 36, 14, 43, 4, -32 },
};

const GFXfont JetBrainsMono_Italic71pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Italic71pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Italic71pt7bGlyphs,
  0x20, 0x7E, 94
};

#endif // _JETBRAINSMONO_ITALIC71PT7B_H_
