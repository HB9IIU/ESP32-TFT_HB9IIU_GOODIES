#ifndef _JETBRAINSMONO_ITALIC10PT7B_H_
#define _JETBRAINSMONO_ITALIC10PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Italic.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Italic10pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x88, 0xB6, 0x80, 0x34, 0xA7, 0xD2, 0xF9, 0x49, 0x00, 0x10,
  0x43, 0x95, 0x70, 0xE2, 0x9A, 0x70, 0x80, 0x77, 0x51, 0xC0, 0x83, 0xCA,
  0xA6, 0x00, 0x39, 0x02, 0x19, 0x9A, 0x46, 0x80, 0xE0, 0x34, 0x88, 0x88,
  0x88, 0x40, 0x62, 0x12, 0x22, 0x24, 0x80, 0x25, 0x5C, 0xC9, 0x00, 0x21,
  0x3E, 0x84, 0x00, 0x6A, 0x40, 0xF0, 0xB0, 0x04, 0x20, 0x84, 0x10, 0x82,
  0x10, 0x80, 0x74, 0x63, 0x69, 0x4B, 0x80, 0x3A, 0x84, 0x21, 0x0B, 0xE0,
  0x39, 0x10, 0x86, 0x31, 0x0F, 0x80, 0x3C, 0x43, 0x02, 0x09, 0x27, 0x00,
  0x12, 0x49, 0xF1, 0x10, 0x7C, 0x3D, 0x21, 0x4B, 0x80, 0x19, 0x0C, 0x94,
  0xA5, 0xC0, 0xFC, 0x84, 0x42, 0x23, 0x00, 0x74, 0x54, 0xC9, 0x4B, 0x80,
  0x74, 0x63, 0xE2, 0x13, 0x00, 0x70, 0x20, 0x2C, 0x06, 0xA4, 0x0B, 0xA1,
  0x83, 0x00, 0xF0, 0xF0, 0x86, 0x13, 0xC0, 0x71, 0x16, 0x40, 0xC0, 0x3D,
  0x15, 0xE9, 0xA6, 0xA9, 0x20, 0x60, 0x11, 0x4A, 0x97, 0xA6, 0x20, 0x39,
  0x14, 0x9E, 0x49, 0x2F, 0x00, 0x74, 0x61, 0x08, 0x4B, 0x80, 0x79, 0x14,
  0x92, 0x49, 0x2F, 0x00, 0x7C, 0x21, 0xE8, 0x43, 0xC0, 0x7C, 0x21, 0xE8,
  0x42, 0x00, 0x74, 0x61, 0x69, 0x4B, 0x80, 0x65, 0x14, 0x9E, 0x49, 0x2C,
  0x80, 0x79, 0x08, 0x44, 0x23, 0xC0, 0x1C, 0x20, 0x82, 0x0A, 0x27, 0x00,
  0x65, 0x25, 0x1C, 0x51, 0x2C, 0x80, 0x44, 0x88, 0x88, 0xF0, 0x6D, 0xB7,
  0x56, 0x4A, 0x28, 0x80, 0x65, 0x96, 0x96, 0x59, 0x69, 0x80, 0x74, 0x65,
  0x29, 0x4B, 0x80, 0x3D, 0x14, 0x5E, 0x41, 0x0C, 0x00, 0x74, 0x63, 0x29,
  0x4B, 0x84, 0x30, 0x3D, 0x14, 0x5E, 0x51, 0x2C, 0x80, 0x39, 0x16, 0x0E,
  0x09, 0x27, 0x00, 0xF9, 0x08, 0x44, 0x21, 0x00, 0xCC, 0x65, 0x29, 0x4B,
  0x80, 0x8C, 0x64, 0xA6, 0x31, 0x00, 0xAD, 0x7B, 0xDB, 0x5A, 0xC0, 0x64,
  0xA3, 0x0C, 0x31, 0x28, 0x80, 0x8A, 0x94, 0xC4, 0x21, 0x00, 0x7C, 0x21,
  0x08, 0x21, 0x0F, 0x80, 0x32, 0x44, 0x44, 0x44, 0xE0, 0x92, 0x44, 0x92,
  0x20, 0x71, 0x22, 0x22, 0x22, 0xC0, 0x25, 0x99, 0xF8, 0xC0, 0x6C, 0xA5,
  0x29, 0x78, 0x62, 0x9A, 0x94, 0xA7, 0xC0, 0x2D, 0x88, 0x9E, 0x0B, 0x65,
  0x29, 0x4B, 0xC0, 0x69, 0x9E, 0x9E, 0x1C, 0x47, 0xC8, 0x20, 0x82, 0x08,
  0xC0, 0x6C, 0xA5, 0x2B, 0x28, 0x5C, 0x62, 0x9A, 0x94, 0xA7, 0x20, 0x18,
  0x9C, 0x21, 0x08, 0x9F, 0x08, 0x4E, 0x90, 0x88, 0x42, 0x17, 0x00, 0xC4,
  0x65, 0x4E, 0x52, 0x40, 0xE4, 0x44, 0x44, 0x70, 0x69, 0x55, 0x5A, 0xAA,
  0xA0, 0x53, 0x52, 0x94, 0xE4, 0x2D, 0x99, 0x9E, 0x53, 0x52, 0x94, 0xDA,
  0x10, 0x6C, 0xA5, 0x29, 0x78, 0x44, 0xB6, 0xE5, 0x08, 0x40, 0x69, 0x87,
  0x1E, 0x27, 0xD0, 0x84, 0x21, 0xC0, 0x8C, 0xA5, 0x29, 0x70, 0x8C, 0xA5,
  0x46, 0x20, 0xAD, 0x7B, 0xEB, 0x50, 0x44, 0xA3, 0x0C, 0x53, 0x20, 0x8C,
  0xA5, 0x2B, 0x28, 0x5C, 0x78, 0x44, 0x44, 0x7C, 0x19, 0x08, 0x4C, 0x10,
  0x88, 0x30, 0x55, 0x6A, 0x80, 0x30, 0x84, 0x41, 0x90, 0x84, 0xC0, 0x4D,
  0x84,
};

const GFXglyph JetBrainsMono_Italic10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 2, 7, 6, 2, -7 },
  { 3, 3, 3, 6, 2, -7 },
  { 5, 6, 7, 6, 0, -7 },
  { 11, 6, 10, 6, 0, -9 },
  { 19, 7, 7, 6, 0, -7 },
  { 26, 6, 7, 6, 0, -7 },
  { 32, 1, 3, 6, 3, -7 },
  { 33, 4, 9, 6, 2, -8 },
  { 38, 4, 9, 6, 1, -8 },
  { 43, 5, 5, 6, 1, -6 },
  { 47, 5, 5, 6, 1, -6 },
  { 51, 3, 4, 6, 1, -2 },
  { 53, 4, 1, 6, 1, -4 },
  { 54, 2, 2, 6, 2, -2 },
  { 55, 6, 9, 6, 0, -8 },
  { 62, 5, 7, 6, 1, -7 },
  { 67, 5, 7, 6, 0, -7 },
  { 72, 6, 7, 6, 0, -7 },
  { 78, 6, 7, 6, 0, -7 },
  { 84, 4, 7, 6, 1, -7 },
  { 88, 5, 7, 6, 1, -7 },
  { 93, 5, 7, 6, 0, -7 },
  { 98, 5, 7, 6, 1, -7 },
  { 103, 5, 7, 6, 1, -7 },
  { 108, 5, 7, 6, 1, -7 },
  { 113, 2, 6, 6, 2, -6 },
  { 115, 3, 8, 6, 1, -6 },
  { 118, 5, 5, 6, 1, -6 },
  { 122, 4, 3, 6, 1, -5 },
  { 124, 4, 5, 6, 1, -6 },
  { 127, 4, 7, 6, 1, -7 },
  { 131, 6, 9, 6, 0, -7 },
  { 138, 5, 7, 6, 0, -7 },
  { 143, 6, 7, 6, 0, -7 },
  { 149, 5, 7, 6, 1, -7 },
  { 154, 6, 7, 6, 0, -7 },
  { 160, 5, 7, 6, 1, -7 },
  { 165, 5, 7, 6, 1, -7 },
  { 170, 5, 7, 6, 1, -7 },
  { 175, 6, 7, 6, 0, -7 },
  { 181, 5, 7, 6, 1, -7 },
  { 186, 6, 7, 6, 0, -7 },
  { 192, 6, 7, 6, 0, -7 },
  { 198, 4, 7, 6, 1, -7 },
  { 202, 6, 7, 6, 0, -7 },
  { 208, 6, 7, 6, 0, -7 },
  { 214, 5, 7, 6, 1, -7 },
  { 219, 6, 7, 6, 0, -7 },
  { 225, 5, 9, 6, 1, -7 },
  { 231, 6, 7, 6, 0, -7 },
  { 237, 6, 7, 6, 0, -7 },
  { 243, 5, 7, 6, 1, -7 },
  { 248, 5, 7, 6, 1, -7 },
  { 253, 5, 7, 6, 1, -7 },
  { 258, 5, 7, 6, 1, -7 },
  { 263, 6, 7, 6, 0, -7 },
  { 269, 5, 7, 6, 1, -7 },
  { 274, 6, 7, 6, 0, -7 },
  { 280, 4, 9, 6, 1, -8 },
  { 285, 3, 9, 6, 2, -8 },
  { 289, 4, 9, 6, 1, -8 },
  { 294, 4, 4, 6, 1, -7 },
  { 296, 5, 1, 6, 0, 0 },
  { 297, 1, 2, 6, 3, -8 },
  { 298, 5, 6, 6, 1, -6 },
  { 302, 5, 7, 6, 0, -7 },
  { 307, 4, 6, 6, 1, -6 },
  { 310, 5, 7, 6, 1, -7 },
  { 315, 4, 6, 6, 1, -6 },
  { 318, 6, 9, 6, 0, -7 },
  { 325, 5, 8, 6, 1, -6 },
  { 330, 5, 7, 6, 0, -7 },
  { 335, 5, 8, 6, 0, -8 },
  { 340, 5, 10, 6, 0, -8 },
  { 347, 5, 7, 6, 1, -7 },
  { 352, 4, 7, 6, 1, -7 },
  { 356, 6, 6, 6, 0, -6 },
  { 361, 5, 6, 6, 0, -6 },
  { 365, 4, 6, 6, 1, -6 },
  { 368, 5, 8, 6, 0, -6 },
  { 373, 5, 8, 6, 1, -6 },
  { 378, 5, 6, 6, 1, -6 },
  { 382, 4, 6, 6, 1, -6 },
  { 385, 5, 7, 6, 1, -7 },
  { 390, 5, 6, 6, 1, -6 },
  { 394, 5, 6, 6, 1, -6 },
  { 398, 5, 6, 6, 1, -6 },
  { 402, 6, 6, 6, 0, -6 },
  { 407, 5, 8, 6, 1, -6 },
  { 412, 5, 6, 6, 0, -6 },
  { 416, 5, 9, 6, 1, -8 },
  { 422, 2, 9, 6, 2, -8 },
  { 425, 5, 9, 6, 0, -8 },
  { 431, 5, 3, 6, 1, -5 },
};

const GFXfont JetBrainsMono_Italic10pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Italic10pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Italic10pt7bGlyphs,
  0x20, 0x7E, 13
};

#endif // _JETBRAINSMONO_ITALIC10PT7B_H_
