#ifndef _JETBRAINSMONO_ITALIC14PT7B_H_
#define _JETBRAINSMONO_ITALIC14PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Italic.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Italic14pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0x24, 0x90, 0x98, 0x99, 0x9B, 0x09, 0x11, 0x12, 0x7F, 0x22,
  0x24, 0xFE, 0x44, 0x48, 0x48, 0x08, 0x10, 0xF2, 0x95, 0x0A, 0x1E, 0x0E,
  0x15, 0x2A, 0xB7, 0xC2, 0x04, 0x00, 0x78, 0xA4, 0x92, 0x8E, 0x80, 0x80,
  0x90, 0x74, 0x52, 0x49, 0x47, 0x00, 0x1E, 0x22, 0x20, 0x30, 0x30, 0x5B,
  0x4A, 0x44, 0xCC, 0x72, 0xFA, 0x04, 0x63, 0x08, 0x61, 0x04, 0x10, 0x43,
  0x04, 0x10, 0x30, 0x40, 0x21, 0x86, 0x10, 0x84, 0x21, 0x18, 0x84, 0x4C,
  0x40, 0x18, 0x22, 0x4F, 0xF1, 0x07, 0x33, 0x24, 0x10, 0x20, 0x47, 0xF1,
  0x06, 0x08, 0x00, 0x36, 0x4C, 0xF8, 0x6C, 0x01, 0x80, 0x80, 0x80, 0x40,
  0x40, 0x60, 0x20, 0x30, 0x10, 0x18, 0x08, 0x0C, 0x04, 0x06, 0x00, 0x3C,
  0x8D, 0x0A, 0x3D, 0x72, 0xA1, 0x42, 0x8C, 0xF0, 0x39, 0xA4, 0x86, 0x18,
  0x41, 0x04, 0x13, 0xF0, 0x3C, 0x8D, 0x08, 0x20, 0xC3, 0x0C, 0x30, 0xC1,
  0xF8, 0x7E, 0x08, 0x61, 0x83, 0xC0, 0x81, 0x42, 0x8D, 0xF0, 0x06, 0x10,
  0x41, 0x06, 0x58, 0xA1, 0x7E, 0x0C, 0x10, 0x7E, 0x81, 0x02, 0xC6, 0xC0,
  0x81, 0x02, 0x8C, 0xF0, 0x0C, 0x43, 0x18, 0x7F, 0x18, 0x61, 0x8D, 0xE0,
  0xFF, 0x08, 0x20, 0x41, 0x06, 0x08, 0x30, 0x41, 0x80, 0x3C, 0x8D, 0x1A,
  0x23, 0x8D, 0xA1, 0x42, 0x8C, 0xF0, 0x3C, 0x8D, 0x0E, 0x1C, 0x4F, 0x82,
  0x08, 0x30, 0xC0, 0x37, 0x00, 0x00, 0x66, 0x19, 0xC0, 0x00, 0x00, 0xC4,
  0x66, 0x00, 0x06, 0x39, 0x84, 0x06, 0x03, 0x01, 0x00, 0x7F, 0x00, 0x07,
  0xEF, 0xC0, 0x40, 0xC0, 0xC1, 0x19, 0x88, 0x00, 0x78, 0x20, 0x82, 0x19,
  0x84, 0x00, 0x43, 0x00, 0x1F, 0x21, 0x41, 0x47, 0x49, 0x59, 0x51, 0xD3,
  0x9E, 0x80, 0xC0, 0x78, 0x18, 0x0C, 0x18, 0x50, 0xA3, 0x64, 0xCF, 0xA1,
  0x43, 0x84, 0x7C, 0x8D, 0x0A, 0x27, 0x99, 0xA1, 0x42, 0x8D, 0xF0, 0x3C,
  0x8D, 0x0A, 0x0C, 0x18, 0x20, 0x42, 0xCC, 0xF0, 0x7C, 0x8D, 0x1A, 0x34,
  0x58, 0xA1, 0x42, 0x89, 0xE0, 0x7E, 0x81, 0x02, 0x07, 0xD8, 0x30, 0x40,
  0x81, 0xF8, 0x7E, 0x81, 0x02, 0x07, 0xD8, 0x30, 0x40, 0x81, 0x00, 0x3C,
  0x8D, 0x0A, 0x0C, 0x1B, 0xA1, 0x42, 0xCC, 0xF0, 0x62, 0x85, 0x1A, 0x37,
  0xD8, 0xA1, 0x42, 0x8D, 0x18, 0x7E, 0x30, 0x40, 0x81, 0x02, 0x0C, 0x18,
  0x25, 0xF0, 0x0F, 0x03, 0x03, 0x02, 0x02, 0x02, 0x02, 0xC6, 0x44, 0x78,
  0x63, 0x46, 0x4C, 0x48, 0x78, 0xD8, 0x88, 0x88, 0x8C, 0x84, 0x21, 0x84,
  0x10, 0x41, 0x04, 0x30, 0x83, 0xF0, 0x33, 0x33, 0x35, 0x75, 0x5B, 0x4A,
  0x42, 0x42, 0x42, 0xC6, 0x62, 0xC5, 0x8A, 0xB5, 0x5A, 0xA5, 0x4A, 0x8D,
  0x18, 0x3C, 0x8D, 0x1A, 0x3C, 0x58, 0xA1, 0x42, 0xCC, 0xF0, 0x7E, 0x85,
  0x0A, 0x14, 0x7F, 0x20, 0x40, 0x81, 0x00, 0x3C, 0x8D, 0x0A, 0x3C, 0x70,
  0xA1, 0x42, 0x8C, 0xF0, 0x40, 0xC0, 0x80, 0x7C, 0x85, 0x0A, 0x34, 0xDF,
  0x22, 0x44, 0x8D, 0x18, 0x3C, 0x85, 0x02, 0x03, 0x81, 0x81, 0x42, 0x8D,
  0xF0, 0xFE, 0x60, 0x81, 0x02, 0x04, 0x08, 0x30, 0x40, 0x80, 0x62, 0x85,
  0x1A, 0x34, 0x58, 0xA1, 0x42, 0xCC, 0xF0, 0x87, 0x0A, 0x34, 0x49, 0x92,
  0x34, 0x70, 0x60, 0xC0, 0xD9, 0x9B, 0x9A, 0xAA, 0xAA, 0xAC, 0xAC, 0xCC,
  0xCC, 0xC8, 0x21, 0x99, 0x05, 0x82, 0x80, 0x80, 0xC0, 0xF0, 0x48, 0x46,
  0x61, 0x00, 0xC3, 0x42, 0x64, 0x2C, 0x28, 0x30, 0x10, 0x30, 0x20, 0x20,
  0x7E, 0x0C, 0x30, 0x41, 0x06, 0x18, 0x20, 0x81, 0xF8, 0x3C, 0xE2, 0x08,
  0x61, 0x84, 0x10, 0x41, 0x0C, 0x30, 0xF3, 0x80, 0xC2, 0x10, 0x84, 0x30,
  0x84, 0x21, 0x84, 0x21, 0x0C, 0x3C, 0xF0, 0x82, 0x08, 0x20, 0x86, 0x10,
  0x41, 0x04, 0xF3, 0xC0, 0x18, 0x62, 0x51, 0xC4, 0xFE, 0x90, 0x3E, 0xCD,
  0x16, 0x28, 0x50, 0xB3, 0x3E, 0x60, 0x81, 0x73, 0x24, 0x58, 0xA1, 0x42,
  0xCD, 0xF0, 0x38, 0xC9, 0x16, 0x08, 0x10, 0xB3, 0x3C, 0x02, 0x04, 0xFB,
  0x34, 0x58, 0xA1, 0x42, 0xCC, 0xF8, 0x39, 0x94, 0x7F, 0x82, 0x08, 0xDE,
  0x07, 0xC1, 0x00, 0x40, 0xFE, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x01, 0x81, 0xC0, 0xC0, 0x00, 0x3E, 0xCD, 0x16, 0x28, 0x51, 0xBD, 0x16,
  0x09, 0xF3, 0x80, 0x60, 0x81, 0x73, 0x24, 0x58, 0xA1, 0x42, 0x85, 0x18,
  0x04, 0x18, 0x01, 0xE0, 0xC1, 0x02, 0x04, 0x08, 0x33, 0xF8, 0x02, 0x0C,
  0x01, 0xF0, 0x40, 0x81, 0x02, 0x04, 0x18, 0x30, 0x4F, 0x98, 0x00, 0x60,
  0x81, 0x0A, 0x24, 0x9E, 0x3C, 0x4C, 0x89, 0x18, 0xF0, 0x43, 0x0C, 0x20,
  0x82, 0x08, 0x20, 0xF0, 0x7E, 0x69, 0x49, 0x4B, 0x4A, 0x52, 0x52, 0xD2,
  0x5C, 0xC9, 0x16, 0x28, 0x50, 0xA1, 0x46, 0x39, 0x94, 0x71, 0x86, 0x1C,
  0xDE, 0x2E, 0x32, 0x22, 0x62, 0x42, 0x42, 0x66, 0x7C, 0x40, 0xC0, 0xC0,
  0x3E, 0xCD, 0x16, 0x28, 0x50, 0xA3, 0x3E, 0x08, 0x10, 0x20, 0x5C, 0xCD,
  0x1A, 0x0C, 0x18, 0x20, 0x40, 0x3D, 0x14, 0x18, 0x3C, 0x18, 0xFE, 0x10,
  0x23, 0xF9, 0x82, 0x04, 0x08, 0x10, 0x20, 0x78, 0x46, 0x8D, 0x16, 0x28,
  0x50, 0xB3, 0x3C, 0xC2, 0x8D, 0x12, 0x64, 0x8F, 0x1C, 0x18, 0x93, 0x92,
  0xAA, 0xAC, 0xAC, 0xCC, 0xC8, 0xC8, 0x23, 0x32, 0x14, 0x18, 0x18, 0x3C,
  0x64, 0xC6, 0x46, 0x8D, 0x16, 0x28, 0x51, 0xBF, 0x06, 0x09, 0xF3, 0x80,
  0x7E, 0x08, 0x20, 0x83, 0x0C, 0x30, 0x7E, 0x02, 0x1C, 0x20, 0x40, 0x81,
  0x3C, 0x78, 0x10, 0x20, 0x41, 0x81, 0xC1, 0x00, 0x25, 0xB4, 0x92, 0x5A,
  0x49, 0x00, 0x30, 0x70, 0x20, 0x40, 0x83, 0x03, 0x87, 0x10, 0x20, 0x40,
  0x8E, 0x18, 0x00, 0xF3, 0x38, 0x20,
};

const GFXglyph JetBrainsMono_Italic14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 3, 10, 8, 3, -10 },
  { 5, 4, 4, 8, 3, -10 },
  { 7, 8, 10, 8, 0, -10 },
  { 17, 7, 14, 8, 1, -12 },
  { 30, 9, 10, 8, 0, -10 },
  { 42, 8, 10, 8, 0, -10 },
  { 52, 2, 4, 8, 4, -10 },
  { 53, 6, 14, 8, 2, -12 },
  { 64, 5, 14, 8, 1, -12 },
  { 73, 7, 8, 8, 1, -9 },
  { 80, 7, 7, 8, 1, -8 },
  { 87, 4, 4, 8, 1, -2 },
  { 89, 5, 1, 8, 2, -5 },
  { 90, 3, 2, 8, 2, -2 },
  { 91, 9, 14, 8, 0, -12 },
  { 107, 7, 10, 8, 1, -10 },
  { 116, 6, 10, 8, 1, -10 },
  { 124, 7, 10, 8, 1, -10 },
  { 133, 7, 10, 8, 1, -10 },
  { 142, 7, 10, 8, 1, -10 },
  { 151, 7, 10, 8, 1, -10 },
  { 160, 6, 10, 8, 1, -10 },
  { 168, 7, 10, 8, 2, -10 },
  { 177, 7, 10, 8, 1, -10 },
  { 186, 7, 10, 8, 1, -10 },
  { 195, 4, 8, 8, 2, -8 },
  { 199, 5, 10, 8, 1, -8 },
  { 206, 7, 7, 8, 1, -8 },
  { 213, 7, 5, 8, 1, -7 },
  { 218, 6, 7, 8, 1, -8 },
  { 224, 6, 10, 8, 2, -10 },
  { 232, 8, 13, 8, 0, -10 },
  { 245, 7, 10, 8, 0, -10 },
  { 254, 7, 10, 8, 1, -10 },
  { 263, 7, 10, 8, 1, -10 },
  { 272, 7, 10, 8, 1, -10 },
  { 281, 7, 10, 8, 1, -10 },
  { 290, 7, 10, 8, 1, -10 },
  { 299, 7, 10, 8, 1, -10 },
  { 308, 7, 10, 8, 1, -10 },
  { 317, 7, 10, 8, 1, -10 },
  { 326, 8, 10, 8, 0, -10 },
  { 336, 8, 10, 8, 1, -10 },
  { 346, 6, 10, 8, 1, -10 },
  { 354, 8, 10, 8, 0, -10 },
  { 364, 7, 10, 8, 1, -10 },
  { 373, 7, 10, 8, 1, -10 },
  { 382, 7, 10, 8, 1, -10 },
  { 391, 7, 13, 8, 1, -10 },
  { 403, 7, 10, 8, 1, -10 },
  { 412, 7, 10, 8, 1, -10 },
  { 421, 7, 10, 8, 2, -10 },
  { 430, 7, 10, 8, 1, -10 },
  { 439, 7, 10, 8, 2, -10 },
  { 448, 8, 10, 8, 1, -10 },
  { 458, 9, 10, 8, 0, -10 },
  { 470, 8, 10, 8, 1, -10 },
  { 480, 7, 10, 8, 1, -10 },
  { 489, 6, 14, 8, 2, -12 },
  { 500, 5, 14, 8, 2, -12 },
  { 509, 6, 14, 8, 1, -12 },
  { 520, 6, 5, 8, 1, -10 },
  { 524, 7, 1, 8, 0, 0 },
  { 525, 2, 2, 8, 4, -11 },
  { 526, 7, 8, 8, 1, -8 },
  { 533, 7, 10, 8, 1, -10 },
  { 542, 7, 8, 8, 1, -8 },
  { 549, 7, 10, 8, 1, -10 },
  { 558, 6, 8, 8, 1, -8 },
  { 564, 10, 13, 8, -1, -10 },
  { 581, 7, 11, 8, 1, -8 },
  { 591, 7, 10, 8, 1, -10 },
  { 600, 7, 11, 8, 0, -11 },
  { 610, 7, 14, 8, 0, -11 },
  { 623, 7, 10, 8, 1, -10 },
  { 632, 6, 10, 8, 1, -10 },
  { 640, 8, 8, 8, 0, -8 },
  { 648, 7, 8, 8, 1, -8 },
  { 655, 6, 8, 8, 1, -8 },
  { 661, 8, 11, 8, 0, -8 },
  { 672, 7, 11, 8, 1, -8 },
  { 682, 7, 8, 8, 1, -8 },
  { 689, 6, 8, 8, 1, -8 },
  { 695, 7, 10, 8, 1, -10 },
  { 704, 7, 8, 8, 1, -8 },
  { 711, 7, 8, 8, 1, -8 },
  { 718, 8, 8, 8, 1, -8 },
  { 726, 8, 8, 8, 0, -8 },
  { 734, 7, 11, 8, 1, -8 },
  { 744, 7, 8, 8, 1, -8 },
  { 751, 7, 14, 8, 1, -12 },
  { 764, 3, 14, 8, 3, -12 },
  { 770, 7, 14, 8, 0, -12 },
  { 783, 7, 3, 8, 1, -6 },
};

const GFXfont JetBrainsMono_Italic14pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Italic14pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Italic14pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _JETBRAINSMONO_ITALIC14PT7B_H_
