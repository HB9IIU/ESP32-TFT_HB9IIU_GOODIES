#ifndef _JETBRAINSMONO_ITALIC36PT7B_H_
#define _JETBRAINSMONO_ITALIC36PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Italic.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Italic36pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0E, 0x0E, 0x1E, 0x1E, 0x1C, 0x1C,
  0x1C, 0x1C, 0x1C, 0x18, 0x18, 0x38, 0x38, 0x00, 0x00, 0x00, 0x00, 0x78,
  0xF8, 0xF8, 0xF0, 0x70, 0xF7, 0x0F, 0x70, 0xEF, 0x0E, 0xF0, 0xEE, 0x1E,
  0xE1, 0xEE, 0x1C, 0xE1, 0xCE, 0x1C, 0xC1, 0xC0, 0x00, 0x70, 0x70, 0x03,
  0x03, 0x80, 0x38, 0x18, 0x01, 0xC1, 0xC0, 0x0C, 0x0E, 0x00, 0xE0, 0x60,
  0x07, 0x07, 0x03, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0x1C, 0x1C, 0x00, 0xC0,
  0xE0, 0x0E, 0x06, 0x00, 0x70, 0x70, 0x03, 0x03, 0x80, 0x38, 0x18, 0x01,
  0xC1, 0xC0, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0x30, 0x30,
  0x03, 0x83, 0x80, 0x1C, 0x1C, 0x00, 0xC0, 0xC0, 0x0E, 0x0E, 0x00, 0x70,
  0x70, 0x07, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x03, 0x80, 0x03, 0xFE, 0x01, 0xFF, 0xE0, 0x7D, 0xBE,
  0x0E, 0x33, 0xC3, 0xC6, 0x38, 0x70, 0xC7, 0x0E, 0x38, 0x01, 0xC6, 0x00,
  0x38, 0xC0, 0x07, 0x98, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80,
  0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0C, 0xF0, 0x01, 0x8E, 0x00, 0x31, 0xE0,
  0x0E, 0x3C, 0xE1, 0xC7, 0x1C, 0x30, 0xE3, 0xC6, 0x3C, 0x78, 0xCF, 0x07,
  0xFF, 0xC0, 0x7F, 0xF0, 0x07, 0xFC, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x03, 0xF0, 0x07, 0x83, 0xFC,
  0x07, 0x03, 0x8E, 0x03, 0x01, 0x83, 0x83, 0x81, 0xC1, 0x83, 0x80, 0xE0,
  0xC3, 0x80, 0x70, 0xE3, 0x80, 0x38, 0x73, 0x80, 0x1C, 0x39, 0x80, 0x0F,
  0xF9, 0xC0, 0x03, 0xF9, 0xC0, 0x00, 0x31, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xC7, 0x80, 0x00, 0xCF, 0xF0, 0x00, 0xEF, 0xF8,
  0x00, 0xE7, 0x0E, 0x00, 0xE3, 0x07, 0x00, 0xE3, 0x83, 0x00, 0x61, 0xC1,
  0x80, 0x60, 0xE1, 0xC0, 0x70, 0x70, 0xE0, 0x70, 0x3C, 0xE0, 0x70, 0x0F,
  0xF0, 0x70, 0x03, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x1F, 0xF0, 0x03, 0xFF,
  0x80, 0x78, 0x78, 0x07, 0x03, 0x80, 0xF0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x0F,
  0xC0, 0x01, 0xFC, 0x00, 0x3D, 0xE0, 0xF7, 0x8E, 0x1E, 0x70, 0xF1, 0xC7,
  0x07, 0x38, 0x70, 0x7F, 0x07, 0x03, 0xF0, 0xF0, 0x1E, 0x0F, 0x01, 0xE0,
  0xE0, 0x3E, 0x0F, 0x07, 0xF0, 0xFF, 0xF7, 0x07, 0xFE, 0x78, 0x3F, 0x83,
  0xC0, 0x7B, 0xDE, 0xE7, 0x3B, 0xDE, 0xE7, 0x38, 0x00, 0x0E, 0x00, 0x78,
  0x03, 0xF0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x1E,
  0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0xC0,
  0x07, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0x80, 0x07, 0x00,
  0x01, 0x00, 0x07, 0x00, 0x0F, 0x80, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0x00,
  0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0xF0, 0x01, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x38, 0x01, 0xF0, 0x07, 0xC0,
  0x7E, 0x00, 0xF8, 0x01, 0xC0, 0x02, 0x00, 0x00, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0xC1, 0xC0, 0x9E, 0x38,
  0xFF, 0xF2, 0x7F, 0x7F, 0x5F, 0xC1, 0xFF, 0xC0, 0x03, 0x00, 0x01, 0xF0,
  0x00, 0x77, 0x00, 0x1C, 0x70, 0x07, 0x8F, 0x01, 0xE1, 0xE0, 0x78, 0x1E,
  0x06, 0x03, 0x80, 0x40, 0x20, 0x00, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x01, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0x07, 0xC3, 0xE0,
  0xF0, 0x7C, 0x1E, 0x07, 0x03, 0xC0, 0xE0, 0x78, 0x1C, 0x0F, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x18, 0x79, 0xFB, 0xF7, 0xCF, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x3F,
  0xE0, 0x1F, 0xFE, 0x07, 0xC3, 0xE0, 0xE0, 0x3C, 0x38, 0x03, 0x87, 0x00,
  0x71, 0xE0, 0x0E, 0x38, 0x01, 0xC7, 0x00, 0x38, 0xE0, 0x07, 0x1C, 0x01,
  0xE3, 0x9E, 0x38, 0xF3, 0xC7, 0x1C, 0x78, 0xE3, 0x87, 0x1C, 0x70, 0x03,
  0x8E, 0x00, 0xF1, 0xC0, 0x1C, 0x78, 0x03, 0x8E, 0x00, 0x71, 0xE0, 0x0E,
  0x3C, 0x03, 0x83, 0xC0, 0xF0, 0x7E, 0xFC, 0x07, 0xFF, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x7C, 0x01, 0xFC, 0x03, 0xDC, 0x0F, 0xBC, 0x1E, 0x38, 0x1C,
  0x38, 0x10, 0x38, 0x20, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x38, 0x00, 0x7F, 0xC0, 0x7F, 0xF8,
  0x3E, 0x3E, 0x1E, 0x03, 0xC7, 0x00, 0x73, 0xC0, 0x1C, 0xE0, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x00, 0xFF,
  0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xE0, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF,
  0xFC, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0xC0, 0x0F, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x73, 0x80, 0x1C, 0xE0, 0x0F, 0x3C, 0x03, 0x8F, 0x01, 0xE1, 0xFF, 0xF0,
  0x3F, 0xF8, 0x07, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0xF1, 0xE0, 0x79, 0xE0, 0x38, 0xE0,
  0x1C, 0xE0, 0x0E, 0x70, 0x07, 0x3F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xFC, 0x38, 0x00, 0x0E, 0x00,
  0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x7F, 0x01,
  0xFF, 0xE0, 0xFF, 0xFC, 0x3E, 0x0F, 0x0F, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0xF0, 0x0F,
  0x3C, 0x03, 0x87, 0x01, 0xE1, 0xFF, 0xF0, 0x3F, 0xF8, 0x07, 0xF8, 0x00,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x80, 0x07, 0x80, 0x07, 0xBF, 0x03,
  0xFF, 0xE3, 0xF3, 0xF1, 0xE0, 0x3D, 0xE0, 0x1E, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xEE, 0x00, 0x77, 0x80, 0x79, 0xE0,
  0x78, 0xFF, 0xF8, 0x3F, 0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0xFF, 0xDF, 0xFF,
  0xF7, 0xFF, 0xF9, 0xC0, 0x0E, 0x70, 0x07, 0x1C, 0x01, 0xCF, 0x00, 0xE0,
  0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00,
  0x70, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0,
  0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x7F, 0xC0,
  0x7F, 0xF8, 0x3E, 0x1E, 0x0E, 0x03, 0xC7, 0x80, 0x71, 0xC0, 0x1C, 0x70,
  0x0F, 0x1C, 0x03, 0x87, 0x81, 0xE0, 0xE0, 0xF0, 0x3C, 0x78, 0x07, 0xFC,
  0x00, 0xFC, 0x00, 0x7F, 0xC0, 0x78, 0x78, 0x3C, 0x0F, 0x1E, 0x01, 0xC7,
  0x00, 0x71, 0xC0, 0x1C, 0xF0, 0x07, 0x3C, 0x01, 0xCF, 0x00, 0xF3, 0xC0,
  0x78, 0x7F, 0xFC, 0x0F, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0x70, 0x00, 0xFF,
  0x80, 0xFF, 0xF0, 0x7C, 0x7E, 0x3C, 0x07, 0x8E, 0x00, 0xE7, 0x80, 0x3D,
  0xC0, 0x0F, 0x70, 0x03, 0x9C, 0x00, 0xE7, 0x00, 0x39, 0xC0, 0x1E, 0x70,
  0x07, 0x1E, 0x07, 0xC7, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xBC, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x0F, 0x0F, 0xC7,
  0xE3, 0xF0, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x7E, 0x3F, 0x1F, 0x0F, 0x80, 0x03, 0xC0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x20, 0x78, 0x1F, 0x03, 0xC0, 0x78, 0x1E, 0x03,
  0xC0, 0xF0, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x03,
  0xC0, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xFE, 0x00, 0xFC,
  0x00, 0xF8, 0x00, 0x70, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x07, 0x00, 0x00,
  0x80, 0x3F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC7,
  0xFF, 0xF3, 0xFF, 0xFC, 0x18, 0x00, 0x0E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xFC, 0x00, 0xF8, 0x00, 0x60, 0x00, 0x20, 0x00, 0x00, 0x3F, 0xE0, 0x7F,
  0xE0, 0xFF, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x07, 0x81, 0xFE, 0x03, 0xF8, 0x07,
  0xC0, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x00, 0x06,
  0x00, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xF0, 0x1E, 0x07, 0x80, 0x38,
  0x3C, 0x00, 0xE0, 0xE0, 0x01, 0x87, 0x00, 0x07, 0x1C, 0x00, 0x18, 0x70,
  0x00, 0xE1, 0xC1, 0xFB, 0x8E, 0x0F, 0xFE, 0x38, 0x38, 0x78, 0xE1, 0xC0,
  0xE3, 0x87, 0x03, 0x8E, 0x1C, 0x1C, 0x38, 0x70, 0x70, 0xC1, 0x81, 0xC7,
  0x0E, 0x07, 0x1C, 0x38, 0x1C, 0x70, 0xE0, 0x71, 0xC3, 0x83, 0x87, 0x0F,
  0x1E, 0x18, 0x1F, 0xD8, 0xE0, 0x3E, 0xE3, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x77, 0x00, 0x1D, 0xC0, 0x0F, 0x70, 0x03, 0x9C, 0x00,
  0xE7, 0x00, 0x70, 0xE0, 0x1C, 0x38, 0x0F, 0x0E, 0x03, 0x83, 0x81, 0xE0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x0F, 0xFF, 0x83, 0xFF, 0xE1, 0xFF, 0xF8,
  0x70, 0x0F, 0x1C, 0x01, 0xCE, 0x00, 0x73, 0x80, 0x1D, 0xE0, 0x07, 0x70,
  0x01, 0xFC, 0x00, 0x70, 0x0F, 0xFE, 0x03, 0xFF, 0xE1, 0xFF, 0xF8, 0x78,
  0x0F, 0x1C, 0x03, 0xC7, 0x00, 0x71, 0xC0, 0x1C, 0x70, 0x07, 0x1C, 0x03,
  0x8F, 0x01, 0xE3, 0x80, 0xF0, 0xFF, 0xF8, 0x3F, 0xFC, 0x0F, 0xFF, 0x83,
  0x80, 0xF1, 0xE0, 0x1E, 0x70, 0x07, 0x9C, 0x00, 0xE7, 0x00, 0x79, 0xC0,
  0x1C, 0x70, 0x07, 0x3C, 0x03, 0xCF, 0x01, 0xE3, 0xFF, 0xF0, 0xFF, 0xF8,
  0x3F, 0xF8, 0x00, 0x00, 0x38, 0x00, 0x7F, 0xC0, 0x7F, 0xF8, 0x3F, 0x3F,
  0x0F, 0x03, 0xC7, 0x80, 0x71, 0xC0, 0x1C, 0x70, 0x07, 0x1C, 0x00, 0x0F,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x07, 0x1C, 0x03, 0xC7, 0x00, 0xE1, 0xE0, 0x78, 0x7F, 0xFC, 0x0F,
  0xFE, 0x01, 0xFE, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0xC1, 0xFF, 0xF8, 0x78,
  0x1E, 0x1C, 0x03, 0xC7, 0x00, 0x71, 0xC0, 0x1C, 0x70, 0x07, 0x3C, 0x03,
  0xCF, 0x00, 0xE3, 0x80, 0x38, 0xE0, 0x0E, 0x38, 0x03, 0x8E, 0x00, 0xE3,
  0x80, 0x79, 0xE0, 0x1E, 0x70, 0x07, 0x1C, 0x01, 0xC7, 0x00, 0x71, 0xC0,
  0x3C, 0x70, 0x0E, 0x3C, 0x07, 0x8F, 0x03, 0xC3, 0xFF, 0xE0, 0xFF, 0xF0,
  0x3F, 0xF0, 0x00, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0x00,
  0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0xFF, 0xF8,
  0xFF, 0xFE, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF,
  0x8F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8,
  0x7F, 0xFE, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x7F, 0xC0,
  0x7F, 0xF8, 0x3F, 0x3F, 0x0F, 0x03, 0xC7, 0x80, 0x71, 0xC0, 0x1C, 0x70,
  0x07, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x8F, 0xF9, 0xE3, 0xFE, 0x78, 0xFF, 0x9C, 0x01, 0xE7,
  0x00, 0x71, 0xC0, 0x1C, 0x70, 0x07, 0x1C, 0x03, 0xC7, 0x00, 0xE1, 0xE0,
  0x78, 0x7F, 0xFC, 0x0F, 0xFE, 0x01, 0xFE, 0x00, 0x0E, 0x01, 0xE1, 0xC0,
  0x3C, 0x78, 0x07, 0x0F, 0x00, 0xE1, 0xC0, 0x1C, 0x38, 0x03, 0x87, 0x00,
  0x70, 0xE0, 0x1E, 0x1C, 0x03, 0x87, 0x80, 0x70, 0xE0, 0x0E, 0x1F, 0xFF,
  0xC3, 0xFF, 0xF8, 0x7F, 0xFF, 0x0E, 0x01, 0xE3, 0xC0, 0x38, 0x78, 0x07,
  0x0E, 0x00, 0xE1, 0xC0, 0x1C, 0x38, 0x07, 0x87, 0x00, 0xF1, 0xE0, 0x1C,
  0x3C, 0x03, 0x87, 0x00, 0x70, 0xE0, 0x0E, 0x1C, 0x03, 0xC0, 0x0F, 0xFF,
  0xC3, 0xFF, 0xF0, 0xFF, 0xFC, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x38, 0x01, 0xFF, 0xF8, 0xFF, 0xFC, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x07, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x07, 0x80, 0x00, 0xF3, 0x80, 0x1C, 0x70, 0x03, 0x8E, 0x00, 0x71, 0xE0,
  0x1C, 0x3C, 0x07, 0x83, 0xFF, 0xE0, 0x3F, 0xF8, 0x03, 0xFC, 0x00, 0x0E,
  0x00, 0xF0, 0xE0, 0x0E, 0x1E, 0x01, 0xE1, 0xE0, 0x3C, 0x1C, 0x03, 0x81,
  0xC0, 0x78, 0x1C, 0x0F, 0x01, 0xC0, 0xE0, 0x3C, 0x1E, 0x03, 0xC3, 0xC0,
  0x38, 0x78, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x38, 0x78,
  0x07, 0x87, 0x80, 0x70, 0x38, 0x07, 0x03, 0xC0, 0x70, 0x3C, 0x07, 0x01,
  0xC0, 0x70, 0x1E, 0x0F, 0x01, 0xE0, 0xF0, 0x0E, 0x0E, 0x00, 0xF0, 0xE0,
  0x0F, 0x0E, 0x00, 0x78, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0x80, 0xF0, 0xF8, 0x1F, 0x0F, 0x81,
  0xF0, 0xD8, 0x3B, 0x0D, 0x83, 0xF1, 0xD8, 0x77, 0x1D, 0xC7, 0x61, 0xDC,
  0xE6, 0x1D, 0xCE, 0xE1, 0xCC, 0xCE, 0x1C, 0xDC, 0xE3, 0x8D, 0x8E, 0x38,
  0xF9, 0xC3, 0x8F, 0x1C, 0x38, 0x01, 0xC3, 0x80, 0x1C, 0x38, 0x01, 0xC7,
  0x80, 0x3C, 0x78, 0x03, 0x87, 0x00, 0x38, 0x70, 0x03, 0x87, 0x00, 0x38,
  0x70, 0x03, 0x87, 0x00, 0x78, 0xF0, 0x07, 0x8E, 0x00, 0x70, 0x0F, 0x00,
  0xE1, 0xE0, 0x1C, 0x7E, 0x07, 0x8F, 0xC0, 0xE1, 0xF8, 0x1C, 0x3F, 0x03,
  0x87, 0x60, 0x70, 0xEE, 0x0E, 0x3D, 0xC3, 0xC7, 0x38, 0x70, 0xE7, 0x0E,
  0x1C, 0x61, 0xC3, 0x8E, 0x38, 0x71, 0xC7, 0x1E, 0x39, 0xE3, 0x87, 0x38,
  0x70, 0x67, 0x0E, 0x0E, 0xE1, 0xC1, 0xDC, 0x38, 0x3B, 0x87, 0x07, 0x71,
  0xE0, 0x6E, 0x38, 0x0F, 0x87, 0x01, 0xF0, 0xE0, 0x3E, 0x1C, 0x07, 0xC0,
  0x00, 0x38, 0x00, 0x7F, 0xC0, 0x7F, 0xF8, 0x3F, 0x3E, 0x0F, 0x03, 0xC7,
  0x80, 0x71, 0xC0, 0x1C, 0x70, 0x07, 0x1C, 0x01, 0xCF, 0x00, 0xF3, 0x80,
  0x38, 0xE0, 0x0E, 0x38, 0x03, 0x8E, 0x00, 0xE3, 0x80, 0x39, 0xE0, 0x1E,
  0x78, 0x07, 0x9C, 0x01, 0xC7, 0x00, 0x71, 0xC0, 0x1C, 0x70, 0x07, 0x1C,
  0x03, 0xC7, 0x00, 0xE1, 0xE0, 0x78, 0x7F, 0xFC, 0x0F, 0xFE, 0x01, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0x1F, 0xFF, 0xC1, 0xE0, 0x1E, 0x1C,
  0x01, 0xE1, 0xC0, 0x0E, 0x1C, 0x00, 0xE1, 0xC0, 0x0E, 0x3C, 0x00, 0xE3,
  0xC0, 0x1E, 0x38, 0x03, 0xC3, 0x80, 0x7C, 0x3F, 0xFF, 0x83, 0xFF, 0xF0,
  0x3F, 0xFC, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x3F, 0xE0, 0x1F,
  0xFE, 0x07, 0xC7, 0xE0, 0xE0, 0x3C, 0x3C, 0x03, 0x87, 0x00, 0x71, 0xE0,
  0x0E, 0x38, 0x01, 0xC7, 0x00, 0x38, 0xE0, 0x0F, 0x1C, 0x01, 0xE3, 0x80,
  0x38, 0xF0, 0x07, 0x1E, 0x00, 0xE3, 0x80, 0x1C, 0x70, 0x03, 0x8E, 0x00,
  0xF1, 0xC0, 0x1C, 0x78, 0x03, 0x8F, 0x00, 0x71, 0xE0, 0x1E, 0x3C, 0x03,
  0x83, 0xC0, 0xF0, 0x7F, 0xFC, 0x07, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C,
  0x00, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0x01, 0xE1, 0xC0,
  0x1E, 0x38, 0x03, 0xC7, 0x00, 0x78, 0xE0, 0x0F, 0x3C, 0x01, 0xC7, 0x80,
  0x78, 0xE0, 0x0F, 0x1C, 0x07, 0xC3, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFC,
  0x03, 0xC3, 0xC0, 0x70, 0x78, 0x0E, 0x07, 0x01, 0xC0, 0xF0, 0x38, 0x1E,
  0x07, 0x01, 0xC1, 0xE0, 0x3C, 0x3C, 0x07, 0x87, 0x00, 0x70, 0xE0, 0x0F,
  0x1C, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x3F, 0xE0, 0x1F, 0xFE, 0x07, 0xC3,
  0xE0, 0xE0, 0x3C, 0x3C, 0x03, 0x87, 0x00, 0x70, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E,
  0x00, 0x03, 0xCE, 0x00, 0x71, 0xC0, 0x0E, 0x3C, 0x03, 0xC7, 0x80, 0xF0,
  0x7F, 0xFC, 0x07, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0xE1, 0xC0, 0x3C,
  0x78, 0x07, 0x8E, 0x00, 0xE1, 0xC0, 0x1C, 0x38, 0x03, 0x87, 0x00, 0x70,
  0xE0, 0x1E, 0x3C, 0x03, 0xC7, 0x80, 0x70, 0xE0, 0x0E, 0x1C, 0x01, 0xC3,
  0x80, 0x38, 0x70, 0x07, 0x1E, 0x01, 0xE3, 0xC0, 0x38, 0x70, 0x07, 0x0E,
  0x00, 0xE1, 0xC0, 0x1C, 0x38, 0x03, 0x87, 0x00, 0xF0, 0xE0, 0x1C, 0x1E,
  0x07, 0x83, 0xFF, 0xE0, 0x3F, 0xF8, 0x03, 0xFC, 0x00, 0xF0, 0x01, 0xDC,
  0x00, 0xF7, 0x00, 0x39, 0xC0, 0x1E, 0x70, 0x07, 0x1C, 0x01, 0xC7, 0x00,
  0xF1, 0xC0, 0x38, 0x70, 0x1E, 0x1E, 0x07, 0x07, 0x81, 0xC0, 0xE0, 0xE0,
  0x38, 0x38, 0x0E, 0x1E, 0x03, 0x87, 0x00, 0xE1, 0xC0, 0x38, 0xE0, 0x0E,
  0x38, 0x03, 0x9E, 0x00, 0xE7, 0x00, 0x3D, 0xC0, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x78, 0x3B, 0x83,
  0xC1, 0xDC, 0x1E, 0x0E, 0xE0, 0xF0, 0xE7, 0x0D, 0x87, 0x38, 0x6C, 0x39,
  0xC3, 0x61, 0x8E, 0x3B, 0x1C, 0x71, 0x98, 0xE3, 0x8C, 0xC7, 0x1C, 0x66,
  0x70, 0xE6, 0x33, 0x87, 0x31, 0x9C, 0x39, 0x8C, 0xC1, 0xCC, 0xEE, 0x0E,
  0xC6, 0x70, 0x76, 0x33, 0x83, 0xB1, 0x98, 0x1B, 0x8D, 0xC0, 0xD8, 0x6E,
  0x06, 0xC3, 0x70, 0x36, 0x1B, 0x03, 0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8,
  0x3C, 0x07, 0xC1, 0xE0, 0x00, 0x0F, 0x00, 0x3C, 0x1E, 0x01, 0xE0, 0x38,
  0x07, 0x00, 0xE0, 0x3C, 0x03, 0xC1, 0xE0, 0x07, 0x07, 0x00, 0x1E, 0x3C,
  0x00, 0x79, 0xE0, 0x00, 0xE7, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xDE, 0x00, 0x0F, 0x38, 0x00, 0x78, 0xF0, 0x01, 0xC1, 0xC0,
  0x0E, 0x07, 0x00, 0x78, 0x1E, 0x03, 0xC0, 0x38, 0x0E, 0x00, 0xF0, 0x78,
  0x03, 0xC3, 0xC0, 0x07, 0x80, 0xE0, 0x01, 0xFE, 0x00, 0x79, 0xC0, 0x0E,
  0x38, 0x03, 0xC7, 0x80, 0xF0, 0x70, 0x1C, 0x0E, 0x07, 0x81, 0xE0, 0xE0,
  0x1C, 0x38, 0x03, 0x8F, 0x00, 0x79, 0xC0, 0x07, 0x70, 0x00, 0xFE, 0x00,
  0x1F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x7F, 0xFE,
  0x0F, 0xFF, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x78, 0x00, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xF0,
  0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1F, 0xE0, 0xFF, 0x83, 0xFE, 0x00,
  0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1E, 0x03, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xF0, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x3C, 0x07,
  0xFC, 0x1F, 0xF0, 0x7F, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x1F, 0xE0, 0xFF, 0x83, 0xFE, 0x00, 0x00,
  0xF0, 0x00, 0xF0, 0x01, 0xF8, 0x01, 0xB8, 0x03, 0x98, 0x07, 0x1C, 0x07,
  0x1C, 0x0E, 0x0C, 0x1C, 0x0E, 0x1C, 0x0E, 0x38, 0x0E, 0x38, 0x06, 0x70,
  0x07, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xF8, 0xE1, 0xC7,
  0x8E, 0x1C, 0x03, 0xF1, 0xC1, 0xFE, 0xF0, 0xFF, 0xFC, 0x78, 0x3E, 0x3C,
  0x07, 0x8E, 0x00, 0xE3, 0x80, 0x38, 0xE0, 0x1E, 0x78, 0x07, 0x9E, 0x01,
  0xC7, 0x00, 0x71, 0xC0, 0x1C, 0x70, 0x07, 0x1C, 0x03, 0xC7, 0x00, 0xF1,
  0xC0, 0x38, 0x78, 0x1E, 0x1F, 0xBF, 0x83, 0xFE, 0xE0, 0x7E, 0x78, 0x0E,
  0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x71, 0xF0, 0x3B, 0xFE, 0x3F, 0xFF, 0x1F, 0x03, 0xCF, 0x01, 0xE7, 0x80,
  0x73, 0x80, 0x39, 0xC0, 0x1C, 0xE0, 0x1E, 0xF0, 0x0F, 0x70, 0x07, 0x38,
  0x03, 0x9C, 0x01, 0xCE, 0x00, 0xE7, 0x00, 0xF7, 0x80, 0x73, 0xE0, 0x79,
  0xDD, 0xF8, 0xEF, 0xF8, 0x73, 0xF8, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0xC0,
  0xFF, 0xF0, 0x78, 0x1E, 0x3C, 0x03, 0x8E, 0x00, 0xE3, 0x80, 0x38, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x71, 0xC0, 0x38, 0x78, 0x1E, 0x1F, 0xFF, 0x03,
  0xFF, 0x80, 0x7F, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0xFC, 0x70, 0x3F, 0xDE, 0x0F,
  0xFF, 0xC3, 0xC1, 0xF0, 0xF0, 0x1E, 0x1C, 0x01, 0xC3, 0x80, 0x38, 0x70,
  0x0F, 0x1E, 0x01, 0xE3, 0xC0, 0x38, 0x70, 0x07, 0x0E, 0x00, 0xE1, 0xC0,
  0x1C, 0x38, 0x07, 0x87, 0x00, 0xF0, 0xE0, 0x1C, 0x1E, 0x07, 0x83, 0xF7,
  0xF0, 0x3F, 0xEE, 0x03, 0xF3, 0xC0, 0x01, 0xFC, 0x03, 0xFF, 0x03, 0xFF,
  0xC3, 0xC0, 0xF3, 0xC0, 0x79, 0xC0, 0x1C, 0xE0, 0x0E, 0x70, 0x07, 0x7F,
  0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xCE, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x1E, 0x78, 0x1E, 0x3F, 0x3E, 0x0F, 0xFE, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x01,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00,
  0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF1, 0xC1, 0xFE, 0xF0, 0xFF, 0xFC,
  0x78, 0x1E, 0x3C, 0x07, 0x8E, 0x00, 0xE3, 0x80, 0x38, 0xE0, 0x1E, 0x78,
  0x07, 0x9E, 0x01, 0xC7, 0x00, 0x71, 0xC0, 0x1C, 0x70, 0x07, 0x1C, 0x03,
  0xC7, 0x81, 0xF1, 0xF0, 0xF8, 0x3F, 0xEE, 0x07, 0xF3, 0x80, 0xF0, 0xE0,
  0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x03, 0xF0, 0x3F,
  0xF8, 0x1F, 0xF8, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x73, 0xF0, 0x3B, 0xFE, 0x3F, 0xFF, 0x1F,
  0x03, 0xCF, 0x01, 0xE7, 0x80, 0x73, 0x80, 0x39, 0xC0, 0x1C, 0xE0, 0x1E,
  0xF0, 0x0E, 0x70, 0x07, 0x38, 0x03, 0x9C, 0x01, 0xCE, 0x00, 0xE7, 0x00,
  0xF7, 0x80, 0x7B, 0xC0, 0x39, 0xC0, 0x1C, 0xE0, 0x0E, 0x70, 0x07, 0x00,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x1F, 0xFF, 0xF7, 0xFF,
  0xFB, 0xFF, 0xFE, 0x00, 0x01, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xE0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1E, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x78, 0xE0, 0x1E, 0x1C, 0x07, 0x87, 0x81, 0xE0,
  0xF0, 0x38, 0x1C, 0x0F, 0x03, 0x83, 0xC0, 0x70, 0xF0, 0x0F, 0xFC, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x0E, 0x1E, 0x01, 0xC1, 0xC0, 0x38, 0x3C, 0x07,
  0x03, 0x80, 0xE0, 0x78, 0x3C, 0x07, 0x07, 0x00, 0xF0, 0xE0, 0x0E, 0x1C,
  0x01, 0xE0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x00, 0x3C, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0F, 0xFF, 0x0F,
  0xFC, 0x0F, 0xF8, 0x1D, 0xE3, 0xC3, 0xFE, 0xFC, 0x6B, 0xF7, 0x9E, 0x38,
  0x73, 0x87, 0x0E, 0x70, 0xE1, 0xCE, 0x1C, 0x39, 0xC3, 0x87, 0x38, 0x61,
  0xCE, 0x0C, 0x39, 0xC3, 0x87, 0x38, 0x70, 0xE7, 0x0E, 0x1C, 0xE1, 0xC3,
  0x9C, 0x30, 0x77, 0x86, 0x1C, 0xE1, 0xC3, 0x9C, 0x38, 0x73, 0x87, 0x0E,
  0x70, 0xE1, 0xC0, 0x1C, 0xFC, 0x0E, 0xFF, 0x8F, 0xFF, 0xC7, 0xC0, 0xF3,
  0xC0, 0x79, 0xE0, 0x1C, 0xE0, 0x0E, 0x70, 0x07, 0x38, 0x07, 0xBC, 0x03,
  0x9C, 0x01, 0xCE, 0x00, 0xE7, 0x00, 0x73, 0x80, 0x39, 0xC0, 0x3D, 0xE0,
  0x1E, 0xF0, 0x0E, 0x70, 0x07, 0x38, 0x03, 0x9C, 0x01, 0xC0, 0x01, 0xFC,
  0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xC0, 0xF3, 0xC0, 0x79, 0xC0, 0x1C, 0xE0,
  0x0E, 0x70, 0x07, 0x78, 0x07, 0xB8, 0x03, 0xDC, 0x01, 0xCE, 0x00, 0xE7,
  0x00, 0x73, 0x80, 0x39, 0xC0, 0x3C, 0xE0, 0x1C, 0x78, 0x1E, 0x3F, 0xFE,
  0x0F, 0xFE, 0x03, 0xFC, 0x00, 0x0E, 0x3F, 0x03, 0xBF, 0xE1, 0xFF, 0xF8,
  0x7C, 0x0F, 0x1E, 0x03, 0xC7, 0x80, 0x71, 0xC0, 0x1C, 0x70, 0x07, 0x1C,
  0x03, 0xCF, 0x00, 0xF3, 0x80, 0x38, 0xE0, 0x0E, 0x38, 0x03, 0x8E, 0x00,
  0xE3, 0x80, 0x79, 0xE0, 0x1C, 0x74, 0x0F, 0x1D, 0xDF, 0x87, 0x7F, 0xC1,
  0xCF, 0xE0, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x00, 0x03, 0xF1, 0xC1, 0xFE, 0xF0, 0xFF, 0xF8, 0x78,
  0x3E, 0x3C, 0x07, 0x8E, 0x01, 0xE3, 0x80, 0x38, 0xE0, 0x1E, 0x78, 0x07,
  0x9C, 0x01, 0xC7, 0x00, 0x71, 0xC0, 0x1C, 0x70, 0x07, 0x1C, 0x03, 0xC7,
  0x00, 0xF1, 0xC0, 0x38, 0x78, 0x1E, 0x1F, 0xBB, 0x83, 0xFE, 0xE0, 0x7E,
  0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x0F, 0x00, 0x1E, 0x7E, 0x07, 0xBF, 0xC1, 0xDF, 0xF8, 0x7C, 0x0F,
  0x1E, 0x03, 0xC7, 0x00, 0xF1, 0xC0, 0x3C, 0xF0, 0x0F, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xFE, 0x07, 0xFF, 0x87, 0xFF, 0xE3, 0xC0, 0xF3, 0xC0, 0x39, 0xE0,
  0x00, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0xC0, 0x0F, 0xFE, 0x01, 0xFF, 0x80,
  0x07, 0xE0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1D, 0xE0, 0x1E, 0xF0, 0x1E,
  0x3F, 0xFF, 0x1F, 0xFF, 0x07, 0xFE, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x78, 0x00, 0x38, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x03, 0xFC,
  0x00, 0x1C, 0x01, 0xC7, 0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x0E, 0x38, 0x03,
  0x8E, 0x00, 0xE3, 0x80, 0x38, 0xE0, 0x0E, 0x78, 0x07, 0x9E, 0x01, 0xC7,
  0x00, 0x71, 0xC0, 0x1C, 0x70, 0x07, 0x1C, 0x01, 0xC7, 0x00, 0xF1, 0xC0,
  0x38, 0x78, 0x1E, 0x1F, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0x80, 0xE0, 0x07,
  0xF0, 0x03, 0xB8, 0x01, 0xDC, 0x01, 0xCF, 0x00, 0xE3, 0x80, 0xE1, 0xC0,
  0x70, 0xE0, 0x70, 0x70, 0x38, 0x38, 0x3C, 0x1E, 0x1C, 0x07, 0x1E, 0x03,
  0x8E, 0x01, 0xCF, 0x00, 0xE7, 0x00, 0x77, 0x80, 0x3B, 0x80, 0x0F, 0xC0,
  0x07, 0xC0, 0x03, 0xE0, 0x00, 0xE0, 0xE0, 0xFC, 0x3C, 0x1B, 0x87, 0x87,
  0x70, 0xF0, 0xEE, 0x36, 0x1D, 0xC6, 0xC3, 0x30, 0xD8, 0xE6, 0x33, 0x1C,
  0xC6, 0x63, 0x18, 0xCC, 0xE3, 0x31, 0x9C, 0x66, 0x33, 0x0C, 0xC6, 0xE1,
  0xB8, 0xDC, 0x36, 0x1B, 0x06, 0xC3, 0xE0, 0xD8, 0x7C, 0x1E, 0x0F, 0x03,
  0xC1, 0xE0, 0x78, 0x3C, 0x00, 0x0F, 0x00, 0x78, 0x38, 0x07, 0x81, 0xE0,
  0x78, 0x07, 0x07, 0x80, 0x3C, 0x38, 0x00, 0xE3, 0x80, 0x07, 0xBC, 0x00,
  0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF8,
  0x00, 0x1D, 0xC0, 0x01, 0xCF, 0x00, 0x1E, 0x38, 0x01, 0xE1, 0xE0, 0x1E,
  0x07, 0x01, 0xE0, 0x3C, 0x0E, 0x00, 0xE1, 0xF0, 0x07, 0x80, 0x38, 0x03,
  0x9C, 0x03, 0xDE, 0x01, 0xEF, 0x00, 0xE7, 0x00, 0x73, 0x80, 0x39, 0xC0,
  0x1C, 0xE0, 0x0E, 0x70, 0x0F, 0x78, 0x07, 0x38, 0x03, 0x9C, 0x01, 0xCE,
  0x00, 0xE7, 0x00, 0xF3, 0xC0, 0xF9, 0xF0, 0xF8, 0x7F, 0xDC, 0x1F, 0xCE,
  0x01, 0x87, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x03,
  0xF0, 0x7F, 0xF0, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0xC7, 0xFF, 0xE1, 0xFF,
  0xF8, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3F, 0xFF, 0x8F, 0xFF,
  0xE3, 0xFF, 0xF8, 0x00, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1E,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x1F, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x00, 0x3F, 0x00,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x0F, 0x00,
  0x07, 0x83, 0x81, 0xC0, 0xE0, 0x70, 0x78, 0x3C, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC1, 0xE0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x0F, 0x07, 0x83, 0x81,
  0xC0, 0xE0, 0x70, 0x78, 0x3C, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC1, 0xE0,
  0xE0, 0x70, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x03, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0xE0, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x0F, 0xC0, 0x07, 0x80,
  0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0xF0,
  0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x81, 0xCF, 0xF0,
  0x77, 0xBE, 0x1D, 0xC7, 0x8F, 0x70, 0xFF, 0xB8, 0x1F, 0xCE, 0x03, 0xE0,
};

const GFXglyph JetBrainsMono_Italic36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 8, 26, 22, 7, -26 },
  { 27, 12, 11, 22, 7, -26 },
  { 44, 21, 26, 22, 1, -26 },
  { 113, 19, 36, 22, 2, -31 },
  { 199, 25, 26, 22, -1, -26 },
  { 281, 20, 27, 22, 1, -27 },
  { 349, 5, 11, 22, 10, -26 },
  { 356, 15, 35, 22, 6, -30 },
  { 422, 15, 35, 22, 2, -30 },
  { 488, 19, 19, 22, 2, -22 },
  { 534, 18, 17, 22, 2, -20 },
  { 573, 10, 11, 22, 3, -5 },
  { 587, 12, 3, 22, 5, -13 },
  { 592, 7, 6, 22, 6, -6 },
  { 598, 22, 34, 22, 0, -30 },
  { 692, 19, 27, 22, 2, -27 },
  { 757, 16, 26, 22, 2, -26 },
  { 809, 18, 27, 22, 2, -27 },
  { 870, 18, 26, 22, 2, -26 },
  { 929, 17, 26, 22, 2, -26 },
  { 985, 18, 26, 22, 2, -26 },
  { 1044, 17, 26, 22, 2, -26 },
  { 1100, 18, 26, 22, 4, -26 },
  { 1159, 18, 27, 22, 2, -27 },
  { 1220, 18, 27, 22, 3, -27 },
  { 1281, 9, 20, 22, 6, -20 },
  { 1304, 11, 26, 22, 4, -20 },
  { 1340, 17, 19, 22, 3, -21 },
  { 1381, 18, 12, 22, 2, -18 },
  { 1408, 17, 19, 22, 2, -21 },
  { 1449, 15, 26, 22, 5, -26 },
  { 1498, 22, 33, 22, 0, -27 },
  { 1589, 18, 26, 22, 0, -26 },
  { 1648, 18, 26, 22, 2, -26 },
  { 1707, 18, 27, 22, 2, -27 },
  { 1768, 18, 26, 22, 2, -26 },
  { 1827, 19, 26, 22, 2, -26 },
  { 1889, 19, 26, 22, 2, -26 },
  { 1951, 18, 27, 22, 2, -27 },
  { 2012, 19, 26, 22, 2, -26 },
  { 2074, 18, 26, 22, 2, -26 },
  { 2133, 19, 26, 22, 1, -26 },
  { 2195, 20, 26, 22, 2, -26 },
  { 2260, 15, 26, 22, 3, -26 },
  { 2309, 20, 26, 22, 1, -26 },
  { 2374, 19, 26, 22, 2, -26 },
  { 2436, 18, 27, 22, 2, -27 },
  { 2497, 20, 26, 22, 2, -26 },
  { 2562, 19, 33, 22, 2, -27 },
  { 2641, 19, 26, 22, 2, -26 },
  { 2703, 19, 27, 22, 2, -27 },
  { 2768, 18, 26, 22, 4, -26 },
  { 2827, 19, 26, 22, 2, -26 },
  { 2889, 18, 26, 22, 4, -26 },
  { 2948, 21, 26, 22, 2, -26 },
  { 3017, 22, 26, 22, 0, -26 },
  { 3089, 19, 26, 22, 4, -26 },
  { 3151, 20, 26, 22, 1, -26 },
  { 3216, 14, 34, 22, 5, -30 },
  { 3276, 11, 34, 22, 6, -30 },
  { 3323, 14, 34, 22, 3, -30 },
  { 3383, 16, 14, 22, 3, -26 },
  { 3411, 18, 3, 22, 0, 1 },
  { 3418, 6, 5, 22, 10, -28 },
  { 3422, 18, 20, 22, 2, -20 },
  { 3467, 17, 26, 22, 2, -26 },
  { 3523, 18, 20, 22, 2, -20 },
  { 3568, 19, 26, 22, 2, -26 },
  { 3630, 17, 20, 22, 2, -20 },
  { 3673, 25, 32, 22, -2, -26 },
  { 3773, 18, 26, 22, 2, -20 },
  { 3832, 17, 26, 22, 2, -26 },
  { 3888, 18, 28, 22, 1, -28 },
  { 3951, 19, 34, 22, 0, -28 },
  { 4032, 19, 26, 22, 2, -26 },
  { 4094, 15, 26, 22, 4, -26 },
  { 4143, 19, 20, 22, 1, -20 },
  { 4191, 17, 20, 22, 2, -20 },
  { 4234, 17, 20, 22, 2, -20 },
  { 4277, 18, 26, 22, 1, -20 },
  { 4336, 18, 26, 22, 2, -20 },
  { 4395, 18, 20, 22, 2, -20 },
  { 4440, 17, 20, 22, 2, -20 },
  { 4483, 17, 25, 22, 3, -25 },
  { 4537, 18, 20, 22, 2, -20 },
  { 4582, 17, 20, 22, 4, -20 },
  { 4625, 19, 20, 22, 3, -20 },
  { 4673, 21, 20, 22, 0, -20 },
  { 4726, 17, 26, 22, 3, -20 },
  { 4782, 18, 20, 22, 2, -20 },
  { 4827, 19, 34, 22, 3, -30 },
  { 4908, 9, 34, 22, 7, -30 },
  { 4947, 18, 34, 22, 1, -30 },
  { 5024, 18, 7, 22, 2, -16 },
};

const GFXfont JetBrainsMono_Italic36pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Italic36pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Italic36pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _JETBRAINSMONO_ITALIC36PT7B_H_
