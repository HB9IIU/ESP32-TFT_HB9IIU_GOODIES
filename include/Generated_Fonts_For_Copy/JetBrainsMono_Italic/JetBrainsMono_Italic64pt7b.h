#ifndef _JETBRAINSMONO_ITALIC64PT7B_H_
#define _JETBRAINSMONO_ITALIC64PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Italic.ttf
// Size: 64pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Italic64pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F,
  0xF8, 0x1F, 0xF0, 0x1F, 0xC0, 0x00, 0x3F, 0x01, 0xF9, 0xF8, 0x0F, 0xCF,
  0xC0, 0x7E, 0x7E, 0x03, 0xF7, 0xF0, 0x3F, 0xBF, 0x81, 0xFD, 0xF8, 0x0F,
  0xCF, 0xC0, 0x7E, 0x7E, 0x03, 0xF3, 0xF0, 0x1F, 0x9F, 0x80, 0xFC, 0xF8,
  0x07, 0xC7, 0xC0, 0x3E, 0x7E, 0x03, 0xF3, 0xF0, 0x1F, 0x9F, 0x00, 0xF8,
  0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0xFC, 0x08, 0x3C, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x01, 0xE0, 0x00, 0x07, 0xC0,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xF3, 0xCF, 0xF0, 0x03, 0xF0, 0xF0, 0xFE,
  0x01, 0xF8, 0x3C, 0x1F, 0x80, 0x7E, 0x0F, 0x07, 0xE0, 0x3F, 0x03, 0xC1,
  0xF8, 0x0F, 0xC0, 0xE0, 0x7E, 0x03, 0xE0, 0x78, 0x1F, 0x81, 0xF8, 0x1E,
  0x00, 0x00, 0x7E, 0x07, 0x80, 0x00, 0x1F, 0x81, 0xE0, 0x00, 0x07, 0xF0,
  0x78, 0x00, 0x00, 0xFC, 0x1C, 0x00, 0x00, 0x3F, 0x8F, 0x00, 0x00, 0x0F,
  0xF3, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x01, 0xE7, 0xF8, 0x00, 0x00, 0x78, 0xFE, 0x00, 0x00, 0x1C,
  0x1F, 0xC0, 0x00, 0x0F, 0x03, 0xF0, 0x00, 0x03, 0xC0, 0xFC, 0x00, 0x00,
  0xF0, 0x3F, 0x00, 0x00, 0x3C, 0x0F, 0xC0, 0x00, 0x0F, 0x03, 0xF0, 0x7C,
  0x03, 0x80, 0xFC, 0x1F, 0x01, 0xE0, 0x3F, 0x07, 0xC0, 0x78, 0x1F, 0x81,
  0xF8, 0x1E, 0x07, 0xE0, 0x7E, 0x07, 0x83, 0xF0, 0x1F, 0xC1, 0xE1, 0xFC,
  0x07, 0xFC, 0x71, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF0, 0x01,
  0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xC0, 0x0F, 0xFF,
  0xE0, 0x00, 0x78, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0x80, 0x1F, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xF0, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x01, 0xF0, 0x07,
  0xC0, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x00, 0x3E, 0x01, 0xF0, 0x0F, 0x00,
  0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x00, 0x3E, 0x01, 0xF0, 0x3E, 0x00, 0x03,
  0xC0, 0x1E, 0x07, 0xC0, 0x00, 0x3C, 0x01, 0xE0, 0xF8, 0x00, 0x07, 0xC0,
  0x3E, 0x1F, 0x00, 0x00, 0x3E, 0x03, 0xE3, 0xE0, 0x00, 0x03, 0xF0, 0xFC,
  0x3E, 0x00, 0x00, 0x3F, 0xFF, 0xC7, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0xF8,
  0x00, 0x00, 0x1F, 0xFE, 0x1F, 0x00, 0x00, 0x00, 0x7F, 0xC3, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0x87, 0xFF, 0x00, 0x00, 0x00, 0xF0, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0x1F,
  0xFF, 0xC0, 0x00, 0x03, 0xE3, 0xF0, 0xFC, 0x00, 0x00, 0x7C, 0x3E, 0x07,
  0xE0, 0x00, 0x0F, 0x87, 0xC0, 0x3E, 0x00, 0x01, 0xF0, 0x7C, 0x03, 0xE0,
  0x00, 0x1E, 0x07, 0xC0, 0x3E, 0x00, 0x03, 0xE0, 0x78, 0x03, 0xC0, 0x00,
  0x7C, 0x0F, 0x80, 0x7C, 0x00, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x00, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x03, 0xC0, 0x0F,
  0x80, 0x78, 0x00, 0x7C, 0x00, 0xF8, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0xC1,
  0xF8, 0x01, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x3E, 0x00, 0x07, 0xFF, 0xE0,
  0x07, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x03,
  0xF8, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x0F, 0xF7, 0xF0, 0x07, 0xF0, 0xFC, 0x3F, 0x00, 0x7E, 0x1F, 0x83, 0xF8,
  0x0F, 0xC1, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x00, 0xFC, 0x1F, 0x83, 0xF0,
  0x0F, 0xC3, 0xF0, 0x3F, 0x00, 0x7E, 0x7E, 0x03, 0xF0, 0x07, 0xFF, 0xC0,
  0x3F, 0x00, 0x3F, 0xFC, 0x03, 0xF0, 0x03, 0xFF, 0x80, 0x3E, 0x00, 0x1F,
  0xF0, 0x03, 0xE0, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x07, 0xE0,
  0x00, 0xFE, 0x00, 0x7E, 0x00, 0x1F, 0xF0, 0x07, 0xE0, 0x03, 0xFF, 0x00,
  0x7E, 0x00, 0x7F, 0xF8, 0x07, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0xFC,
  0xFC, 0x03, 0xFF, 0xFF, 0x8F, 0xC0, 0x1F, 0xFF, 0xF0, 0x7E, 0x00, 0xFF,
  0xFC, 0x07, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3F, 0x9F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF9, 0xFC, 0xFC, 0x7E, 0x3F, 0x1F,
  0x8F, 0xC7, 0xC3, 0xE3, 0xF1, 0xF8, 0xFC, 0x7C, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x06, 0x00, 0x3E, 0x00, 0x63, 0xE0, 0x0F, 0x00,
  0x78, 0xFF, 0x03, 0xC0, 0xFF, 0x7F, 0xE0, 0xF0, 0xFF, 0xDF, 0xFE, 0x38,
  0xFF, 0xFF, 0xFF, 0xCE, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x0F, 0x9F, 0x00, 0x00,
  0x07, 0xE7, 0xE0, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x01, 0xF8, 0x3F, 0x00,
  0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x7F,
  0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x02, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x7F,
  0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x00,
  0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x00,
  0x1F, 0x80, 0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0x81, 0xFE, 0x3F, 0xE7, 0xFE, 0x7F,
  0xE7, 0xFE, 0x7F, 0xE7, 0xFE, 0x7F, 0xC3, 0xF8, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x03,
  0xF0, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x0F,
  0xC0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x3F, 0x0F,
  0x80, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3E, 0x1F,
  0x80, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x7E, 0x1F,
  0x00, 0x00, 0x7E, 0x3F, 0x03, 0xE0, 0x7E, 0x3F, 0x07, 0xE0, 0x7E, 0x3F,
  0x0F, 0xF0, 0x7C, 0x3F, 0x0F, 0xF0, 0x7C, 0x3E, 0x0F, 0xF0, 0xFC, 0x3E,
  0x07, 0xE0, 0xFC, 0x3E, 0x03, 0xE0, 0xFC, 0x7E, 0x00, 0x00, 0xFC, 0x7E,
  0x00, 0x00, 0xF8, 0x7E, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x01, 0xF8, 0x7C,
  0x00, 0x01, 0xF8, 0x7C, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x01, 0xF8, 0xFC,
  0x00, 0x01, 0xF0, 0xFC, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x0F, 0xE0, 0x7E,
  0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x3F, 0x80, 0x3F, 0xE1, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xF9, 0xF8, 0x00, 0x7F, 0xC7,
  0xE0, 0x03, 0xFC, 0x1F, 0x80, 0x0F, 0xE0, 0x7C, 0x00, 0x3E, 0x03, 0xF0,
  0x00, 0xF0, 0x0F, 0xC0, 0x07, 0x00, 0x3F, 0x00, 0x18, 0x00, 0xFC, 0x00,
  0x40, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xE0, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x01, 0xFC, 0x07, 0xF0, 0x00,
  0x7E, 0x03, 0xF0, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0x07, 0xE0, 0xF8, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x1F, 0x00, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x3F, 0x0F, 0xC0,
  0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x1F, 0xC0, 0xFC,
  0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xFE, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x0F, 0x80, 0x3F, 0x00,
  0x3F, 0x00, 0xFC, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xE0, 0x01,
  0xF8, 0x3F, 0x80, 0x03, 0xF0, 0xFE, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x1F,
  0x87, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0xFC,
  0x3F, 0x00, 0x01, 0xF8, 0x7F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFE, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x0F,
  0xC7, 0xFF, 0x80, 0x0F, 0xCF, 0xFF, 0xC0, 0x0F, 0xDF, 0xFF, 0xE0, 0x0F,
  0xBF, 0xFF, 0xF0, 0x0F, 0xFE, 0x3F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x1F,
  0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x07, 0xE0, 0xFE, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0xC0, 0x7F,
  0x00, 0x3F, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF1, 0xFC, 0x00, 0x0F, 0xDF, 0xFE, 0x00, 0x3F, 0x7F, 0xFF,
  0x00, 0xFD, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x07, 0xFC, 0x03, 0xFE,
  0x1F, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x7E, 0x00, 0x03, 0xF9,
  0xF8, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x0F, 0xDF,
  0x80, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7E, 0xF8,
  0x00, 0x00, 0xF9, 0xF0, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0xFE, 0x3F, 0x80,
  0x03, 0xF8, 0x7F, 0x80, 0x0F, 0xE0, 0x7F, 0x80, 0x3F, 0xC0, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x9F, 0x80, 0x00, 0x3F,
  0x3E, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x07, 0xE3,
  0xF0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xF8, 0x07,
  0xF8, 0x03, 0xF0, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x7E, 0x01, 0xF8, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x07, 0xC0, 0x7E, 0x00,
  0x07, 0xE0, 0x3E, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x01, 0xF8, 0x0F, 0xC0,
  0x01, 0xF8, 0x07, 0xE0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xBF, 0xE0, 0x00,
  0xFF, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x3F, 0x00,
  0xFE, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x01, 0xF0,
  0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x3E,
  0x0F, 0xC0, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x07,
  0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0xFF, 0x0F, 0xE0, 0x00,
  0xFE, 0x1F, 0x80, 0x00, 0xFC, 0x7E, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x01,
  0xFB, 0xF0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x0F,
  0xDF, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFD,
  0xF8, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x0F, 0xC7,
  0xE0, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xFC, 0x3F,
  0xE0, 0x0F, 0xF0, 0x3F, 0xF9, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFD, 0xFC, 0x00, 0x3F, 0xE3, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x78, 0x01,
  0xFE, 0x03, 0xFE, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFE, 0x07,
  0xFE, 0x03, 0xFC, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x1F, 0xE0, 0x3F, 0xE0, 0x7F, 0xE0, 0x7F,
  0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xC0, 0x3F, 0x80, 0x0C, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x7F, 0x80, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF,
  0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xE0, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x80,
  0x1F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x80, 0x02, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F,
  0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0,
  0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0x81, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x0F, 0x81,
  0xF8, 0x00, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x01,
  0xF8, 0x7C, 0x0F, 0x80, 0x1F, 0xFC, 0xF8, 0x1F, 0x00, 0x7F, 0xFD, 0xF0,
  0x7E, 0x01, 0xFF, 0xFB, 0xC0, 0xF8, 0x03, 0xF0, 0x3F, 0x81, 0xF0, 0x0F,
  0xC0, 0x3F, 0x03, 0xE0, 0x1F, 0x00, 0x7E, 0x07, 0xC0, 0x7E, 0x00, 0xFC,
  0x0F, 0x80, 0xF8, 0x01, 0xF8, 0x3F, 0x01, 0xF0, 0x03, 0xE0, 0x7C, 0x03,
  0xE0, 0x07, 0xC0, 0xF8, 0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x1F, 0x80, 0x1F,
  0x03, 0xE0, 0x3E, 0x00, 0x3E, 0x07, 0xC0, 0x7C, 0x00, 0xFC, 0x1F, 0x80,
  0xF8, 0x01, 0xF0, 0x3E, 0x01, 0xF0, 0x03, 0xE0, 0x7C, 0x03, 0xE0, 0x07,
  0xC0, 0xF8, 0x0F, 0xC0, 0x0F, 0x81, 0xF0, 0x1F, 0x80, 0x3F, 0x03, 0xE0,
  0x3F, 0x00, 0x7E, 0x07, 0xC0, 0x7E, 0x01, 0xFC, 0x1F, 0x80, 0x7E, 0x07,
  0xF0, 0x3E, 0x00, 0xFF, 0xFD, 0xE0, 0x7C, 0x01, 0xFF, 0xF7, 0xC0, 0xF8,
  0x01, 0xFF, 0xCF, 0x81, 0xF0, 0x01, 0xFF, 0x1F, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7D, 0xF0, 0x00,
  0x00, 0x7D, 0xF8, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0xF9, 0xF8, 0x00,
  0x01, 0xF8, 0xF8, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x03, 0xF0, 0xF8, 0x00,
  0x03, 0xF0, 0xF8, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0xE0, 0xF8, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x0F, 0xC0, 0xFC, 0x00,
  0x1F, 0x80, 0xFC, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x1F, 0x00, 0x7C, 0x00,
  0x3F, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7C, 0x00,
  0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0x7E, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x07,
  0xE0, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x3E, 0x0F,
  0xC0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3F, 0x1F,
  0x80, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x3F, 0x7E,
  0x00, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0x80, 0x7F, 0xF8,
  0x07, 0xC0, 0x03, 0xFC, 0x07, 0xE0, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x3F,
  0x81, 0xF8, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x03,
  0xF0, 0x3E, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00,
  0xFC, 0x0F, 0xC0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7E, 0x03, 0xE0, 0x00,
  0x7F, 0x01, 0xF0, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xC0, 0x07, 0xFC, 0x07, 0xE0,
  0x00, 0xFE, 0x03, 0xF0, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x0F, 0xC0, 0xFC,
  0x00, 0x07, 0xE0, 0x7C, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0xF8, 0x3F,
  0x00, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x0F, 0xF0,
  0x3F, 0x00, 0x3F, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0x01,
  0xFE, 0x01, 0xFC, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x7F, 0x03, 0xF0, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00,
  0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03,
  0xF0, 0x7C, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07,
  0xE0, 0x7E, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x3F,
  0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0x80,
  0x7F, 0xF0, 0x0F, 0xC0, 0x07, 0xF8, 0x07, 0xE0, 0x00, 0xFE, 0x03, 0xF0,
  0x00, 0x3F, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x0F, 0xC0, 0x7C,
  0x00, 0x03, 0xE0, 0x3E, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x01, 0xF8, 0x1F,
  0x80, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x07, 0xC0,
  0xFC, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x01, 0xF8,
  0x1F, 0x80, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3E,
  0x07, 0xE0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x0F,
  0xC0, 0xFC, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x01,
  0xF0, 0x3F, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0xFC, 0x0F, 0xC0, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3F, 0x01, 0xF0, 0x00,
  0x1F, 0x81, 0xF8, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x1F, 0xC0, 0x7E, 0x00,
  0x1F, 0xC0, 0x3F, 0x00, 0x7F, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xF0, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0x01,
  0xFE, 0x01, 0xFC, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x7F, 0x03, 0xF0, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00,
  0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x01, 0xFF,
  0xFC, 0x3F, 0x01, 0xFF, 0xFC, 0x3F, 0x03, 0xFF, 0xFC, 0x3F, 0x03, 0xFF,
  0xFC, 0x3F, 0x03, 0xFF, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x01,
  0xF8, 0x7E, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x01,
  0xF8, 0x7E, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03,
  0xF0, 0x7C, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07,
  0xE0, 0x7E, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x3F,
  0x80, 0x3F, 0xFB, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x03, 0xF0, 0x1F, 0x80,
  0x00, 0xFC, 0x07, 0xE0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x7C,
  0x00, 0x07, 0xE0, 0x1F, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x7E, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x01, 0xF0,
  0x0F, 0xC0, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x7E, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0xFC, 0x07, 0xE0, 0x00,
  0x3E, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x07, 0xE0, 0x3F, 0x00,
  0x01, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x03, 0xF0,
  0x1F, 0x80, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x7C, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00,
  0x7E, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x07, 0xC0, 0x3F, 0x00,
  0x01, 0xF0, 0x0F, 0x80, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x3F, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0xFC, 0x07,
  0xE0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x07, 0xE0,
  0x3F, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x03, 0xF0, 0x3F, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0xFC,
  0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x1F, 0x80,
  0x7F, 0x00, 0x07, 0xE0, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x01,
  0xF8, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0xF8,
  0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x0F, 0xE0,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00,
  0x7F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x3F, 0x80, 0x03,
  0xF0, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0xFC, 0x01, 0xFC,
  0x00, 0x07, 0xE0, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x01, 0xF0,
  0x0F, 0xE0, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x07,
  0xE0, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x07, 0xF0,
  0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x03, 0xE0,
  0x07, 0xF0, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x1F, 0x00, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x07, 0xF0, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00,
  0xFF, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x01, 0xFF, 0x01, 0xFF,
  0x00, 0x3E, 0xE0, 0x1F, 0xF0, 0x03, 0xFE, 0x03, 0xFF, 0x00, 0x3D, 0xE0,
  0x3F, 0xF0, 0x07, 0xDE, 0x03, 0xCF, 0x00, 0x79, 0xE0, 0x3C, 0xF0, 0x0F,
  0xBE, 0x03, 0xCF, 0x80, 0xF3, 0xE0, 0x3C, 0xF8, 0x1F, 0x3C, 0x03, 0xCF,
  0x81, 0xF3, 0xC0, 0x7C, 0xF8, 0x3E, 0x7C, 0x07, 0xC7, 0x83, 0xE7, 0xC0,
  0x7C, 0x78, 0x7C, 0x7C, 0x07, 0xC7, 0x87, 0xC7, 0xC0, 0x7C, 0x7C, 0xF8,
  0xF8, 0x07, 0xC7, 0xCF, 0x8F, 0x80, 0xFC, 0x3C, 0xF0, 0xF8, 0x0F, 0xC3,
  0xDF, 0x0F, 0x80, 0xF8, 0x3D, 0xE1, 0xF8, 0x0F, 0x83, 0xFE, 0x1F, 0x80,
  0xF8, 0x3F, 0xC1, 0xF0, 0x0F, 0x83, 0xFC, 0x1F, 0x01, 0xF8, 0x1F, 0x81,
  0xF0, 0x1F, 0x81, 0xF8, 0x3F, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x1F, 0x80,
  0x00, 0x3F, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00, 0x3E, 0x03,
  0xF0, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x3F, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x3E, 0x00,
  0x00, 0x7C, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x00, 0xFC, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x7C, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0xFC, 0x00,
  0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x07, 0xC0, 0x7F, 0x80, 0x03, 0xF0, 0x1F, 0xE0, 0x00,
  0xFC, 0x07, 0xFC, 0x00, 0x3F, 0x01, 0xFF, 0x00, 0x0F, 0xC0, 0x7F, 0xC0,
  0x03, 0xE0, 0x3F, 0xF0, 0x00, 0xF8, 0x0F, 0xFC, 0x00, 0x3E, 0x03, 0xEF,
  0x80, 0x1F, 0x80, 0xFB, 0xE0, 0x07, 0xE0, 0x3E, 0xF8, 0x01, 0xF8, 0x0F,
  0xBE, 0x00, 0x7C, 0x07, 0xEF, 0x80, 0x1F, 0x01, 0xF9, 0xF0, 0x07, 0xC0,
  0x7E, 0x7C, 0x03, 0xF0, 0x1F, 0x1F, 0x00, 0xFC, 0x07, 0xC7, 0xC0, 0x3F,
  0x01, 0xF1, 0xF0, 0x0F, 0xC0, 0xFC, 0x3E, 0x03, 0xE0, 0x3F, 0x0F, 0x80,
  0xF8, 0x0F, 0xC3, 0xE0, 0x7E, 0x03, 0xF0, 0xF8, 0x1F, 0x80, 0xF8, 0x3E,
  0x07, 0xE0, 0x3E, 0x07, 0xC1, 0xF8, 0x0F, 0x81, 0xF0, 0x7C, 0x07, 0xE0,
  0x7C, 0x1F, 0x01, 0xF8, 0x1F, 0x07, 0xC0, 0x7E, 0x07, 0xC3, 0xF0, 0x1F,
  0x00, 0xF8, 0xFC, 0x07, 0xC0, 0x3E, 0x3F, 0x01, 0xF0, 0x0F, 0x8F, 0x80,
  0xFC, 0x03, 0xE3, 0xE0, 0x3F, 0x00, 0xF8, 0xF8, 0x0F, 0xC0, 0x1F, 0x3E,
  0x03, 0xF0, 0x07, 0xDF, 0x80, 0xF8, 0x01, 0xF7, 0xE0, 0x3E, 0x00, 0x7D,
  0xF8, 0x1F, 0x80, 0x1F, 0x7C, 0x07, 0xE0, 0x03, 0xFF, 0x01, 0xF8, 0x00,
  0xFF, 0xC0, 0x7E, 0x00, 0x3F, 0xF0, 0x1F, 0x00, 0x0F, 0xFC, 0x07, 0xC0,
  0x03, 0xFF, 0x03, 0xF0, 0x00, 0x7F, 0x80, 0xFC, 0x00, 0x1F, 0xE0, 0x3F,
  0x00, 0x07, 0xF8, 0x0F, 0xC0, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0xFE,
  0x03, 0xF0, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x3F,
  0x07, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3E,
  0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7E,
  0x0F, 0x80, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x7C,
  0x1F, 0x80, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFC,
  0x1F, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC,
  0x3F, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF8,
  0x3F, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x01, 0xF8,
  0x7E, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x03, 0xF0,
  0x7E, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x03, 0xF0,
  0x7E, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xC0,
  0x7F, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xE0, 0x07, 0xFF, 0x00, 0xFC,
  0x00, 0x0F, 0xF0, 0x1F, 0x80, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x0F, 0xE0,
  0x7E, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x03,
  0xF0, 0x3E, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0x01, 0xF8, 0x3F, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0xFC,
  0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x1F, 0xC0,
  0xFC, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x01, 0xFE, 0x03, 0xF0, 0x03, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xF8,
  0x00, 0xFE, 0x03, 0xF0, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x0F, 0xC0,
  0x00, 0x3F, 0x0F, 0x80, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3F, 0x1F, 0x80,
  0x00, 0x3E, 0x1F, 0x80, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x7E, 0x1F, 0x80,
  0x00, 0x7E, 0x1F, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x7E, 0x3F, 0x00,
  0x00, 0x7E, 0x3F, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x00,
  0x00, 0xFC, 0x3E, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x00, 0xFC, 0x7E, 0x00,
  0x00, 0xFC, 0x7E, 0x00, 0x00, 0xF8, 0x7E, 0x00, 0x01, 0xF8, 0x7E, 0x00,
  0x01, 0xF8, 0x7E, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x01, 0xF8, 0xFC, 0x00,
  0x01, 0xF8, 0xFC, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00,
  0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xE0, 0xFE, 0x00,
  0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x3F, 0x80, 0x3F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x01, 0xFF, 0xC0, 0x3F, 0x00, 0x07, 0xF8,
  0x0F, 0xC0, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x07,
  0xF0, 0x3F, 0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0x3F, 0x03, 0xE0, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x80,
  0x00, 0x7E, 0x07, 0xE0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x0F, 0xE0, 0x7C,
  0x00, 0x03, 0xF0, 0x3F, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0xFE, 0x03,
  0xF0, 0x01, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x7E, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x07, 0xE0, 0x1F,
  0x80, 0x01, 0xF0, 0x07, 0xF0, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x0F, 0x80, 0x03, 0xF0, 0x07,
  0xE0, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x07, 0xE0,
  0x1F, 0x80, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x7F, 0x01, 0xF0, 0x00, 0x1F,
  0xC0, 0xFC, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x3F, 0xC0, 0x3F, 0xC0, 0x0F, 0xC0, 0x03, 0xF8, 0x07, 0xE0, 0x00, 0xFE,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x01,
  0xF8, 0x0F, 0x80, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x03, 0xF0, 0x7C,
  0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x1F, 0x81,
  0xF8, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x07, 0xF0, 0x1F, 0xF0, 0x07, 0xF8,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x07, 0xE0, 0x7E,
  0x00, 0x03, 0xF0, 0x3E, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x1F,
  0x80, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x07, 0xC0,
  0xFC, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x01, 0xF8,
  0x1F, 0x80, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x3F,
  0x07, 0xE0, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x0F,
  0xC0, 0xFC, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x01,
  0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0xFC, 0x0F, 0xC0, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x0F, 0xC0, 0xF8, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x03, 0xE0, 0x7E, 0x00,
  0x03, 0xF0, 0x3F, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0xFC, 0x0F, 0xC0,
  0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x3F, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0xFC, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x1F, 0xC0, 0x3F,
  0xC0, 0x1F, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7E,
  0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x00, 0xFC,
  0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x01, 0xF8,
  0x7C, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x03, 0xF0,
  0x7E, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xC0,
  0x7E, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x1F, 0x80,
  0x3E, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3F, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0xF8, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x1F, 0x03, 0xF0, 0x00,
  0x1F, 0x03, 0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x1F, 0x07, 0xE0, 0x00,
  0x1F, 0x87, 0xC0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x1F, 0x8F, 0xC0, 0x00,
  0x1F, 0x8F, 0x80, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x1F, 0x9F, 0x00, 0x00,
  0x0F, 0xBF, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x7E, 0x00, 0xF9, 0xF8, 0x07, 0xF0, 0x07, 0xCF, 0x80, 0x3F,
  0x80, 0x3E, 0x7C, 0x01, 0xFC, 0x03, 0xF3, 0xE0, 0x0F, 0xE0, 0x1F, 0x1F,
  0x00, 0xFF, 0x00, 0xF8, 0xF8, 0x07, 0xF8, 0x0F, 0xC7, 0xC0, 0x3B, 0xC0,
  0x7C, 0x3E, 0x03, 0xDE, 0x03, 0xE1, 0xF0, 0x1E, 0xF0, 0x1F, 0x0F, 0x80,
  0xF7, 0x01, 0xF8, 0x7C, 0x07, 0x38, 0x0F, 0x83, 0xE0, 0x79, 0xC0, 0x7C,
  0x1F, 0x03, 0xCE, 0x03, 0xE0, 0xF8, 0x1E, 0x70, 0x3E, 0x07, 0xC0, 0xE3,
  0x81, 0xF0, 0x7E, 0x0F, 0x1C, 0x0F, 0x83, 0xF0, 0x78, 0xE0, 0x7C, 0x1F,
  0x83, 0x87, 0x07, 0xC0, 0xF8, 0x3C, 0x78, 0x3E, 0x07, 0xC1, 0xE3, 0xC1,
  0xF0, 0x3E, 0x0F, 0x1E, 0x0F, 0x81, 0xF0, 0x70, 0xF0, 0xF8, 0x0F, 0x87,
  0x87, 0x87, 0xC0, 0x7C, 0x3C, 0x3C, 0x3E, 0x03, 0xE1, 0xC1, 0xE3, 0xE0,
  0x1F, 0x1E, 0x0F, 0x1F, 0x00, 0xF8, 0xF0, 0x78, 0xF8, 0x07, 0xC7, 0x83,
  0xC7, 0xC0, 0x3E, 0x38, 0x1E, 0x7C, 0x01, 0xF3, 0xC0, 0xF3, 0xE0, 0x0F,
  0x9E, 0x07, 0x9F, 0x00, 0x7C, 0xE0, 0x3C, 0xF8, 0x03, 0xEF, 0x01, 0xCF,
  0x80, 0x1F, 0x78, 0x0E, 0x7C, 0x00, 0xFB, 0xC0, 0x73, 0xE0, 0x07, 0xDC,
  0x03, 0x9E, 0x00, 0x3D, 0xE0, 0x1D, 0xF0, 0x01, 0xEF, 0x00, 0xEF, 0x80,
  0x1F, 0x78, 0x07, 0x7C, 0x00, 0xFF, 0x80, 0x3B, 0xC0, 0x07, 0xFC, 0x03,
  0xFE, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x00,
  0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x7F, 0x00, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0xFC, 0x00,
  0x00, 0x07, 0xE1, 0xFC, 0x00, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x00, 0x03,
  0xF3, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x00, 0x0F, 0xCF, 0xC0,
  0x00, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x00,
  0x7F, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x03,
  0xF0, 0x00, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x00, 0x7E,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x03, 0xF1, 0xF8, 0x00,
  0x00, 0xFC, 0x7E, 0x00, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x03, 0xF8, 0x07,
  0xE0, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x0F, 0xC0, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0xFC, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0xFC, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x01, 0xF8, 0x1F,
  0x80, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x03, 0xF1,
  0xF8, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x3F,
  0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x07,
  0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03,
  0xE0, 0x00, 0x3F, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x1F, 0x3C, 0x00,
  0x01, 0xF3, 0xE0, 0x00, 0x3E, 0x3E, 0x00, 0x07, 0xE1, 0xE0, 0x00, 0x7C,
  0x1F, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0xF8, 0x1F, 0x00, 0x1F, 0x00, 0xF0,
  0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x07, 0x80, 0x7C,
  0x00, 0x7C, 0x0F, 0x80, 0x07, 0xC1, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x03,
  0xE3, 0xE0, 0x00, 0x3E, 0x7E, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E, 0xFC,
  0x00, 0x01, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x07, 0xE0, 0x3F, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7F, 0xF0, 0xFC, 0x01, 0xFF, 0xF9, 0xF8, 0x0F, 0xFF, 0xF3,
  0xF0, 0x3F, 0xFF, 0xF7, 0xE0, 0x7F, 0xC1, 0xEF, 0xC1, 0xFC, 0x00, 0xDF,
  0x07, 0xF0, 0x00, 0xBE, 0x0F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xF8,
  0x7E, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x0F, 0x87,
  0xE0, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0xFC, 0x3F,
  0x00, 0x01, 0xF8, 0x7E, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x07, 0xE3, 0xF0,
  0x00, 0x0F, 0x87, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x7E, 0x1F, 0x80,
  0x00, 0xFC, 0x3F, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x03, 0xF0, 0xFC, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00,
  0xFE, 0x0F, 0xE0, 0x03, 0xFC, 0x1F, 0xE0, 0x0F, 0xF8, 0x1F, 0xF0, 0xFB,
  0xE0, 0x3F, 0xFF, 0xE7, 0xC0, 0x3F, 0xFF, 0xDF, 0x80, 0x3F, 0xFE, 0x3F,
  0x00, 0x3F, 0xF8, 0x7E, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x03, 0xE1, 0xFF,
  0xE0, 0x07, 0xE3, 0xFF, 0xF0, 0x07, 0xE7, 0xFF, 0xF8, 0x07, 0xEF, 0xFF,
  0xF8, 0x07, 0xFF, 0x07, 0xFC, 0x07, 0xDC, 0x01, 0xFC, 0x07, 0xF0, 0x00,
  0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x00,
  0x7E, 0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0x80, 0x00,
  0x7E, 0x1F, 0x80, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0x00,
  0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x00, 0x00,
  0xFC, 0x1F, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x01,
  0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x01,
  0xF8, 0x3F, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x07,
  0xF0, 0x7F, 0x80, 0x0F, 0xE0, 0x7F, 0xC0, 0x1F, 0xC0, 0x7F, 0xF8, 0xFF,
  0xC0, 0x7D, 0xFF, 0xFF, 0x80, 0xFC, 0xFF, 0xFF, 0x00, 0xFC, 0x7F, 0xFE,
  0x00, 0xFC, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xC3, 0xFF, 0x01, 0xFE, 0x00, 0xFF,
  0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x80, 0x01, 0xF8,
  0x7E, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0xF8, 0x00,
  0x07, 0xE1, 0xF8, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00,
  0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0xE0, 0x0F, 0xF0, 0x1F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x07, 0xC0, 0x03,
  0xFF, 0x87, 0xE0, 0x03, 0xFF, 0xF3, 0xF0, 0x07, 0xFF, 0xF9, 0xF8, 0x07,
  0xFF, 0xFE, 0xFC, 0x03, 0xFE, 0x0F, 0x7E, 0x03, 0xF8, 0x01, 0xBE, 0x03,
  0xF8, 0x00, 0x5F, 0x01, 0xF8, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x1F, 0xC0,
  0xFC, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x01, 0xF8,
  0x3F, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x7E,
  0x07, 0xE0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x03,
  0xF0, 0x3F, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0xFC, 0x0F, 0xC0, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x3F, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x1F, 0xE0, 0x3F, 0xC0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x7D, 0xF0, 0x07, 0xFF, 0xFC, 0xF8, 0x01, 0xFF,
  0xFE, 0xFC, 0x00, 0x7F, 0xFC, 0x7E, 0x00, 0x1F, 0xFC, 0x3F, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xF0,
  0x1F, 0xE0, 0x7F, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x00,
  0xFC, 0x3E, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x3F,
  0x1F, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x0F, 0x8F,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFE, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x7E, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x3F, 0x07, 0xF0, 0x01, 0xFC, 0x0F,
  0xF8, 0x3F, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0xFC, 0x01, 0xFF, 0xF9, 0xF8, 0x0F,
  0xFF, 0xFB, 0xF0, 0x3F, 0xFF, 0xF7, 0xE0, 0x7F, 0xC1, 0xEF, 0xC1, 0xFC,
  0x00, 0xFF, 0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xC0, 0x01, 0xFC, 0x3F, 0x80,
  0x01, 0xF8, 0x7E, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xE1, 0xF0, 0x00,
  0x0F, 0x87, 0xE0, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x00,
  0xFC, 0x3F, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x07,
  0xE1, 0xF0, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x7E,
  0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x07, 0xF0,
  0xFE, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x3F, 0x81, 0xFC, 0x01, 0xFF, 0x03,
  0xFE, 0x0F, 0xFE, 0x03, 0xFF, 0xFE, 0xFC, 0x07, 0xFF, 0xF9, 0xF8, 0x07,
  0xFF, 0xE3, 0xE0, 0x07, 0xFF, 0x87, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x3F, 0x00, 0x03, 0xE1, 0xFF, 0xE0, 0x07, 0xE3, 0xFF,
  0xF0, 0x07, 0xE7, 0xFF, 0xF8, 0x07, 0xEF, 0xFF, 0xFC, 0x07, 0xFF, 0x07,
  0xFC, 0x07, 0xD8, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x00,
  0xFE, 0x0F, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0xC0, 0x00,
  0x7E, 0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x7C, 0x1F, 0x80, 0x00,
  0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0x00,
  0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00,
  0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x01,
  0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x01,
  0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x03,
  0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x03,
  0xE0, 0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x10,
  0x3F, 0x00, 0x01, 0xFC, 0x07, 0xC0, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x1F,
  0xC0, 0x3F, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0xFC, 0x00,
  0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xE0, 0x03, 0xF8, 0x00, 0xFC,
  0x00, 0xFE, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x03, 0xF0, 0x07, 0xE0, 0x00,
  0x7E, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x01, 0xF0, 0x1F, 0xC0,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xF8,
  0x0F, 0xC0, 0x00, 0x1F, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00,
  0xFC, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x03, 0xF0, 0x07, 0xF0,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x0F, 0xC0, 0x01, 0xF8, 0x01, 0xF8,
  0x00, 0x3F, 0x80, 0x3F, 0x00, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0x7F, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xFF, 0x80,
  0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xF0,
  0x00, 0x01, 0xE0, 0x1E, 0x00, 0x7C, 0xFF, 0x0F, 0xF0, 0x0F, 0xBF, 0xF3,
  0xFF, 0x01, 0xFF, 0xFE, 0xFF, 0xE0, 0x7D, 0xFF, 0xDF, 0xFE, 0x0F, 0xE0,
  0xFE, 0x0F, 0xC1, 0xF8, 0x1F, 0x81, 0xF8, 0x3E, 0x03, 0xE0, 0x3F, 0x07,
  0xC0, 0x7C, 0x07, 0xE0, 0xF8, 0x0F, 0x80, 0xFC, 0x3F, 0x01, 0xF0, 0x1F,
  0x07, 0xE0, 0x3E, 0x03, 0xE0, 0xF8, 0x07, 0x80, 0x7C, 0x1F, 0x00, 0xF0,
  0x0F, 0x83, 0xE0, 0x3E, 0x03, 0xF0, 0x7C, 0x07, 0xC0, 0x7E, 0x1F, 0x80,
  0xF8, 0x0F, 0x83, 0xF0, 0x1F, 0x01, 0xF0, 0x7E, 0x03, 0xC0, 0x3E, 0x0F,
  0x80, 0x78, 0x07, 0xC1, 0xF0, 0x0F, 0x01, 0xF8, 0x3E, 0x03, 0xE0, 0x3F,
  0x07, 0xC0, 0x7C, 0x07, 0xC1, 0xF8, 0x0F, 0x80, 0xF8, 0x3F, 0x01, 0xF0,
  0x1F, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0xF8, 0x07, 0x80, 0x7C, 0x1F, 0x01,
  0xF0, 0x1F, 0x83, 0xE0, 0x3E, 0x03, 0xF0, 0xFC, 0x07, 0xC0, 0x7C, 0x1F,
  0x80, 0xF8, 0x0F, 0x83, 0xE0, 0x1E, 0x01, 0xF0, 0x7C, 0x03, 0xC0, 0x3E,
  0x0F, 0x80, 0xF8, 0x0F, 0xC1, 0xF0, 0x1F, 0x01, 0xF8, 0x7E, 0x03, 0xE0,
  0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x03, 0xE1, 0xFF, 0xE0, 0x07, 0xE3,
  0xFF, 0xF0, 0x07, 0xE7, 0xFF, 0xF8, 0x07, 0xEF, 0xFF, 0xFC, 0x07, 0xFF,
  0x07, 0xFC, 0x07, 0xD8, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xE0,
  0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0xC0,
  0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x7C, 0x1F, 0x80,
  0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x80,
  0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x00,
  0x00, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x00,
  0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x3E, 0x00,
  0x01, 0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x7E, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x7C, 0x00,
  0x03, 0xE0, 0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xF8, 0x7F,
  0xE0, 0x7F, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xFC,
  0x7F, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x3F, 0x1F,
  0x00, 0x00, 0xFC, 0xFC, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x0F, 0x8F, 0xC0,
  0x00, 0x7E, 0x3F, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x07, 0xE3, 0xE0, 0x00,
  0x1F, 0x9F, 0x80, 0x00, 0x7E, 0x7E, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x0F,
  0xC7, 0xE0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0xFC, 0x7C, 0x00, 0x03, 0xF1,
  0xF0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x7E, 0x1F, 0x80, 0x01, 0xF8, 0x7E,
  0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x7F, 0x07, 0xF8, 0x03, 0xF8, 0x0F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x3E, 0x1F, 0xFE, 0x00, 0x1F, 0x8F, 0xFF, 0xC0, 0x07, 0xE7,
  0xFF, 0xF8, 0x01, 0xFB, 0xFF, 0xFF, 0x00, 0x7F, 0xF0, 0x7F, 0xC0, 0x1F,
  0x70, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0xFE, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x7E,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x01,
  0xF0, 0x1F, 0x80, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x3F, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x7E, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00, 0xFC, 0x0F, 0xC0,
  0x00, 0x3E, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x07, 0xE0, 0x3F,
  0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x01, 0xF8,
  0x07, 0xF8, 0x00, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x7D, 0xF8, 0xFF,
  0xC0, 0x1F, 0x3F, 0xFF, 0xE0, 0x0F, 0xCF, 0xFF, 0xF0, 0x03, 0xF1, 0xFF,
  0xF8, 0x00, 0xFC, 0x3F, 0xF8, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7F, 0xF0, 0xFC, 0x03, 0xFF, 0xF9, 0xF8, 0x0F, 0xFF, 0xF3,
  0xF0, 0x3F, 0xFF, 0xF7, 0xE0, 0xFF, 0xC3, 0xEF, 0xC1, 0xFC, 0x00, 0xDF,
  0x07, 0xF0, 0x01, 0xFE, 0x0F, 0xC0, 0x01, 0xFC, 0x3F, 0x00, 0x03, 0xF8,
  0x7E, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x0F, 0x87,
  0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0xFC, 0x3F,
  0x00, 0x01, 0xF8, 0x7E, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x07, 0xC3, 0xF0,
  0x00, 0x0F, 0x87, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x7E, 0x1F, 0x80,
  0x00, 0xFC, 0x3F, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x03, 0xF0, 0xF8, 0x00,
  0x0F, 0xC1, 0xF0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7F, 0x07, 0xE0, 0x00,
  0xFE, 0x0F, 0xE0, 0x03, 0xFC, 0x1F, 0xE0, 0x1F, 0xF8, 0x3F, 0xF0, 0xFB,
  0xE0, 0x3F, 0xFF, 0xE7, 0xC0, 0x3F, 0xFF, 0x9F, 0x80, 0x3F, 0xFE, 0x3F,
  0x00, 0x3F, 0xF8, 0x7E, 0x00, 0x07, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x03, 0xE1, 0xFF, 0xE0, 0x03,
  0xE3, 0xFF, 0xF0, 0x07, 0xE7, 0xFF, 0xF8, 0x07, 0xEF, 0xFF, 0xFC, 0x07,
  0xFF, 0x03, 0xFC, 0x07, 0xFC, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x07,
  0xF0, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7E, 0x0F,
  0xC0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7E, 0x0F,
  0x80, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xF0,
  0x1F, 0xE0, 0x7E, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x00,
  0xFC, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0xF8,
  0xFC, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x3F, 0x8F, 0xF0, 0x01, 0xFC, 0x1F,
  0xFC, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x00,
  0xFC, 0x3F, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07,
  0xE1, 0xF0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x7E,
  0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x03, 0xF0,
  0xF8, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x3F, 0x0F,
  0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x01, 0xF8, 0x7E,
  0x00, 0x03, 0xF0, 0xF8, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x0F, 0x87, 0xE0,
  0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x00,
  0x01, 0xF8, 0x7E, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0x1F, 0x83, 0xF0, 0x00, 0x7E, 0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xFC, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F,
  0xBF, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x0F, 0xC7,
  0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x01, 0xF8, 0x7E, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8, 0x0F, 0x80, 0x07, 0xE0, 0x3E, 0x00,
  0x3F, 0x00, 0xF8, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7C, 0x00, 0x7C, 0x03, 0xF0, 0x01, 0xF0, 0x0F, 0x80,
  0x07, 0xC0, 0x7E, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x01,
  0xF8, 0x3E, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3E,
  0x3F, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x0F, 0xDF,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0xF8, 0x03, 0xF0, 0x07, 0xFE, 0x00, 0xFC, 0x01, 0xEF, 0x80, 0x7F,
  0x00, 0xFB, 0xE0, 0x1F, 0xC0, 0x3E, 0xF8, 0x07, 0xF0, 0x0F, 0x3E, 0x03,
  0xFC, 0x07, 0xCF, 0x80, 0xFF, 0x01, 0xF3, 0xE0, 0x3B, 0xC0, 0x78, 0xF8,
  0x1E, 0xF0, 0x3E, 0x3E, 0x07, 0xBC, 0x0F, 0x8F, 0x81, 0xCF, 0x03, 0xC3,
  0xE0, 0xF3, 0xC1, 0xF0, 0xF8, 0x3C, 0xF0, 0x7C, 0x3E, 0x0E, 0x3C, 0x1E,
  0x0F, 0x87, 0x8F, 0x07, 0x83, 0xE1, 0xE3, 0xC3, 0xE0, 0xF8, 0x70, 0xF0,
  0xF0, 0x3E, 0x3C, 0x3C, 0x3C, 0x0F, 0x8F, 0x0F, 0x1F, 0x03, 0xE3, 0x83,
  0xC7, 0xC0, 0xF9, 0xE0, 0xF1, 0xE0, 0x3E, 0x78, 0x3C, 0xF8, 0x0F, 0x9C,
  0x0F, 0x3E, 0x03, 0xE7, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0xF3, 0xC0, 0x3C,
  0xE0, 0x3D, 0xF0, 0x0F, 0x38, 0x0F, 0x78, 0x03, 0xDE, 0x03, 0xDE, 0x00,
  0xF7, 0x00, 0xFF, 0x80, 0x3D, 0xC0, 0x3F, 0xC0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x03, 0xFC, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x3F,
  0x80, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x1F,
  0x80, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x0F, 0xC0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x7F, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x01,
  0xF8, 0x3F, 0x00, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x00, 0xFC, 0xFC, 0x00,
  0x00, 0x07, 0xDF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x3F, 0x1F,
  0x80, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0xFC, 0x00, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x7E, 0x00,
  0x07, 0xF0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x01, 0xFC, 0x07, 0xF0,
  0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x7E,
  0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x03, 0xF0,
  0xFC, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x1F, 0x0F,
  0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x01, 0xF8, 0x7E,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x0F, 0x87, 0xE0,
  0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x00,
  0x01, 0xF8, 0x7E, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x07, 0xC3, 0xF0, 0x00,
  0x0F, 0x87, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x00,
  0xFC, 0x3F, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x37,
  0xC0, 0xFE, 0x00, 0xFF, 0x81, 0xFF, 0xCF, 0xFF, 0x01, 0xFF, 0xFF, 0x7E,
  0x03, 0xFF, 0xFC, 0xFC, 0x03, 0xFF, 0xF1, 0xF8, 0x01, 0xFF, 0x83, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x01,
  0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03,
  0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C,
  0x00, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0x07, 0xFE, 0x00, 0x3F, 0x0F,
  0xFF, 0x00, 0x3F, 0x1F, 0xFF, 0x80, 0x3E, 0x3F, 0xFF, 0xC0, 0x3E, 0x7E,
  0x0F, 0xE0, 0x3E, 0x7E, 0x07, 0xE0, 0x7E, 0x7C, 0x07, 0xF0, 0xFC, 0x7C,
  0x03, 0xFF, 0xFC, 0xFC, 0x01, 0xFF, 0xF8, 0xFC, 0x00, 0xFF, 0xF0, 0xFC,
  0x00, 0x7F, 0xE0, 0xF8, 0x00, 0x3F, 0x80,
};

const GFXglyph JetBrainsMono_Italic64pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 38, 0, -1 },
  { 1, 15, 47, 38, 12, -47 },
  { 90, 21, 19, 38, 12, -47 },
  { 140, 38, 47, 38, 1, -47 },
  { 364, 34, 65, 38, 3, -56 },
  { 641, 44, 47, 38, -2, -47 },
  { 900, 36, 48, 38, 1, -47 },
  { 1116, 9, 19, 38, 18, -47 },
  { 1138, 27, 62, 38, 10, -54 },
  { 1348, 26, 62, 38, 3, -54 },
  { 1550, 34, 33, 38, 3, -39 },
  { 1691, 31, 30, 38, 4, -36 },
  { 1808, 17, 20, 38, 6, -10 },
  { 1851, 21, 5, 38, 9, -24 },
  { 1865, 12, 11, 38, 11, -10 },
  { 1882, 38, 60, 38, 1, -53 },
  { 2167, 32, 48, 38, 4, -47 },
  { 2359, 30, 47, 38, 3, -47 },
  { 2536, 33, 47, 38, 3, -47 },
  { 2730, 33, 48, 38, 3, -47 },
  { 2928, 31, 47, 38, 4, -47 },
  { 3111, 32, 48, 38, 4, -47 },
  { 3303, 31, 48, 38, 3, -47 },
  { 3489, 31, 47, 38, 8, -47 },
  { 3672, 33, 48, 38, 3, -47 },
  { 3870, 31, 47, 38, 6, -47 },
  { 4053, 16, 37, 38, 11, -36 },
  { 4127, 21, 46, 38, 6, -36 },
  { 4248, 31, 34, 38, 5, -38 },
  { 4380, 31, 20, 38, 4, -31 },
  { 4458, 31, 34, 38, 3, -38 },
  { 4590, 26, 47, 38, 9, -47 },
  { 4743, 39, 59, 38, 0, -47 },
  { 5031, 32, 47, 38, 0, -47 },
  { 5219, 33, 47, 38, 3, -47 },
  { 5413, 32, 48, 38, 4, -47 },
  { 5605, 33, 47, 38, 3, -47 },
  { 5799, 34, 47, 38, 4, -47 },
  { 5999, 35, 47, 38, 3, -47 },
  { 6205, 32, 48, 38, 4, -47 },
  { 6397, 34, 47, 38, 3, -47 },
  { 6597, 32, 47, 38, 4, -47 },
  { 6785, 35, 48, 38, 1, -47 },
  { 6995, 37, 47, 38, 3, -47 },
  { 7213, 27, 47, 38, 5, -47 },
  { 7372, 36, 47, 38, 2, -47 },
  { 7584, 34, 47, 38, 3, -47 },
  { 7784, 32, 48, 38, 4, -47 },
  { 7976, 35, 47, 38, 3, -47 },
  { 8182, 32, 59, 38, 4, -47 },
  { 8418, 34, 47, 38, 3, -47 },
  { 8618, 34, 48, 38, 3, -47 },
  { 8822, 32, 47, 38, 7, -47 },
  { 9010, 33, 48, 38, 4, -47 },
  { 9208, 32, 47, 38, 8, -47 },
  { 9396, 37, 47, 38, 4, -47 },
  { 9614, 40, 47, 38, 0, -47 },
  { 9849, 34, 47, 38, 7, -47 },
  { 10049, 34, 47, 38, 3, -47 },
  { 10249, 25, 60, 38, 9, -53 },
  { 10437, 20, 60, 38, 10, -53 },
  { 10587, 25, 60, 38, 6, -53 },
  { 10775, 28, 25, 38, 6, -47 },
  { 10863, 31, 4, 38, 0, 2 },
  { 10879, 12, 9, 38, 17, -50 },
  { 10893, 31, 37, 38, 4, -36 },
  { 11037, 32, 48, 38, 3, -47 },
  { 11229, 31, 37, 38, 4, -36 },
  { 11373, 33, 48, 38, 4, -47 },
  { 11571, 30, 37, 38, 4, -36 },
  { 11710, 44, 59, 38, -3, -47 },
  { 12035, 31, 48, 38, 4, -36 },
  { 12221, 32, 47, 38, 3, -47 },
  { 12409, 31, 50, 38, 2, -50 },
  { 12603, 33, 62, 38, 1, -50 },
  { 12859, 35, 47, 38, 3, -47 },
  { 13065, 27, 47, 38, 6, -47 },
  { 13224, 35, 36, 38, 1, -36 },
  { 13382, 32, 36, 38, 3, -36 },
  { 13526, 30, 37, 38, 4, -36 },
  { 13665, 34, 48, 38, 1, -36 },
  { 13869, 31, 48, 38, 4, -36 },
  { 14055, 32, 36, 38, 4, -36 },
  { 14199, 30, 37, 38, 4, -36 },
  { 14338, 31, 45, 38, 5, -45 },
  { 14513, 31, 36, 38, 4, -35 },
  { 14653, 30, 35, 38, 7, -35 },
  { 14785, 34, 35, 38, 5, -35 },
  { 14934, 36, 35, 38, 1, -35 },
  { 15092, 31, 47, 38, 4, -35 },
  { 15275, 32, 35, 38, 3, -35 },
  { 15415, 33, 60, 38, 6, -53 },
  { 15663, 16, 60, 38, 12, -53 },
  { 15783, 32, 60, 38, 2, -53 },
  { 16023, 32, 13, 38, 4, -29 },
};

const GFXfont JetBrainsMono_Italic64pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Italic64pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Italic64pt7bGlyphs,
  0x20, 0x7E, 84
};

#endif // _JETBRAINSMONO_ITALIC64PT7B_H_
