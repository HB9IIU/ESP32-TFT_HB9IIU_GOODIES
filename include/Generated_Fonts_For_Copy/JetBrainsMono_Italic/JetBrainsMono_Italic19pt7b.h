#ifndef _JETBRAINSMONO_ITALIC19PT7B_H_
#define _JETBRAINSMONO_ITALIC19PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Italic.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Italic19pt7bBitmaps[] PROGMEM = {
  0x00, 0x33, 0x32, 0x66, 0x66, 0x44, 0x00, 0xCC, 0xCF, 0x3C, 0xE2, 0x8A,
  0x60, 0x06, 0x20, 0x46, 0x04, 0x40, 0xC5, 0x3F, 0xE0, 0x88, 0x18, 0x81,
  0x18, 0x11, 0x07, 0xFC, 0xA3, 0x02, 0x20, 0x62, 0x04, 0x60, 0x02, 0x00,
  0x80, 0x20, 0x3C, 0x1F, 0x8D, 0x32, 0x4D, 0x90, 0x34, 0x0F, 0x80, 0xF0,
  0x2E, 0x09, 0xB2, 0x6C, 0x93, 0xBC, 0x7E, 0x04, 0x01, 0x00, 0x40, 0x0E,
  0x0C, 0x4C, 0x43, 0x33, 0x0C, 0x98, 0x32, 0xC0, 0xFA, 0x00, 0x10, 0x00,
  0x80, 0x05, 0xE0, 0x34, 0xC1, 0x93, 0x04, 0xCC, 0x23, 0x23, 0x07, 0x80,
  0x0F, 0x83, 0xB8, 0x63, 0x08, 0x01, 0x80, 0x30, 0x0F, 0x03, 0x63, 0x66,
  0xCC, 0xF1, 0x0C, 0x21, 0x86, 0x78, 0xF9, 0x80, 0x6D, 0xAD, 0x80, 0x03,
  0x07, 0x1C, 0x10, 0x30, 0x20, 0x60, 0x60, 0x60, 0x40, 0x40, 0xC0, 0xC0,
  0xC0, 0x60, 0x60, 0x38, 0x18, 0x10, 0x1C, 0x0E, 0x06, 0x02, 0x03, 0x03,
  0x02, 0x02, 0x06, 0x06, 0x06, 0x04, 0x0C, 0x0C, 0x18, 0x70, 0xC0, 0x06,
  0x01, 0x00, 0x41, 0x13, 0xF7, 0xCF, 0x81, 0xC0, 0xD8, 0x66, 0x10, 0xC0,
  0x04, 0x02, 0x03, 0x01, 0x8F, 0xF8, 0x60, 0x20, 0x10, 0x18, 0x00, 0x39,
  0x98, 0xCC, 0x60, 0xFC, 0x6F, 0x60, 0x00, 0x30, 0x06, 0x00, 0x40, 0x0C,
  0x00, 0x80, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0,
  0x18, 0x01, 0x80, 0x30, 0x02, 0x00, 0x60, 0x0C, 0x00, 0x0F, 0x0E, 0x63,
  0x0D, 0x83, 0x60, 0xD8, 0x26, 0xC9, 0x36, 0x41, 0xB0, 0x6C, 0x1B, 0x0C,
  0x67, 0x1F, 0x00, 0x07, 0x0F, 0x0D, 0x8C, 0xC0, 0x60, 0x30, 0x18, 0x08,
  0x04, 0x06, 0x03, 0x01, 0x8F, 0xFF, 0xFC, 0x0F, 0x0E, 0xE2, 0x0D, 0x83,
  0x00, 0x80, 0x60, 0x30, 0x1C, 0x0E, 0x06, 0x03, 0x01, 0x80, 0xFF, 0x3F,
  0xC0, 0x3F, 0xCF, 0xE0, 0x18, 0x18, 0x0C, 0x03, 0x81, 0xF0, 0x06, 0x01,
  0x80, 0x6C, 0x13, 0x0C, 0xE6, 0x1F, 0x00, 0x01, 0x81, 0x81, 0x80, 0x80,
  0xC0, 0xC0, 0xC6, 0xC3, 0x41, 0xFF, 0xBF, 0xC0, 0x60, 0x30, 0x18, 0x3F,
  0xCF, 0xE3, 0x00, 0x80, 0x20, 0x1B, 0xC7, 0x39, 0x86, 0x01, 0x80, 0x60,
  0x1B, 0x0C, 0x67, 0x1F, 0x00, 0x03, 0x03, 0x03, 0x01, 0x81, 0x81, 0xB1,
  0xFC, 0xC3, 0xC1, 0xE0, 0xF0, 0x78, 0x66, 0x73, 0xE0, 0x7F, 0xDF, 0xE4,
  0x1B, 0x04, 0x03, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x06, 0x01, 0x00, 0xC0,
  0x20, 0x18, 0x00, 0x0F, 0x0E, 0xE3, 0x0C, 0x82, 0x21, 0x8C, 0xC1, 0xE0,
  0xFC, 0x63, 0x10, 0x6C, 0x1B, 0x04, 0xE7, 0x1F, 0x80, 0x1E, 0x3B, 0x98,
  0x78, 0x3C, 0x1E, 0x0F, 0x0D, 0xFE, 0x36, 0x06, 0x06, 0x03, 0x03, 0x03,
  0x00, 0x11, 0xCE, 0x00, 0x00, 0x00, 0x63, 0xB8, 0x08, 0x71, 0xC0, 0x00,
  0x00, 0x00, 0x38, 0xC6, 0x18, 0x43, 0x00, 0x01, 0x83, 0x87, 0x0E, 0x0C,
  0x06, 0x01, 0xC0, 0x38, 0x06, 0x01, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F,
  0xFF, 0xFC, 0x60, 0x1C, 0x07, 0x80, 0xF0, 0x18, 0x1C, 0x38, 0xF0, 0xE0,
  0x40, 0x00, 0x78, 0xFC, 0x18, 0x30, 0x60, 0xC7, 0x3C, 0x60, 0xC0, 0x00,
  0x0E, 0x18, 0x00, 0x07, 0xC1, 0xC6, 0x30, 0x23, 0x02, 0x20, 0x26, 0x3A,
  0x66, 0x66, 0x46, 0x44, 0x64, 0xC6, 0x4C, 0x4C, 0xCC, 0xC7, 0x4C, 0x00,
  0xC0, 0x06, 0x00, 0x3C, 0x00, 0x03, 0x01, 0xC0, 0x70, 0x16, 0x0D, 0x82,
  0x61, 0x98, 0x66, 0x31, 0x8F, 0xE2, 0x09, 0x82, 0x60, 0xB0, 0x30, 0x3F,
  0x0F, 0xE2, 0x0C, 0x83, 0x60, 0x98, 0x67, 0xE1, 0xFC, 0x41, 0x90, 0x6C,
  0x1B, 0x04, 0xFF, 0x3F, 0x00, 0x0F, 0x0F, 0xE3, 0x0C, 0x83, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x40, 0x10, 0x0C, 0x1B, 0x0C, 0x67, 0x1F, 0x80, 0x3F,
  0x0F, 0xE2, 0x18, 0x83, 0x60, 0x98, 0x26, 0x19, 0x86, 0x61, 0x90, 0x6C,
  0x13, 0x0C, 0xFE, 0x3F, 0x00, 0x3F, 0xCF, 0xF3, 0x00, 0x80, 0x20, 0x18,
  0x07, 0xF9, 0xFC, 0x60, 0x10, 0x04, 0x03, 0x00, 0xFF, 0x3F, 0xC0, 0x3F,
  0xCF, 0xF2, 0x00, 0x80, 0x60, 0x18, 0x07, 0xF9, 0xFE, 0x60, 0x10, 0x04,
  0x03, 0x00, 0xC0, 0x30, 0x00, 0x0F, 0x0F, 0xE3, 0x0C, 0x83, 0x60, 0x18,
  0x06, 0x01, 0x9E, 0x49, 0x90, 0x6C, 0x1B, 0x0C, 0x67, 0x1F, 0x80, 0x30,
  0xCC, 0x32, 0x0C, 0x82, 0x60, 0x98, 0x67, 0xF9, 0xFE, 0x61, 0x90, 0x6C,
  0x13, 0x0C, 0xC3, 0x30, 0xC0, 0x3F, 0xCF, 0xF0, 0x60, 0x10, 0x04, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x60, 0xFF, 0x3F, 0xC0, 0x03,
  0xE0, 0xFC, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x80,
  0x11, 0x06, 0x20, 0xC6, 0x30, 0x7C, 0x00, 0x30, 0x66, 0x18, 0x86, 0x10,
  0xC6, 0x30, 0xCC, 0x1F, 0x83, 0xF0, 0x46, 0x08, 0xC3, 0x0C, 0x61, 0x8C,
  0x31, 0x83, 0x00, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x00, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x08, 0x07, 0xFF, 0xF8, 0x30, 0xCC, 0x77, 0x15, 0xEF,
  0x7A, 0xD2, 0xA4, 0xC9, 0x32, 0xC1, 0xB0, 0x6C, 0x1B, 0x06, 0xC1, 0x20,
  0xC0, 0x30, 0xCE, 0x33, 0x8C, 0xA3, 0x68, 0x9A, 0x26, 0xD9, 0xB6, 0x45,
  0x91, 0x6C, 0x53, 0x1C, 0xC7, 0x31, 0xC0, 0x0F, 0x0F, 0xE3, 0x0C, 0x83,
  0x60, 0x98, 0x26, 0x19, 0x86, 0x41, 0x90, 0x6C, 0x13, 0x0C, 0x67, 0x1F,
  0x00, 0x3F, 0x0F, 0xF2, 0x0C, 0x83, 0x60, 0xD8, 0x36, 0x19, 0xFC, 0x40,
  0x10, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x00, 0x0F, 0x0E, 0xE3, 0x0D, 0x83,
  0x60, 0xD8, 0x26, 0x09, 0x06, 0x41, 0xB0, 0x6C, 0x1B, 0x0C, 0x67, 0x1F,
  0x00, 0xC0, 0x18, 0x07, 0x00, 0x3F, 0x0F, 0xE2, 0x0C, 0x83, 0x60, 0xD8,
  0x26, 0x39, 0xFC, 0x46, 0x11, 0x8C, 0x23, 0x0C, 0xC3, 0x30, 0xE0, 0x0F,
  0x06, 0x63, 0x0C, 0x83, 0x20, 0x0C, 0x03, 0xC0, 0x3C, 0x01, 0x80, 0x6C,
  0x1B, 0x04, 0xE7, 0x1F, 0x80, 0xFF, 0xFF, 0xE0, 0xC0, 0x20, 0x08, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x04, 0x01, 0x00, 0xC0, 0x30, 0x0C, 0x00, 0x30,
  0xCC, 0x32, 0x0C, 0x83, 0x60, 0x98, 0x66, 0x19, 0x86, 0x41, 0x90, 0x6C,
  0x13, 0x0C, 0x67, 0x1F, 0x00, 0xC0, 0xF0, 0x64, 0x19, 0x04, 0x43, 0x18,
  0xC6, 0x61, 0x98, 0x64, 0x1B, 0x06, 0x81, 0xE0, 0x38, 0x0C, 0x00, 0x46,
  0x28, 0xCD, 0x19, 0xA5, 0x24, 0xA4, 0x95, 0x94, 0xB2, 0x94, 0xD2, 0x9A,
  0x73, 0x9C, 0x72, 0x8E, 0x71, 0xCE, 0x00, 0x30, 0x31, 0x86, 0x18, 0xC0,
  0x88, 0x0D, 0x80, 0xF0, 0x06, 0x00, 0x60, 0x0F, 0x01, 0xB0, 0x31, 0x03,
  0x18, 0x61, 0x8C, 0x0C, 0xC0, 0xF0, 0x66, 0x19, 0x8C, 0x62, 0x0D, 0x83,
  0xC0, 0xE0, 0x18, 0x04, 0x01, 0x00, 0xC0, 0x30, 0x0C, 0x00, 0x3F, 0xCF,
  0xF0, 0x18, 0x04, 0x03, 0x01, 0x80, 0xC0, 0x20, 0x18, 0x0C, 0x06, 0x01,
  0x80, 0xFF, 0x3F, 0xC0, 0x1E, 0x7C, 0xC1, 0x83, 0x04, 0x08, 0x30, 0x60,
  0xC1, 0x82, 0x04, 0x18, 0x30, 0x60, 0xC9, 0xE0, 0xC3, 0x04, 0x18, 0x61,
  0x86, 0x08, 0x30, 0xC3, 0x04, 0x18, 0x61, 0x82, 0x08, 0x30, 0x3E, 0x7C,
  0x18, 0x30, 0x40, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x40, 0x83, 0x06, 0x0C,
  0x19, 0xE0, 0x0C, 0x1C, 0x16, 0x36, 0x22, 0x62, 0xC3, 0x81, 0xFF, 0xFF,
  0xC0, 0xC6, 0x30, 0x0C, 0x1F, 0x58, 0x6C, 0x36, 0x1A, 0x0D, 0x07, 0x82,
  0xC3, 0x33, 0x9E, 0xC0, 0x30, 0x18, 0x08, 0x04, 0xC6, 0xFB, 0x8D, 0x86,
  0xC3, 0x41, 0xA0, 0xF0, 0x58, 0x6E, 0x77, 0xF0, 0x0E, 0x1F, 0xCC, 0x6C,
  0x36, 0x02, 0x01, 0x01, 0x81, 0xC3, 0x33, 0x9F, 0x80, 0x00, 0xC0, 0x30,
  0x0C, 0x32, 0x3E, 0x98, 0x66, 0x19, 0x86, 0x41, 0x90, 0x6C, 0x13, 0x0C,
  0x67, 0x1E, 0xC0, 0x0E, 0x1F, 0x88, 0x6C, 0x36, 0x1B, 0xFD, 0x01, 0x80,
  0xC3, 0x33, 0x9F, 0x80, 0x00, 0xF8, 0x0F, 0xC0, 0xC0, 0x06, 0x00, 0x30,
  0x0F, 0xF8, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00,
  0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0xF8, 0x00, 0x0C, 0x1F, 0x5C, 0x6C,
  0x36, 0x1A, 0x0D, 0x06, 0x82, 0x63, 0x3F, 0x80, 0xC0, 0x60, 0x23, 0xF0,
  0x30, 0x18, 0x08, 0x04, 0xC7, 0xFB, 0x8D, 0x86, 0xC3, 0x41, 0xA0, 0xF0,
  0x58, 0x2C, 0x36, 0x18, 0x02, 0x03, 0x81, 0x80, 0x00, 0x01, 0xF0, 0x10,
  0x08, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x87, 0xFF, 0xFE, 0x00, 0xC0, 0x70,
  0x08, 0x00, 0x00, 0x07, 0xE0, 0x18, 0x06, 0x01, 0x00, 0x40, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x18, 0x0E, 0x3F, 0x00, 0x30, 0x0C, 0x03, 0x00,
  0x81, 0x61, 0x98, 0xC6, 0x31, 0x98, 0x7C, 0x13, 0x04, 0x63, 0x18, 0xC3,
  0x30, 0xE0, 0xF8, 0xF8, 0x18, 0x10, 0x10, 0x30, 0x30, 0x30, 0x30, 0x20,
  0x20, 0x60, 0x3F, 0x3F, 0x14, 0xC5, 0xFC, 0xD9, 0x93, 0x26, 0x64, 0xC8,
  0x99, 0x33, 0x26, 0x44, 0xC9, 0x9B, 0x32, 0x00, 0x06, 0x3F, 0xDC, 0x6C,
  0x36, 0x1A, 0x0D, 0x07, 0x82, 0xC1, 0x61, 0xB0, 0xC0, 0x0E, 0x1F, 0x8C,
  0x6C, 0x36, 0x1A, 0x0D, 0x07, 0x82, 0xC3, 0x33, 0x9F, 0x00, 0x03, 0x0D,
  0xF3, 0x8C, 0xC3, 0x30, 0xC8, 0x32, 0x0D, 0x82, 0x61, 0x9C, 0xE6, 0xF1,
  0x80, 0x40, 0x30, 0x00, 0x0C, 0x1F, 0x58, 0x6C, 0x36, 0x1A, 0x0D, 0x07,
  0x82, 0xC3, 0x33, 0x9E, 0xC0, 0x60, 0x30, 0x10, 0x16, 0x0B, 0xE3, 0x19,
  0x82, 0x60, 0x98, 0x06, 0x01, 0x80, 0x40, 0x10, 0x0C, 0x00, 0x0E, 0x1F,
  0xD8, 0x6C, 0x06, 0x01, 0xF0, 0x1C, 0x02, 0xC1, 0x71, 0x9F, 0x80, 0x18,
  0x0C, 0x06, 0x1F, 0xF1, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x08, 0x07,
  0xC3, 0xE0, 0x60, 0xD8, 0x66, 0x19, 0x86, 0x41, 0x90, 0x6C, 0x13, 0x0C,
  0x66, 0x1F, 0x00, 0xC1, 0xE1, 0xB0, 0xC8, 0xC4, 0x63, 0x21, 0xB0, 0xD0,
  0x78, 0x18, 0x00, 0xCC, 0x79, 0x8B, 0x33, 0x6A, 0x4D, 0x49, 0xAB, 0x3D,
  0x47, 0x28, 0xE7, 0x1C, 0xC0, 0x38, 0xE3, 0x30, 0x26, 0x07, 0x80, 0x60,
  0x1C, 0x06, 0xC1, 0x98, 0x61, 0x9C, 0x38, 0x60, 0xD8, 0x66, 0x19, 0x86,
  0x41, 0x90, 0x64, 0x31, 0x94, 0x7F, 0x00, 0xC0, 0x30, 0x08, 0x7E, 0x00,
  0x7F, 0x80, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0x7F, 0x80,
  0x01, 0x83, 0xC1, 0x80, 0x80, 0xC0, 0x60, 0x30, 0x18, 0xF8, 0x78, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x20, 0x18, 0x07, 0x00, 0x33, 0x33, 0x32,
  0x26, 0x66, 0x64, 0x4C, 0xCC, 0xC8, 0x1C, 0x07, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x40, 0x10, 0x07, 0xC1, 0xF0, 0xC0, 0x30, 0x0C, 0x02, 0x00,
  0x80, 0x60, 0x38, 0x3C, 0x00, 0x30, 0xDE, 0x3C, 0xCB, 0x1E,
};

const GFXglyph JetBrainsMono_Italic19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 4, 14, 11, 4, -14 },
  { 8, 6, 6, 11, 4, -14 },
  { 13, 12, 14, 11, 0, -14 },
  { 34, 10, 20, 11, 1, -17 },
  { 59, 14, 14, 11, -1, -14 },
  { 84, 11, 14, 11, 0, -14 },
  { 104, 3, 6, 11, 5, -14 },
  { 107, 8, 18, 11, 3, -16 },
  { 125, 8, 18, 11, 1, -16 },
  { 143, 10, 10, 11, 1, -12 },
  { 156, 9, 9, 11, 1, -11 },
  { 167, 5, 6, 11, 2, -3 },
  { 171, 6, 1, 11, 3, -7 },
  { 172, 4, 3, 11, 3, -3 },
  { 174, 12, 18, 11, 0, -16 },
  { 201, 10, 14, 11, 1, -14 },
  { 219, 9, 14, 11, 1, -14 },
  { 235, 10, 14, 11, 1, -14 },
  { 253, 10, 14, 11, 1, -14 },
  { 271, 9, 14, 11, 1, -14 },
  { 287, 10, 14, 11, 1, -14 },
  { 305, 9, 14, 11, 1, -14 },
  { 321, 10, 14, 11, 2, -14 },
  { 339, 10, 14, 11, 1, -14 },
  { 357, 9, 14, 11, 2, -14 },
  { 373, 5, 11, 11, 3, -11 },
  { 380, 6, 14, 11, 2, -11 },
  { 391, 9, 10, 11, 2, -11 },
  { 403, 9, 6, 11, 1, -9 },
  { 410, 9, 10, 11, 1, -11 },
  { 422, 7, 14, 11, 3, -14 },
  { 435, 12, 17, 11, 0, -14 },
  { 461, 10, 14, 11, 0, -14 },
  { 479, 10, 14, 11, 1, -14 },
  { 497, 10, 14, 11, 1, -14 },
  { 515, 10, 14, 11, 1, -14 },
  { 533, 10, 14, 11, 1, -14 },
  { 551, 10, 14, 11, 1, -14 },
  { 569, 10, 14, 11, 1, -14 },
  { 587, 10, 14, 11, 1, -14 },
  { 605, 10, 14, 11, 1, -14 },
  { 623, 11, 14, 11, 0, -14 },
  { 643, 11, 14, 11, 1, -14 },
  { 663, 9, 14, 11, 1, -14 },
  { 679, 10, 14, 11, 1, -14 },
  { 697, 10, 14, 11, 1, -14 },
  { 715, 10, 14, 11, 1, -14 },
  { 733, 10, 14, 11, 1, -14 },
  { 751, 10, 17, 11, 1, -14 },
  { 773, 10, 14, 11, 1, -14 },
  { 791, 10, 14, 11, 1, -14 },
  { 809, 10, 14, 11, 2, -14 },
  { 827, 10, 14, 11, 1, -14 },
  { 845, 10, 14, 11, 2, -14 },
  { 863, 11, 14, 11, 1, -14 },
  { 883, 12, 14, 11, 0, -14 },
  { 904, 10, 14, 11, 2, -14 },
  { 922, 10, 14, 11, 1, -14 },
  { 940, 7, 18, 11, 3, -16 },
  { 956, 6, 18, 11, 3, -16 },
  { 970, 7, 18, 11, 2, -16 },
  { 986, 8, 8, 11, 2, -14 },
  { 994, 9, 2, 11, 0, 0 },
  { 997, 4, 3, 11, 5, -15 },
  { 999, 9, 11, 11, 1, -11 },
  { 1012, 9, 14, 11, 1, -14 },
  { 1028, 9, 11, 11, 1, -11 },
  { 1041, 10, 14, 11, 1, -14 },
  { 1059, 9, 11, 11, 1, -11 },
  { 1072, 13, 17, 11, -1, -14 },
  { 1100, 9, 14, 11, 1, -11 },
  { 1116, 9, 14, 11, 1, -14 },
  { 1132, 9, 15, 11, 1, -15 },
  { 1149, 10, 18, 11, 0, -15 },
  { 1172, 10, 14, 11, 1, -14 },
  { 1190, 8, 14, 11, 2, -14 },
  { 1204, 11, 11, 11, 0, -11 },
  { 1220, 9, 11, 11, 1, -11 },
  { 1233, 9, 11, 11, 1, -11 },
  { 1246, 10, 14, 11, 0, -11 },
  { 1264, 9, 14, 11, 1, -11 },
  { 1280, 10, 11, 11, 1, -11 },
  { 1294, 9, 11, 11, 1, -11 },
  { 1307, 9, 13, 11, 2, -13 },
  { 1322, 10, 10, 11, 1, -10 },
  { 1335, 9, 10, 11, 2, -10 },
  { 1347, 11, 10, 11, 1, -10 },
  { 1361, 11, 10, 11, 0, -10 },
  { 1375, 10, 13, 11, 1, -10 },
  { 1392, 9, 10, 11, 1, -10 },
  { 1404, 9, 18, 11, 2, -16 },
  { 1425, 4, 18, 11, 4, -16 },
  { 1434, 10, 18, 11, 0, -16 },
  { 1457, 10, 4, 11, 1, -9 },
};

const GFXfont JetBrainsMono_Italic19pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Italic19pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Italic19pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _JETBRAINSMONO_ITALIC19PT7B_H_
