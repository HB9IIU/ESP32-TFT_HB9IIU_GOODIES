#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated_Fonts_For_Copy/JetBrainsMono_Italic
// Headers: 67

#include "JetBrainsMono_Italic6pt7b.h"
#include "JetBrainsMono_Italic7pt7b.h"
#include "JetBrainsMono_Italic8pt7b.h"
#include "JetBrainsMono_Italic9pt7b.h"
#include "JetBrainsMono_Italic10pt7b.h"
#include "JetBrainsMono_Italic11pt7b.h"
#include "JetBrainsMono_Italic12pt7b.h"
#include "JetBrainsMono_Italic13pt7b.h"
#include "JetBrainsMono_Italic14pt7b.h"
#include "JetBrainsMono_Italic15pt7b.h"
#include "JetBrainsMono_Italic16pt7b.h"
#include "JetBrainsMono_Italic17pt7b.h"
#include "JetBrainsMono_Italic18pt7b.h"
#include "JetBrainsMono_Italic19pt7b.h"
#include "JetBrainsMono_Italic20pt7b.h"
#include "JetBrainsMono_Italic21pt7b.h"
#include "JetBrainsMono_Italic22pt7b.h"
#include "JetBrainsMono_Italic23pt7b.h"
#include "JetBrainsMono_Italic24pt7b.h"
#include "JetBrainsMono_Italic25pt7b.h"
#include "JetBrainsMono_Italic26pt7b.h"
#include "JetBrainsMono_Italic27pt7b.h"
#include "JetBrainsMono_Italic28pt7b.h"
#include "JetBrainsMono_Italic29pt7b.h"
#include "JetBrainsMono_Italic30pt7b.h"
#include "JetBrainsMono_Italic31pt7b.h"
#include "JetBrainsMono_Italic32pt7b.h"
#include "JetBrainsMono_Italic33pt7b.h"
#include "JetBrainsMono_Italic34pt7b.h"
#include "JetBrainsMono_Italic35pt7b.h"
#include "JetBrainsMono_Italic36pt7b.h"
#include "JetBrainsMono_Italic37pt7b.h"
#include "JetBrainsMono_Italic38pt7b.h"
#include "JetBrainsMono_Italic39pt7b.h"
#include "JetBrainsMono_Italic40pt7b.h"
#include "JetBrainsMono_Italic41pt7b.h"
#include "JetBrainsMono_Italic42pt7b.h"
#include "JetBrainsMono_Italic43pt7b.h"
#include "JetBrainsMono_Italic44pt7b.h"
#include "JetBrainsMono_Italic45pt7b.h"
#include "JetBrainsMono_Italic46pt7b.h"
#include "JetBrainsMono_Italic47pt7b.h"
#include "JetBrainsMono_Italic48pt7b.h"
#include "JetBrainsMono_Italic49pt7b.h"
#include "JetBrainsMono_Italic50pt7b.h"
#include "JetBrainsMono_Italic51pt7b.h"
#include "JetBrainsMono_Italic52pt7b.h"
#include "JetBrainsMono_Italic53pt7b.h"
#include "JetBrainsMono_Italic54pt7b.h"
#include "JetBrainsMono_Italic55pt7b.h"
#include "JetBrainsMono_Italic56pt7b.h"
#include "JetBrainsMono_Italic57pt7b.h"
#include "JetBrainsMono_Italic58pt7b.h"
#include "JetBrainsMono_Italic59pt7b.h"
#include "JetBrainsMono_Italic60pt7b.h"
#include "JetBrainsMono_Italic61pt7b.h"
#include "JetBrainsMono_Italic62pt7b.h"
#include "JetBrainsMono_Italic63pt7b.h"
#include "JetBrainsMono_Italic64pt7b.h"
#include "JetBrainsMono_Italic65pt7b.h"
#include "JetBrainsMono_Italic66pt7b.h"
#include "JetBrainsMono_Italic67pt7b.h"
#include "JetBrainsMono_Italic68pt7b.h"
#include "JetBrainsMono_Italic69pt7b.h"
#include "JetBrainsMono_Italic70pt7b.h"
#include "JetBrainsMono_Italic71pt7b.h"
#include "JetBrainsMono_Italic72pt7b.h"
