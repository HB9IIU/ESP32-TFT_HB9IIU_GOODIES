#ifndef _NOTOSANS_REGULAR13PT7B_H_
#define _NOTOSANS_REGULAR13PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Regular.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Regular13pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xA2, 0xC0, 0xB6, 0x80, 0x12, 0x12, 0x7F, 0x24, 0x24, 0xFF,
  0x24, 0x28, 0x68, 0x21, 0xEA, 0xA8, 0xE0, 0xE2, 0xC9, 0xF8, 0x82, 0x00,
  0xE2, 0x52, 0x29, 0x15, 0x6A, 0xAA, 0xA4, 0x52, 0x49, 0x63, 0x80, 0x78,
  0x48, 0x48, 0x70, 0x71, 0x9B, 0x8E, 0x86, 0x7B, 0xE0, 0x72, 0x49, 0x24,
  0x99, 0x80, 0xCC, 0x92, 0x49, 0x2B, 0x00, 0x20, 0x8F, 0xC8, 0x53, 0x60,
  0x20, 0x82, 0x3F, 0x20, 0x82, 0x00, 0xEA, 0xE0, 0xB0, 0x18, 0x84, 0x42,
  0x31, 0x08, 0x80, 0x7A, 0x28, 0xE1, 0x86, 0x18, 0xE2, 0x78, 0x3D, 0x33,
  0x33, 0x33, 0x30, 0xF8, 0x20, 0x82, 0x10, 0x84, 0x20, 0xFC, 0xF8, 0x20,
  0x86, 0x78, 0x30, 0xC2, 0xF8, 0x0C, 0x28, 0x51, 0x24, 0x48, 0xBF, 0x82,
  0x04, 0xFA, 0x08, 0x3C, 0x08, 0x30, 0x42, 0xF8, 0x7B, 0x08, 0x2E, 0xCE,
  0x18, 0x63, 0x78, 0xFC, 0x20, 0x84, 0x10, 0xC2, 0x18, 0x40, 0xFA, 0x28,
  0x96, 0x72, 0x38, 0x63, 0xF8, 0xFA, 0x28, 0x63, 0xD4, 0xB0, 0x82, 0xF0,
  0xE0, 0x2C, 0x68, 0x00, 0x92, 0x80, 0x04, 0x66, 0x20, 0x60, 0x70, 0xFC,
  0x0F, 0xC0, 0x83, 0x81, 0x03, 0x33, 0x00, 0xF8, 0x42, 0x33, 0x10, 0x04,
  0x20, 0x3F, 0x10, 0x28, 0xE6, 0x49, 0xA2, 0x68, 0x99, 0x6A, 0x24, 0x40,
  0x0F, 0x80, 0x18, 0x18, 0x14, 0x24, 0x26, 0x7E, 0x42, 0x43, 0x81, 0xFD,
  0x0A, 0x14, 0x6F, 0xD0, 0xE1, 0xC3, 0xFC, 0x7E, 0x82, 0x04, 0x08, 0x10,
  0x20, 0x20, 0x3C, 0xFC, 0x86, 0x82, 0x83, 0x83, 0x83, 0x82, 0x86, 0xF8,
  0xFC, 0x21, 0x0F, 0xC2, 0x10, 0xF8, 0xFC, 0x21, 0x0F, 0xC2, 0x10, 0x80,
  0x3E, 0x40, 0x80, 0x80, 0x8F, 0x83, 0x83, 0x43, 0x3F, 0x83, 0x06, 0x0C,
  0x1F, 0xF0, 0x60, 0xC1, 0x82, 0xE9, 0x24, 0x92, 0xE0, 0x24, 0x92, 0x49,
  0x27, 0x80, 0x87, 0x12, 0x45, 0x0F, 0x12, 0x22, 0x42, 0x86, 0x84, 0x21,
  0x08, 0x42, 0x10, 0xF8, 0xC0, 0xE8, 0x7A, 0x1E, 0x8B, 0x92, 0xE4, 0xB9,
  0xCE, 0x33, 0x8C, 0xC0, 0xC1, 0xE1, 0xA1, 0x91, 0x99, 0x89, 0x85, 0x87,
  0x83, 0x7E, 0xC3, 0x81, 0x81, 0x81, 0x81, 0x81, 0x43, 0x3C, 0xFA, 0x18,
  0x61, 0xFA, 0x08, 0x20, 0x80, 0x7E, 0xC3, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x43, 0x3C, 0x04, 0x03, 0xFD, 0x0A, 0x14, 0x2F, 0x93, 0x22, 0x42, 0x86,
  0xFA, 0x08, 0x30, 0x30, 0x20, 0xC2, 0xF8, 0xFE, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xA1, 0x7C, 0x83,
  0x42, 0x42, 0x64, 0x24, 0x24, 0x38, 0x18, 0x18, 0xC6, 0x14, 0x62, 0x46,
  0x24, 0x92, 0x69, 0x62, 0x94, 0x38, 0xC3, 0x0C, 0x30, 0xC0, 0xC2, 0x64,
  0x2C, 0x18, 0x18, 0x28, 0x24, 0x46, 0xC3, 0xC2, 0x88, 0x91, 0x41, 0x82,
  0x04, 0x08, 0x10, 0x7E, 0x08, 0x30, 0x41, 0x06, 0x08, 0x20, 0xFE, 0xF2,
  0x49, 0x24, 0x93, 0x80, 0xC2, 0x10, 0x42, 0x10, 0x42, 0x18, 0xE4, 0x92,
  0x49, 0x27, 0x80, 0x10, 0x50, 0xA2, 0x24, 0x58, 0x40, 0xFC, 0x90, 0xF8,
  0x43, 0xF8, 0xC7, 0xE0, 0x82, 0x08, 0x2E, 0xC6, 0x18, 0x61, 0xC6, 0xE0,
  0x7C, 0x21, 0x08, 0x41, 0xE0, 0x04, 0x10, 0x5D, 0x8E, 0x18, 0x61, 0x8D,
  0xD0, 0x7A, 0x28, 0xFF, 0x82, 0x07, 0x80, 0x39, 0x19, 0xE6, 0x31, 0x8C,
  0x63, 0x00, 0x76, 0x38, 0x61, 0x86, 0x37, 0x41, 0x0F, 0xE0, 0x82, 0x08,
  0x2E, 0xC6, 0x18, 0x61, 0x86, 0x10, 0xDF, 0xC0, 0x24, 0x12, 0x49, 0x24,
  0x9E, 0x82, 0x08, 0x23, 0x92, 0x8E, 0x24, 0x9A, 0x30, 0xFF, 0xC0, 0xBB,
  0xF3, 0x18, 0x46, 0x11, 0x84, 0x61, 0x18, 0x44, 0xBB, 0x18, 0x61, 0x86,
  0x18, 0x40, 0x7A, 0x38, 0x61, 0x86, 0x37, 0x80, 0xBB, 0x18, 0x61, 0x87,
  0x1B, 0xA0, 0x82, 0x00, 0x76, 0x38, 0x61, 0x86, 0x37, 0x41, 0x04, 0x10,
  0xBC, 0x88, 0x88, 0x80, 0xFC, 0x20, 0xE1, 0x8F, 0xC0, 0x44, 0xF4, 0x44,
  0x44, 0x30, 0x86, 0x18, 0x61, 0x86, 0x37, 0x40, 0x86, 0x89, 0x32, 0x42,
  0x87, 0x0C, 0x00, 0x8C, 0x53, 0x14, 0xE9, 0x4A, 0x52, 0x8C, 0xA3, 0x10,
  0xC6, 0xD0, 0xA0, 0x82, 0x8D, 0xB1, 0x80, 0x86, 0x89, 0x13, 0x42, 0x87,
  0x04, 0x08, 0x21, 0xC0, 0x7C, 0x21, 0x0C, 0x21, 0x0F, 0xC0, 0x39, 0x08,
  0x42, 0x60, 0x84, 0x21, 0x06, 0xFF, 0xF8, 0xE1, 0x08, 0x42, 0x0C, 0x84,
  0x21, 0x30, 0xFC,
};

const GFXglyph NotoSans_Regular13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 2, 9, 4, 1, -9 },
  { 4, 3, 3, 5, 1, -9 },
  { 6, 8, 9, 8, 0, -9 },
  { 15, 6, 11, 7, 1, -10 },
  { 24, 9, 9, 11, 1, -9 },
  { 35, 8, 9, 10, 1, -9 },
  { 44, 1, 3, 3, 1, -9 },
  { 45, 3, 11, 4, 1, -9 },
  { 50, 3, 11, 4, 0, -9 },
  { 55, 6, 6, 7, 1, -10 },
  { 60, 6, 7, 7, 1, -8 },
  { 66, 2, 4, 3, 1, -2 },
  { 67, 3, 1, 4, 1, -4 },
  { 68, 2, 2, 3, 1, -2 },
  { 69, 5, 9, 5, 0, -9 },
  { 75, 6, 9, 7, 1, -9 },
  { 82, 4, 9, 7, 1, -9 },
  { 87, 6, 9, 7, 1, -9 },
  { 94, 6, 9, 7, 1, -9 },
  { 101, 7, 9, 7, 0, -9 },
  { 109, 6, 9, 7, 1, -9 },
  { 116, 6, 9, 7, 1, -9 },
  { 123, 6, 9, 7, 1, -9 },
  { 130, 6, 9, 7, 1, -9 },
  { 137, 6, 9, 7, 1, -9 },
  { 144, 2, 7, 3, 1, -7 },
  { 146, 3, 9, 3, 0, -7 },
  { 150, 6, 6, 7, 1, -8 },
  { 155, 6, 3, 7, 1, -6 },
  { 158, 6, 6, 7, 1, -8 },
  { 163, 5, 9, 6, 0, -9 },
  { 169, 10, 10, 12, 1, -9 },
  { 182, 8, 9, 8, 0, -9 },
  { 191, 7, 9, 8, 1, -9 },
  { 199, 7, 9, 8, 1, -9 },
  { 207, 8, 9, 9, 1, -9 },
  { 216, 5, 9, 7, 1, -9 },
  { 222, 5, 9, 7, 1, -9 },
  { 228, 8, 9, 9, 1, -9 },
  { 237, 7, 9, 10, 1, -9 },
  { 245, 3, 9, 4, 1, -9 },
  { 249, 3, 11, 4, -1, -9 },
  { 254, 7, 9, 8, 1, -9 },
  { 262, 5, 9, 7, 1, -9 },
  { 268, 10, 9, 12, 1, -9 },
  { 280, 8, 9, 10, 1, -9 },
  { 289, 8, 9, 10, 1, -9 },
  { 298, 6, 9, 8, 1, -9 },
  { 305, 8, 11, 10, 1, -9 },
  { 316, 7, 9, 8, 1, -9 },
  { 324, 6, 9, 7, 1, -9 },
  { 331, 7, 9, 7, 0, -9 },
  { 339, 7, 9, 10, 1, -9 },
  { 347, 8, 9, 8, 0, -9 },
  { 356, 12, 9, 12, 0, -9 },
  { 370, 8, 9, 8, 0, -9 },
  { 379, 7, 9, 7, 0, -9 },
  { 387, 7, 9, 7, 0, -9 },
  { 395, 3, 11, 4, 1, -9 },
  { 400, 5, 9, 5, 0, -9 },
  { 406, 3, 11, 4, 0, -9 },
  { 411, 7, 6, 7, 0, -9 },
  { 417, 6, 1, 6, 0, 1 },
  { 418, 2, 2, 4, 1, -10 },
  { 419, 5, 7, 7, 1, -7 },
  { 424, 6, 10, 8, 1, -10 },
  { 432, 5, 7, 6, 1, -7 },
  { 437, 6, 10, 8, 1, -10 },
  { 445, 6, 7, 7, 1, -7 },
  { 451, 5, 10, 4, 0, -10 },
  { 458, 6, 10, 8, 1, -7 },
  { 466, 6, 10, 8, 1, -10 },
  { 474, 1, 10, 3, 1, -10 },
  { 476, 3, 13, 3, -1, -10 },
  { 481, 6, 10, 7, 1, -10 },
  { 489, 1, 10, 3, 1, -10 },
  { 491, 10, 7, 12, 1, -7 },
  { 500, 6, 7, 8, 1, -7 },
  { 506, 6, 7, 8, 1, -7 },
  { 512, 6, 10, 8, 1, -7 },
  { 520, 6, 10, 8, 1, -7 },
  { 528, 4, 7, 5, 1, -7 },
  { 532, 5, 7, 6, 1, -7 },
  { 537, 4, 9, 5, 0, -9 },
  { 542, 6, 7, 8, 1, -7 },
  { 548, 7, 7, 7, 0, -7 },
  { 555, 10, 7, 10, 0, -7 },
  { 564, 7, 7, 7, 0, -7 },
  { 571, 7, 10, 7, 0, -7 },
  { 580, 6, 7, 6, 0, -7 },
  { 586, 5, 11, 5, 0, -9 },
  { 593, 1, 13, 7, 3, -10 },
  { 595, 5, 11, 5, 0, -9 },
  { 602, 6, 1, 7, 1, -5 },
};

const GFXfont NotoSans_Regular13pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Regular13pt7bBitmaps,
  (GFXglyph *)NotoSans_Regular13pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _NOTOSANS_REGULAR13PT7B_H_
