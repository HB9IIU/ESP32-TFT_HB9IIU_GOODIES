#ifndef _NOTOSANS_REGULAR63PT7B_H_
#define _NOTOSANS_REGULAR63PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Regular.ttf
// Size: 63pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Regular63pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9,
  0xF3, 0xE7, 0x87, 0x0E, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x03, 0x3F, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0x00, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0,
  0xFB, 0xF0, 0x3E, 0xFC, 0x0F, 0x9F, 0x03, 0xE7, 0xC0, 0xF9, 0xF0, 0x3E,
  0x78, 0x0F, 0x9E, 0x03, 0xE7, 0x80, 0xF9, 0xE0, 0x1E, 0x78, 0x07, 0x9E,
  0x01, 0xE7, 0x80, 0x79, 0xE0, 0x1C, 0x00, 0x03, 0xC0, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x3C,
  0x00, 0x00, 0x78, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0xF0, 0x00, 0x01, 0xF0, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x3C, 0x00,
  0x00, 0x78, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0xF0, 0x00, 0x01, 0xF0, 0x07, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x80, 0x3C, 0x00, 0x00, 0x78,
  0x03, 0xE0, 0x00, 0x03, 0xC0, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00,
  0x01, 0xF0, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x00, 0x78, 0x03,
  0xE0, 0x00, 0x03, 0xC0, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x07, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xF0,
  0x07, 0x80, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00,
  0x03, 0xC0, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x07,
  0x80, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x03,
  0xC0, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x07, 0x80,
  0x00, 0x0F, 0x80, 0x3C, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xF0, 0xFE, 0x1E, 0x07, 0x8F, 0xE0, 0xF0, 0x04, 0x7E, 0x07,
  0x80, 0x03, 0xE0, 0x3C, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0xF8, 0x0F, 0x00,
  0x07, 0xE0, 0x78, 0x00, 0x3F, 0x03, 0xC0, 0x01, 0xFC, 0x1E, 0x00, 0x07,
  0xF0, 0xF0, 0x00, 0x3F, 0xF7, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0x8F, 0xF0,
  0x00, 0x3C, 0x1F, 0xC0, 0x01, 0xE0, 0x7E, 0x00, 0x0F, 0x01, 0xF0, 0x00,
  0x78, 0x0F, 0x80, 0x03, 0xC0, 0x7E, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0xF0,
  0x1F, 0x40, 0x07, 0x81, 0xFB, 0x80, 0x3C, 0x1F, 0xDF, 0xC1, 0xE7, 0xFC,
  0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x0F,
  0x80, 0x07, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x3F, 0x3F, 0x80, 0x01, 0xF0,
  0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x03, 0xC0, 0x07, 0xC0, 0x03,
  0xE0, 0x0F, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0xF8, 0x07, 0xC0, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x03, 0xE0,
  0x0F, 0x80, 0xF8, 0x00, 0x0F, 0x80, 0x3E, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0x0F,
  0x83, 0xE0, 0x00, 0x0F, 0x80, 0x3C, 0x0F, 0x01, 0xC0, 0x3E, 0x00, 0xF0,
  0x7C, 0x3F, 0xE0, 0x78, 0x07, 0xC3, 0xE1, 0xFF, 0xE1, 0xF0, 0x1F, 0x0F,
  0x8F, 0xFF, 0x87, 0xC0, 0x7C, 0x7C, 0x3F, 0x3F, 0x0F, 0x83, 0xE1, 0xF1,
  0xF0, 0x7E, 0x3F, 0x3F, 0x8F, 0x87, 0x80, 0xF8, 0x7F, 0xFC, 0x3E, 0x3E,
  0x01, 0xE0, 0xFF, 0xE1, 0xF0, 0xF8, 0x07, 0xC1, 0xFF, 0x07, 0x83, 0xE0,
  0x1F, 0x00, 0xC0, 0x3E, 0x0F, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x3C, 0x00,
  0xF0, 0x00, 0x07, 0xC0, 0xF0, 0x03, 0xC0, 0x00, 0x3E, 0x03, 0xC0, 0x0F,
  0x00, 0x00, 0xF8, 0x0F, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0xF0,
  0x00, 0x1F, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00,
  0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x3E, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0xF8, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x1E, 0x00, 0x1F,
  0x00, 0x07, 0x80, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x03, 0xE0, 0x03, 0xE0,
  0x00, 0x3F, 0x3F, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x7C, 0x00,
  0x01, 0xFF, 0xE0, 0x03, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x01,
  0xF8, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0,
  0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0x9F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x3F, 0x01, 0xFE, 0x7F, 0x80, 0x07, 0xE0, 0x7F,
  0x07, 0xF8, 0x00, 0xF8, 0x1F, 0xC0, 0x7F, 0x80, 0x3F, 0x03, 0xF0, 0x07,
  0xF8, 0x07, 0xE0, 0xFC, 0x00, 0x7F, 0x80, 0xF8, 0x1F, 0x80, 0x03, 0xF8,
  0x3F, 0x03, 0xE0, 0x00, 0x3F, 0x87, 0xC0, 0xFC, 0x00, 0x03, 0xF9, 0xF8,
  0x1F, 0x80, 0x00, 0x3F, 0xFE, 0x03, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x7E,
  0x00, 0x00, 0x3F, 0xF0, 0x0F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x1F, 0x80, 0x00, 0x1F, 0xF8, 0x03, 0xF8, 0x00, 0x0F,
  0xFF, 0x80, 0x3F, 0xC0, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0x0F, 0xFF, 0x3F,
  0x80, 0x7F, 0xFF, 0xFF, 0xC3, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0x80,
  0x3F, 0xFF, 0xF8, 0x03, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFD, 0xF7, 0xDF, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x9E, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x00, 0xFC, 0x03,
  0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xC0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E,
  0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x01,
  0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0,
  0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3E,
  0x00, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x03,
  0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0,
  0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xF0, 0x0F, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x07, 0x00, 0x78, 0x01, 0xBF, 0x03, 0xC0, 0xFD, 0xFF, 0x9E,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0x7C, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0xF8,
  0x7E, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xE0, 0x3F,
  0x00, 0x7F, 0x01, 0xFC, 0x00, 0xF0, 0x07, 0x80, 0x03, 0x80, 0x30, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x9F, 0xCF, 0xC7, 0xE3, 0xF1, 0xF8,
  0xF8, 0xFC, 0x7C, 0x3E, 0x1F, 0x1F, 0x0F, 0x87, 0x83, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x19, 0xFB, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x38, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0x80, 0x3F, 0xC0, 0xFF, 0x01, 0xFC, 0x00, 0xFC, 0x07, 0xE0,
  0x01, 0xF8, 0x3F, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xC3, 0xE0, 0x00,
  0x1F, 0x1F, 0x80, 0x00, 0x7C, 0x7E, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x07,
  0xE7, 0xC0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xF7, 0xC0, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0xF9,
  0xF0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0x7E, 0x3E,
  0x00, 0x01, 0xF0, 0xFC, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x3F, 0x07, 0xE0,
  0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0xE0, 0x3F, 0xC0, 0xFF, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x7F, 0x01,
  0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x1F, 0xFF, 0x3F, 0x9F, 0x7F, 0x1F, 0xFE,
  0x1F, 0xFC, 0x1F, 0x78, 0x1F, 0x20, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0x07, 0xF0, 0x01,
  0xFE, 0x0F, 0x00, 0x01, 0xF8, 0x18, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x7F, 0xE0,
  0x1F, 0xE1, 0xF8, 0x00, 0x3F, 0x87, 0x00, 0x00, 0xFC, 0x20, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xD0, 0x00, 0x00, 0xFE, 0xF0, 0x00, 0x0F, 0xE7, 0xF0, 0x03, 0xFF,
  0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF8, 0x00, 0x01, 0xF4, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x00, 0x7C,
  0xF8, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0x07,
  0xC3, 0xE0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00,
  0xFC, 0x0F, 0x80, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0xF8, 0x00,
  0x0F, 0xC0, 0x3E, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x01, 0xF0, 0x03, 0xE0,
  0x00, 0xFC, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x0F, 0x80, 0x03, 0xE0, 0x07, 0xE0, 0x00, 0xF8, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x03, 0xE0, 0x1F, 0x00,
  0x00, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0x83, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0xD0, 0x00, 0x7F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8,
  0x1E, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x80, 0x00, 0x0F, 0xEE,
  0x00, 0x03, 0xFC, 0xFE, 0x01, 0xFF, 0x8F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xA0, 0x00,
  0x00, 0x00, 0x2F, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x80, 0x3F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0xFF, 0xC0, 0x1F,
  0x0F, 0xFF, 0xC0, 0x7C, 0x7F, 0xFF, 0x81, 0xF3, 0xFF, 0xFF, 0x87, 0xDF,
  0x83, 0xFE, 0x1F, 0xF8, 0x01, 0xFC, 0xFF, 0x80, 0x03, 0xFB, 0xFC, 0x00,
  0x07, 0xEF, 0xE0, 0x00, 0x0F, 0xBF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0xFD, 0xF0, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x1F,
  0x7C, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x0F, 0xCF,
  0x80, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x07, 0xE1, 0xF8,
  0x00, 0x1F, 0x87, 0xF0, 0x00, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x1F, 0xE0,
  0x7F, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0x80, 0x7F, 0x81, 0xF8, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x07, 0xC3,
  0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF0, 0xF8,
  0x00, 0x07, 0xC3, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xF8, 0x1F, 0x80,
  0x07, 0xE0, 0x7F, 0x00, 0x3F, 0x00, 0xFF, 0x03, 0xF8, 0x01, 0xFF, 0x3F,
  0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xC3, 0xFE, 0x01,
  0xFE, 0x03, 0xFC, 0x07, 0xE0, 0x03, 0xF8, 0x3F, 0x00, 0x07, 0xF1, 0xF8,
  0x00, 0x0F, 0xE7, 0xC0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x1F,
  0x9F, 0x80, 0x00, 0x7E, 0x7F, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x3F, 0xC1,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x80, 0x7F, 0xC1, 0xFF, 0x03, 0xF8, 0x01, 0xFC, 0x0F, 0xC0, 0x01,
  0xF8, 0x7E, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x1F,
  0x1F, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x03, 0xEF,
  0xC0, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x7F, 0x7E, 0x00,
  0x01, 0xFD, 0xF8, 0x00, 0x0F, 0xF3, 0xF0, 0x00, 0x7F, 0xCF, 0xE0, 0x03,
  0xFF, 0x1F, 0xF0, 0x7E, 0xFC, 0x3F, 0xFF, 0xFB, 0xE0, 0x7F, 0xFF, 0xCF,
  0x80, 0xFF, 0xFC, 0x3E, 0x00, 0xFF, 0xC0, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x40, 0x0F, 0xF8, 0x01, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x31, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xCF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF9, 0xC0,
  0x06, 0x07, 0xE1, 0xFC, 0xFF, 0x3F, 0xCF, 0xF1, 0xFC, 0x7E, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xC7, 0xE1, 0xF8, 0x7E, 0x3F, 0x0F, 0xC3, 0xF0, 0xF8, 0x7E, 0x1F, 0x07,
  0xC1, 0xF0, 0x78, 0x3E, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xE3, 0xFC, 0x1F, 0xF1, 0xE0, 0x01, 0xFC, 0x40, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0xF8,
  0x00, 0x7F, 0xFF, 0x00, 0xF0, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x7C, 0x7C,
  0x00, 0xFF, 0xFF, 0xC0, 0x1E, 0x7C, 0x00, 0xFE, 0x07, 0xE0, 0x0F, 0x3E,
  0x00, 0xFC, 0x01, 0xF0, 0x07, 0xDE, 0x00, 0xFC, 0x00, 0xF8, 0x03, 0xEF,
  0x00, 0x7C, 0x00, 0x7C, 0x01, 0xFF, 0x80, 0x7C, 0x00, 0x3E, 0x00, 0xFF,
  0xC0, 0x3E, 0x00, 0x1F, 0x00, 0x3F, 0xE0, 0x1F, 0x00, 0x0F, 0x80, 0x1F,
  0xE0, 0x1F, 0x00, 0x07, 0xC0, 0x0F, 0xF0, 0x0F, 0x80, 0x03, 0xE0, 0x0F,
  0xF8, 0x07, 0xC0, 0x01, 0xF0, 0x07, 0xFC, 0x03, 0xE0, 0x00, 0xF8, 0x03,
  0xFE, 0x01, 0xF0, 0x00, 0x7C, 0x01, 0xEF, 0x00, 0xF8, 0x00, 0x7E, 0x00,
  0xF7, 0x80, 0x7C, 0x00, 0x3F, 0x00, 0xFB, 0xC0, 0x1F, 0x00, 0x1F, 0x80,
  0x7D, 0xE0, 0x0F, 0x80, 0x1F, 0xC0, 0x3C, 0xF8, 0x07, 0xE0, 0x1F, 0xE0,
  0x3E, 0x7C, 0x01, 0xF8, 0x1F, 0x78, 0x3E, 0x3E, 0x00, 0x7F, 0xFF, 0x3F,
  0xFE, 0x0F, 0x00, 0x3F, 0xFF, 0x0F, 0xFE, 0x07, 0xC0, 0x07, 0xFF, 0x03,
  0xFE, 0x03, 0xE0, 0x01, 0xFE, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x00, 0x03, 0xE7, 0xC0,
  0x00, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x00, 0x0F, 0xC1,
  0xF0, 0x00, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xFF, 0xE0, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x0F,
  0x80, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x7E, 0x00,
  0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x00, 0x1F,
  0xF8, 0xFC, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x01,
  0xFC, 0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00,
  0xFC, 0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00,
  0xFC, 0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03,
  0xF0, 0xFC, 0x00, 0x0F, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFC, 0x00, 0x0F, 0xF8, 0xFC, 0x00, 0x03, 0xFC, 0xFC, 0x00, 0x00,
  0xFC, 0xFC, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00,
  0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00,
  0x7E, 0xFC, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x03,
  0xFC, 0xFC, 0x00, 0x0F, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFC, 0x7F, 0xE0, 0x3F, 0xE0, 0x00, 0xF0, 0x1F, 0xE0, 0x00, 0x04, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x03, 0x00, 0xFF, 0xF8, 0x3F, 0xC0,
  0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xC0, 0x01, 0xFF, 0xC0,
  0xFC, 0x00, 0x03, 0xFE, 0x0F, 0xC0, 0x00, 0x0F, 0xF0, 0xFC, 0x00, 0x00,
  0x7F, 0x8F, 0xC0, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x00, 0x1F, 0xCF, 0xC0,
  0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x00, 0x7E,
  0xFC, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7E,
  0xFC, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00,
  0x0F, 0xCF, 0xC0, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x00, 0x1F, 0x8F, 0xC0,
  0x00, 0x03, 0xF8, 0xFC, 0x00, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x1F, 0xE0,
  0xFC, 0x00, 0x07, 0xFE, 0x0F, 0xC0, 0x03, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xBF, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xF8, 0x3F, 0xF8, 0x0F, 0xFC, 0x00, 0x0F, 0x80, 0xFF,
  0x80, 0x00, 0x0C, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x00,
  0x03, 0xEF, 0xC0, 0x00, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x00, 0xFB, 0xF8,
  0x00, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x00, 0x3E, 0x7F, 0x00, 0x00, 0x01,
  0xF1, 0xFC, 0x00, 0x00, 0x0F, 0x8F, 0xF0, 0x00, 0x00, 0x7C, 0x3F, 0xC0,
  0x00, 0x03, 0xE0, 0xFF, 0x00, 0x00, 0x1F, 0x07, 0xFE, 0x00, 0x00, 0xF8,
  0x1F, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7E, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x81, 0xFE, 0xFF,
  0xFC, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xE0, 0x7F, 0x80, 0xFC, 0x00, 0x00,
  0x7F, 0x7E, 0x00, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0x7F, 0x1F, 0x80, 0x00,
  0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x03, 0xF0, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x3F, 0x80, 0x7E, 0x00,
  0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0x0F, 0xC0,
  0x1F, 0x80, 0x07, 0xE0, 0x1F, 0x80, 0x03, 0xF0, 0x1F, 0x80, 0x01, 0xF8,
  0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x3F,
  0x1F, 0x80, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0x0F, 0xDF, 0xE0, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0x9F, 0xC0, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0x3F, 0x81, 0xFC, 0x00,
  0x1F, 0x80, 0xFE, 0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x07, 0xE0, 0x0F, 0xE0,
  0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7F,
  0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x03,
  0xF8, 0x0F, 0xC0, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x3F, 0x83, 0xF0, 0x00,
  0x1F, 0xC1, 0xF8, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x01, 0xFC, 0x7E, 0x00,
  0x00, 0x7E, 0x3F, 0x00, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x0F, 0xEF, 0xC0,
  0x00, 0x03, 0xF8, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xEF, 0x80,
  0x00, 0x00, 0xFB, 0xFF, 0x7C, 0x00, 0x00, 0x07, 0xDF, 0xFB, 0xF0, 0x00,
  0x00, 0x7E, 0xFF, 0xCF, 0x80, 0x00, 0x03, 0xE7, 0xFE, 0x7C, 0x00, 0x00,
  0x1F, 0x3F, 0xF3, 0xF0, 0x00, 0x01, 0xF1, 0xFF, 0x8F, 0x80, 0x00, 0x0F,
  0x9F, 0xFC, 0x7E, 0x00, 0x00, 0x7C, 0xFF, 0xE1, 0xF0, 0x00, 0x07, 0xC7,
  0xFF, 0x0F, 0x80, 0x00, 0x3E, 0x3F, 0xF8, 0x7E, 0x00, 0x03, 0xE1, 0xFF,
  0xC1, 0xF0, 0x00, 0x1F, 0x0F, 0xFE, 0x0F, 0x80, 0x00, 0xF8, 0x7F, 0xF0,
  0x7E, 0x00, 0x0F, 0x83, 0xFF, 0x81, 0xF0, 0x00, 0x7C, 0x1F, 0xFC, 0x0F,
  0xC0, 0x07, 0xE0, 0xFF, 0xE0, 0x3E, 0x00, 0x3E, 0x07, 0xFF, 0x01, 0xF0,
  0x01, 0xF0, 0x3F, 0xF8, 0x0F, 0xC0, 0x1F, 0x01, 0xFF, 0xC0, 0x3E, 0x00,
  0xF8, 0x0F, 0xFE, 0x01, 0xF0, 0x07, 0xC0, 0x7F, 0xF0, 0x0F, 0xC0, 0x7C,
  0x03, 0xFF, 0x80, 0x3E, 0x03, 0xE0, 0x1F, 0xFC, 0x01, 0xF8, 0x3F, 0x00,
  0xFF, 0xE0, 0x07, 0xC1, 0xF0, 0x07, 0xFF, 0x00, 0x3E, 0x0F, 0x80, 0x3F,
  0xF8, 0x01, 0xF8, 0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xC7, 0xC0, 0x0F, 0xFE,
  0x00, 0x3E, 0x7E, 0x00, 0x7F, 0xF0, 0x01, 0xFB, 0xE0, 0x03, 0xFF, 0x80,
  0x07, 0xDF, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0x80, 0x07, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xF8, 0x00,
  0x1F, 0x80, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xFB, 0xF0, 0x00, 0x03, 0xFF, 0xBF, 0x80, 0x00, 0x3F, 0xF9,
  0xF8, 0x00, 0x03, 0xFF, 0x8F, 0xC0, 0x00, 0x3F, 0xF8, 0xFE, 0x00, 0x03,
  0xFF, 0x87, 0xE0, 0x00, 0x3F, 0xF8, 0x7F, 0x00, 0x03, 0xFF, 0x83, 0xF8,
  0x00, 0x3F, 0xF8, 0x1F, 0x80, 0x03, 0xFF, 0x81, 0xFC, 0x00, 0x3F, 0xF8,
  0x0F, 0xE0, 0x03, 0xFF, 0x80, 0x7E, 0x00, 0x3F, 0xF8, 0x07, 0xF0, 0x03,
  0xFF, 0x80, 0x3F, 0x80, 0x3F, 0xF8, 0x01, 0xF8, 0x03, 0xFF, 0x80, 0x1F,
  0xC0, 0x3F, 0xF8, 0x00, 0xFC, 0x03, 0xFF, 0x80, 0x07, 0xE0, 0x3F, 0xF8,
  0x00, 0x7F, 0x03, 0xFF, 0x80, 0x03, 0xF0, 0x3F, 0xF8, 0x00, 0x1F, 0x81,
  0xFF, 0x80, 0x01, 0xFC, 0x1F, 0xF8, 0x00, 0x0F, 0xC1, 0xFF, 0x80, 0x00,
  0xFE, 0x1F, 0xF8, 0x00, 0x07, 0xF1, 0xFF, 0x80, 0x00, 0x3F, 0x1F, 0xF8,
  0x00, 0x03, 0xF9, 0xFF, 0x80, 0x00, 0x1F, 0xDF, 0xF8, 0x00, 0x00, 0xFD,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0x0F, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xC0, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x87, 0xF0, 0x00,
  0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x00, 0x01,
  0xF9, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x00, 0x1F,
  0x87, 0xF0, 0x00, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xE0, 0x7F, 0xF0,
  0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x74,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x7E, 0x00, 0x3F, 0xF3,
  0xF0, 0x00, 0x7F, 0x9F, 0x80, 0x00, 0xFE, 0xFC, 0x00, 0x03, 0xF7, 0xE0,
  0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F,
  0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0xFD, 0xF8,
  0x00, 0x0F, 0xEF, 0xC0, 0x00, 0xFE, 0x7E, 0x00, 0x1F, 0xE3, 0xF0, 0x1F,
  0xFF, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00,
  0x1F, 0xFE, 0x0F, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x00, 0x01, 0xF9, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x7E, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x00, 0x1F, 0x87, 0xF0, 0x00,
  0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x07,
  0xFC, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0x7F, 0xFF,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC,
  0x00, 0x7F, 0xE0, 0xFC, 0x00, 0x0F, 0xF0, 0xFC, 0x00, 0x07, 0xF0, 0xFC,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x01, 0xF8, 0xFC,
  0x00, 0x01, 0xF8, 0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x01, 0xF8, 0xFC,
  0x00, 0x01, 0xF8, 0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x0F, 0xE0, 0xFC,
  0x00, 0x1F, 0xC0, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFC,
  0x01, 0xF8, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0xFC,
  0x00, 0x3F, 0x80, 0xFC, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x1F, 0xC0, 0xFC,
  0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07, 0xF0, 0xFC,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x01, 0xF8, 0xFC,
  0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0x7E, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x03, 0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFC, 0x3F,
  0xF0, 0xFF, 0x00, 0x0F, 0x07, 0xE0, 0x00, 0x08, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xD0, 0x00, 0x00, 0xFC, 0xF0, 0x00, 0x1F, 0xE7, 0xFC, 0x07, 0xFE, 0x3F,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00,
  0x1F, 0x8F, 0xC0, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x07, 0xF0, 0x7F, 0x80,
  0x07, 0xF8, 0x0F, 0xFC, 0x1F, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x00,
  0x07, 0xE7, 0xE0, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x00, 0x7E, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x00,
  0x3E, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x00, 0x7E,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x1F, 0x00,
  0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x00, 0x7C,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x07, 0xE1, 0xF8, 0x00,
  0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0xFC, 0x00, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x00, 0x07, 0xDF, 0x80, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xCF,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xF3, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFC, 0x3F,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x01, 0xFB, 0xE0, 0x00,
  0x7E, 0x07, 0xC0, 0x00, 0xF9, 0xF0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x7C,
  0xF8, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x0F, 0x80, 0xFC,
  0x00, 0x3F, 0x1F, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x07,
  0xE0, 0x1F, 0x80, 0x0F, 0x87, 0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x0F, 0xC1,
  0xF0, 0x01, 0xF0, 0x07, 0xE0, 0x07, 0xC0, 0xF8, 0x01, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0x00, 0x7E,
  0x00, 0x7E, 0x01, 0xF8, 0x0F, 0x80, 0x3E, 0x00, 0x3F, 0x00, 0xF8, 0x07,
  0xC0, 0x3F, 0x00, 0x0F, 0x80, 0x7C, 0x03, 0xF0, 0x1F, 0x80, 0x07, 0xE0,
  0x7E, 0x00, 0xF8, 0x0F, 0xC0, 0x03, 0xF0, 0x3E, 0x00, 0x7C, 0x07, 0xC0,
  0x00, 0xF8, 0x1F, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7C, 0x1F, 0x80, 0x0F,
  0x83, 0xF0, 0x00, 0x3F, 0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x87,
  0xC0, 0x03, 0xF0, 0xF8, 0x00, 0x07, 0xC3, 0xE0, 0x01, 0xF8, 0xFC, 0x00,
  0x03, 0xE3, 0xF0, 0x00, 0x7C, 0x7E, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x3E,
  0x3E, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0x3E, 0x7C,
  0x00, 0x07, 0xDF, 0x80, 0x00, 0x1F, 0x7C, 0x00, 0x03, 0xEF, 0xC0, 0x00,
  0x0F, 0xBE, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7B,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x07, 0xC0, 0x00, 0x3F, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x00,
  0x1F, 0x83, 0xF0, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x03, 0xF1, 0xF8,
  0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x03, 0xF7, 0xE0, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0xFC,
  0x00, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x7E, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0xFE, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x00,
  0x7E, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x0F, 0xEF, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x00,
  0x7E, 0x7E, 0x00, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x00, 0xFC, 0x3F, 0x80,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x00, 0x1F,
  0x9F, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1E, 0xF0,
  0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x7C, 0x7C,
  0x00, 0x00, 0x78, 0x3E, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0xF0, 0x1F,
  0x00, 0x01, 0xF0, 0x1F, 0x00, 0x01, 0xE0, 0x0F, 0x80, 0x03, 0xE0, 0x0F,
  0x80, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x03,
  0xE0, 0x0F, 0x80, 0x03, 0xE0, 0x0F, 0x80, 0x01, 0xF0, 0x0F, 0x00, 0x01,
  0xF0, 0x1F, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00,
  0x7C, 0x3E, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xE0, 0x7F, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0xFE, 0x07, 0xFC, 0x0E,
  0x00, 0x1F, 0x81, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0xFF, 0x80, 0x0F, 0xBF, 0x80,
  0x01, 0xF7, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFE, 0xFF, 0x01, 0xFF, 0xDF,
  0xFF, 0xFE, 0xF9, 0xFF, 0xFF, 0x8F, 0x1F, 0xFF, 0xE1, 0xE0, 0xFF, 0xF0,
  0x3C, 0x01, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC1, 0xFF,
  0x80, 0x3F, 0x1F, 0xFF, 0x80, 0xFC, 0xFF, 0xFF, 0x83, 0xF7, 0xFF, 0xFF,
  0x0F, 0xFF, 0x83, 0xFE, 0x3F, 0xF0, 0x03, 0xFC, 0xFF, 0x80, 0x07, 0xF3,
  0xFC, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x7E, 0xFE,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x7E, 0xFF,
  0x00, 0x03, 0xFB, 0xFE, 0x00, 0x0F, 0xCF, 0xFC, 0x00, 0x7F, 0x3F, 0xFC,
  0x07, 0xF8, 0xF9, 0xFF, 0xFF, 0xC3, 0xE3, 0xFF, 0xFE, 0x0F, 0x87, 0xFF,
  0xF0, 0x3C, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xF7,
  0xF0, 0x7F, 0x00, 0x18, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x18, 0x7F, 0xC0, 0x7C, 0x1F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x07, 0xFF, 0x07, 0xC0, 0x7F, 0xFF, 0x1F, 0x03,
  0xFF, 0xFE, 0x7C, 0x1F, 0xFF, 0xFD, 0xF0, 0xFF, 0x83, 0xFF, 0xC7, 0xF8,
  0x01, 0xFF, 0x1F, 0x80, 0x03, 0xFC, 0xFE, 0x00, 0x07, 0xF3, 0xF0, 0x00,
  0x1F, 0xDF, 0xC0, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x03,
  0xF7, 0xE0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x7D, 0xF0, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x07, 0xDF, 0x80,
  0x00, 0x1F, 0x7E, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x03, 0xF7, 0xE0, 0x00,
  0x0F, 0xCF, 0xC0, 0x00, 0x3F, 0x3F, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x0F,
  0xF1, 0xFC, 0x00, 0x7F, 0xC3, 0xFC, 0x07, 0xFF, 0x0F, 0xFF, 0xFF, 0x7C,
  0x1F, 0xFF, 0xF9, 0xF0, 0x1F, 0xFF, 0xC3, 0xC0, 0x1F, 0xFC, 0x0F, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0x83, 0xFC, 0x07, 0xE0, 0x07,
  0xF0, 0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x01, 0xF1,
  0xF0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xF7, 0xC0,
  0x00, 0x1F, 0xBE, 0x00, 0x00, 0x7D, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x07,
  0x07, 0xFE, 0x01, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x1F, 0xF3,
  0xC0, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x03, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xC0, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x3C, 0x07, 0xFF, 0xE0, 0xF0,
  0x3F, 0xFF, 0xE3, 0xC1, 0xFF, 0xFF, 0xDF, 0x0F, 0xF8, 0x7F, 0xFC, 0x7F,
  0x80, 0x3F, 0xF1, 0xF8, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x7F, 0x3F, 0x00,
  0x01, 0xFD, 0xFC, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x0F, 0xDF, 0x80, 0x00,
  0x3F, 0x7E, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x7D, 0xF8,
  0x00, 0x01, 0xF7, 0xE0, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x3F, 0x7E, 0x00,
  0x00, 0xFC, 0xFC, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x1F, 0xC7, 0xE0, 0x00,
  0xFF, 0x1F, 0xC0, 0x07, 0xFC, 0x3F, 0xC0, 0x7F, 0xF0, 0x7F, 0xFF, 0xF7,
  0xC0, 0xFF, 0xFF, 0x9F, 0x01, 0xFF, 0xFC, 0x7C, 0x01, 0xFF, 0xC1, 0xF0,
  0x00, 0x78, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE1, 0x00, 0x00, 0x3F, 0x87, 0x80, 0x03,
  0xFC, 0x1F, 0xFE, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x3F, 0xF0, 0x1F, 0x8F, 0xFF, 0xE0, 0xFC, 0xFF, 0xFF, 0xC7, 0xEF, 0xFF,
  0xFF, 0x3F, 0xFF, 0x0F, 0xF9, 0xFF, 0x80, 0x0F, 0xEF, 0xF8, 0x00, 0x3F,
  0x7F, 0x80, 0x01, 0xFB, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x3F, 0x7F, 0xFF, 0xFF, 0xFD, 0xF3, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x01, 0xF0,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x7E, 0xFF, 0xFB, 0xFF, 0xCF, 0xFF, 0x3F, 0xF0, 0xFF, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x0F, 0xEF, 0xC0, 0x01, 0xFC, 0xFC, 0x00, 0x3F, 0x8F,
  0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xC0, 0xFC, 0x01,
  0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0xFC, 0x00,
  0xFC, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x7F, 0x00, 0x0F, 0xCF,
  0xE0, 0x00, 0xFD, 0xFC, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xBF, 0x00, 0x0F, 0xF1, 0xF8, 0x00, 0xFE,
  0x1F, 0xC0, 0x0F, 0xC0, 0xFE, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF8, 0x0F, 0xC0, 0x1F, 0xC0, 0xFC, 0x00, 0xFC, 0x0F,
  0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x7F, 0x0F, 0xC0, 0x03, 0xF8, 0xFC, 0x00,
  0x1F, 0x8F, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x7C, 0x3F, 0xFF, 0x01, 0xFF, 0xFC,
  0x3E, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x1F, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF,
  0xCF, 0xFF, 0x87, 0xFD, 0xFC, 0x3F, 0xE7, 0xFE, 0x00, 0xFF, 0xF0, 0x03,
  0xFB, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFD, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7E, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7E, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xFE, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0xC0, 0xF8, 0x1F, 0xFC, 0x07, 0xC3, 0xFF, 0xF8,
  0x3E, 0x3F, 0xFF, 0xF1, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0x83, 0xFE, 0x7F,
  0xE0, 0x03, 0xFB, 0xFE, 0x00, 0x0F, 0xDF, 0xE0, 0x00, 0x7E, 0xFE, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xE0, 0x0F, 0xF8, 0x3F, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x1F, 0x80, 0x03,
  0xF8, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00,
  0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00,
  0x3E, 0x7C, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0x7C, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00,
  0x3E, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x3E, 0x00, 0x00,
  0x7E, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0x01,
  0xF8, 0x0F, 0xE0, 0x03, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x07, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x01, 0x80, 0x00, 0xF8, 0x1F, 0xFC, 0x03, 0xE1, 0xFF, 0xFC,
  0x0F, 0x8F, 0xFF, 0xF8, 0x3E, 0x7F, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xE3,
  0xFF, 0x00, 0x3F, 0xCF, 0xF8, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0xFE, 0xFE,
  0x00, 0x01, 0xFB, 0xF8, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFE,
  0x00, 0x01, 0xFB, 0xF8, 0x00, 0x07, 0xEF, 0xF0, 0x00, 0x3F, 0xBF, 0xE0,
  0x01, 0xFC, 0xFF, 0xC0, 0x0F, 0xF3, 0xFF, 0xC0, 0x7F, 0x8F, 0xDF, 0xFF,
  0xFC, 0x3F, 0x3F, 0xFF, 0xE0, 0xFC, 0x7F, 0xFF, 0x03, 0xF0, 0x7F, 0xF0,
  0x0F, 0xC0, 0x1E, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x3C, 0x07, 0xFF, 0xE0, 0xF0, 0x3F, 0xFF, 0xE3, 0xC1, 0xFF, 0xFF, 0xDF,
  0x0F, 0xF8, 0x3F, 0xFC, 0x7F, 0x80, 0x1F, 0xF1, 0xF8, 0x00, 0x3F, 0xCF,
  0xE0, 0x00, 0x7F, 0x3F, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x03, 0xF7, 0xE0,
  0x00, 0x0F, 0xDF, 0x80, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7D, 0xF0, 0x00,
  0x01, 0xF7, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x1F,
  0x7C, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x0F, 0xDF,
  0x80, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x03, 0xF3, 0xF0,
  0x00, 0x1F, 0xCF, 0xE0, 0x00, 0xFF, 0x1F, 0xC0, 0x07, 0xFC, 0x3F, 0xC0,
  0x7F, 0xF0, 0xFF, 0xFF, 0xF7, 0xC1, 0xFF, 0xFF, 0x9F, 0x01, 0xFF, 0xFC,
  0x7C, 0x01, 0xFF, 0xC1, 0xF0, 0x00, 0x60, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7C, 0xF8, 0x0F, 0xFF, 0x83, 0xFF, 0xF8, 0x7F, 0xFF, 0x8F, 0xFF, 0xF9,
  0xFF, 0xEF, 0xBF, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFE, 0x7F, 0x80, 0xFE, 0x7E, 0x00, 0x0C, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x1F, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x81, 0x03, 0xFF,
  0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x07, 0x00, 0xFC,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x01,
  0xFE, 0xFC, 0x00, 0x1F, 0xF7, 0xF0, 0x01, 0xFF, 0xBF, 0xE0, 0x3F, 0xFC,
  0xFF, 0xFF, 0xF7, 0xE3, 0xFF, 0xFF, 0x1F, 0x0F, 0xFF, 0xF0, 0xF8, 0x1F,
  0xFE, 0x07, 0xC0, 0x07, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x3E, 0x00,
  0x00, 0x7C, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x80,
  0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x0F, 0x80, 0x01, 0xF0, 0x0F, 0xC0,
  0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x03, 0xF0,
  0x0F, 0xC0, 0x01, 0xF0, 0x0F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8,
  0x1F, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC,
  0x3F, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x3E,
  0x7C, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3E, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0xF0, 0x00, 0x7E, 0x7E, 0x00,
  0x1F, 0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x1F, 0xF0, 0x00, 0x7C, 0x7E, 0x00,
  0x1E, 0xF8, 0x00, 0xFC, 0x3E, 0x00, 0x3E, 0xF8, 0x00, 0xFC, 0x3F, 0x00,
  0x3E, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x3E, 0x7C, 0x00, 0xF8, 0x1F, 0x00,
  0x3E, 0x7C, 0x01, 0xF8, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xF8, 0x1F, 0x80,
  0x7C, 0x7E, 0x01, 0xF0, 0x1F, 0x80, 0x7C, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0xF8, 0x3E, 0x03, 0xF0, 0x0F, 0x80, 0xF8, 0x3F, 0x03, 0xF0, 0x0F, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x0F, 0xC1, 0xF8, 0x1F, 0x03, 0xE0, 0x07, 0xC1,
  0xF0, 0x1F, 0x07, 0xE0, 0x07, 0xC1, 0xF0, 0x0F, 0x87, 0xC0, 0x07, 0xE3,
  0xF0, 0x0F, 0x87, 0xC0, 0x03, 0xE3, 0xE0, 0x0F, 0x87, 0xC0, 0x03, 0xE3,
  0xE0, 0x0F, 0xCF, 0xC0, 0x03, 0xE3, 0xE0, 0x07, 0xCF, 0x80, 0x03, 0xF7,
  0xC0, 0x07, 0xCF, 0x80, 0x01, 0xF7, 0xC0, 0x07, 0xCF, 0x80, 0x01, 0xF7,
  0xC0, 0x03, 0xFF, 0x80, 0x01, 0xF7, 0x80, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x7E, 0x00,
  0x00, 0xFE, 0x7E, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x07, 0xE0, 0xFC, 0x00,
  0x1F, 0x80, 0xFC, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x7E,
  0x00, 0x03, 0xF1, 0xF8, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xDF, 0x80, 0x00,
  0x3F, 0x1F, 0x80, 0x00, 0x7E, 0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0x07,
  0xE0, 0x3F, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0xFC,
  0x00, 0x7E, 0x03, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0xFE, 0x1F, 0x80,
  0x00, 0xFC, 0x7E, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00,
  0x00, 0x3F, 0x7C, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00,
  0x00, 0x7E, 0x3F, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x00,
  0x00, 0xFC, 0x1F, 0x80, 0x00, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x0F, 0xC0,
  0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xF0, 0x07, 0xC0, 0x03, 0xF0, 0x07, 0xE0,
  0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x03, 0xF0,
  0x07, 0xC0, 0x01, 0xF0, 0x0F, 0xC0, 0x01, 0xF8, 0x0F, 0xC0, 0x01, 0xF8,
  0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0x7C,
  0x1F, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0x7E, 0x3E, 0x00, 0x00, 0x3E,
  0x3E, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x1F,
  0x7C, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x67, 0xFE, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00,
  0x7F, 0xF0, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F,
  0x00, 0x0F, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xC0, 0x00, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0xFF, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0x00, 0x1F, 0xF0,
  0x07, 0xFF, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x0F,
  0xE0, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x04, 0xFF, 0xFC, 0x00,
  0x37, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xEC, 0x00, 0x1F, 0xFE, 0x20, 0x00, 0x07, 0xE0,
};

const GFXglyph NotoSans_Regular63pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 7, 46, 17, 5, -45 },
  { 42, 18, 16, 26, 4, -45 },
  { 78, 37, 45, 41, 2, -45 },
  { 287, 29, 52, 36, 4, -48 },
  { 476, 46, 47, 52, 3, -46 },
  { 747, 43, 47, 46, 3, -46 },
  { 1000, 6, 16, 14, 4, -45 },
  { 1012, 14, 55, 19, 3, -45 },
  { 1109, 14, 55, 19, 2, -45 },
  { 1206, 29, 28, 35, 3, -48 },
  { 1308, 30, 30, 36, 3, -37 },
  { 1421, 9, 15, 17, 3, -7 },
  { 1438, 15, 5, 20, 3, -19 },
  { 1448, 7, 9, 17, 5, -8 },
  { 1456, 22, 45, 23, 1, -45 },
  { 1580, 30, 47, 36, 3, -46 },
  { 1757, 16, 45, 36, 6, -45 },
  { 1847, 30, 46, 36, 3, -46 },
  { 2020, 29, 47, 36, 3, -46 },
  { 2191, 34, 45, 36, 1, -45 },
  { 2383, 28, 46, 36, 4, -45 },
  { 2544, 30, 47, 36, 3, -46 },
  { 2721, 30, 45, 36, 3, -45 },
  { 2890, 30, 47, 36, 3, -46 },
  { 3067, 30, 47, 36, 3, -46 },
  { 3244, 7, 36, 17, 5, -35 },
  { 3276, 10, 43, 17, 2, -35 },
  { 3330, 30, 31, 36, 3, -38 },
  { 3447, 28, 17, 36, 4, -31 },
  { 3507, 30, 31, 36, 3, -38 },
  { 3624, 25, 47, 27, 1, -46 },
  { 3771, 49, 51, 57, 4, -45 },
  { 4084, 40, 45, 40, 0, -45 },
  { 4309, 32, 45, 41, 6, -45 },
  { 4489, 34, 47, 40, 4, -46 },
  { 4689, 36, 45, 46, 6, -45 },
  { 4892, 25, 45, 35, 6, -45 },
  { 5033, 25, 45, 33, 6, -45 },
  { 5174, 37, 47, 46, 4, -46 },
  { 5392, 35, 45, 47, 6, -45 },
  { 5589, 16, 45, 21, 3, -45 },
  { 5679, 16, 57, 17, -5, -45 },
  { 5793, 33, 45, 39, 6, -45 },
  { 5979, 25, 45, 33, 6, -45 },
  { 6120, 45, 45, 57, 6, -45 },
  { 6374, 36, 45, 48, 6, -45 },
  { 6577, 41, 47, 49, 4, -46 },
  { 6818, 29, 45, 38, 6, -45 },
  { 6982, 41, 57, 49, 4, -46 },
  { 7275, 32, 45, 39, 6, -45 },
  { 7455, 29, 47, 35, 3, -46 },
  { 7626, 33, 45, 35, 1, -45 },
  { 7812, 34, 46, 46, 6, -45 },
  { 8008, 38, 45, 38, 0, -45 },
  { 8222, 57, 45, 59, 1, -45 },
  { 8543, 37, 45, 37, 0, -45 },
  { 8752, 36, 45, 36, 0, -45 },
  { 8955, 32, 45, 36, 2, -45 },
  { 9135, 14, 55, 21, 5, -45 },
  { 9232, 22, 45, 23, 1, -45 },
  { 9356, 14, 55, 21, 2, -45 },
  { 9453, 32, 28, 36, 2, -45 },
  { 9565, 28, 4, 28, 0, 6 },
  { 9579, 12, 10, 18, 3, -48 },
  { 9594, 27, 35, 35, 3, -34 },
  { 9713, 30, 49, 39, 5, -48 },
  { 9897, 25, 35, 30, 3, -34 },
  { 10007, 30, 49, 39, 3, -48 },
  { 10191, 29, 35, 36, 3, -34 },
  { 10318, 23, 48, 22, 1, -48 },
  { 10456, 30, 49, 39, 3, -34 },
  { 10640, 29, 48, 39, 5, -48 },
  { 10814, 6, 46, 16, 5, -46 },
  { 10849, 14, 61, 16, -3, -46 },
  { 10956, 28, 48, 34, 5, -48 },
  { 11124, 6, 48, 16, 5, -48 },
  { 11160, 49, 34, 59, 5, -34 },
  { 11369, 29, 34, 39, 5, -34 },
  { 11493, 32, 35, 38, 3, -34 },
  { 11633, 30, 49, 39, 5, -34 },
  { 11817, 30, 49, 39, 3, -34 },
  { 12001, 20, 34, 26, 5, -34 },
  { 12086, 24, 35, 30, 3, -34 },
  { 12191, 20, 43, 23, 1, -42 },
  { 12299, 29, 35, 39, 5, -34 },
  { 12426, 32, 34, 32, 0, -34 },
  { 12562, 48, 34, 50, 1, -34 },
  { 12766, 31, 34, 33, 1, -34 },
  { 12898, 32, 49, 32, 0, -34 },
  { 13094, 25, 34, 30, 2, -34 },
  { 13201, 20, 55, 24, 2, -45 },
  { 13339, 5, 63, 35, 15, -48 },
  { 13379, 20, 55, 24, 2, -45 },
  { 13517, 30, 8, 36, 3, -26 },
};

const GFXfont NotoSans_Regular63pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Regular63pt7bBitmaps,
  (GFXglyph *)NotoSans_Regular63pt7bGlyphs,
  0x20, 0x7E, 86
};

#endif // _NOTOSANS_REGULAR63PT7B_H_
