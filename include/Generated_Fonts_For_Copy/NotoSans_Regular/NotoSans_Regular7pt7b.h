#ifndef _NOTOSANS_REGULAR7PT7B_H_
#define _NOTOSANS_REGULAR7PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Regular.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Regular7pt7bBitmaps[] PROGMEM = {
  0x00, 0xF8, 0xF0, 0x5F, 0x6F, 0x60, 0x6C, 0x65, 0xE0, 0xCD, 0xBE, 0x75,
  0x80, 0x63, 0x1B, 0x27, 0x80, 0xC0, 0x6A, 0x90, 0x95, 0x60, 0x4F, 0x60,
  0x4F, 0x40, 0xC0, 0xC0, 0x80, 0x29, 0x48, 0x69, 0x99, 0x60, 0xF8, 0xE1,
  0x24, 0xF0, 0xE1, 0x61, 0xE0, 0x26, 0x6F, 0x20, 0x68, 0xE1, 0xE0, 0x78,
  0xF9, 0x60, 0xF2, 0x24, 0x40, 0x69, 0x69, 0x60, 0x69, 0xF1, 0xE0, 0x90,
  0x98, 0x3C, 0x30, 0xF0, 0xC3, 0xE0, 0xE5, 0x24, 0x39, 0x5A, 0xEF, 0x40,
  0xE0, 0x26, 0x5B, 0x90, 0xF7, 0x5E, 0x78, 0x88, 0x70, 0xE9, 0x99, 0xE0,
  0xEE, 0xC0, 0xEE, 0x80, 0x7C, 0x27, 0x17, 0x80, 0x99, 0xF9, 0x90, 0xD5,
  0xC0, 0x55, 0x70, 0xBB, 0x6A, 0x92, 0x4E, 0x8C, 0xF7, 0xDA, 0x80, 0x99,
  0xDB, 0x90, 0x74, 0x63, 0x17, 0x00, 0xF7, 0xC8, 0x74, 0x63, 0x17, 0x0C,
  0xF7, 0x6A, 0x68, 0x61, 0xE0, 0xF4, 0x44, 0x40, 0xB6, 0xDE, 0x99, 0x66,
  0x20, 0x96, 0xD6, 0xD2, 0x48, 0x96, 0x26, 0x90, 0x96, 0x64, 0x40, 0xF2,
  0x44, 0xF0, 0xFC, 0x91, 0x22, 0xD5, 0x70, 0x46, 0x90, 0xE0, 0xC0, 0x67,
  0xF0, 0x9A, 0xDE, 0x72, 0x30, 0x17, 0x99, 0x70, 0x69, 0xE7, 0x79, 0x24,
  0x79, 0x97, 0x16, 0x9A, 0xDA, 0xF8, 0xFE, 0x9E, 0x6E, 0xF8, 0xDD, 0x6B,
  0x50, 0xD6, 0xD0, 0x69, 0x96, 0xD6, 0xF9, 0x00, 0x79, 0x97, 0x11, 0xEA,
  0x78, 0xF0, 0x7A, 0x40, 0xB6, 0xF0, 0x9A, 0x64, 0xAD, 0x76, 0x90, 0xB6,
  0x6B, 0x9A, 0x64, 0x48, 0xE5, 0x70, 0x57, 0x50, 0xFE, 0x95, 0x70, 0xF0,
};

const GFXglyph NotoSans_Regular7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 5, 2, 0, -5 },
  { 2, 2, 2, 3, 0, -5 },
  { 3, 4, 5, 5, 0, -5 },
  { 6, 4, 5, 4, 0, -5 },
  { 9, 5, 5, 6, 0, -5 },
  { 13, 5, 5, 5, 0, -5 },
  { 17, 1, 2, 2, 0, -5 },
  { 18, 2, 6, 2, 0, -5 },
  { 20, 2, 6, 2, 0, -5 },
  { 22, 4, 3, 4, 0, -5 },
  { 24, 4, 3, 4, 0, -4 },
  { 26, 1, 2, 2, 0, -1 },
  { 27, 2, 1, 2, 0, -2 },
  { 28, 1, 1, 2, 0, -1 },
  { 29, 3, 5, 3, 0, -5 },
  { 31, 4, 5, 4, 0, -5 },
  { 34, 1, 5, 4, 1, -5 },
  { 35, 4, 5, 4, 0, -5 },
  { 38, 4, 5, 4, 0, -5 },
  { 41, 4, 5, 4, 0, -5 },
  { 44, 4, 5, 4, 0, -5 },
  { 47, 4, 5, 4, 0, -5 },
  { 50, 4, 5, 4, 0, -5 },
  { 53, 4, 5, 4, 0, -5 },
  { 56, 4, 5, 4, 0, -5 },
  { 59, 1, 4, 2, 0, -4 },
  { 60, 1, 5, 2, 0, -4 },
  { 61, 4, 3, 4, 0, -4 },
  { 63, 4, 1, 4, 0, -3 },
  { 64, 4, 3, 4, 0, -4 },
  { 66, 3, 5, 3, 0, -5 },
  { 68, 6, 6, 6, 0, -5 },
  { 73, 4, 5, 4, 0, -5 },
  { 76, 3, 5, 5, 1, -5 },
  { 78, 4, 5, 4, 0, -5 },
  { 81, 4, 5, 5, 1, -5 },
  { 84, 2, 5, 4, 1, -5 },
  { 86, 2, 5, 4, 1, -5 },
  { 88, 5, 5, 5, 0, -5 },
  { 92, 4, 5, 5, 1, -5 },
  { 95, 2, 5, 2, 0, -5 },
  { 97, 2, 6, 2, -1, -5 },
  { 99, 3, 5, 4, 1, -5 },
  { 101, 3, 5, 4, 1, -5 },
  { 103, 5, 5, 6, 1, -5 },
  { 107, 4, 5, 5, 1, -5 },
  { 110, 5, 5, 5, 0, -5 },
  { 114, 3, 5, 4, 1, -5 },
  { 116, 5, 6, 5, 0, -5 },
  { 120, 3, 5, 4, 1, -5 },
  { 122, 4, 5, 4, 0, -5 },
  { 125, 4, 5, 4, 0, -5 },
  { 128, 3, 5, 5, 1, -5 },
  { 130, 4, 5, 4, 0, -5 },
  { 133, 6, 5, 7, 0, -5 },
  { 137, 4, 5, 4, 0, -5 },
  { 140, 4, 5, 4, 0, -5 },
  { 143, 4, 5, 4, 0, -5 },
  { 146, 1, 6, 2, 1, -5 },
  { 147, 3, 5, 3, 0, -5 },
  { 149, 2, 6, 2, 0, -5 },
  { 151, 4, 3, 4, 0, -5 },
  { 153, 3, 1, 3, 0, 0 },
  { 154, 2, 1, 2, 0, -5 },
  { 155, 3, 4, 4, 0, -4 },
  { 157, 3, 5, 4, 1, -5 },
  { 159, 3, 4, 3, 0, -4 },
  { 161, 4, 5, 4, 0, -5 },
  { 164, 4, 4, 4, 0, -4 },
  { 166, 3, 5, 2, 0, -5 },
  { 168, 4, 6, 4, 0, -4 },
  { 171, 3, 5, 4, 1, -5 },
  { 173, 1, 5, 2, 0, -5 },
  { 174, 1, 7, 2, 0, -5 },
  { 175, 3, 5, 4, 1, -5 },
  { 177, 1, 5, 2, 0, -5 },
  { 178, 5, 4, 7, 1, -4 },
  { 181, 3, 4, 4, 1, -4 },
  { 183, 4, 4, 4, 0, -4 },
  { 185, 3, 6, 4, 1, -4 },
  { 188, 4, 6, 4, 0, -4 },
  { 191, 2, 4, 3, 1, -4 },
  { 192, 3, 4, 3, 0, -4 },
  { 194, 2, 5, 3, 0, -5 },
  { 196, 3, 4, 4, 1, -4 },
  { 198, 4, 4, 4, 0, -4 },
  { 200, 5, 4, 6, 0, -4 },
  { 203, 4, 4, 4, 0, -4 },
  { 205, 4, 6, 4, 0, -4 },
  { 208, 3, 4, 3, 0, -4 },
  { 210, 2, 6, 3, 0, -5 },
  { 212, 1, 7, 4, 1, -5 },
  { 213, 2, 6, 3, 0, -5 },
  { 215, 4, 1, 4, 0, -3 },
};

const GFXfont NotoSans_Regular7pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Regular7pt7bBitmaps,
  (GFXglyph *)NotoSans_Regular7pt7bGlyphs,
  0x20, 0x7E, 10
};

#endif // _NOTOSANS_REGULAR7PT7B_H_
