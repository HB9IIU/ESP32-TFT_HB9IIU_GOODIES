#ifndef _NOTOSANS_REGULAR61PT7B_H_
#define _NOTOSANS_REGULAR61PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Regular.ttf
// Size: 61pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Regular61pt7bBitmaps[] PROGMEM = {
  0x00, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0x7E, 0x3C, 0xFC, 0x1F,
  0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xE0,
  0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x3C, 0x07, 0x9E, 0x03, 0xCF, 0x01, 0xE7,
  0x80, 0xF3, 0xC0, 0x79, 0xE0, 0x3C, 0xF0, 0x1E, 0x00, 0x07, 0xC0, 0x3E,
  0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x78,
  0x03, 0xC0, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00,
  0x0F, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x78,
  0x00, 0x01, 0xF0, 0x07, 0x80, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x01, 0xE0,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x1E, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x3E, 0x00, 0x00,
  0x78, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x78, 0x03, 0xC0,
  0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0xF0, 0x07, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x3E, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x1E, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x3E, 0x00,
  0x00, 0x7C, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x78, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF1,
  0xFC, 0x78, 0x3E, 0x7E, 0x0F, 0x00, 0x4F, 0xC1, 0xE0, 0x01, 0xF0, 0x3C,
  0x00, 0x3E, 0x07, 0x80, 0x07, 0xC0, 0xF0, 0x00, 0xF8, 0x1E, 0x00, 0x1F,
  0x83, 0xC0, 0x03, 0xF8, 0x78, 0x00, 0x3F, 0x8F, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x01,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0x7F,
  0xE0, 0x01, 0xE1, 0xFE, 0x00, 0x3C, 0x0F, 0xC0, 0x07, 0x80, 0xF8, 0x00,
  0xF0, 0x1F, 0x00, 0x1E, 0x03, 0xE0, 0x03, 0xC0, 0x7C, 0x00, 0x78, 0x0F,
  0x80, 0x0F, 0x03, 0xFC, 0x01, 0xE0, 0xFF, 0xF0, 0x3C, 0x7F, 0xBF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0x80, 0x07, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xC0, 0x03, 0xE1, 0xF0, 0x00, 0x3E, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xE0, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0xF0, 0x01, 0xF0, 0x00,
  0xF8, 0x07, 0xC0, 0x0F, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x00, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x01, 0xE0, 0x07, 0x80, 0x7C, 0x00, 0x0F, 0x00,
  0x3C, 0x07, 0xC0, 0x00, 0x78, 0x01, 0xE0, 0x3E, 0x00, 0x03, 0xC0, 0x0F,
  0x03, 0xE0, 0x00, 0x1E, 0x00, 0x78, 0x1E, 0x00, 0x00, 0xF8, 0x07, 0xC1,
  0xF0, 0x00, 0x07, 0xC0, 0x3E, 0x0F, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0xF8,
  0x7F, 0xC0, 0xF0, 0x0F, 0x07, 0x87, 0xFF, 0x07, 0x80, 0x78, 0x7C, 0x7F,
  0xFC, 0x3E, 0x07, 0xC7, 0xC7, 0xE3, 0xF0, 0xF8, 0x7C, 0x3E, 0x3E, 0x0F,
  0x87, 0xFF, 0xE3, 0xE1, 0xE0, 0x3E, 0x1F, 0xFE, 0x1E, 0x1F, 0x01, 0xF0,
  0x7F, 0xE1, 0xF0, 0xF8, 0x07, 0x80, 0xFC, 0x0F, 0x07, 0x80, 0x3C, 0x00,
  0x00, 0xF8, 0x3C, 0x01, 0xF0, 0x00, 0x07, 0x81, 0xE0, 0x0F, 0x80, 0x00,
  0x7C, 0x0F, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x78, 0x03, 0xE0, 0x00, 0x3E,
  0x03, 0xC0, 0x1F, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0xF8, 0x00, 0x1E, 0x00,
  0xF0, 0x07, 0xC0, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0x0F, 0x00, 0x3C,
  0x01, 0xE0, 0x00, 0xF8, 0x01, 0xF0, 0x0F, 0x00, 0x07, 0x80, 0x0F, 0x80,
  0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x07, 0xC0, 0x07, 0xC0, 0x01, 0xF0, 0x7C,
  0x00, 0x3E, 0x00, 0x07, 0xC7, 0xE0, 0x03, 0xE0, 0x00, 0x3F, 0xFE, 0x00,
  0x1E, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0xC0, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xC1, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x07, 0xE0, 0x3F, 0xDF, 0xC0, 0x01, 0xF8, 0x1F,
  0xE3, 0xF8, 0x00, 0x7C, 0x0F, 0xE0, 0x7F, 0x00, 0x3F, 0x03, 0xF0, 0x0F,
  0xF0, 0x0F, 0xC1, 0xF8, 0x01, 0xFE, 0x03, 0xE0, 0x7E, 0x00, 0x3F, 0xC1,
  0xF8, 0x1F, 0x00, 0x07, 0xF8, 0x7C, 0x0F, 0xC0, 0x00, 0xFF, 0x3F, 0x03,
  0xF0, 0x00, 0x1F, 0xFF, 0x80, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x3F, 0x00,
  0x00, 0x7F, 0xF0, 0x0F, 0xC0, 0x00, 0x0F, 0xF8, 0x03, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0xC0, 0x1F, 0xC0, 0x00, 0x7F, 0xF8,
  0x07, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xCF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xE1, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0x80, 0x7F, 0xFF,
  0xF0, 0x07, 0xF0, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x17, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFB, 0xEF, 0x9E, 0x79, 0xE7, 0x9E, 0x79,
  0xE7, 0x9E, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xF0, 0x0F,
  0x80, 0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0,
  0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x7C,
  0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01,
  0xF0, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00,
  0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0,
  0x0F, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x03,
  0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x03,
  0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x60, 0x07, 0x80, 0x13, 0xE0, 0x3C, 0x0F,
  0x9F, 0xF1, 0xE7, 0xFE, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x1F, 0x3E, 0x00, 0x01, 0xF1, 0xF0,
  0x00, 0x1F, 0x87, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xC0, 0xFC, 0x00,
  0xFC, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0x80, 0x0F, 0x00, 0xF0, 0x00, 0x10,
  0x06, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0xC7, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xC3, 0xF0, 0xF8, 0x3E, 0x0F,
  0x83, 0xC1, 0xF0, 0x7C, 0x1E, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3E, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0x7E,
  0x3C, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00,
  0xFF, 0x8F, 0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x7E, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0xF8, 0x3F, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x1F, 0x1F, 0x80, 0x00,
  0xF8, 0xF8, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0xFB,
  0xF0, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x3E, 0xFC, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xF9, 0xF0, 0x00,
  0x07, 0xCF, 0x80, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x1F,
  0x8F, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7E, 0x0F,
  0xC0, 0x07, 0xE0, 0x7F, 0x00, 0x7F, 0x01, 0xFC, 0x0F, 0xF0, 0x07, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0,
  0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xFC, 0x3F, 0xBE, 0x3F, 0x9F, 0x3F, 0x8F,
  0xFF, 0x8F, 0xDF, 0x87, 0xE7, 0x03, 0xF1, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xBF, 0xF8, 0x3F, 0x80, 0x1F,
  0xC0, 0xF0, 0x00, 0x3F, 0x07, 0x00, 0x01, 0xF8, 0x10, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0xFF, 0xF1, 0xFF,
  0x87, 0xE0, 0x01, 0xFC, 0x38, 0x00, 0x0F, 0xC2, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7E, 0xE0, 0x00, 0x1F, 0xEF,
  0xC0, 0x07, 0xFC, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFA, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x01,
  0xF3, 0xE0, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00,
  0xF8, 0x7C, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00,
  0x7C, 0x0F, 0x80, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x3E, 0x03, 0xE0, 0x00,
  0x3E, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x07, 0xC0, 0x0F, 0x80, 0x03, 0xE0, 0x0F, 0xC0, 0x01, 0xF0,
  0x07, 0xC0, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x7C, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x1F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xF0, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x8F, 0xC0, 0x01,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFE, 0x06, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFD, 0x00, 0x00, 0x3F, 0xB8, 0x00, 0x0F, 0xE7, 0xE0,
  0x0F, 0xF8, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xF8,
  0x0C, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x7F, 0xC0,
  0x1F, 0x1F, 0xFF, 0x80, 0xF9, 0xFF, 0xFF, 0x07, 0xDF, 0xFF, 0xFC, 0x7F,
  0xF8, 0x0F, 0xF3, 0xFF, 0x00, 0x1F, 0x9F, 0xE0, 0x00, 0x7E, 0xFE, 0x00,
  0x03, 0xF7, 0xF0, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x0F, 0xCF, 0x80,
  0x00, 0x7E, 0x7C, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x03,
  0xF0, 0x3F, 0x00, 0x3F, 0x81, 0xFE, 0x03, 0xF8, 0x07, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0x07,
  0xFC, 0x1F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0xFC,
  0x7E, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0xF8, 0xFC,
  0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x03, 0xF0, 0xFC, 0x00,
  0x1F, 0x83, 0xF0, 0x01, 0xF8, 0x1F, 0xC0, 0x1F, 0x80, 0x7F, 0x83, 0xF8,
  0x01, 0xFF, 0x7F, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0x7F, 0xE0, 0x0F, 0xE0,
  0xFF, 0x80, 0xFE, 0x01, 0xFE, 0x0F, 0xC0, 0x03, 0xF8, 0xFC, 0x00, 0x0F,
  0xC7, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0x3F, 0x00, 0x01,
  0xF9, 0xFC, 0x00, 0x1F, 0x87, 0xF8, 0x03, 0xFC, 0x1F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0x1F, 0xF0, 0x1F, 0xE0, 0x1F,
  0xC0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xF8, 0x7E, 0x00, 0x07, 0xE3,
  0xE0, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x03, 0xEF, 0x80,
  0x00, 0x1F, 0x7C, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x07, 0xDF, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7E,
  0xF8, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x7F, 0xBF, 0x80, 0x07, 0xFC, 0xFE,
  0x00, 0xFF, 0xE3, 0xFF, 0xFF, 0xBF, 0x0F, 0xFF, 0xF9, 0xF0, 0x3F, 0xFF,
  0x8F, 0x80, 0x7F, 0xF8, 0x7C, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8,
  0x02, 0x00, 0x7F, 0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1D, 0x00, 0x00, 0x00, 0x18,
  0x7E, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0x7E, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0x7E, 0x3C, 0x04, 0x07,
  0xE1, 0xF8, 0xFF, 0x3F, 0xCF, 0xF1, 0xFC, 0x7E, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x1F, 0x87, 0xE3,
  0xF0, 0xFC, 0x3F, 0x0F, 0x83, 0xE1, 0xF8, 0x7C, 0x1F, 0x07, 0x83, 0xE0,
  0xF8, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x7C, 0x00, 0xFE, 0x60,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFB, 0xFF,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1E, 0x00, 0x07,
  0x83, 0xC0, 0x03, 0xFF, 0xF0, 0x0F, 0x8F, 0x80, 0x1F, 0xFF, 0xF0, 0x0F,
  0x1E, 0x00, 0x7F, 0xFF, 0xE0, 0x1E, 0x7C, 0x01, 0xFC, 0x0F, 0xC0, 0x3E,
  0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x3D, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7F,
  0xC0, 0x3E, 0x00, 0x3E, 0x00, 0xFF, 0x80, 0x7C, 0x00, 0x7C, 0x01, 0xFE,
  0x01, 0xF0, 0x00, 0xF8, 0x03, 0xFC, 0x03, 0xE0, 0x01, 0xF0, 0x07, 0xF8,
  0x07, 0xC0, 0x03, 0xE0, 0x0F, 0xF0, 0x0F, 0x80, 0x07, 0x80, 0x1F, 0xE0,
  0x1F, 0x00, 0x0F, 0x00, 0x3F, 0xC0, 0x3E, 0x00, 0x1E, 0x00, 0x7F, 0x80,
  0x7C, 0x00, 0x7C, 0x01, 0xFF, 0x00, 0xF8, 0x00, 0xF8, 0x03, 0xDE, 0x01,
  0xF0, 0x01, 0xF0, 0x07, 0xBC, 0x03, 0xE0, 0x07, 0xF0, 0x1F, 0x78, 0x03,
  0xE0, 0x0F, 0xE0, 0x3C, 0xF8, 0x07, 0xE0, 0x3F, 0xC0, 0xF9, 0xF0, 0x07,
  0xFB, 0xF3, 0xFF, 0xE3, 0xE0, 0x0F, 0xFF, 0xC7, 0xFF, 0x83, 0xC0, 0x07,
  0xFF, 0x07, 0xFE, 0x07, 0xC0, 0x07, 0xFC, 0x07, 0xF8, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x00, 0x1F, 0x1F,
  0x00, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x7E, 0x00, 0x00,
  0x01, 0xF0, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0xF8, 0x00, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00,
  0x00, 0xF8, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x07, 0xE0,
  0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x07,
  0xC0, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0xFC,
  0x00, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x00,
  0x01, 0xF7, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xE3, 0xE0, 0x01, 0xFF, 0x8F, 0x80, 0x00, 0xFF, 0x3E, 0x00, 0x00,
  0xFC, 0xF8, 0x00, 0x03, 0xFB, 0xE0, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x1F,
  0xBE, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x07, 0xEF,
  0x80, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x03, 0xF3, 0xE0,
  0x00, 0x1F, 0x8F, 0x80, 0x03, 0xFC, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xF8, 0xF8, 0x00, 0x0F, 0xF3, 0xE0, 0x00, 0x0F, 0xEF, 0x80, 0x00, 0x1F,
  0xBE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xEF, 0x80, 0x00, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xF0, 0x01, 0xF0, 0x1F, 0xE0, 0x00, 0x18, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x18, 0x07, 0xFF, 0x01,
  0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0x80, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xF0, 0x01, 0xFF, 0xF0,
  0x3E, 0x00, 0x03, 0xFF, 0x07, 0xC0, 0x00, 0x1F, 0xE0, 0xF8, 0x00, 0x00,
  0xFE, 0x1F, 0x00, 0x00, 0x0F, 0xE3, 0xE0, 0x00, 0x00, 0xFC, 0x7C, 0x00,
  0x00, 0x0F, 0xCF, 0x80, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x00, 0x1F, 0xBE,
  0x00, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0x0F,
  0xDF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x07,
  0xEF, 0x80, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x00, 0x1F, 0xBE, 0x00, 0x00,
  0x03, 0xF7, 0xC0, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x00, 0x1F, 0x9F, 0x00,
  0x00, 0x07, 0xE3, 0xE0, 0x00, 0x01, 0xFC, 0x7C, 0x00, 0x00, 0x7F, 0x0F,
  0x80, 0x00, 0x1F, 0xC1, 0xF0, 0x00, 0x0F, 0xF8, 0x3E, 0x00, 0x0F, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xF0,
  0x00, 0xFC, 0x07, 0xFC, 0x00, 0x00, 0xC0, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0x7E, 0x00, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00, 0x3F, 0x7F,
  0x00, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x03,
  0xF1, 0xFC, 0x00, 0x00, 0x3F, 0x1F, 0xE0, 0x00, 0x03, 0xF0, 0xFF, 0x00,
  0x00, 0x3F, 0x07, 0xFC, 0x00, 0x03, 0xF0, 0x3F, 0xFC, 0x01, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xF8, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x3F, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0xC3, 0xFE, 0xFF, 0xFC,
  0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xC0, 0x0E, 0x00, 0xF8, 0x00, 0x00, 0x7E,
  0xF8, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x03, 0xF0,
  0xF8, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x0F, 0xE0, 0xF8, 0x00, 0x1F, 0xC0,
  0xF8, 0x00, 0x3F, 0x80, 0xF8, 0x00, 0x7F, 0x00, 0xF8, 0x00, 0x7E, 0x00,
  0xF8, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x03, 0xF0, 0x00,
  0xF8, 0x07, 0xE0, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0xF8, 0x1F, 0x80, 0x00,
  0xF8, 0x3F, 0x00, 0x00, 0xF8, 0x7F, 0x00, 0x00, 0xF8, 0xFE, 0x00, 0x00,
  0xF8, 0xFC, 0x00, 0x00, 0xF9, 0xFE, 0x00, 0x00, 0xFB, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0x1F, 0xC0, 0x00,
  0xFE, 0x0F, 0xC0, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0xF8, 0x07, 0xF0, 0x00,
  0xF8, 0x03, 0xF0, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x01, 0xFC, 0x00,
  0xF8, 0x00, 0xFE, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x7F, 0x00,
  0xF8, 0x00, 0x3F, 0x80, 0xF8, 0x00, 0x1F, 0xC0, 0xF8, 0x00, 0x0F, 0xC0,
  0xF8, 0x00, 0x0F, 0xE0, 0xF8, 0x00, 0x07, 0xF0, 0xF8, 0x00, 0x03, 0xF0,
  0xF8, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x01, 0xFC, 0xF8, 0x00, 0x00, 0xFE,
  0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFB,
  0xE0, 0x00, 0x00, 0xFB, 0xFF, 0x7C, 0x00, 0x00, 0x1F, 0x7F, 0xE7, 0xC0,
  0x00, 0x07, 0xCF, 0xFC, 0xF8, 0x00, 0x00, 0xF9, 0xFF, 0x9F, 0x80, 0x00,
  0x1F, 0x3F, 0xF1, 0xF0, 0x00, 0x07, 0xC7, 0xFE, 0x3E, 0x00, 0x00, 0xF8,
  0xFF, 0xC7, 0xE0, 0x00, 0x1F, 0x1F, 0xF8, 0x7C, 0x00, 0x07, 0xC3, 0xFF,
  0x0F, 0x80, 0x00, 0xF8, 0x7F, 0xE0, 0xF8, 0x00, 0x3E, 0x0F, 0xFC, 0x1F,
  0x00, 0x07, 0xC1, 0xFF, 0x83, 0xF0, 0x00, 0xF8, 0x3F, 0xF0, 0x3E, 0x00,
  0x3E, 0x07, 0xFE, 0x07, 0xC0, 0x07, 0xC0, 0xFF, 0xC0, 0xFC, 0x00, 0xF0,
  0x1F, 0xF8, 0x0F, 0x80, 0x3E, 0x03, 0xFF, 0x01, 0xF0, 0x07, 0xC0, 0x7F,
  0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0xFC, 0x03, 0xE0, 0x3E, 0x01, 0xFF, 0x80,
  0x7E, 0x07, 0xC0, 0x3F, 0xF0, 0x07, 0xC1, 0xF0, 0x07, 0xFE, 0x00, 0xF8,
  0x3E, 0x00, 0xFF, 0xC0, 0x1F, 0x8F, 0x80, 0x1F, 0xF8, 0x01, 0xF1, 0xF0,
  0x03, 0xFF, 0x00, 0x3E, 0x3E, 0x00, 0x7F, 0xE0, 0x03, 0xEF, 0x80, 0x0F,
  0xFC, 0x00, 0x7D, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x03,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x07, 0xFE, 0xFC, 0x00, 0x01, 0xFF, 0xBF, 0x80, 0x00, 0x7F,
  0xE7, 0xE0, 0x00, 0x1F, 0xF8, 0xFC, 0x00, 0x07, 0xFE, 0x3F, 0x80, 0x01,
  0xFF, 0x87, 0xE0, 0x00, 0x7F, 0xE0, 0xFC, 0x00, 0x1F, 0xF8, 0x3F, 0x80,
  0x07, 0xFE, 0x07, 0xE0, 0x01, 0xFF, 0x80, 0xFC, 0x00, 0x7F, 0xE0, 0x3F,
  0x80, 0x1F, 0xF8, 0x07, 0xE0, 0x07, 0xFE, 0x00, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0x00, 0x7F, 0xE0, 0x07, 0xE0, 0x1F, 0xF8, 0x01, 0xFC, 0x07, 0xFE,
  0x00, 0x3F, 0x01, 0xFF, 0x80, 0x07, 0xE0, 0x7F, 0xE0, 0x01, 0xFC, 0x1F,
  0xF8, 0x00, 0x3F, 0x07, 0xFE, 0x00, 0x07, 0xE1, 0xFF, 0x80, 0x01, 0xFC,
  0x7F, 0xE0, 0x00, 0x3F, 0x1F, 0xF8, 0x00, 0x07, 0xE3, 0xFE, 0x00, 0x01,
  0xFC, 0xFF, 0x80, 0x00, 0x3F, 0x3F, 0xE0, 0x00, 0x07, 0xEF, 0xF8, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x1F, 0xE0, 0x00, 0x07, 0xF0,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x3F, 0x00,
  0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x00, 0x7E,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x3F, 0x80,
  0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x03,
  0xFF, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x1A, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x8F, 0x80,
  0x1F, 0xF8, 0xF8, 0x00, 0x3F, 0xCF, 0x80, 0x00, 0xFE, 0xF8, 0x00, 0x07,
  0xEF, 0x80, 0x00, 0x7E, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x3F, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7E, 0xF8, 0x00, 0x07, 0xEF,
  0x80, 0x00, 0xFC, 0xF8, 0x00, 0x1F, 0xCF, 0x80, 0x07, 0xF8, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x80, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00,
  0x0F, 0xE0, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x3F, 0x80, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x7F, 0x00,
  0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x00,
  0x7E, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0xFC,
  0x00, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00,
  0x00, 0x7E, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x1F, 0x80,
  0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x0F,
  0xF0, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0x00, 0x3F, 0xF8, 0x3E, 0x00, 0x07, 0xF0,
  0x7C, 0x00, 0x07, 0xF0, 0xF8, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x0F, 0xC3,
  0xE0, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0x3F, 0x1F,
  0x00, 0x00, 0x7E, 0x3E, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0x01, 0xF8, 0xF8,
  0x00, 0x03, 0xE1, 0xF0, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x3F, 0x87, 0xC0,
  0x00, 0xFE, 0x0F, 0x80, 0x03, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xE0, 0x03, 0xE0, 0x0F, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F,
  0xC0, 0x1F, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x3F,
  0x00, 0xF8, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x7F, 0x03, 0xE0, 0x00, 0x7E,
  0x07, 0xC0, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0xFC,
  0x3E, 0x00, 0x01, 0xFC, 0x7C, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x01, 0xF9,
  0xF0, 0x00, 0x03, 0xFB, 0xE0, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xC3, 0xFC, 0x00, 0x78, 0x3F, 0x00, 0x00,
  0x87, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE8, 0x00, 0x00,
  0xFE, 0xF0, 0x00, 0x1F, 0xCF, 0xF0, 0x0F, 0xF8, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x07, 0xDF, 0x00, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x00, 0xFD, 0xF0, 0x00,
  0x00, 0x3F, 0x7C, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x03, 0xE7, 0xE0,
  0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x0F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF0,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x02, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0x00, 0xFC,
  0xFC, 0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0xFC, 0x00, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x07,
  0xE0, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x03, 0xE0,
  0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x07, 0xC0,
  0x03, 0xE0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x3E,
  0x00, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0xF8, 0x00, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x7E, 0x00,
  0x00, 0x1F, 0x83, 0xE0, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0x03, 0xF1,
  0xF8, 0x00, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x00,
  0x03, 0xE7, 0xC0, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x00, 0x7D, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xE7, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3E, 0x1F, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xF8,
  0x7E, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x3E, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x7C,
  0xFC, 0x00, 0x3F, 0x03, 0xF0, 0x01, 0xF8, 0xF8, 0x00, 0x7C, 0x07, 0xE0,
  0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x07, 0xC0, 0x07, 0xC3, 0xF0, 0x03, 0xF0,
  0x0F, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xF8,
  0x0F, 0x80, 0x7E, 0x00, 0x7E, 0x03, 0xF0, 0x1F, 0x00, 0xFC, 0x00, 0xFC,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x00, 0xF8, 0x0F, 0x80, 0x7E, 0x03, 0xE0,
  0x01, 0xF0, 0x1F, 0x00, 0x7C, 0x0F, 0xC0, 0x03, 0xF0, 0x7C, 0x00, 0xF8,
  0x1F, 0x80, 0x07, 0xE0, 0xF8, 0x01, 0xF8, 0x3E, 0x00, 0x07, 0xC1, 0xF0,
  0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x87, 0xE0, 0x03, 0xE1, 0xF8, 0x00, 0x1F,
  0x8F, 0x80, 0x07, 0xC3, 0xE0, 0x00, 0x3F, 0x1F, 0x00, 0x0F, 0xC7, 0xC0,
  0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x7C, 0xF8, 0x00, 0x1F,
  0x3F, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x01, 0xFB, 0xE0,
  0x00, 0x3E, 0xF8, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x7D, 0xF0, 0x00, 0x03,
  0xEF, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x00, 0xFC, 0x3F, 0x80,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0xFC,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00,
  0x03, 0xE0, 0xFC, 0x00, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x01, 0xF9, 0xF8,
  0x00, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0x9F, 0x00, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x3F,
  0x00, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x0F, 0x80, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x3F, 0x00, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x00, 0xFC, 0x7E, 0x00,
  0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x7E, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0x3E, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x3E, 0x00, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x0F, 0xC1,
  0xF0, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x01,
  0xFB, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x03, 0xE1, 0xF0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x1F, 0x03, 0xE0,
  0x00, 0x3C, 0x03, 0xC0, 0x00, 0x78, 0x07, 0xC0, 0x01, 0xF0, 0x07, 0x80,
  0x03, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x1F, 0x00,
  0x7C, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3C, 0x07,
  0x80, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x78, 0x3E, 0x00, 0x00, 0xF8, 0xF8,
  0x00, 0x00, 0xF1, 0xF0, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x01, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xE0, 0x7F, 0x81, 0xC0,
  0x07, 0xE0, 0x40, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xCF, 0xFE, 0x01, 0xF7, 0xF8, 0x00, 0x7D, 0xF8, 0x00, 0x1F, 0xFC,
  0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00,
  0xFF, 0x7F, 0x00, 0xFF, 0xDF, 0xFF, 0xFC, 0xF3, 0xFF, 0xFE, 0x3C, 0x7F,
  0xFF, 0x0F, 0x07, 0xFF, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x0F, 0xF8, 0x03,
  0xE1, 0xFF, 0xF0, 0x1F, 0x3F, 0xFF, 0xE0, 0xFB, 0xFF, 0xFF, 0x87, 0xDF,
  0x83, 0xFE, 0x3F, 0xE0, 0x03, 0xF9, 0xFE, 0x00, 0x0F, 0xCF, 0xE0, 0x00,
  0x3F, 0x7F, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x3F,
  0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0x7F,
  0x00, 0x01, 0xFB, 0xF8, 0x00, 0x0F, 0xDF, 0xE0, 0x00, 0xFC, 0xFF, 0x80,
  0x0F, 0xE7, 0xFF, 0x01, 0xFE, 0x3E, 0xFF, 0xFF, 0xE1, 0xF3, 0xFF, 0xFE,
  0x0F, 0x0F, 0xFF, 0xE0, 0x78, 0x1F, 0xFC, 0x00, 0x00, 0x16, 0x00, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0x0F, 0xFE, 0xFE, 0x1F, 0xE0, 0x06, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x01,
  0x0F, 0xF0, 0x0F, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0x00, 0x7F, 0xFC, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x3F, 0xF0, 0x7C, 0x07, 0xFF, 0xE3,
  0xE0, 0x7F, 0xFF, 0x9F, 0x0F, 0xFF, 0xFE, 0xF8, 0x7F, 0x81, 0xFF, 0xC7,
  0xF0, 0x03, 0xFE, 0x7F, 0x00, 0x0F, 0xF3, 0xF0, 0x00, 0x3F, 0x9F, 0x80,
  0x00, 0xFD, 0xF8, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x3F, 0x7C, 0x00, 0x00,
  0xFB, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x07, 0xDF, 0x00, 0x00,
  0x3E, 0xFC, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0xFC,
  0xFC, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x7F, 0x1F, 0x80, 0x07, 0xF8, 0xFF,
  0x00, 0xFF, 0xC3, 0xFF, 0xFF, 0xBE, 0x0F, 0xFF, 0xF8, 0xF0, 0x3F, 0xFF,
  0x87, 0x80, 0x7F, 0xF0, 0x3C, 0x00, 0x18, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x0F,
  0xF0, 0x3F, 0x81, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xE3, 0xF0, 0x00,
  0x7E, 0x3E, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xF7,
  0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x01, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x06, 0x0F,
  0xF8, 0x03, 0xE0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F,
  0x01, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC0,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x78, 0x0F, 0xFF, 0xC3, 0xC0, 0xFF, 0xFF, 0x1E, 0x0F,
  0xFF, 0xFC, 0xF0, 0xFF, 0x07, 0xFF, 0x8F, 0xE0, 0x07, 0xFC, 0xFE, 0x00,
  0x1F, 0xE7, 0xE0, 0x00, 0x7F, 0x3F, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x0F,
  0xDF, 0x80, 0x00, 0x7E, 0xF8, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01,
  0xF7, 0xC0, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x03, 0xEF,
  0xC0, 0x00, 0x3F, 0x7E, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x0F, 0xCF, 0xC0,
  0x00, 0xFE, 0x3F, 0x00, 0x0F, 0xF1, 0xFE, 0x01, 0xFF, 0x87, 0xFF, 0xFF,
  0x7C, 0x1F, 0xFF, 0xF3, 0xE0, 0x7F, 0xFF, 0x1F, 0x00, 0xFF, 0xF0, 0xF8,
  0x00, 0x30, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xF0, 0xC0, 0x00, 0x3F, 0x87, 0xC0, 0x07, 0xF8,
  0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC1, 0xFF, 0x80, 0xFC, 0x7F, 0xFE, 0x0F, 0x8F,
  0xFF, 0xF8, 0xF9, 0xFF, 0xFF, 0xCF, 0xBF, 0x03, 0xFC, 0xFF, 0xC0, 0x0F,
  0xEF, 0xF0, 0x00, 0x7E, 0xFE, 0x00, 0x03, 0xEF, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0x7B,
  0xFF, 0xFF, 0xFF, 0xF7, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x78, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x3F, 0xBF, 0xFC, 0xFF,
  0xF3, 0xFF, 0x8F, 0xFC, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0xBE, 0x00, 0x07, 0xE7, 0xC0, 0x01, 0xF8,
  0xF8, 0x00, 0x7E, 0x1F, 0x00, 0x1F, 0x83, 0xE0, 0x07, 0xE0, 0x7C, 0x01,
  0xF8, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x1F, 0x80, 0x3E, 0x07, 0xE0, 0x07,
  0xC1, 0xF8, 0x00, 0xF8, 0x7F, 0x00, 0x1F, 0x1F, 0xC0, 0x03, 0xE3, 0xF0,
  0x00, 0x7C, 0xFC, 0x00, 0x0F, 0xBF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0x80, 0x07, 0xF9, 0xF8, 0x00, 0xFE, 0x1F, 0x80, 0x1F, 0x83, 0xF8,
  0x03, 0xE0, 0x3F, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x7F, 0x01, 0xF0,
  0x07, 0xF0, 0x3E, 0x00, 0x7E, 0x07, 0xC0, 0x07, 0xE0, 0xF8, 0x00, 0xFE,
  0x1F, 0x00, 0x0F, 0xE3, 0xE0, 0x00, 0xFC, 0x7C, 0x00, 0x0F, 0xCF, 0x80,
  0x01, 0xFD, 0xF0, 0x00, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x1F, 0xF0, 0x01, 0xFF, 0x81, 0xF0,
  0xFF, 0xF8, 0x0F, 0xFF, 0xC3, 0xE7, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7, 0xDF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xCF, 0xBF, 0x07, 0xFB, 0xF0, 0x7F, 0xDF, 0xF0,
  0x03, 0xFF, 0x80, 0x3F, 0xBF, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0x7F, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3E,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xF8,
  0x00, 0x07, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x7F, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3E, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xF8, 0x00,
  0x07, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0xF8, 0x1F, 0xF8, 0x0F, 0x87,
  0xFF, 0xE0, 0xF8, 0xFF, 0xFF, 0x8F, 0x9F, 0xFF, 0xFC, 0xFB, 0xF0, 0x3F,
  0xCF, 0xF8, 0x00, 0xFE, 0xFF, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x3E, 0xFE,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0x83, 0xFE, 0x03, 0xF8,
  0x00, 0xFE, 0x07, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x00,
  0x01, 0xF8, 0xFC, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x03, 0xF3, 0xE0, 0x00,
  0x07, 0xE7, 0xC0, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x0F, 0xBF, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x07,
  0xCF, 0x80, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x7E,
  0x3E, 0x00, 0x00, 0xF8, 0x7E, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xC0,
  0xFE, 0x00, 0x3F, 0x80, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x07, 0x00, 0x00, 0xF8, 0x1F, 0xF8, 0x07, 0xC3, 0xFF, 0xF0, 0x3E, 0x3F,
  0xFF, 0xC1, 0xF3, 0xFF, 0xFF, 0x0F, 0xBF, 0x07, 0xFC, 0x7F, 0xC0, 0x0F,
  0xF3, 0xFC, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0xFE, 0xFE, 0x00, 0x03, 0xF7,
  0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x7E, 0xFE, 0x00, 0x03, 0xF7, 0xF0, 0x00,
  0x1F, 0xBF, 0xC0, 0x01, 0xF9, 0xFF, 0x00, 0x1F, 0xCF, 0xFE, 0x03, 0xFC,
  0x7D, 0xFF, 0xFF, 0xC3, 0xE7, 0xFF, 0xFC, 0x1F, 0x1F, 0xFF, 0xC0, 0xF8,
  0x3F, 0xF8, 0x07, 0xE0, 0x1C, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x78, 0x0F, 0xFF, 0xC3, 0xC0, 0xFF, 0xFF, 0x1E, 0x0F, 0xFF, 0xFD, 0xF0,
  0xFF, 0x03, 0xFF, 0x8F, 0xE0, 0x07, 0xFC, 0xFE, 0x00, 0x1F, 0xE7, 0xE0,
  0x00, 0x7F, 0x3F, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x0F, 0xDF, 0x80, 0x00,
  0x7E, 0xF8, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xF7, 0xC0, 0x00,
  0x0F, 0xBE, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x3F,
  0x7E, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0xFE, 0x3F,
  0x80, 0x0F, 0xF1, 0xFE, 0x01, 0xFF, 0x87, 0xFF, 0xFF, 0x7C, 0x1F, 0xFF,
  0xF3, 0xE0, 0x7F, 0xFF, 0x1F, 0x00, 0xFF, 0xE0, 0xF8, 0x00, 0x70, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0xF8, 0x1F, 0xFF, 0x07, 0xFF, 0xE3, 0xFF, 0xFC, 0xFF,
  0xFF, 0x9F, 0xFF, 0xF7, 0xC0, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE7, 0xF8, 0x0F,
  0xCF, 0xC0, 0x03, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00,
  0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x1F, 0xDF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x01, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x01, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xE0, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x01,
  0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x06, 0x00, 0xF8, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xF7, 0xE0, 0x01, 0xFF, 0x7F, 0x80, 0x7F,
  0xF3, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xF9, 0xF0, 0xFF, 0xFE, 0x1F, 0x07,
  0xFF, 0x81, 0xF0, 0x03, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0xFD, 0xF8, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x07, 0xE3, 0xE0, 0x00,
  0x0F, 0x87, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0x80, 0x00,
  0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x3F, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x0F,
  0x80, 0x7E, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x01, 0xF8,
  0x01, 0xF8, 0x03, 0xF0, 0x01, 0xF0, 0x07, 0xC0, 0x03, 0xF0, 0x1F, 0x80,
  0x03, 0xE0, 0x3E, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3F, 0x1F, 0x80, 0x00,
  0x3E, 0x3E, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00,
  0xFB, 0xE0, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xDF, 0x00, 0x07, 0xF8, 0x00,
  0x3E, 0x7C, 0x00, 0x1F, 0xE0, 0x00, 0xF9, 0xF8, 0x00, 0xFF, 0xC0, 0x07,
  0xE7, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0x8F, 0x80, 0x0F, 0x7C, 0x00, 0x7C,
  0x3E, 0x00, 0x7C, 0xF0, 0x01, 0xF0, 0xFC, 0x01, 0xF3, 0xE0, 0x0F, 0xC3,
  0xF0, 0x07, 0xCF, 0x80, 0x3E, 0x07, 0xC0, 0x1E, 0x3E, 0x00, 0xF8, 0x1F,
  0x00, 0xF8, 0x7C, 0x03, 0xE0, 0x7E, 0x03, 0xE1, 0xF0, 0x1F, 0x80, 0xF8,
  0x0F, 0x87, 0xC0, 0x7C, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x0F, 0x81,
  0xF0, 0x3E, 0x0F, 0xC0, 0x3F, 0x07, 0xC0, 0xF8, 0x3F, 0x00, 0x7C, 0x3E,
  0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x07, 0xC3, 0xE0,
  0x1F, 0x1F, 0x80, 0x1F, 0x9F, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x7C, 0x00,
  0xF9, 0xF0, 0x00, 0xF9, 0xF0, 0x03, 0xE7, 0xC0, 0x03, 0xE7, 0x80, 0x0F,
  0x9F, 0x00, 0x07, 0xDE, 0x00, 0x1E, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x3F, 0x07,
  0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0x3F, 0x00, 0x3F, 0x00, 0x7E,
  0x01, 0xF8, 0x00, 0xFC, 0x07, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x07, 0xE1,
  0xF8, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x0F,
  0x87, 0xE0, 0x00, 0x7E, 0x0F, 0x80, 0x03, 0xF0, 0x3F, 0x00, 0x1F, 0x80,
  0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x03, 0xF0, 0x1F, 0x80, 0x07,
  0xE0, 0x7E, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x7E,
  0xFE, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0xFD,
  0xF8, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x0F, 0xC7,
  0xE0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0xF8, 0x1F,
  0x80, 0x03, 0xF0, 0x1F, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x0F, 0x80, 0x3E,
  0x00, 0x3F, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8,
  0x03, 0xF0, 0x01, 0xF8, 0x07, 0xC0, 0x01, 0xF0, 0x1F, 0x80, 0x03, 0xE0,
  0x3F, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x0F, 0x83,
  0xE0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x3E, 0x3E,
  0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x00, 0x7B, 0xE0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x20, 0x00, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x07,
  0xFE, 0x01, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x3F, 0xE0,
  0x1F, 0xF0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0x40, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x1F, 0x80, 0x03, 0xFC, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0x80, 0x0F, 0xC0, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x08, 0xFF, 0xC0, 0x00, 0x5F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0x90, 0x00, 0x1F, 0xF8, 0x80, 0x00, 0x04, 0x00,
};

const GFXglyph NotoSans_Regular61pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 8, 45, 16, 4, -44 },
  { 46, 17, 16, 25, 4, -44 },
  { 80, 36, 44, 39, 2, -44 },
  { 278, 27, 50, 35, 4, -46 },
  { 447, 45, 45, 51, 3, -44 },
  { 701, 42, 45, 45, 3, -44 },
  { 938, 6, 16, 14, 4, -44 },
  { 950, 14, 54, 18, 2, -44 },
  { 1045, 14, 54, 18, 2, -44 },
  { 1140, 29, 27, 34, 2, -46 },
  { 1238, 29, 29, 35, 3, -36 },
  { 1344, 10, 15, 16, 2, -7 },
  { 1363, 15, 5, 20, 2, -19 },
  { 1373, 8, 8, 16, 4, -7 },
  { 1381, 21, 44, 23, 1, -44 },
  { 1497, 29, 45, 35, 3, -44 },
  { 1661, 17, 44, 35, 5, -44 },
  { 1755, 29, 44, 35, 3, -44 },
  { 1915, 28, 45, 35, 3, -44 },
  { 2073, 33, 44, 35, 1, -44 },
  { 2255, 27, 45, 35, 4, -44 },
  { 2407, 29, 45, 35, 3, -44 },
  { 2571, 29, 44, 35, 3, -44 },
  { 2731, 29, 45, 35, 3, -44 },
  { 2895, 29, 45, 35, 3, -44 },
  { 3059, 8, 35, 16, 4, -34 },
  { 3094, 10, 42, 16, 2, -34 },
  { 3147, 29, 30, 35, 3, -37 },
  { 3256, 28, 17, 35, 3, -30 },
  { 3316, 29, 30, 35, 3, -37 },
  { 3425, 24, 45, 26, 1, -44 },
  { 3560, 47, 49, 55, 4, -44 },
  { 3848, 39, 44, 39, 0, -44 },
  { 4063, 30, 44, 40, 6, -44 },
  { 4228, 33, 45, 39, 4, -44 },
  { 4414, 35, 44, 45, 6, -44 },
  { 4607, 24, 44, 34, 6, -44 },
  { 4739, 24, 44, 32, 6, -44 },
  { 4871, 36, 45, 44, 4, -44 },
  { 5074, 33, 44, 45, 6, -44 },
  { 5256, 16, 44, 21, 2, -44 },
  { 5344, 16, 56, 17, -5, -44 },
  { 5456, 32, 44, 38, 6, -44 },
  { 5632, 24, 44, 32, 6, -44 },
  { 5764, 43, 44, 55, 6, -44 },
  { 6001, 34, 44, 46, 6, -44 },
  { 6188, 40, 45, 48, 4, -44 },
  { 6413, 28, 44, 37, 6, -44 },
  { 6567, 40, 54, 48, 4, -44 },
  { 6837, 31, 44, 38, 6, -44 },
  { 7008, 28, 45, 33, 3, -44 },
  { 7166, 32, 44, 34, 1, -44 },
  { 7342, 34, 45, 45, 5, -44 },
  { 7534, 37, 44, 37, 0, -44 },
  { 7738, 55, 44, 57, 1, -44 },
  { 8041, 36, 44, 36, 0, -44 },
  { 8239, 35, 44, 35, 0, -44 },
  { 8432, 31, 44, 35, 2, -44 },
  { 8603, 14, 54, 20, 5, -44 },
  { 8698, 21, 44, 23, 1, -44 },
  { 8814, 13, 54, 20, 2, -44 },
  { 8902, 31, 28, 35, 2, -44 },
  { 9011, 27, 4, 27, 0, 5 },
  { 9025, 13, 10, 17, 2, -47 },
  { 9042, 26, 34, 34, 3, -33 },
  { 9153, 29, 47, 38, 5, -46 },
  { 9324, 24, 34, 29, 3, -33 },
  { 9426, 29, 47, 38, 3, -46 },
  { 9597, 28, 34, 34, 3, -33 },
  { 9716, 23, 47, 21, 1, -47 },
  { 9852, 29, 48, 38, 3, -33 },
  { 10026, 28, 46, 38, 5, -46 },
  { 10187, 6, 45, 16, 5, -45 },
  { 10221, 14, 60, 16, -3, -45 },
  { 10326, 27, 46, 33, 5, -46 },
  { 10482, 6, 46, 16, 5, -46 },
  { 10517, 47, 33, 57, 5, -33 },
  { 10711, 28, 33, 38, 5, -33 },
  { 10827, 31, 34, 37, 3, -33 },
  { 10959, 29, 48, 38, 5, -33 },
  { 11133, 29, 48, 38, 3, -33 },
  { 11307, 19, 33, 25, 5, -33 },
  { 11386, 23, 34, 29, 3, -33 },
  { 11484, 20, 41, 22, 1, -40 },
  { 11587, 28, 34, 38, 5, -33 },
  { 11706, 31, 33, 31, 0, -33 },
  { 11834, 46, 33, 48, 1, -33 },
  { 12024, 30, 33, 32, 1, -33 },
  { 12148, 31, 48, 31, 0, -33 },
  { 12334, 24, 33, 29, 2, -33 },
  { 12433, 19, 54, 23, 2, -44 },
  { 12562, 4, 61, 34, 15, -46 },
  { 12593, 19, 54, 23, 2, -44 },
  { 12722, 29, 9, 35, 3, -26 },
};

const GFXfont NotoSans_Regular61pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Regular61pt7bBitmaps,
  (GFXglyph *)NotoSans_Regular61pt7bGlyphs,
  0x20, 0x7E, 83
};

#endif // _NOTOSANS_REGULAR61PT7B_H_
