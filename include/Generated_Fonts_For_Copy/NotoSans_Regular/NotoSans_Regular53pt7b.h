#ifndef _NOTOSANS_REGULAR53PT7B_H_
#define _NOTOSANS_REGULAR53PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Regular.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Regular53pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x78, 0xE3, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF3, 0x00, 0xF8, 0x3E, 0xF0, 0x7D, 0xE0,
  0xFB, 0xC1, 0xF7, 0x83, 0xEF, 0x03, 0xDE, 0x07, 0xBC, 0x0F, 0x78, 0x1E,
  0xF0, 0x39, 0xE0, 0x73, 0xC0, 0xE7, 0x81, 0xCE, 0x03, 0x80, 0x00, 0x0F,
  0x00, 0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0E,
  0x01, 0xE0, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x3C,
  0x03, 0xC0, 0x00, 0x3C, 0x03, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x78,
  0x07, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x70,
  0x0F, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0xF0,
  0x1E, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xE0,
  0x3C, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x03, 0xC0,
  0x38, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x03, 0x80, 0x78, 0x00, 0x07, 0x80, 0x70, 0x00, 0x07, 0x80,
  0xF0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x07, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x7E, 0x3C, 0x1C,
  0x7C, 0x3C, 0x00, 0xF8, 0x3C, 0x00, 0xF8, 0x3C, 0x00, 0xF8, 0x3C, 0x00,
  0xF8, 0x3C, 0x00, 0x7C, 0x3C, 0x00, 0x7E, 0x3C, 0x00, 0x7F, 0xBC, 0x00,
  0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3C, 0xFE, 0x00, 0x3C, 0x3F,
  0x00, 0x3C, 0x1F, 0x00, 0x3C, 0x0F, 0x00, 0x3C, 0x0F, 0x00, 0x3C, 0x0F,
  0x00, 0x3C, 0x1F, 0x80, 0x3C, 0x3F, 0xF0, 0x3C, 0x7E, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x00, 0xFF, 0xC0, 0x00, 0x78,
  0x03, 0xFF, 0x80, 0x03, 0xC0, 0x1F, 0x1F, 0x00, 0x0F, 0x00, 0x78, 0x3C,
  0x00, 0x78, 0x03, 0xC0, 0x78, 0x03, 0xE0, 0x0F, 0x01, 0xE0, 0x0F, 0x00,
  0x3C, 0x07, 0x80, 0x7C, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x03, 0xC0, 0x78,
  0x0F, 0x00, 0x0E, 0x01, 0xE0, 0x3C, 0x00, 0x38, 0x07, 0x81, 0xE0, 0x00,
  0xE0, 0x1E, 0x07, 0x80, 0x03, 0xC0, 0x78, 0x3C, 0x00, 0x0F, 0x01, 0xE0,
  0xF0, 0x00, 0x3C, 0x07, 0x87, 0x87, 0xF0, 0xF0, 0x1E, 0x3E, 0x3F, 0xE3,
  0xC0, 0x78, 0xF1, 0xFF, 0xC7, 0x83, 0xC7, 0x8F, 0x8F, 0x9F, 0x1F, 0x1E,
  0x3C, 0x1E, 0x3F, 0xF8, 0xF1, 0xE0, 0x3C, 0x7F, 0xC3, 0xC7, 0x80, 0xF0,
  0xFE, 0x1E, 0x1E, 0x03, 0xC0, 0x00, 0x78, 0x78, 0x0F, 0x00, 0x03, 0xC1,
  0xE0, 0x3C, 0x00, 0x1F, 0x07, 0x80, 0x70, 0x00, 0x78, 0x1E, 0x01, 0xC0,
  0x03, 0xC0, 0x78, 0x07, 0x00, 0x0F, 0x01, 0xE0, 0x3C, 0x00, 0x78, 0x07,
  0x80, 0xF0, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x0F, 0x00,
  0x3C, 0x01, 0xE0, 0x3C, 0x01, 0xE0, 0x03, 0xC1, 0xE0, 0x0F, 0x80, 0x0F,
  0x8F, 0x80, 0x3C, 0x00, 0x1F, 0xFC, 0x01, 0xE0, 0x00, 0x3F, 0xF0, 0x0F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0x3F, 0x80, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x3C,
  0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x0F, 0x80, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00,
  0x03, 0xEF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x78, 0x1F, 0xDF, 0xC0, 0x0F, 0x83, 0xF0, 0xFE, 0x00, 0xF8,
  0x7E, 0x07, 0xF0, 0x0F, 0x07, 0xC0, 0x3F, 0x81, 0xF0, 0xFC, 0x01, 0xFC,
  0x1F, 0x0F, 0x80, 0x0F, 0xE3, 0xE0, 0xF8, 0x00, 0x3F, 0x3E, 0x0F, 0x80,
  0x01, 0xFF, 0xC0, 0xF8, 0x00, 0x0F, 0xFC, 0x0F, 0x80, 0x00, 0x7F, 0x80,
  0xF8, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x7F, 0x80, 0x7E, 0x00, 0x1F,
  0xFC, 0x07, 0xF0, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x3F, 0x01, 0xFF,
  0xFF, 0xC1, 0xF8, 0x0F, 0xFF, 0xF8, 0x0F, 0xC0, 0x3F, 0xFC, 0x00, 0x7F,
  0x00, 0x10, 0x00, 0x00, 0x00, 0xFB, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE,
  0xF7, 0xB8, 0x00, 0xF0, 0x1E, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F,
  0x81, 0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x07, 0x80, 0x78,
  0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x3E, 0x01, 0xE0, 0x1F,
  0x01, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x1F, 0xF0,
  0x07, 0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x0F,
  0x80, 0x78, 0x07, 0xC0, 0x7C, 0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x1E, 0x01, 0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x80, 0xF0, 0x1F,
  0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x78, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0xC0, 0x38, 0x02, 0x7C, 0x1C, 0x1F,
  0x3F, 0xEE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xEF, 0x00, 0x01, 0xE7,
  0xC0, 0x01, 0xF1, 0xF0, 0x00, 0xF8, 0xFC, 0x00, 0xF8, 0x3E, 0x00, 0xFC,
  0x1F, 0x80, 0x7C, 0x07, 0xC0, 0x0E, 0x03, 0x80, 0x01, 0x01, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x1F, 0x3F,
  0x3E, 0x3E, 0x3E, 0x3C, 0x7C, 0x78, 0x78, 0x78, 0xF0, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xF3, 0x00, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C,
  0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0x01, 0xF8, 0x0F, 0x81, 0xF0, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0xF8,
  0x00, 0x7C, 0x7C, 0x00, 0x1E, 0x3C, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xDF,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0xF7, 0xC0, 0x00, 0x7B, 0xC0, 0x00, 0x3D,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0x7C, 0x00, 0x07, 0xBE, 0x00,
  0x07, 0xDF, 0x00, 0x03, 0xE7, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0xF1, 0xF0,
  0x00, 0xF8, 0x78, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x0F, 0x80, 0x7E, 0x07,
  0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x7C, 0x03, 0xF0, 0x1F, 0xC0, 0xFF, 0x0F, 0xFC,
  0x7F, 0xF3, 0xF7, 0xFF, 0x9F, 0xFC, 0x7D, 0xC1, 0xF2, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xFF,
  0x80, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x0F, 0xE0,
  0x1F, 0xC3, 0xC0, 0x03, 0xE0, 0x80, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x87, 0xE0, 0x07,
  0xE1, 0xC0, 0x01, 0xF0, 0x40, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF8, 0x03,
  0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x78, 0x00, 0x3F, 0xBF, 0xE3, 0xFF, 0x9F, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xA0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7B, 0xE0, 0x00, 0x0F, 0x3E, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x1E,
  0x3E, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x83, 0xE0,
  0x00, 0xF0, 0x3E, 0x00, 0x1F, 0x03, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x3C,
  0x03, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3E,
  0x01, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0x78,
  0x00, 0x3E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x10, 0x01, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x80, 0x00, 0x7E, 0xF0, 0x01, 0xFC, 0xFF, 0x9F, 0xF8, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x00, 0xD0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xF7, 0x80, 0x7F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x3C, 0x01, 0xF1, 0xFF, 0xC0, 0xF9,
  0xFF, 0xF8, 0x7D, 0xFF, 0xFE, 0x3F, 0xF0, 0x3F, 0x9F, 0xE0, 0x07, 0xCF,
  0xE0, 0x01, 0xF7, 0xE0, 0x00, 0xFB, 0xE0, 0x00, 0x3D, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xF7, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x79, 0xF0, 0x00, 0x7C, 0x7C, 0x00,
  0x3E, 0x3F, 0x00, 0x3E, 0x0F, 0xC0, 0x3F, 0x03, 0xFC, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x20, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xFE,
  0x07, 0xFC, 0xFF, 0x83, 0xF0, 0x07, 0xC3, 0xF0, 0x01, 0xF1, 0xF0, 0x00,
  0xF8, 0xF8, 0x00, 0x3C, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x0F, 0x1F, 0x00,
  0x07, 0x8F, 0x80, 0x07, 0xC3, 0xE0, 0x03, 0xE1, 0xF8, 0x03, 0xE0, 0x7E,
  0x07, 0xE0, 0x1F, 0xC7, 0xE0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0xFE, 0xFF, 0x81, 0xFC, 0x0F, 0xE0,
  0xF8, 0x03, 0xF8, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x0F,
  0xBC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x3D, 0xF0, 0x00, 0x3E, 0xFC, 0x00, 0x1F, 0x3F, 0x00,
  0x3F, 0x0F, 0xF0, 0xFF, 0x87, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x30, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x03,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x03, 0xF0, 0x1F, 0x83, 0xF0, 0x03, 0xE1,
  0xF0, 0x00, 0xF9, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x1E, 0x7C, 0x00, 0x0F,
  0xBC, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xEF, 0x00, 0x00, 0xF7, 0x80, 0x00,
  0x7B, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFE, 0x00,
  0x1F, 0xDF, 0x00, 0x1F, 0xE7, 0xE0, 0x3F, 0xE3, 0xFF, 0xFE, 0xF0, 0xFF,
  0xFE, 0x78, 0x1F, 0xFC, 0x3C, 0x03, 0xF8, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF8, 0x0E, 0x0F, 0xF8, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xF0,
  0x01, 0xFF, 0xE0, 0x00, 0x04, 0x00, 0x00, 0x7B, 0xFF, 0xFF, 0xFF, 0xF7,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x1E, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x3E, 0x3E, 0x3E, 0x3C, 0x7C, 0x7C,
  0x78, 0x78, 0xF8, 0xF0, 0xF0, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0x03, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0x80, 0x3F,
  0x20, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x07, 0x80, 0x00, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x81, 0xF0,
  0x00, 0x70, 0x00, 0xF0, 0x78, 0x01, 0xFF, 0xE0, 0x3C, 0x3C, 0x01, 0xFF,
  0xFC, 0x07, 0x8F, 0x00, 0xFF, 0xFF, 0x01, 0xE7, 0x80, 0x7E, 0x03, 0xC0,
  0x79, 0xE0, 0x3E, 0x00, 0xF0, 0x0E, 0x78, 0x0F, 0x00, 0x3C, 0x03, 0x9C,
  0x07, 0xC0, 0x0F, 0x00, 0xFF, 0x01, 0xE0, 0x03, 0xC0, 0x3F, 0xC0, 0x78,
  0x00, 0xF0, 0x0F, 0xF0, 0x1E, 0x00, 0x3C, 0x03, 0xFC, 0x07, 0x80, 0x1F,
  0x00, 0xEF, 0x01, 0xE0, 0x07, 0x80, 0x3B, 0xC0, 0x78, 0x01, 0xE0, 0x1E,
  0xF0, 0x1E, 0x00, 0x78, 0x07, 0xBC, 0x07, 0x80, 0x1E, 0x01, 0xEF, 0x01,
  0xF0, 0x0F, 0xC0, 0xF3, 0xC0, 0x3C, 0x07, 0xF0, 0x3C, 0x70, 0x0F, 0xC3,
  0xDE, 0x3E, 0x1E, 0x01, 0xFF, 0xE3, 0xFF, 0x07, 0x80, 0x3F, 0xF0, 0xFF,
  0x81, 0xF0, 0x07, 0xF8, 0x1F, 0xC0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x80, 0x00, 0x3F, 0xC0, 0x03, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x00, 0x3C,
  0xF0, 0x00, 0x00, 0x1F, 0x3C, 0x00, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x01,
  0xE1, 0xE0, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x01, 0xE0, 0x3E, 0x00,
  0x00, 0xF8, 0x07, 0x80, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x3C,
  0x00, 0x07, 0xC0, 0x0F, 0x80, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x78, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x3E,
  0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x0F, 0x81,
  0xF0, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x1F,
  0x0F, 0x80, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x00, 0xF1, 0xF0, 0x00, 0x00,
  0x3E, 0x78, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x01, 0xF0, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x0F,
  0x80, 0x3F, 0xF1, 0xF0, 0x00, 0x7F, 0x3E, 0x00, 0x07, 0xE7, 0xC0, 0x00,
  0x7C, 0xF8, 0x00, 0x0F, 0x9F, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x3E, 0x7C,
  0x00, 0x07, 0xCF, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x1E, 0x3E, 0x00, 0x07,
  0xC7, 0xC0, 0x03, 0xF0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x0F, 0x80, 0x1F, 0xF1, 0xF0, 0x00, 0x3F,
  0x3E, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xDF, 0x00,
  0x00, 0xFB, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F,
  0xF0, 0x00, 0x0F, 0xBE, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x7E, 0xF8, 0x00,
  0x1F, 0x9F, 0x00, 0x0F, 0xF3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xC0,
  0x1F, 0x03, 0xF8, 0x00, 0x10, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0x00, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x01, 0x40, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0xF8, 0x03, 0xFF, 0x83,
  0xE0, 0x00, 0xFF, 0x0F, 0x80, 0x00, 0xFE, 0x3E, 0x00, 0x01, 0xFC, 0xF8,
  0x00, 0x03, 0xF3, 0xE0, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x0F, 0xBE, 0x00,
  0x00, 0x3E, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xBE, 0x00,
  0x00, 0x3E, 0xF8, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x0F, 0xCF, 0x80, 0x00,
  0x7E, 0x3E, 0x00, 0x03, 0xF8, 0xF8, 0x00, 0x3F, 0xC3, 0xE0, 0x07, 0xFE,
  0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xFF, 0xFD, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFE, 0x00, 0x7C, 0x07, 0xF0, 0x00, 0x0C,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x1F,
  0x7C, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x1F,
  0x3E, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0x1F,
  0x1F, 0x80, 0x00, 0x1F, 0x1F, 0xC0, 0x00, 0x1F, 0x0F, 0xE0, 0x00, 0x1F,
  0x07, 0xFC, 0x00, 0x1F, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x28, 0x00,
  0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7,
  0xF8, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x01, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x78, 0x03, 0xE0, 0x1F, 0xA0, 0xFC, 0xFF, 0xF3, 0xFF, 0x8F, 0xFC, 0x3F,
  0xC0, 0xF8, 0x00, 0x07, 0xEF, 0x80, 0x00, 0xFC, 0xF8, 0x00, 0x0F, 0x8F,
  0x80, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC0, 0xF8, 0x00,
  0xF8, 0x0F, 0x80, 0x1F, 0x80, 0xF8, 0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x00,
  0xF8, 0x0F, 0xC0, 0x0F, 0x80, 0xF8, 0x00, 0xF8, 0x1F, 0x00, 0x0F, 0x83,
  0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0xF9, 0xF0, 0x00,
  0x0F, 0xBF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF,
  0x7E, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0x81, 0xF8,
  0x00, 0xF8, 0x0F, 0xC0, 0x0F, 0x80, 0x7E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3F, 0x00, 0xF8, 0x01, 0xF8, 0x0F, 0x80, 0x0F, 0xC0, 0xF8, 0x00,
  0x7C, 0x0F, 0x80, 0x07, 0xE0, 0xF8, 0x00, 0x3F, 0x0F, 0x80, 0x01, 0xF8,
  0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0xFC, 0xF8, 0x00, 0x07, 0xEF, 0x80,
  0x00, 0x3F, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xDE, 0x00, 0x00, 0x1E, 0xFF, 0x7C,
  0x00, 0x00, 0xFF, 0xFD, 0xF0, 0x00, 0x03, 0xDF, 0xF3, 0xC0, 0x00, 0x0F,
  0x7F, 0xCF, 0x80, 0x00, 0x7D, 0xFF, 0x1E, 0x00, 0x01, 0xE7, 0xFC, 0x78,
  0x00, 0x07, 0x9F, 0xF9, 0xF0, 0x00, 0x3C, 0x7F, 0xE3, 0xC0, 0x00, 0xF1,
  0xFF, 0x8F, 0x80, 0x07, 0xC7, 0xFE, 0x3E, 0x00, 0x1E, 0x1F, 0xF8, 0x78,
  0x00, 0x78, 0x7F, 0xE1, 0xF0, 0x03, 0xE1, 0xFF, 0x83, 0xC0, 0x0F, 0x07,
  0xFE, 0x0F, 0x00, 0x3C, 0x1F, 0xF8, 0x3E, 0x01, 0xE0, 0x7F, 0xE0, 0x78,
  0x07, 0x81, 0xFF, 0x81, 0xF0, 0x3E, 0x07, 0xFE, 0x07, 0xC0, 0xF0, 0x1F,
  0xF8, 0x0F, 0x03, 0xC0, 0x7F, 0xE0, 0x3E, 0x1F, 0x01, 0xFF, 0x80, 0x78,
  0x78, 0x07, 0xFE, 0x01, 0xE3, 0xE0, 0x1F, 0xF8, 0x07, 0xCF, 0x00, 0x7F,
  0xE0, 0x0F, 0x3C, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xF0, 0x01, 0xFF,
  0x80, 0x0F, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xF8, 0x00, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0xFC, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFD, 0xF0, 0x00,
  0x0F, 0xF3, 0xE0, 0x00, 0x3F, 0xCF, 0xC0, 0x00, 0xFF, 0x1F, 0x00, 0x03,
  0xFC, 0x7E, 0x00, 0x0F, 0xF0, 0xFC, 0x00, 0x3F, 0xC1, 0xF0, 0x00, 0xFF,
  0x87, 0xE0, 0x03, 0xFE, 0x0F, 0xC0, 0x0F, 0xF8, 0x1F, 0x00, 0x3F, 0xE0,
  0x7E, 0x00, 0xFF, 0x80, 0xF8, 0x03, 0xFE, 0x01, 0xF0, 0x0F, 0xF8, 0x07,
  0xE0, 0x3F, 0xE0, 0x0F, 0x80, 0xFF, 0x80, 0x1F, 0x03, 0xFE, 0x00, 0x7E,
  0x0F, 0xF8, 0x00, 0xF8, 0x3F, 0xE0, 0x01, 0xF0, 0xFF, 0x80, 0x07, 0xE3,
  0xFE, 0x00, 0x0F, 0x8F, 0xF8, 0x00, 0x3F, 0x3F, 0xE0, 0x00, 0x7E, 0xFF,
  0x80, 0x00, 0xFB, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x0F,
  0xC0, 0xFC, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x0F, 0x87, 0xC0, 0x00,
  0x01, 0xF1, 0xF8, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x03, 0xE7, 0xC0,
  0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFB, 0xE0,
  0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x00, 0xF9,
  0xF0, 0x00, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x00,
  0xFC, 0x7E, 0x00, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0xFC, 0x00,
  0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xF8, 0x0F, 0xFC,
  0xF8, 0x00, 0xFE, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3E,
  0xF8, 0x00, 0x7E, 0xF8, 0x03, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0x80, 0x1F,
  0xC0, 0x1F, 0xC0, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0xFC, 0x00,
  0x00, 0xFC, 0x3F, 0x00, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x01, 0xF1, 0xF8,
  0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x00, 0x7C,
  0xF8, 0x00, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x00, 0x1F,
  0x7C, 0x00, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00,
  0x1F, 0x3F, 0x00, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x00, 0xF8, 0x7E, 0x00,
  0x00, 0x1F, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x0F,
  0xE0, 0x00, 0x7E, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0x80, 0x7F, 0xE1, 0xF0, 0x00,
  0xFC, 0x3E, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x1F, 0x1F,
  0x00, 0x03, 0xE3, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x8F, 0x80, 0x01,
  0xF1, 0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x07, 0xC7, 0xC0, 0x01, 0xF0, 0xF8,
  0x00, 0x7E, 0x1F, 0x00, 0x1F, 0x83, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x3E, 0x01, 0xF0, 0x07, 0xC0,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x7E, 0x03, 0xE0, 0x07, 0xC0,
  0x7C, 0x00, 0xFC, 0x0F, 0x80, 0x0F, 0x81, 0xF0, 0x00, 0xF8, 0x3E, 0x00,
  0x1F, 0x87, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x3F, 0x1F, 0x00, 0x03, 0xE3,
  0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x7D, 0xF0, 0x00,
  0x0F, 0xC0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFC, 0x7F, 0x00, 0x7C, 0x7E, 0x00, 0x08, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x01,
  0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x80, 0x00, 0x7E, 0xF0, 0x01, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x00, 0x50, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xF9, 0xF0, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x7C, 0x3F, 0x00, 0x07, 0xE1,
  0xFC, 0x00, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E, 0x7C, 0x00,
  0x00, 0x3E, 0x3E, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x7C, 0x3E, 0x00,
  0x00, 0x7C, 0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x00,
  0x01, 0xF0, 0x0F, 0x80, 0x01, 0xF0, 0x0F, 0x80, 0x01, 0xF0, 0x0F, 0x80,
  0x03, 0xE0, 0x07, 0xC0, 0x03, 0xE0, 0x07, 0xC0, 0x03, 0xE0, 0x07, 0xC0,
  0x07, 0xC0, 0x03, 0xE0, 0x07, 0xC0, 0x03, 0xE0, 0x07, 0xC0, 0x01, 0xE0,
  0x0F, 0x80, 0x01, 0xF0, 0x0F, 0x80, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0xF0,
  0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0x7C,
  0x3E, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0x3E,
  0x7C, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x00, 0x1E,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3E,
  0x78, 0x00, 0x0F, 0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0xE0, 0x00, 0x3C,
  0x7C, 0x00, 0x1F, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x1E, 0xF0, 0x00, 0x7C,
  0x3C, 0x00, 0x1E, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x1E, 0xF0, 0x00, 0x78,
  0x3E, 0x00, 0x3E, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x3C, 0x78, 0x00, 0xF8,
  0x1F, 0x00, 0x3C, 0x78, 0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xF0,
  0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xF0, 0x1F, 0x00, 0x78, 0x3C, 0x01, 0xF0,
  0x0F, 0x80, 0xF8, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x3E, 0x03, 0xE0,
  0x0F, 0x80, 0xF0, 0x1E, 0x03, 0xE0, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xE0,
  0x07, 0xC1, 0xF0, 0x1F, 0x03, 0xC0, 0x07, 0xC1, 0xF0, 0x0F, 0x07, 0xC0,
  0x07, 0xC1, 0xE0, 0x0F, 0x07, 0xC0, 0x03, 0xC3, 0xE0, 0x0F, 0x87, 0xC0,
  0x03, 0xE3, 0xE0, 0x0F, 0x87, 0x80, 0x03, 0xE3, 0xC0, 0x07, 0x8F, 0x80,
  0x03, 0xE3, 0xC0, 0x07, 0xCF, 0x80, 0x01, 0xE7, 0xC0, 0x07, 0xCF, 0x80,
  0x01, 0xE7, 0xC0, 0x03, 0xCF, 0x00, 0x01, 0xF7, 0x80, 0x03, 0xCF, 0x00,
  0x01, 0xF7, 0x80, 0x03, 0xDF, 0x00, 0x00, 0xF7, 0x80, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x7C, 0x00,
  0x01, 0xF0, 0x7C, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0x3E, 0x01, 0xF8, 0x00, 0x78, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x07,
  0xC0, 0x03, 0xF0, 0x0F, 0x80, 0x03, 0xE0, 0x3E, 0x00, 0x03, 0xE0, 0xF8,
  0x00, 0x07, 0xC1, 0xF0, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x07, 0xCF, 0x00,
  0x00, 0x0F, 0xBE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00,
  0x3E, 0x3E, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03,
  0xC0, 0xFC, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x7C,
  0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x07, 0xC0, 0x03, 0xF0, 0x0F, 0x80,
  0x03, 0xE0, 0x3E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0xE1, 0xF0, 0x00,
  0x07, 0xC7, 0xC0, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x0F, 0xC0, 0xF8, 0x00,
  0x00, 0x7D, 0xF0, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x0F, 0x8F, 0x80, 0x00,
  0x7C, 0x3E, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x7E,
  0x03, 0xE0, 0x01, 0xF0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x3E, 0x01, 0xF0, 0x00, 0xF8, 0x07, 0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x07,
  0xC0, 0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x7C,
  0xF8, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00,
  0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1D, 0xE0, 0x00, 0x0F, 0x78, 0x00, 0x03, 0x8F, 0x00, 0x01,
  0xE3, 0xC0, 0x00, 0x78, 0x78, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x03, 0xC0,
  0x07, 0x80, 0xF0, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00,
  0xF0, 0x1E, 0x00, 0x3C, 0x07, 0x80, 0x07, 0x81, 0xE0, 0x01, 0xF0, 0xF0,
  0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x9E, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xE0, 0xF8, 0x0F, 0xC0, 0x80, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0x8F, 0xF8, 0x0F, 0x3F,
  0x00, 0x1E, 0xFC, 0x00, 0x3D, 0xF0, 0x00, 0x7B, 0xC0, 0x00, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x07, 0xDF, 0x00, 0x0F, 0xBE, 0x00, 0x3F, 0x7E, 0x01,
  0xFE, 0xFE, 0x1F, 0xBC, 0xFF, 0xFF, 0x78, 0xFF, 0xF8, 0x70, 0xFF, 0xE0,
  0xE0, 0x08, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0xF8, 0xFF, 0xF0, 0x3E, 0x7F,
  0xFE, 0x0F, 0xBF, 0xFF, 0xC3, 0xFF, 0x03, 0xF8, 0xFF, 0x00, 0x3F, 0x3F,
  0x80, 0x07, 0xCF, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0x3E, 0xFC, 0x00, 0x0F,
  0xBE, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7B, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xEF, 0xC0, 0x00, 0xFB, 0xF0, 0x00, 0x3E,
  0xFC, 0x00, 0x0F, 0xBF, 0x80, 0x07, 0xCF, 0xE0, 0x03, 0xF3, 0xFC, 0x01,
  0xF8, 0xFF, 0xE1, 0xFE, 0x3E, 0xFF, 0xFF, 0x0F, 0x1F, 0xFF, 0x83, 0xC1,
  0xFF, 0x80, 0x00, 0x04, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0xC1,
  0xFF, 0xFC, 0x1F, 0xFF, 0xE1, 0xFC, 0x0F, 0x1F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x80, 0x10,
  0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x1F, 0xC1, 0xF0, 0x3F, 0xF8, 0xF8, 0x7F, 0xFF, 0x3C, 0x7F, 0xFF, 0xDE,
  0x3F, 0x01, 0xFF, 0x3F, 0x00, 0x3F, 0xBF, 0x00, 0x0F, 0xDF, 0x00, 0x07,
  0xEF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xBE, 0x00, 0x0F, 0xCF,
  0x80, 0x0F, 0xE7, 0xE0, 0x0F, 0xF1, 0xFE, 0x3F, 0x78, 0x7F, 0xFF, 0x3C,
  0x1F, 0xFF, 0x1E, 0x03, 0xFF, 0x0F, 0x00, 0x18, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x1F, 0x80,
  0xFC, 0x3F, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00,
  0x1F, 0x78, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x06, 0x1F, 0xF9, 0xFE, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00, 0xFF,
  0xF8, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x07, 0xFF, 0x00, 0xFF, 0xE0,
  0x1F, 0xFE, 0x03, 0xF8, 0xC0, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x07, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFF, 0xC3, 0xC3, 0xFF, 0xF9, 0xE3, 0xFF, 0xFE, 0xF1,
  0xFC, 0x0F, 0xF9, 0xF8, 0x03, 0xFC, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x3F,
  0x7C, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xF7, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x7E, 0x7C,
  0x00, 0x7F, 0x3F, 0x00, 0x7F, 0x8F, 0xE0, 0xFB, 0xC3, 0xFF, 0xF9, 0xE0,
  0xFF, 0xF9, 0xF0, 0x1F, 0xF8, 0xF8, 0x00, 0xC0, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE3, 0x00, 0x07, 0xF1, 0xF8, 0x0F, 0xF0, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x1F, 0xC0, 0xF8,
  0xFF, 0xF0, 0xF9, 0xFF, 0xFC, 0xFB, 0xFF, 0xFE, 0xFF, 0xC0, 0x7E, 0xFF,
  0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0x7B,
  0xEF, 0xFF, 0xF9, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0xFB, 0xEF, 0xBE, 0xFB,
  0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB,
  0xEF, 0xBE, 0xFB, 0xEF, 0x80, 0x00, 0xF0, 0x0F, 0x80, 0x7E, 0x03, 0xF0,
  0x1F, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xD0, 0xFC, 0xFF,
  0xE7, 0xFE, 0x3F, 0xE0, 0x78, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x02, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0xF8,
  0xF8, 0x01, 0xF0, 0xF8, 0x03, 0xE0, 0xF8, 0x07, 0xC0, 0xF8, 0x0F, 0x80,
  0xF8, 0x1F, 0x80, 0xF8, 0x3F, 0x00, 0xF8, 0x7E, 0x00, 0xF8, 0xFC, 0x00,
  0xF9, 0xF8, 0x00, 0xF9, 0xF0, 0x00, 0xFB, 0xF0, 0x00, 0xFF, 0xF8, 0x00,
  0xFF, 0xFC, 0x00, 0xFE, 0x7C, 0x00, 0xFC, 0x3E, 0x00, 0xF8, 0x3F, 0x00,
  0xF8, 0x1F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0xF8, 0x07, 0xE0,
  0xF8, 0x03, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xFC,
  0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x80, 0x0F, 0xE0,
  0x78, 0x7F, 0xF8, 0x1F, 0xFE, 0x3E, 0x7F, 0xFE, 0x3F, 0xFF, 0x9F, 0x7F,
  0xFF, 0xBF, 0xFF, 0xEF, 0xFC, 0x0F, 0xDF, 0x03, 0xF7, 0xF8, 0x03, 0xFE,
  0x00, 0xFF, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0x80, 0x03, 0xFE, 0x00,
  0x07, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x78, 0x00, 0x1F,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0x00, 0x03, 0xFE, 0x00, 0x07, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xC0,
  0x00, 0xFF, 0x80, 0x01, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x78, 0x00, 0x1F, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0xF8, 0x00,
  0x1E, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0x00, 0x03, 0xFE, 0x00, 0x07, 0x80,
  0x01, 0xFF, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1F, 0xC0, 0xF0, 0xFF, 0xF8, 0xF9, 0xFF, 0xFC, 0xFB, 0xFF, 0xFE,
  0xFF, 0xC0, 0x7E, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF,
  0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xC0, 0xFE, 0x0F, 0xC0, 0x0F, 0xC3, 0xE0,
  0x01, 0xF1, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0xBE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0x9F,
  0x00, 0x03, 0xE7, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x7C, 0x1F, 0x80, 0x3F,
  0x07, 0xFC, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0xFF,
  0xE0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x3C, 0x3F, 0xFC, 0x0F,
  0x9F, 0xFF, 0x83, 0xEF, 0xFF, 0xF0, 0xFF, 0xC0, 0xFE, 0x3F, 0xC0, 0x0F,
  0xCF, 0xE0, 0x01, 0xF3, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xBF, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFB, 0xF0, 0x00, 0x3E, 0xFC, 0x00,
  0x0F, 0xBF, 0x00, 0x03, 0xEF, 0xE0, 0x01, 0xF3, 0xF8, 0x00, 0xFC, 0xFF,
  0x80, 0x7E, 0x3F, 0xFC, 0xFF, 0x8F, 0xBF, 0xFF, 0xC3, 0xE7, 0xFF, 0xE0,
  0xF8, 0x7F, 0xE0, 0x3E, 0x01, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFF, 0xC3, 0xC3, 0xFF, 0xF9, 0xE3, 0xFF, 0xFE, 0xF1, 0xF8,
  0x0F, 0xF9, 0xF8, 0x01, 0xFD, 0xF8, 0x00, 0xFE, 0xF8, 0x00, 0x3F, 0x7C,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xF7, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x7E, 0x7C, 0x00,
  0x7F, 0x3F, 0x00, 0x7F, 0x8F, 0xF1, 0xFB, 0xC3, 0xFF, 0xFB, 0xE0, 0xFF,
  0xF9, 0xF0, 0x1F, 0xF8, 0xF8, 0x00, 0xC0, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0xF8, 0x3F, 0xFE, 0x3F, 0xFF, 0x3F, 0xFF, 0xBF, 0x0F, 0xFC, 0x03, 0xFC,
  0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0xFF, 0xFC, 0x3F, 0xFF, 0xE7, 0xFF, 0xFE, 0xFC, 0x03,
  0xCF, 0x80, 0x04, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x1F,
  0xC0, 0x03, 0xEF, 0xC0, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0x7F, 0xFE,
  0x00, 0x08, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC3, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xE3, 0x07,
  0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xE0, 0x01, 0x00, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC,
  0x00, 0x3F, 0x7C, 0x00, 0x7F, 0x7E, 0x00, 0xFF, 0x3F, 0xC7, 0xEF, 0x3F,
  0xFF, 0xEF, 0x1F, 0xFF, 0x8F, 0x07, 0xFF, 0x0F, 0x00, 0x30, 0x00, 0xF8,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x03,
  0xC3, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x07, 0x80, 0x07, 0xC0, 0xF8,
  0x00, 0xF8, 0x1F, 0x00, 0x1F, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF8,
  0x03, 0xC0, 0x1E, 0x00, 0x7C, 0x07, 0xC0, 0x0F, 0x80, 0xF8, 0x00, 0xF0,
  0x1E, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x3C, 0x3E, 0x00,
  0x07, 0xC7, 0xC0, 0x00, 0x78, 0xF0, 0x00, 0x0F, 0x3E, 0x00, 0x01, 0xF7,
  0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x00, 0xFE, 0x00,
  0x1E, 0x78, 0x00, 0xFF, 0x00, 0x3E, 0x7C, 0x00, 0xFF, 0x00, 0x3E, 0x7C,
  0x01, 0xEF, 0x00, 0x3C, 0x7C, 0x01, 0xEF, 0x80, 0x7C, 0x3C, 0x01, 0xE7,
  0x80, 0x7C, 0x3E, 0x01, 0xE7, 0x80, 0x7C, 0x3E, 0x03, 0xE7, 0x80, 0x78,
  0x1E, 0x03, 0xC7, 0xC0, 0xF8, 0x1E, 0x03, 0xC3, 0xC0, 0xF8, 0x1F, 0x07,
  0xC3, 0xC0, 0xF0, 0x1F, 0x07, 0x83, 0xE0, 0xF0, 0x0F, 0x07, 0x81, 0xE1,
  0xF0, 0x0F, 0x8F, 0x81, 0xE1, 0xF0, 0x0F, 0x8F, 0x01, 0xF1, 0xE0, 0x07,
  0x8F, 0x00, 0xF1, 0xE0, 0x07, 0x9F, 0x00, 0xF3, 0xE0, 0x07, 0xDE, 0x00,
  0xF3, 0xE0, 0x07, 0xDE, 0x00, 0xFB, 0xC0, 0x03, 0xDE, 0x00, 0x7B, 0xC0,
  0x03, 0xDC, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x3F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x0F, 0xCF, 0x80, 0x07,
  0xC3, 0xF0, 0x03, 0xF0, 0x7C, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x01, 0xF0,
  0x3E, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x01, 0xF3, 0xE0, 0x00,
  0x7E, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x07,
  0xC0, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x7C, 0x00, 0xF8,
  0x3F, 0x00, 0x3F, 0x0F, 0x80, 0x07, 0xC7, 0xC0, 0x00, 0xFB, 0xF0, 0x00,
  0x3F, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x1F, 0x1F,
  0x00, 0x03, 0xE3, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x03,
  0xC0, 0xF8, 0x00, 0xF8, 0x0F, 0x00, 0x1F, 0x01, 0xF0, 0x07, 0xC0, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x07, 0xC0, 0x07, 0x80, 0xF8,
  0x00, 0xF8, 0x1E, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xE0, 0xF8, 0x00, 0x3E,
  0x1E, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x78, 0xF8, 0x00, 0x0F, 0x9E, 0x00,
  0x00, 0xF7, 0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF3, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03,
  0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x78, 0x00, 0x7C, 0x00, 0x7C, 0x07, 0xFE, 0x03, 0xFC, 0x01, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x3F, 0xE0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0x7C,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xE0, 0x00, 0x7E, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0x00, 0xFF, 0x80, 0xFE, 0x00, 0xFC,
  0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x3F, 0xE0, 0x1F, 0xE0,
  0x0F, 0xE0, 0x07, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0xBF, 0xFC, 0x00, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xF4, 0x00, 0x7F, 0xF2,
  0x00, 0x03, 0xC0,
};

const GFXglyph NotoSans_Regular53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 6, 39, 14, 4, -38 },
  { 31, 15, 14, 22, 3, -38 },
  { 58, 32, 38, 34, 1, -38 },
  { 210, 24, 43, 30, 3, -40 },
  { 339, 38, 39, 44, 3, -38 },
  { 525, 36, 39, 39, 3, -38 },
  { 701, 5, 14, 12, 3, -38 },
  { 710, 12, 46, 16, 2, -38 },
  { 779, 12, 46, 16, 2, -38 },
  { 848, 25, 24, 29, 2, -40 },
  { 923, 25, 26, 30, 3, -32 },
  { 1005, 8, 13, 14, 2, -6 },
  { 1018, 13, 4, 17, 2, -16 },
  { 1025, 6, 7, 14, 4, -6 },
  { 1031, 18, 38, 20, 1, -38 },
  { 1117, 25, 39, 30, 3, -38 },
  { 1239, 14, 38, 30, 5, -38 },
  { 1306, 25, 38, 30, 3, -38 },
  { 1425, 25, 39, 30, 2, -38 },
  { 1547, 28, 38, 30, 1, -38 },
  { 1680, 24, 39, 30, 3, -38 },
  { 1797, 25, 39, 30, 3, -38 },
  { 1919, 26, 38, 30, 2, -38 },
  { 2043, 25, 39, 30, 3, -38 },
  { 2165, 25, 39, 30, 3, -38 },
  { 2287, 6, 30, 14, 4, -29 },
  { 2310, 8, 36, 14, 2, -29 },
  { 2346, 25, 26, 30, 3, -32 },
  { 2428, 24, 15, 30, 3, -26 },
  { 2473, 25, 26, 30, 3, -32 },
  { 2555, 21, 39, 23, 1, -38 },
  { 2658, 42, 43, 48, 3, -38 },
  { 2884, 34, 38, 34, 0, -38 },
  { 3046, 27, 38, 34, 5, -38 },
  { 3175, 29, 39, 34, 3, -38 },
  { 3317, 30, 38, 39, 5, -38 },
  { 3460, 21, 38, 29, 5, -38 },
  { 3560, 21, 38, 28, 5, -38 },
  { 3660, 32, 39, 39, 3, -38 },
  { 3816, 29, 38, 39, 5, -38 },
  { 3954, 14, 38, 18, 2, -38 },
  { 4021, 14, 48, 14, -4, -38 },
  { 4105, 28, 38, 33, 5, -38 },
  { 4238, 21, 38, 28, 5, -38 },
  { 4338, 38, 38, 48, 5, -38 },
  { 4519, 30, 38, 40, 5, -38 },
  { 4662, 35, 39, 41, 3, -38 },
  { 4833, 24, 38, 32, 5, -38 },
  { 4947, 35, 47, 41, 3, -38 },
  { 5153, 27, 38, 33, 5, -38 },
  { 5282, 24, 39, 29, 3, -38 },
  { 5399, 28, 38, 29, 1, -38 },
  { 5532, 29, 39, 39, 5, -38 },
  { 5674, 32, 38, 32, 0, -38 },
  { 5826, 48, 38, 49, 1, -38 },
  { 6054, 31, 38, 31, 0, -38 },
  { 6202, 30, 38, 30, 0, -38 },
  { 6345, 26, 38, 30, 2, -38 },
  { 6469, 12, 46, 17, 4, -38 },
  { 6538, 18, 38, 20, 1, -38 },
  { 6624, 12, 46, 17, 1, -38 },
  { 6693, 26, 24, 30, 2, -38 },
  { 6771, 24, 3, 24, 0, 5 },
  { 6780, 11, 9, 15, 2, -41 },
  { 6793, 23, 30, 30, 2, -29 },
  { 6880, 26, 41, 33, 4, -40 },
  { 7014, 21, 30, 25, 3, -29 },
  { 7093, 25, 41, 33, 3, -40 },
  { 7222, 24, 30, 30, 3, -29 },
  { 7312, 20, 41, 18, 1, -41 },
  { 7415, 25, 42, 33, 3, -29 },
  { 7547, 24, 40, 33, 4, -40 },
  { 7667, 6, 39, 14, 4, -39 },
  { 7697, 13, 52, 14, -3, -39 },
  { 7782, 24, 40, 28, 4, -40 },
  { 7902, 5, 40, 14, 4, -40 },
  { 7927, 41, 29, 50, 4, -29 },
  { 8076, 24, 29, 33, 4, -29 },
  { 8163, 26, 30, 32, 3, -29 },
  { 8261, 26, 42, 33, 4, -29 },
  { 8398, 25, 42, 33, 3, -29 },
  { 8530, 17, 29, 22, 4, -29 },
  { 8592, 20, 30, 25, 3, -29 },
  { 8667, 17, 36, 19, 1, -35 },
  { 8744, 24, 29, 33, 4, -28 },
  { 8831, 27, 28, 27, 0, -28 },
  { 8926, 40, 28, 42, 1, -28 },
  { 9066, 26, 28, 28, 1, -28 },
  { 9157, 27, 41, 27, 0, -28 },
  { 9296, 21, 28, 25, 2, -28 },
  { 9370, 17, 46, 20, 1, -38 },
  { 9468, 4, 53, 29, 13, -40 },
  { 9495, 17, 46, 20, 2, -38 },
  { 9593, 25, 7, 30, 3, -22 },
};

const GFXfont NotoSans_Regular53pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Regular53pt7bBitmaps,
  (GFXglyph *)NotoSans_Regular53pt7bGlyphs,
  0x20, 0x7E, 72
};

#endif // _NOTOSANS_REGULAR53PT7B_H_
