#ifndef _NOTOSANS_REGULAR12PT7B_H_
#define _NOTOSANS_REGULAR12PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Regular.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Regular12pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0x80, 0xB6, 0xD0, 0x14, 0x28, 0x53, 0xF2, 0x45, 0x3F, 0x94,
  0x48, 0x27, 0xE9, 0x47, 0x1C, 0xBF, 0x21, 0x00, 0x42, 0xA4, 0xA4, 0xA8,
  0xAF, 0x55, 0x25, 0x25, 0x47, 0x30, 0x58, 0xC8, 0x50, 0x60, 0x92, 0x8E,
  0x8C, 0xFB, 0xF0, 0x25, 0x25, 0x92, 0x48, 0x80, 0x89, 0x92, 0x49, 0x2B,
  0x00, 0x10, 0x4F, 0xCC, 0x68, 0x21, 0x3E, 0x42, 0x10, 0x58, 0xE0, 0x80,
  0x11, 0x12, 0x24, 0x44, 0x80, 0x64, 0xE3, 0x18, 0xC6, 0x31, 0x70, 0x2E,
  0x92, 0x49, 0x20, 0x64, 0xC2, 0x11, 0x11, 0x10, 0xF8, 0x74, 0xC2, 0x36,
  0x0C, 0x21, 0xF0, 0x08, 0x10, 0x61, 0x44, 0x89, 0x3F, 0x84, 0x08, 0xFC,
  0x21, 0x0F, 0x04, 0x21, 0xF0, 0x3A, 0x21, 0x0F, 0xC6, 0x31, 0x70, 0xF8,
  0x42, 0x21, 0x10, 0x88, 0x40, 0x74, 0x63, 0x36, 0x4E, 0x31, 0xF0, 0x64,
  0xE3, 0x18, 0xBC, 0x22, 0xF0, 0xC2, 0x50, 0x05, 0x80, 0x09, 0xB1, 0xC1,
  0x84, 0xF8, 0x3E, 0x83, 0x06, 0x6C, 0x40, 0x74, 0xC2, 0x33, 0x10, 0x80,
  0x60, 0x1C, 0x11, 0x90, 0x33, 0x9A, 0x4D, 0x26, 0x93, 0x36, 0x40, 0x1F,
  0x00, 0x10, 0x18, 0x18, 0x2C, 0x24, 0x7C, 0x42, 0x42, 0x83, 0xF2, 0x38,
  0x61, 0xFA, 0x18, 0x61, 0xF8, 0x39, 0x98, 0x20, 0x82, 0x08, 0x30, 0x7C,
  0xF1, 0x1A, 0x1C, 0x18, 0x30, 0x60, 0xC2, 0xF8, 0xFC, 0x21, 0x0F, 0xC2,
  0x10, 0xF8, 0xFC, 0x21, 0x0F, 0xC2, 0x10, 0x80, 0x1C, 0xC6, 0x04, 0x08,
  0xF0, 0x60, 0xE1, 0x7E, 0x83, 0x06, 0x0C, 0x1F, 0xF0, 0x60, 0xC1, 0x82,
  0xF6, 0x66, 0x66, 0x66, 0xF0, 0x24, 0x92, 0x49, 0x27, 0x80, 0x86, 0x29,
  0x2C, 0xE2, 0x49, 0xA2, 0x84, 0x84, 0x21, 0x08, 0x42, 0x10, 0xF8, 0xC1,
  0xE0, 0xE8, 0xB4, 0x5A, 0x2C, 0xA6, 0x53, 0x31, 0x88, 0x80, 0x83, 0x86,
  0x8D, 0x19, 0x33, 0x62, 0xC3, 0x86, 0x38, 0x46, 0x82, 0x83, 0x83, 0x83,
  0x82, 0xC2, 0x7C, 0xE2, 0x68, 0xE3, 0x8B, 0xC8, 0x20, 0x80, 0x38, 0x46,
  0x82, 0x83, 0x83, 0x83, 0x82, 0xC2, 0x7C, 0x0C, 0x06, 0xE2, 0x68, 0xE3,
  0x9B, 0xC8, 0xA2, 0x84, 0x74, 0x61, 0x06, 0x0C, 0x21, 0xF0, 0xFE, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xE2, 0x7C, 0x83, 0x85, 0x12, 0x26, 0x45, 0x0A, 0x0C, 0x10, 0x84, 0x38,
  0x85, 0x29, 0x25, 0x24, 0xA4, 0xD2, 0x8C, 0x61, 0x8C, 0x31, 0x80, 0x82,
  0x88, 0xA1, 0x41, 0x05, 0x0A, 0x22, 0x86, 0x82, 0x89, 0x11, 0x43, 0x82,
  0x04, 0x08, 0x10, 0x7C, 0x10, 0x82, 0x10, 0x82, 0x10, 0xFC, 0xF2, 0x49,
  0x24, 0x93, 0x80, 0x84, 0x44, 0x22, 0x21, 0x10, 0xE4, 0x92, 0x49, 0x27,
  0x80, 0x10, 0xC2, 0x92, 0x47, 0x10, 0xF8, 0xC4, 0x26, 0xC2, 0xF8, 0xCF,
  0xA0, 0x82, 0x09, 0x32, 0x8E, 0x18, 0x62, 0xF8, 0x2D, 0x88, 0x88, 0x70,
  0x08, 0x4B, 0xB8, 0xC6, 0x31, 0x78, 0x26, 0xE3, 0xF8, 0x41, 0xE0, 0x3A,
  0x1D, 0x84, 0x21, 0x08, 0x40, 0x26, 0xE3, 0x18, 0xC5, 0xE1, 0x8F, 0x80,
  0x84, 0x2D, 0x98, 0xC6, 0x31, 0x88, 0xDF, 0x80, 0x24, 0x12, 0x49, 0x24,
  0xF0, 0x84, 0x23, 0x2A, 0x72, 0x92, 0x88, 0xFF, 0x80, 0x33, 0x66, 0x62,
  0x31, 0x18, 0x8C, 0x46, 0x22, 0x36, 0x63, 0x18, 0xC6, 0x20, 0x23, 0x68,
  0xA1, 0x8E, 0x27, 0x80, 0x33, 0x28, 0xE1, 0x86, 0x2F, 0xA0, 0x82, 0x00,
  0x26, 0xE3, 0x18, 0xC5, 0xE1, 0x08, 0x40, 0x1E, 0x88, 0x88, 0x80, 0x69,
  0x8E, 0x11, 0xF0, 0x47, 0xC4, 0x44, 0x47, 0x8C, 0x63, 0x18, 0xFC, 0x85,
  0x24, 0x9A, 0x30, 0xC0, 0x8C, 0xA6, 0x55, 0x4A, 0x65, 0x31, 0x18, 0xCC,
  0xA3, 0x0C, 0x4B, 0x10, 0x85, 0x24, 0x8A, 0x30, 0xC2, 0x08, 0xC0, 0x78,
  0x8C, 0x44, 0x7C, 0x12, 0x22, 0x2C, 0x22, 0x22, 0x10, 0xFF, 0xF0, 0x86,
  0x22, 0x21, 0x22, 0x22, 0xC0, 0xEC, 0x80,
};

const GFXglyph NotoSans_Regular12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 1, 9, 3, 1, -9 },
  { 3, 3, 4, 5, 1, -9 },
  { 5, 7, 9, 8, 0, -9 },
  { 13, 5, 10, 7, 1, -9 },
  { 20, 8, 9, 10, 1, -9 },
  { 29, 8, 9, 9, 1, -9 },
  { 38, 1, 4, 3, 1, -9 },
  { 39, 3, 11, 4, 0, -9 },
  { 44, 3, 11, 4, 0, -9 },
  { 49, 6, 5, 7, 0, -9 },
  { 53, 5, 6, 7, 1, -7 },
  { 57, 2, 3, 3, 0, -1 },
  { 58, 3, 1, 4, 0, -4 },
  { 59, 1, 1, 3, 1, -1 },
  { 60, 4, 9, 4, 0, -9 },
  { 65, 5, 9, 7, 1, -9 },
  { 71, 3, 9, 7, 1, -9 },
  { 75, 5, 9, 7, 1, -9 },
  { 81, 5, 9, 7, 1, -9 },
  { 87, 7, 9, 7, 0, -9 },
  { 95, 5, 9, 7, 1, -9 },
  { 101, 5, 9, 7, 1, -9 },
  { 107, 5, 9, 7, 1, -9 },
  { 113, 5, 9, 7, 1, -9 },
  { 119, 5, 9, 7, 1, -9 },
  { 125, 1, 7, 3, 1, -7 },
  { 126, 2, 9, 3, 0, -7 },
  { 129, 5, 6, 7, 1, -7 },
  { 133, 5, 3, 7, 1, -6 },
  { 135, 5, 6, 7, 1, -7 },
  { 139, 5, 9, 5, 0, -9 },
  { 145, 9, 10, 11, 1, -9 },
  { 157, 8, 9, 8, 0, -9 },
  { 166, 6, 9, 8, 1, -9 },
  { 173, 6, 9, 8, 1, -9 },
  { 180, 7, 9, 9, 1, -9 },
  { 188, 5, 9, 7, 1, -9 },
  { 194, 5, 9, 6, 1, -9 },
  { 200, 7, 9, 9, 1, -9 },
  { 208, 7, 9, 9, 1, -9 },
  { 216, 4, 9, 4, 0, -9 },
  { 221, 3, 11, 3, -1, -9 },
  { 226, 6, 9, 7, 1, -9 },
  { 233, 5, 9, 6, 1, -9 },
  { 239, 9, 9, 11, 1, -9 },
  { 250, 7, 9, 9, 1, -9 },
  { 258, 8, 9, 9, 1, -9 },
  { 267, 6, 9, 7, 1, -9 },
  { 274, 8, 11, 9, 1, -9 },
  { 285, 6, 9, 7, 1, -9 },
  { 292, 5, 9, 7, 1, -9 },
  { 298, 7, 9, 7, 0, -9 },
  { 306, 7, 9, 9, 1, -9 },
  { 314, 7, 9, 7, 0, -9 },
  { 322, 11, 9, 11, 0, -9 },
  { 335, 7, 9, 7, 0, -9 },
  { 343, 7, 9, 7, 0, -9 },
  { 351, 6, 9, 7, 0, -9 },
  { 358, 3, 11, 4, 1, -9 },
  { 363, 4, 9, 4, 0, -9 },
  { 368, 3, 11, 4, 0, -9 },
  { 373, 6, 6, 7, 0, -9 },
  { 378, 5, 1, 5, 0, 1 },
  { 379, 3, 2, 3, 0, -9 },
  { 380, 5, 7, 7, 1, -7 },
  { 385, 6, 9, 7, 1, -9 },
  { 392, 4, 7, 6, 1, -7 },
  { 396, 5, 9, 7, 1, -9 },
  { 402, 5, 7, 7, 1, -7 },
  { 407, 5, 9, 4, 0, -9 },
  { 413, 5, 10, 7, 1, -7 },
  { 420, 5, 9, 7, 1, -9 },
  { 426, 1, 9, 3, 1, -9 },
  { 428, 3, 12, 3, -1, -9 },
  { 433, 5, 9, 6, 1, -9 },
  { 439, 1, 9, 3, 1, -9 },
  { 441, 9, 7, 11, 1, -7 },
  { 449, 5, 7, 7, 1, -7 },
  { 454, 6, 7, 7, 1, -7 },
  { 460, 6, 10, 7, 1, -7 },
  { 468, 5, 10, 7, 1, -7 },
  { 475, 4, 7, 5, 1, -7 },
  { 479, 4, 7, 6, 1, -7 },
  { 483, 4, 8, 4, 0, -8 },
  { 487, 5, 6, 7, 1, -6 },
  { 491, 6, 6, 6, 0, -6 },
  { 496, 9, 6, 9, 0, -6 },
  { 503, 6, 6, 6, 0, -6 },
  { 508, 6, 9, 6, 0, -6 },
  { 515, 5, 6, 6, 0, -6 },
  { 519, 4, 11, 5, 0, -9 },
  { 525, 1, 12, 7, 3, -9 },
  { 527, 4, 11, 5, 0, -9 },
  { 533, 5, 2, 7, 1, -5 },
};

const GFXfont NotoSans_Regular12pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Regular12pt7bBitmaps,
  (GFXglyph *)NotoSans_Regular12pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _NOTOSANS_REGULAR12PT7B_H_
