#ifndef _NOTOSANS_REGULAR25PT7B_H_
#define _NOTOSANS_REGULAR25PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Regular.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Regular25pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xB6, 0xD9, 0x24, 0x07, 0xFC, 0xCF, 0x9B, 0x36, 0x6C,
  0x58, 0xB1, 0x00, 0x06, 0x10, 0x0C, 0x60, 0x18, 0xC0, 0x21, 0x80, 0xC3,
  0x0F, 0xFF, 0xDF, 0xFF, 0x86, 0x30, 0x08, 0x60, 0x30, 0xC0, 0x61, 0x07,
  0xFF, 0xEF, 0xFF, 0xC2, 0x18, 0x0C, 0x30, 0x18, 0x40, 0x31, 0x80, 0x63,
  0x00, 0x0C, 0x01, 0x80, 0x7C, 0x3F, 0xEE, 0xCD, 0x98, 0x33, 0x06, 0x60,
  0xFC, 0x0F, 0xC0, 0x7E, 0x06, 0xE0, 0xCE, 0x18, 0xC3, 0x1E, 0x6E, 0xFF,
  0x8F, 0xC0, 0x30, 0x06, 0x00, 0x3C, 0x06, 0x0F, 0xC0, 0xC1, 0x18, 0x30,
  0x61, 0x04, 0x0C, 0x31, 0x81, 0x86, 0x60, 0x30, 0xCC, 0x06, 0x13, 0x3C,
  0x46, 0x6F, 0xCF, 0xD9, 0x18, 0xF3, 0x61, 0x00, 0xCC, 0x20, 0x11, 0x86,
  0x06, 0x30, 0xC1, 0x86, 0x10, 0x30, 0x46, 0x0C, 0x0D, 0xC3, 0x80, 0xF0,
  0x0F, 0x80, 0x0F, 0xE0, 0x0E, 0x38, 0x06, 0x0C, 0x03, 0x06, 0x01, 0xC7,
  0x00, 0x67, 0x00, 0x1F, 0x00, 0x0E, 0x00, 0x1D, 0x81, 0x9C, 0x70, 0xCC,
  0x1C, 0xCE, 0x07, 0x67, 0x01, 0xE3, 0x80, 0x70, 0xE0, 0xFC, 0x7F, 0xE7,
  0x0F, 0xE1, 0xC0, 0xFF, 0xFC, 0x1C, 0x63, 0x0C, 0x61, 0x86, 0x38, 0xC3,
  0x0C, 0x30, 0xC3, 0x0E, 0x38, 0x61, 0x87, 0x0C, 0x18, 0x70, 0xC1, 0x86,
  0x0C, 0x30, 0xE1, 0x86, 0x18, 0x61, 0x87, 0x18, 0x61, 0x86, 0x38, 0xC3,
  0x1C, 0x63, 0x00, 0x06, 0x00, 0x60, 0x06, 0x08, 0x61, 0xF6, 0xFF, 0xFF,
  0x0E, 0x00, 0xF0, 0x19, 0x83, 0x9C, 0x30, 0x80, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x0F, 0xFF, 0xFF, 0xF0, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x76, 0x66, 0xCC, 0xFF, 0xF0, 0xFF, 0x80, 0x01, 0x81, 0xC0,
  0xC0, 0x60, 0x60, 0x30, 0x18, 0x18, 0x0C, 0x0E, 0x06, 0x03, 0x03, 0x01,
  0x80, 0xC0, 0xC0, 0x60, 0x70, 0x00, 0x1F, 0x83, 0xFC, 0x70, 0xE6, 0x06,
  0x60, 0x7E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3E, 0x03,
  0xE0, 0x36, 0x07, 0x60, 0x67, 0x0E, 0x3F, 0xC1, 0xF8, 0x06, 0x3C, 0xFF,
  0xB4, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x1F, 0x87, 0xFC, 0xE0, 0xE0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x0E, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xFF, 0xFF, 0xFF, 0x3F, 0x8F, 0xFC, 0x60, 0xE0, 0x06, 0x00, 0x60,
  0x06, 0x00, 0xE0, 0x1C, 0x1F, 0x01, 0xFC, 0x00, 0xE0, 0x07, 0x00, 0x30,
  0x03, 0x00, 0x78, 0x0E, 0xFF, 0xE7, 0xF8, 0x00, 0xC0, 0x0E, 0x00, 0xF0,
  0x07, 0x80, 0x6C, 0x06, 0x60, 0x73, 0x03, 0x18, 0x30, 0xC3, 0x06, 0x18,
  0x31, 0x81, 0x8F, 0xFF, 0xFF, 0xFC, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x7F, 0xCF, 0xFB, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x07, 0xF8,
  0xFF, 0x80, 0x38, 0x03, 0x80, 0x70, 0x06, 0x00, 0xC0, 0x3C, 0x0E, 0xFF,
  0x9F, 0xE0, 0x07, 0xE1, 0xFE, 0x38, 0x03, 0x00, 0x70, 0x06, 0x00, 0x60,
  0x06, 0xFC, 0xFF, 0xEF, 0x07, 0xE0, 0x3E, 0x03, 0x60, 0x36, 0x03, 0x60,
  0x33, 0x06, 0x3F, 0xE0, 0xF8, 0xFF, 0xFF, 0xFF, 0x00, 0x30, 0x06, 0x00,
  0x60, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x00, 0x70, 0x06,
  0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x1C, 0x03, 0x80, 0x1F, 0x83, 0xFE, 0x70,
  0x66, 0x06, 0x60, 0x66, 0x06, 0x70, 0xE3, 0xDC, 0x0F, 0x03, 0xFC, 0x70,
  0xE6, 0x07, 0xE0, 0x3C, 0x03, 0xE0, 0x36, 0x07, 0x7F, 0xE1, 0xFC, 0x1F,
  0x83, 0xFC, 0x70, 0xE6, 0x06, 0xE0, 0x7C, 0x03, 0xE0, 0x3E, 0x07, 0x60,
  0x77, 0xBB, 0x3F, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x1C, 0x3F,
  0x83, 0xF0, 0x5F, 0xA0, 0x00, 0x00, 0x7F, 0xC0, 0x27, 0x72, 0x00, 0x00,
  0x00, 0x07, 0x66, 0xEC, 0xC0, 0x00, 0x10, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x70, 0x1E, 0x0F, 0x03,
  0xC0, 0xF0, 0x0C, 0x00, 0x3F, 0x3F, 0xE4, 0x1C, 0x03, 0x00, 0xC0, 0x30,
  0x1C, 0x0E, 0x07, 0x03, 0x80, 0xC0, 0x20, 0x18, 0x00, 0x00, 0x00, 0x70,
  0x1C, 0x07, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0xF0, 0x0E, 0x03, 0x81, 0x80,
  0x0C, 0x30, 0x00, 0x63, 0x0F, 0xC2, 0x61, 0xFE, 0x36, 0x30, 0x43, 0x43,
  0x04, 0x3C, 0x30, 0xC3, 0xC6, 0x0C, 0x3C, 0x30, 0xC3, 0x43, 0x0C, 0x26,
  0x39, 0xE6, 0x61, 0xF3, 0xC6, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x10,
  0x0F, 0x9E, 0x00, 0x3F, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x06, 0x60, 0x06, 0x60, 0x0E, 0x70, 0x0C, 0x30, 0x0C, 0x30, 0x1C,
  0x38, 0x1F, 0xF8, 0x1F, 0xF8, 0x30, 0x1C, 0x30, 0x0C, 0x70, 0x0E, 0x60,
  0x06, 0x60, 0x06, 0xC0, 0x07, 0xFF, 0x87, 0xFF, 0x38, 0x3D, 0xC0, 0x6E,
  0x03, 0x70, 0x1B, 0x80, 0xDC, 0x1C, 0xFF, 0x87, 0xFF, 0x38, 0x0D, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x0E, 0xFF, 0xE7, 0xFE, 0x00, 0x07,
  0xF0, 0xFF, 0xCE, 0x04, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x0F,
  0x00, 0x3F, 0xF0, 0x7F, 0x80, 0xFF, 0x81, 0xFF, 0xC3, 0x83, 0xC7, 0x01,
  0xCE, 0x01, 0xDC, 0x01, 0xB8, 0x03, 0x70, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x6E, 0x00, 0xDC, 0x03, 0xB8, 0x0E, 0x70, 0x38, 0xFF,
  0xE1, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xFF, 0xFF, 0xFE, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xFF, 0xFF, 0xFE, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x00, 0x07, 0xF8, 0x7F, 0xF3, 0xC0, 0x9C, 0x00, 0xE0, 0x03, 0x80, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x03, 0xFC, 0x0F, 0xF0, 0x03, 0xC0, 0x0F,
  0x80, 0x37, 0x00, 0xDE, 0x03, 0x3F, 0xFC, 0x3F, 0xF0, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x30, 0xFF, 0xF3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x7F, 0xF0, 0x0E, 0x1C, 0x38, 0x70, 0xE1,
  0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0x61, 0xDF, 0x3C, 0x00, 0xE0, 0x3F, 0x03, 0xB8, 0x39, 0xC1, 0x8E, 0x18,
  0x71, 0x83, 0x98, 0x1D, 0xC0, 0xFE, 0x07, 0xB0, 0x39, 0xC1, 0xC7, 0x0E,
  0x18, 0x70, 0xE3, 0x83, 0x9C, 0x0E, 0xE0, 0x37, 0x01, 0xC0, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xFF, 0xFF, 0xF0, 0xF0, 0x01, 0xFC,
  0x00, 0xFF, 0x80, 0x3F, 0x60, 0x0F, 0xD8, 0x06, 0xF3, 0x01, 0xBC, 0xC0,
  0x6F, 0xB8, 0x33, 0xE6, 0x0C, 0xF9, 0x86, 0x3E, 0x71, 0x8F, 0x8C, 0x63,
  0xE3, 0x30, 0xF8, 0x6C, 0x3E, 0x1F, 0x0F, 0x87, 0x83, 0xE0, 0xE0, 0xF8,
  0x30, 0x30, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x3E, 0xC0, 0x7D, 0xC0, 0xF9,
  0x81, 0xF1, 0x83, 0xE3, 0x87, 0xE3, 0x0F, 0xC7, 0x1F, 0x87, 0x3F, 0x06,
  0x7E, 0x0E, 0x7C, 0x0E, 0xF8, 0x0D, 0xF0, 0x1F, 0xE0, 0x1F, 0xC0, 0x1C,
  0x0F, 0xE0, 0x3F, 0xF8, 0x78, 0x1C, 0x70, 0x0E, 0xE0, 0x06, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07,
  0xC0, 0x07, 0xE0, 0x06, 0x60, 0x0E, 0x78, 0x1C, 0x3F, 0xF8, 0x0F, 0xF0,
  0xFF, 0x0F, 0xFC, 0xE0, 0xEE, 0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x7E, 0x07,
  0xE0, 0xEF, 0xFC, 0xFF, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0x0F, 0xE0, 0x3F, 0xF8, 0x78, 0x1C, 0x70, 0x0E, 0xE0,
  0x06, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x06, 0x60, 0x0E, 0x78, 0x1C, 0x3F,
  0xF8, 0x0F, 0xF0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1E, 0xFF,
  0x07, 0xFE, 0x38, 0x39, 0xC0, 0xEE, 0x07, 0x70, 0x1B, 0x81, 0xDC, 0x0C,
  0xE1, 0xE7, 0xFC, 0x3F, 0xE1, 0xC3, 0x0E, 0x1C, 0x70, 0x63, 0x83, 0x9C,
  0x0E, 0xE0, 0x37, 0x01, 0xC0, 0x1F, 0xC3, 0xFE, 0x70, 0x26, 0x00, 0xE0,
  0x06, 0x00, 0x70, 0x07, 0x80, 0x1F, 0x00, 0xFC, 0x01, 0xE0, 0x06, 0x00,
  0x60, 0x07, 0x00, 0x68, 0x0E, 0xFF, 0xC7, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x36, 0x01, 0x9C, 0x0E, 0x3F, 0xF0, 0x7F, 0x80,
  0xC0, 0x0F, 0xC0, 0x1D, 0x80, 0x33, 0x80, 0xE3, 0x01, 0x86, 0x03, 0x0E,
  0x0E, 0x0C, 0x18, 0x18, 0x30, 0x38, 0xE0, 0x31, 0x80, 0x63, 0x00, 0xEE,
  0x00, 0xD8, 0x01, 0xB0, 0x03, 0xE0, 0x03, 0x80, 0x07, 0x00, 0xE0, 0x38,
  0x0E, 0xC0, 0x70, 0x1D, 0x80, 0xE0, 0x33, 0x83, 0x60, 0x67, 0x06, 0xC1,
  0xC6, 0x0D, 0x83, 0x8C, 0x1B, 0x86, 0x1C, 0x63, 0x0C, 0x18, 0xC6, 0x38,
  0x31, 0x8E, 0x60, 0x66, 0x0C, 0xC0, 0xEC, 0x19, 0x80, 0xD8, 0x37, 0x01,
  0xB0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0xF0, 0x07, 0x01, 0xE0, 0x0C,
  0x01, 0x80, 0xE0, 0x0C, 0xE0, 0x30, 0xC0, 0xE0, 0xC1, 0x81, 0xC6, 0x01,
  0x9C, 0x01, 0xB0, 0x03, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x76,
  0x00, 0xC6, 0x03, 0x0E, 0x0E, 0x0C, 0x18, 0x1C, 0x60, 0x1D, 0xC0, 0x1C,
  0xE0, 0x0D, 0x80, 0x67, 0x03, 0x8C, 0x0C, 0x38, 0x70, 0x61, 0x81, 0xCE,
  0x03, 0x30, 0x07, 0xC0, 0x1E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x70, 0x0E, 0x00, 0xC0, 0x1C, 0x03, 0x80, 0x30, 0x07, 0x00, 0xE0, 0x0C,
  0x01, 0xC0, 0x38, 0x03, 0x00, 0x70, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xFF, 0xF0, 0xE0, 0x30, 0x18, 0x0E, 0x03, 0x01, 0x80, 0x60,
  0x30, 0x1C, 0x06, 0x03, 0x01, 0xC0, 0x60, 0x30, 0x0C, 0x06, 0x03, 0x80,
  0xC0, 0xFF, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18,
  0xC6, 0x3F, 0xFC, 0x06, 0x00, 0x60, 0x0F, 0x00, 0xB0, 0x19, 0x81, 0x98,
  0x30, 0xC3, 0x0C, 0x60, 0x66, 0x06, 0xC0, 0x30, 0xFF, 0xFF, 0xFC, 0xE3,
  0x8C, 0x30, 0x06, 0x07, 0xF8, 0xC3, 0x80, 0x30, 0x06, 0x00, 0xC7, 0xFB,
  0xFB, 0x60, 0x7C, 0x0F, 0x03, 0xF0, 0x77, 0xFE, 0x7C, 0xC0, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x60, 0xDF, 0xCF, 0x0E, 0xE0, 0x6E,
  0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xE0, 0x7E, 0x07, 0xE0, 0x6F,
  0xFC, 0xCF, 0x80, 0x07, 0x07, 0xF3, 0x8D, 0xC0, 0x60, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x18, 0x06, 0x01, 0xC0, 0x3F, 0xC7, 0xF0, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x63, 0x1F, 0xB3, 0x8F, 0x70, 0x76, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0x60, 0x36, 0x03, 0x70, 0x73, 0xFF,
  0x1F, 0xB0, 0x07, 0x01, 0xFC, 0x38, 0xE7, 0x06, 0x60, 0x76, 0x03, 0xFF,
  0xFF, 0xFF, 0xE0, 0x06, 0x00, 0x60, 0x07, 0x01, 0x3F, 0xE1, 0xFE, 0x07,
  0xC7, 0xE1, 0x80, 0x60, 0x18, 0x06, 0x0F, 0xF0, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x06,
  0x01, 0xFB, 0x38, 0xF7, 0x07, 0x60, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x36, 0x03, 0x60, 0x37, 0x07, 0x3F, 0xF1, 0xFB, 0x00, 0x30, 0x03, 0x00,
  0x34, 0x07, 0x7F, 0xE3, 0xF8, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x86, 0x37, 0xF7, 0xC7, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0x80, 0xF8, 0x01, 0xB6, 0xDB,
  0x6D, 0xB6, 0xD8, 0x1C, 0x60, 0x00, 0x00, 0x61, 0x86, 0x18, 0x61, 0x86,
  0x18, 0x61, 0x86, 0x18, 0x61, 0x86, 0x18, 0x6F, 0xBC, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x70, 0x76, 0x1C, 0xC7, 0x19, 0xC3, 0x30,
  0x6C, 0x0F, 0xC1, 0xDC, 0x31, 0xC6, 0x18, 0xC1, 0x98, 0x3B, 0x03, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x03, 0x1B, 0xFB, 0xFB, 0xC7, 0x63,
  0xF0, 0x78, 0x3E, 0x0E, 0x07, 0x80, 0xC0, 0xF0, 0x18, 0x1E, 0x03, 0x03,
  0xC0, 0x60, 0x78, 0x0C, 0x0F, 0x01, 0x81, 0xE0, 0x30, 0x3C, 0x06, 0x07,
  0x80, 0xC0, 0xC0, 0x07, 0x1B, 0xFB, 0xC3, 0xF0, 0x3E, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xC0, 0x07,
  0x00, 0xFE, 0x0E, 0x38, 0xE0, 0xE6, 0x03, 0x70, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3B, 0x01, 0xD8, 0x0C, 0xE0, 0xE3, 0xFE, 0x0F, 0xE0, 0x06, 0x0D,
  0xFC, 0xF1, 0xEE, 0x06, 0xE0, 0x7C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3E,
  0x07, 0xE0, 0x7E, 0x0E, 0xFF, 0xCC, 0xF8, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0x06, 0x01, 0xFB, 0x38, 0xF7, 0x07, 0x60, 0x3E,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x36, 0x03, 0x60, 0x37, 0x07, 0x3F, 0xF1,
  0xFB, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x03, 0xDF,
  0xDD, 0xF0, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0x0E, 0x1F, 0xF7, 0x1B, 0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x7C, 0x03, 0x80,
  0x70, 0x0E, 0x07, 0xFF, 0x9F, 0xC0, 0x18, 0x18, 0x38, 0xFF, 0x38, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x1F, 0x0F, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x83, 0xBF, 0xF3, 0xF6, 0xE0, 0x3B, 0x01, 0x98, 0x1C, 0xE0, 0xC3, 0x06,
  0x18, 0x60, 0x63, 0x03, 0x38, 0x1D, 0x80, 0x6C, 0x03, 0xE0, 0x0E, 0x00,
  0x70, 0x00, 0xE0, 0xE0, 0x6C, 0x1E, 0x0D, 0x83, 0xC3, 0xB8, 0xD8, 0x63,
  0x1B, 0x8C, 0x63, 0x31, 0x8C, 0xE6, 0x61, 0xD8, 0xCC, 0x1B, 0x0D, 0x83,
  0x61, 0xB0, 0x78, 0x3C, 0x07, 0x03, 0x80, 0xE0, 0x70, 0x70, 0x79, 0x83,
  0x06, 0x30, 0x3B, 0x80, 0xF8, 0x03, 0x80, 0x1C, 0x01, 0xF0, 0x0D, 0xC0,
  0xC6, 0x0E, 0x18, 0x60, 0xEE, 0x03, 0x80, 0xE0, 0x3B, 0x01, 0x98, 0x1C,
  0x60, 0xC3, 0x06, 0x1C, 0x70, 0x63, 0x03, 0x18, 0x0D, 0x80, 0x6C, 0x03,
  0x60, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0C, 0x07, 0xE0,
  0x3C, 0x00, 0xFF, 0xC0, 0x60, 0x38, 0x0C, 0x06, 0x03, 0x81, 0xC0, 0x60,
  0x30, 0x1C, 0x06, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0x0F, 0x1C, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x38, 0xF0, 0xE0, 0x38, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x1C, 0x0F, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xC0, 0xF0, 0x30, 0x38, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x0F, 0x0F,
  0x1C, 0x18, 0x18, 0x18, 0x18, 0x18, 0x38, 0x38, 0xF0, 0xC0, 0x7E, 0x1E,
  0xFF, 0x81, 0xE0,
};

const GFXglyph NotoSans_Regular25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 3, 18, 7, 2, -18 },
  { 8, 7, 7, 10, 2, -18 },
  { 15, 15, 18, 16, 1, -18 },
  { 49, 11, 20, 14, 2, -19 },
  { 77, 19, 18, 21, 1, -18 },
  { 120, 17, 18, 18, 1, -18 },
  { 159, 2, 7, 6, 2, -18 },
  { 161, 6, 22, 8, 1, -18 },
  { 178, 6, 22, 8, 1, -18 },
  { 195, 12, 11, 14, 1, -19 },
  { 212, 12, 12, 14, 1, -15 },
  { 230, 4, 6, 7, 1, -3 },
  { 233, 6, 2, 8, 1, -8 },
  { 235, 3, 3, 7, 2, -3 },
  { 237, 9, 18, 9, 0, -18 },
  { 258, 12, 18, 14, 1, -18 },
  { 285, 7, 18, 14, 2, -18 },
  { 301, 12, 18, 14, 1, -18 },
  { 328, 12, 18, 14, 1, -18 },
  { 355, 13, 18, 14, 1, -18 },
  { 385, 11, 18, 14, 2, -18 },
  { 410, 12, 18, 14, 1, -18 },
  { 437, 12, 18, 14, 1, -18 },
  { 464, 12, 18, 14, 1, -18 },
  { 491, 12, 18, 14, 1, -18 },
  { 518, 3, 14, 7, 2, -14 },
  { 524, 4, 17, 7, 1, -14 },
  { 533, 12, 12, 14, 1, -15 },
  { 551, 12, 7, 14, 1, -12 },
  { 562, 12, 12, 14, 1, -15 },
  { 580, 10, 18, 11, 0, -18 },
  { 603, 20, 20, 22, 1, -18 },
  { 653, 16, 18, 16, 0, -18 },
  { 689, 13, 18, 16, 2, -18 },
  { 719, 13, 18, 16, 2, -18 },
  { 749, 15, 18, 18, 2, -18 },
  { 783, 10, 18, 14, 2, -18 },
  { 806, 10, 18, 13, 2, -18 },
  { 829, 14, 18, 18, 2, -18 },
  { 861, 14, 18, 19, 2, -18 },
  { 893, 6, 18, 8, 1, -18 },
  { 907, 7, 23, 7, -2, -18 },
  { 928, 13, 18, 15, 2, -18 },
  { 958, 10, 18, 13, 2, -18 },
  { 981, 18, 18, 23, 2, -18 },
  { 1022, 15, 18, 19, 2, -18 },
  { 1056, 16, 18, 20, 2, -18 },
  { 1092, 12, 18, 15, 2, -18 },
  { 1119, 16, 22, 20, 2, -18 },
  { 1163, 13, 18, 16, 2, -18 },
  { 1193, 12, 18, 14, 1, -18 },
  { 1220, 14, 18, 14, 0, -18 },
  { 1252, 14, 18, 18, 2, -18 },
  { 1284, 15, 18, 15, 0, -18 },
  { 1318, 23, 18, 23, 0, -18 },
  { 1370, 15, 18, 15, 0, -18 },
  { 1404, 14, 18, 14, 0, -18 },
  { 1436, 12, 18, 14, 1, -18 },
  { 1463, 6, 22, 8, 2, -18 },
  { 1480, 9, 18, 9, 0, -18 },
  { 1501, 5, 22, 8, 1, -18 },
  { 1515, 12, 11, 14, 1, -18 },
  { 1532, 11, 2, 11, 0, 2 },
  { 1535, 5, 4, 7, 1, -19 },
  { 1538, 11, 14, 14, 1, -14 },
  { 1558, 12, 19, 15, 2, -19 },
  { 1587, 10, 14, 12, 1, -14 },
  { 1605, 12, 19, 15, 1, -19 },
  { 1634, 12, 14, 14, 1, -14 },
  { 1655, 10, 19, 9, 0, -19 },
  { 1679, 12, 20, 15, 1, -14 },
  { 1709, 11, 19, 15, 2, -19 },
  { 1736, 3, 18, 6, 2, -18 },
  { 1743, 6, 24, 6, -1, -18 },
  { 1761, 11, 19, 13, 2, -19 },
  { 1788, 2, 19, 6, 2, -19 },
  { 1793, 19, 14, 23, 2, -14 },
  { 1827, 11, 14, 15, 2, -14 },
  { 1847, 13, 14, 15, 1, -14 },
  { 1870, 12, 20, 15, 2, -14 },
  { 1900, 12, 20, 15, 1, -14 },
  { 1930, 8, 14, 10, 2, -14 },
  { 1944, 10, 14, 12, 1, -14 },
  { 1962, 8, 16, 9, 0, -16 },
  { 1978, 11, 13, 15, 2, -13 },
  { 1996, 13, 13, 13, 0, -13 },
  { 2018, 19, 13, 20, 0, -13 },
  { 2049, 13, 13, 13, 0, -13 },
  { 2071, 13, 19, 13, 0, -13 },
  { 2102, 10, 13, 12, 1, -13 },
  { 2119, 8, 22, 10, 1, -18 },
  { 2141, 2, 25, 14, 6, -19 },
  { 2148, 8, 22, 10, 1, -18 },
  { 2170, 12, 3, 14, 1, -10 },
};

const GFXfont NotoSans_Regular25pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Regular25pt7bBitmaps,
  (GFXglyph *)NotoSans_Regular25pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _NOTOSANS_REGULAR25PT7B_H_
