#ifndef _NOTOSANS_REGULAR66PT7B_H_
#define _NOTOSANS_REGULAR66PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Regular.ttf
// Size: 66pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Regular66pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0xFE, 0xFE, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0x7C,
  0x7C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E,
  0x3C, 0xFE, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x1F, 0x3E, 0x03, 0xE7, 0xC0,
  0x7C, 0xF8, 0x0F, 0x9F, 0x01, 0xF3, 0xE0, 0x3E, 0x7C, 0x07, 0xCF, 0x80,
  0xF9, 0xF0, 0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0x7C, 0xF8, 0x0F, 0x9E, 0x00,
  0xF1, 0xC0, 0x1C, 0x38, 0x03, 0x80, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x1E, 0x00,
  0x78, 0x00, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x01, 0xE0, 0x00,
  0x01, 0xF0, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x1F, 0x00, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x78, 0x00,
  0x00, 0x7C, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x07, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7C,
  0x01, 0xF0, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x07, 0x80,
  0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x01, 0xE0,
  0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x1F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01,
  0xF0, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x1E,
  0x00, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x07,
  0x80, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x01,
  0xE0, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFF, 0x1F, 0xE1, 0xE0, 0xF8, 0x7E, 0x07, 0x80, 0x63, 0xF0, 0x1E, 0x00,
  0x0F, 0xC0, 0x78, 0x00, 0x3F, 0x01, 0xE0, 0x00, 0xFC, 0x07, 0x80, 0x03,
  0xF0, 0x1E, 0x00, 0x0F, 0xC0, 0x78, 0x00, 0x3F, 0x81, 0xE0, 0x00, 0x7F,
  0x07, 0x80, 0x01, 0xFF, 0x1E, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x78, 0xFF, 0x80, 0x01, 0xE0, 0xFE, 0x00, 0x07, 0x81, 0xFC,
  0x00, 0x1E, 0x03, 0xF0, 0x00, 0x78, 0x0F, 0xC0, 0x01, 0xE0, 0x3F, 0x00,
  0x07, 0x80, 0xFC, 0x00, 0x1E, 0x03, 0xF0, 0x00, 0x78, 0x0F, 0xE0, 0x01,
  0xE0, 0x7E, 0xF8, 0x07, 0x87, 0xFB, 0xFF, 0x1F, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0x0F,
  0x80, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xC0, 0x03, 0xF9, 0xFC, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0xF8, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0x7C, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0x3C, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x78, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x1F, 0x00,
  0xFC, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x7C, 0x00, 0x03, 0xE0, 0x07, 0xC0,
  0x7C, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0xF8, 0x01, 0xF0,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x7C,
  0x1F, 0x00, 0x00, 0x0F, 0x00, 0x3C, 0x0F, 0x81, 0xF8, 0x07, 0x80, 0x3E,
  0x0F, 0x83, 0xFF, 0x03, 0xE0, 0x1F, 0x07, 0xC7, 0xFF, 0xC1, 0xF0, 0x0F,
  0x87, 0xC3, 0xFF, 0xF0, 0x78, 0x0F, 0x87, 0xC3, 0xF1, 0xF8, 0x3E, 0x07,
  0xC3, 0xE1, 0xF0, 0x3E, 0x1F, 0xCF, 0xE3, 0xE1, 0xF0, 0x1F, 0x07, 0xFF,
  0xE1, 0xF0, 0xF8, 0x07, 0xC1, 0xFF, 0xE1, 0xF0, 0x7C, 0x03, 0xE0, 0x7F,
  0xE0, 0xF8, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x3E, 0x00, 0x78, 0x00,
  0x00, 0x7C, 0x1F, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x00,
  0x00, 0x7E, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0x3E, 0x03, 0xE0, 0x07, 0xC0,
  0x00, 0x3E, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0xF8, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x78,
  0x00, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x07, 0x80, 0x3E,
  0x00, 0x07, 0xC0, 0x03, 0xE0, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0xF0, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x3E, 0x0F,
  0xC0, 0x01, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xF0, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00,
  0x01, 0xFE, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x1F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0,
  0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE1, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x0F, 0xC0, 0x3F, 0xFF, 0xE0, 0x00, 0x7E, 0x03, 0xFE,
  0x7F, 0x80, 0x03, 0xF0, 0x3F, 0xC1, 0xFE, 0x00, 0x1F, 0x01, 0xFC, 0x07,
  0xF8, 0x01, 0xF8, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xC1, 0xFC, 0x00, 0x7F,
  0x80, 0xFC, 0x0F, 0xC0, 0x01, 0xFE, 0x07, 0xE0, 0x7E, 0x00, 0x07, 0xF8,
  0x7F, 0x03, 0xF0, 0x00, 0x1F, 0xE3, 0xF0, 0x1F, 0x80, 0x00, 0x7F, 0xBF,
  0x81, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x0F, 0xE0, 0x00, 0x07, 0xFF, 0x80,
  0x3F, 0x00, 0x00, 0x0F, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x0F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xF8, 0x01, 0xFC,
  0x00, 0x07, 0xFF, 0xF0, 0x0F, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFD,
  0xFF, 0xF8, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x83, 0xFC, 0x03, 0xFF, 0xFF,
  0xF0, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xFF, 0xC0,
  0x00, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFB, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9E, 0x1C, 0x38, 0x00,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF8,
  0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7E, 0xFC, 0x00,
  0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03,
  0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x07, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x01,
  0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0xC0, 0x0F, 0x00, 0x1B,
  0xF0, 0x1E, 0x03, 0xF7, 0xFE, 0x3C, 0x3F, 0xEF, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xE7, 0xC0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x7E,
  0x1F, 0x80, 0x01, 0xFC, 0x1F, 0x80, 0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xE0,
  0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x0C, 0x00,
  0xC0, 0x00, 0x08, 0x01, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x87,
  0xF1, 0xF8, 0xFE, 0x3F, 0x8F, 0xC3, 0xF0, 0xFC, 0x3E, 0x1F, 0x87, 0xE1,
  0xF0, 0x7C, 0x3E, 0x0F, 0x83, 0xC0, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3C, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7E, 0x3C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xC0, 0x0F, 0xF8, 0x3F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x1F,
  0xC0, 0x03, 0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x3F,
  0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0xFC, 0x7E,
  0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7C,
  0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC,
  0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x3E, 0xFC,
  0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x3E, 0xFC,
  0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00, 0x7E, 0x7C,
  0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7E,
  0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0xFC, 0x3F,
  0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x1F,
  0x80, 0x03, 0xF8, 0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07,
  0xFC, 0x3F, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0F, 0x80, 0x0F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC,
  0x3F, 0xBE, 0x3F, 0x9F, 0x3F, 0x8F, 0xFF, 0x87, 0xFF, 0x83, 0xEF, 0x81,
  0xF3, 0x00, 0xF9, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFE,
  0x07, 0xFC, 0x1F, 0xE0, 0x03, 0xFC, 0x1F, 0x00, 0x03, 0xF8, 0x18, 0x00,
  0x03, 0xF8, 0x20, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFE, 0x1F, 0xFC, 0x07, 0xFE, 0x1F, 0xC0, 0x01, 0xFC,
  0x1E, 0x00, 0x01, 0xFC, 0x10, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFD,
  0x80, 0x00, 0x07, 0xF3, 0xE0, 0x00, 0x3F, 0xE7, 0xFC, 0x03, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFC, 0x00, 0x00, 0x7E, 0x80, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00,
  0x1F, 0x3F, 0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x01, 0xF8, 0xFC, 0x00,
  0x00, 0x3E, 0x1F, 0x80, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x03, 0xF0, 0x7E,
  0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x3F, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x1F, 0x80, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x7E, 0x00,
  0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x3E, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0xFC, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x7C, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00, 0x7E, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xE0, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE7, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07,
  0x80, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFC, 0xC0, 0x00, 0x07, 0xF3, 0xE0, 0x00, 0x7F, 0x8F, 0xF8,
  0x1F, 0xFC, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0x40, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xF0, 0x04, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x02, 0x00, 0x07, 0xE0,
  0xFF, 0xF0, 0x0F, 0xC7, 0xFF, 0xF8, 0x1F, 0x9F, 0xFF, 0xF8, 0x3F, 0x7F,
  0xFF, 0xF8, 0x7D, 0xF8, 0x0F, 0xF8, 0xFF, 0xC0, 0x07, 0xF9, 0xFF, 0x00,
  0x07, 0xF3, 0xFC, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x0F, 0xDF, 0x80, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x1F,
  0x9F, 0x80, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0xFE, 0x3F, 0x80, 0x01, 0xF8,
  0x3F, 0x80, 0x07, 0xF0, 0x7F, 0x80, 0x1F, 0xC0, 0x7F, 0xC1, 0xFF, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x03, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xFE,
  0x01, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFC, 0x3F, 0x00,
  0x01, 0xFC, 0x7E, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x03, 0xF1, 0xF0, 0x00,
  0x07, 0xE3, 0xE0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x1F, 0x8F, 0xC0, 0x00,
  0x3F, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x80, 0x07,
  0xE0, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0xC0, 0xFE, 0x00, 0x3F, 0xE7, 0xF8,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xE1, 0xFF, 0x80,
  0x7F, 0x00, 0xFF, 0x81, 0xFC, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0x7F, 0x9F,
  0xC0, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xBF, 0x00,
  0x00, 0x3F, 0x7E, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x03, 0xF8, 0xFE, 0x00,
  0x0F, 0xF0, 0xFF, 0x80, 0x7F, 0xC1, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFE, 0x07, 0xFC,
  0x07, 0xF0, 0x03, 0xFC, 0x1F, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF8,
  0xFC, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x07, 0xE7,
  0xC0, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x01, 0xFB, 0xE0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x7F, 0x9F, 0xC0, 0x01, 0xFF, 0x3F, 0xC0,
  0x07, 0xFE, 0x3F, 0xE0, 0x7F, 0xFC, 0x3F, 0xFF, 0xFD, 0xF8, 0x3F, 0xFF,
  0xF3, 0xF0, 0x3F, 0xFF, 0x87, 0xE0, 0x1F, 0xFC, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x60, 0x1F, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x3C,
  0x0F, 0x83, 0xF8, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0xF0, 0x7E, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x3F, 0x87, 0xF0, 0xFC, 0x1F, 0x83, 0xF0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7C, 0x1F, 0x83, 0xF0, 0x7C, 0x0F, 0x81, 0xE0, 0x7C,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x1F, 0xE0,
  0xFF, 0xC7, 0xC0, 0x03, 0xF8, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0x81, 0xFF, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x81, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0xFF, 0xF8, 0x07, 0xC3,
  0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x3C, 0x3E, 0x00, 0x7F, 0xFF, 0xF8, 0x03,
  0xE3, 0xE0, 0x0F, 0xF0, 0x0F, 0x80, 0x3E, 0x7C, 0x00, 0xFC, 0x00, 0xF8,
  0x03, 0xE7, 0xC0, 0x1F, 0x80, 0x0F, 0x80, 0x1E, 0x7C, 0x03, 0xF0, 0x00,
  0xF8, 0x01, 0xEF, 0x80, 0x3E, 0x00, 0x0F, 0x80, 0x1E, 0xF8, 0x03, 0xE0,
  0x00, 0xF8, 0x01, 0xEF, 0x80, 0x7E, 0x00, 0x0F, 0x80, 0x1F, 0xF8, 0x07,
  0xC0, 0x00, 0xF8, 0x01, 0xEF, 0x80, 0x7C, 0x00, 0x0F, 0x80, 0x1E, 0xF8,
  0x07, 0xC0, 0x01, 0xF8, 0x01, 0xEF, 0x80, 0x7C, 0x00, 0x1F, 0x00, 0x1E,
  0xF8, 0x07, 0xC0, 0x01, 0xF0, 0x03, 0xEF, 0x80, 0x7C, 0x00, 0x1F, 0x00,
  0x3E, 0xF8, 0x07, 0xE0, 0x01, 0xF0, 0x03, 0xEF, 0x80, 0x7E, 0x00, 0x3F,
  0x00, 0x7C, 0xF8, 0x03, 0xE0, 0x03, 0xF8, 0x07, 0xCF, 0x80, 0x3F, 0x00,
  0x7F, 0x80, 0xF8, 0xF8, 0x03, 0xF8, 0x0F, 0xFC, 0x1F, 0x87, 0x80, 0x1F,
  0xE3, 0xF3, 0xE7, 0xF0, 0x7C, 0x00, 0xFF, 0xFE, 0x3F, 0xFE, 0x07, 0xC0,
  0x07, 0xFF, 0xC1, 0xFF, 0xC0, 0x7E, 0x00, 0x3F, 0xF8, 0x0F, 0xF8, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F,
  0xFF, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x00, 0x07,
  0xE1, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x7C, 0x00,
  0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x01,
  0xF8, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0xFC, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xC7, 0xE0,
  0x00, 0x7F, 0xE3, 0xF0, 0x00, 0x07, 0xF9, 0xF8, 0x00, 0x01, 0xFC, 0xFC,
  0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0x1F, 0xDF,
  0x80, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x01, 0xFB,
  0xF0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x7E,
  0x7E, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x01, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0x7E, 0x00, 0x03,
  0xFE, 0x3F, 0x00, 0x00, 0x7F, 0x9F, 0x80, 0x00, 0x0F, 0xEF, 0xC0, 0x00,
  0x03, 0xF7, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFE, 0xFC,
  0x00, 0x01, 0xFF, 0x7E, 0x00, 0x07, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xCF, 0xFC, 0x03, 0xFF, 0x00, 0x07, 0xC0,
  0x7F, 0xC0, 0x00, 0x0C, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x03, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xF0, 0x00, 0x7F,
  0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0xF8, 0x3F, 0x00, 0x00, 0x1F, 0xE0, 0xFC,
  0x00, 0x00, 0x3F, 0xC3, 0xF0, 0x00, 0x00, 0x7F, 0x8F, 0xC0, 0x00, 0x00,
  0xFE, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x00, 0x03, 0xF3, 0xF0,
  0x00, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0x00,
  0x7E, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xBF, 0x00, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x03, 0xFB, 0xF0, 0x00,
  0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0x01, 0xFC,
  0xFC, 0x00, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x00, 0x7F, 0x0F, 0xC0, 0x00,
  0x03, 0xFC, 0x3F, 0x00, 0x00, 0x3F, 0xE0, 0xFC, 0x00, 0x03, 0xFF, 0x03,
  0xF0, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xDF, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFE, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0xFF, 0xE8, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xCF, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x3E, 0x01, 0xFF, 0x00,
  0x00, 0x0C, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x00, 0x3F, 0x7E,
  0x00, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x00,
  0x01, 0xF9, 0xFC, 0x00, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x00, 0x07, 0xE3,
  0xF8, 0x00, 0x00, 0x0F, 0xC7, 0xF8, 0x00, 0x00, 0x1F, 0x87, 0xF8, 0x00,
  0x00, 0x3F, 0x0F, 0xF8, 0x00, 0x00, 0x7E, 0x0F, 0xF8, 0x00, 0x00, 0xFC,
  0x0F, 0xFE, 0x00, 0x01, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03,
  0xFC, 0x1F, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xF0, 0x07, 0xFB, 0xFF, 0xF9, 0xFF, 0xF8, 0xFF, 0xF8, 0x7F,
  0xF8, 0x3F, 0xF0, 0x01, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xDF, 0x80,
  0x00, 0x07, 0xF3, 0xF0, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x00, 0x7F, 0x0F,
  0xC0, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x01, 0xFC,
  0x07, 0xE0, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x1F, 0x80, 0x03,
  0xF0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xC0,
  0x0F, 0xE0, 0x01, 0xF8, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x07,
  0xE0, 0x3F, 0x80, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x1F, 0x83, 0xF8, 0x00,
  0x03, 0xF0, 0xFE, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x0F, 0xC7, 0xF0,
  0x00, 0x01, 0xF9, 0xFE, 0x00, 0x00, 0x3F, 0x7F, 0xE0, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xF9, 0xFC, 0x00, 0x03,
  0xFE, 0x1F, 0xC0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x80,
  0x01, 0xF8, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x07,
  0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x03, 0xF0,
  0x00, 0x7F, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x0F, 0xC0, 0x00, 0xFE, 0x01,
  0xF8, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x1F,
  0xC0, 0xFC, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0x1F, 0xC3, 0xF0, 0x00,
  0x01, 0xFC, 0x7E, 0x00, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0x03, 0xF9, 0xF8,
  0x00, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0x07, 0xF8, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xDF, 0xFD, 0xF0,
  0x00, 0x00, 0x1F, 0xBF, 0xFB, 0xF0, 0x00, 0x00, 0x3E, 0x7F, 0xF7, 0xE0,
  0x00, 0x00, 0x7C, 0xFF, 0xE7, 0xE0, 0x00, 0x01, 0xF9, 0xFF, 0xCF, 0xC0,
  0x00, 0x03, 0xE3, 0xFF, 0x8F, 0x80, 0x00, 0x07, 0xC7, 0xFF, 0x1F, 0x80,
  0x00, 0x1F, 0x0F, 0xFE, 0x3F, 0x00, 0x00, 0x3E, 0x1F, 0xFC, 0x3E, 0x00,
  0x00, 0xFC, 0x3F, 0xF8, 0x7E, 0x00, 0x01, 0xF0, 0x7F, 0xF0, 0xFC, 0x00,
  0x03, 0xE0, 0xFF, 0xE0, 0xFC, 0x00, 0x0F, 0xC1, 0xFF, 0xC1, 0xF8, 0x00,
  0x1F, 0x03, 0xFF, 0x81, 0xF0, 0x00, 0x7E, 0x07, 0xFF, 0x03, 0xF0, 0x00,
  0xF8, 0x0F, 0xFE, 0x07, 0xE0, 0x01, 0xF0, 0x1F, 0xFC, 0x07, 0xC0, 0x07,
  0xE0, 0x3F, 0xF8, 0x0F, 0xC0, 0x0F, 0x80, 0x7F, 0xF0, 0x1F, 0x80, 0x1F,
  0x00, 0xFF, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xFF, 0xC0, 0x3F, 0x00, 0xF8,
  0x03, 0xFF, 0x80, 0x3E, 0x03, 0xF0, 0x07, 0xFF, 0x00, 0x7E, 0x07, 0xC0,
  0x0F, 0xFE, 0x00, 0xFC, 0x0F, 0x80, 0x1F, 0xFC, 0x00, 0xF8, 0x3F, 0x00,
  0x3F, 0xF8, 0x01, 0xF8, 0x7C, 0x00, 0x7F, 0xF0, 0x03, 0xF1, 0xF8, 0x00,
  0xFF, 0xE0, 0x03, 0xF3, 0xE0, 0x01, 0xFF, 0xC0, 0x07, 0xE7, 0xC0, 0x03,
  0xFF, 0x80, 0x07, 0xDF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x0F,
  0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFB, 0xF8, 0x00, 0x00, 0xFF, 0xE7, 0xE0, 0x00, 0x03, 0xFF,
  0xDF, 0xC0, 0x00, 0x0F, 0xFF, 0x3F, 0x80, 0x00, 0x3F, 0xFC, 0x7E, 0x00,
  0x00, 0xFF, 0xF1, 0xFC, 0x00, 0x03, 0xFF, 0xC3, 0xF8, 0x00, 0x0F, 0xFF,
  0x07, 0xE0, 0x00, 0x3F, 0xFC, 0x1F, 0xC0, 0x00, 0xFF, 0xF0, 0x3F, 0x80,
  0x03, 0xFF, 0xC0, 0xFE, 0x00, 0x0F, 0xFF, 0x01, 0xFC, 0x00, 0x3F, 0xFC,
  0x03, 0xF8, 0x00, 0xFF, 0xF0, 0x0F, 0xE0, 0x03, 0xFF, 0xC0, 0x1F, 0xC0,
  0x0F, 0xFF, 0x00, 0x3F, 0x80, 0x3F, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0xF0,
  0x01, 0xFC, 0x03, 0xFF, 0xC0, 0x03, 0xF0, 0x0F, 0xFF, 0x00, 0x0F, 0xE0,
  0x3F, 0xFC, 0x00, 0x1F, 0xC0, 0xFF, 0xF0, 0x00, 0x3F, 0x03, 0xFF, 0xC0,
  0x00, 0xFE, 0x0F, 0xFF, 0x00, 0x01, 0xFC, 0x3F, 0xFC, 0x00, 0x07, 0xF0,
  0xFF, 0xF0, 0x00, 0x0F, 0xE3, 0xFF, 0xC0, 0x00, 0x1F, 0xCF, 0xFF, 0x00,
  0x00, 0x7F, 0x3F, 0xFC, 0x00, 0x00, 0xFE, 0x7F, 0xF0, 0x00, 0x01, 0xFD,
  0xFF, 0xC0, 0x00, 0x07, 0xF7, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0xFE, 0x1F, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xE0, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x00, 0x01,
  0xFC, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x00, 0x00, 0xFC,
  0x7E, 0x00, 0x00, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xEF,
  0xE0, 0x00, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xE7, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x00,
  0x01, 0xFC, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x03,
  0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x2F, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0x80, 0x07,
  0xFE, 0x3F, 0x00, 0x03, 0xFE, 0x7E, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x01,
  0xFD, 0xF8, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x01, 0xFB,
  0xF0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x3F, 0x9F,
  0x80, 0x00, 0xFF, 0x3F, 0x00, 0x07, 0xFC, 0x7E, 0x07, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xD0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x1F,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xE0, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x7F, 0x00,
  0x00, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00,
  0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xEF, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x00,
  0x00, 0x7E, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0x00,
  0xFE, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x00, 0x00, 0xFC,
  0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x2F, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3F, 0x00, 0x0F, 0xFE, 0x0F, 0xC0, 0x00, 0x7F, 0x83,
  0xF0, 0x00, 0x0F, 0xF0, 0xFC, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x00, 0x3F,
  0x0F, 0xC0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00,
  0xFE, 0x3F, 0x00, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0x0F, 0xE3, 0xF0, 0x00,
  0x03, 0xF0, 0xFC, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x3F, 0x0F, 0xC0,
  0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x07, 0xF8, 0x3F,
  0x00, 0x03, 0xFC, 0x0F, 0xC0, 0x3F, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x3F, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0xFC, 0x03, 0xF0,
  0x00, 0x3F, 0x80, 0xFC, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x00, 0xFC, 0x0F,
  0xC0, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x01, 0xFC,
  0x3F, 0x00, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x01,
  0xFC, 0xFC, 0x00, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0x0F, 0xEF, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xF9, 0xFF,
  0xC3, 0xFE, 0x00, 0x1F, 0x0F, 0xE0, 0x00, 0x08, 0x7F, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFB,
  0x00, 0x00, 0x1F, 0xEF, 0xC0, 0x00, 0xFF, 0x3F, 0xFE, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFE, 0x00, 0x00, 0x3E, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xF7, 0xE0, 0x00,
  0x00, 0x3F, 0x7E, 0x00, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x00, 0x7E, 0x3F,
  0x00, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x3F,
  0x81, 0xFF, 0x00, 0x0F, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00,
  0x01, 0xFC, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x1F, 0x80, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x81,
  0xF8, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x00, 0x0F,
  0xC7, 0xE0, 0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xE7, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFC,
  0x3F, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x0F, 0xBE,
  0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0x0F, 0xBE, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xFB, 0xF0, 0x00,
  0x1F, 0x81, 0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x01,
  0xF1, 0xF0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3F, 0x1F, 0x80, 0x03, 0xF0,
  0x0F, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x3E, 0x0F,
  0x80, 0x07, 0xE0, 0x0F, 0xC0, 0x03, 0xE0, 0xFC, 0x00, 0x7E, 0x00, 0xFC,
  0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x07, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x0F,
  0xC0, 0x7E, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0xC0,
  0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xFC, 0x00, 0x3F, 0x01, 0xF8, 0x03,
  0xF0, 0x1F, 0x80, 0x03, 0xF0, 0x1F, 0x80, 0x3F, 0x01, 0xF8, 0x00, 0x1F,
  0x81, 0xF8, 0x01, 0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x00, 0x1F, 0x81,
  0xF0, 0x00, 0x1F, 0x83, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x3F,
  0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0xF8, 0x3F, 0x00,
  0x00, 0xFC, 0x7E, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x0F, 0xC7, 0xE0, 0x00,
  0xFC, 0x7E, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x07,
  0xC7, 0xC0, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xE7,
  0xC0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x7E, 0xF8,
  0x00, 0x03, 0xEF, 0xC0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3E, 0xFC, 0x00,
  0x00, 0x3E, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x03, 0xEF, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xF8, 0xFE, 0x00, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x00, 0x7F, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x7F,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x07, 0xF1, 0xF8, 0x00,
  0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x0F, 0xCF,
  0xE0, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0xFE, 0x00, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x07,
  0xF0, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x03,
  0xF8, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x3F,
  0x00, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x00,
  0xFC, 0x3F, 0x00, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x00, 0x07, 0xEF, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00,
  0x1F, 0x9F, 0xC0, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x0F, 0xC3, 0xF8,
  0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x7F,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x3F, 0x80,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x07,
  0xE0, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x03,
  0xF8, 0x1F, 0x80, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x00, 0x3F, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x00, 0x3F,
  0x7E, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3E, 0xF0,
  0x00, 0x00, 0x3C, 0xF8, 0x00, 0x00, 0x7C, 0x78, 0x00, 0x00, 0x7C, 0x7C,
  0x00, 0x00, 0xF8, 0x3C, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x01, 0xF0, 0x1F,
  0x00, 0x01, 0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x03, 0xE0, 0x0F,
  0x80, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x03,
  0xE0, 0x0F, 0x80, 0x03, 0xE0, 0x0F, 0x80, 0x01, 0xF0, 0x1F, 0x00, 0x01,
  0xF0, 0x1F, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00,
  0x7C, 0x7C, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00,
  0x3E, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x07, 0xF0, 0x1F,
  0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0x80, 0x3E, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x03, 0xF0, 0x07, 0xF0,
  0x1C, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x03, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x7F,
  0xF0, 0x03, 0xF3, 0xF8, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0xFD, 0xF8, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0x00, 0x07, 0xFD, 0xFC, 0x00, 0x7F, 0xEF, 0xF8, 0x1F, 0xFF, 0x3F, 0xFF,
  0xFC, 0xF8, 0xFF, 0xFF, 0xC7, 0xC3, 0xFF, 0xF8, 0x3E, 0x0F, 0xFF, 0x81,
  0xF0, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x03, 0xFC, 0x00, 0x7C, 0x1F, 0xFF, 0x00, 0xF8, 0xFF, 0xFF, 0x81, 0xF3,
  0xFF, 0xFF, 0x83, 0xEF, 0xFF, 0xFF, 0x87, 0xFF, 0x00, 0xFF, 0x8F, 0xF8,
  0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x7E, 0x7F, 0x00,
  0x00, 0xFE, 0xFC, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x01, 0xFB, 0xF0, 0x00,
  0x03, 0xF7, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F,
  0x7E, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x03, 0xFB,
  0xFC, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x1F, 0xCF, 0xFC, 0x00, 0xFF, 0x1F,
  0xFE, 0x07, 0xFC, 0x3E, 0xFF, 0xFF, 0xF8, 0x78, 0xFF, 0xFF, 0xE0, 0xF0,
  0x7F, 0xFF, 0x01, 0xE0, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0x87, 0xFE, 0x03, 0xC1, 0xFC, 0x00, 0x10, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x18, 0x7F, 0xF8, 0xFE, 0x0F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x0F, 0xF8, 0x1F, 0x80, 0xFF,
  0xFC, 0x3F, 0x03, 0xFF, 0xFE, 0x7E, 0x0F, 0xFF, 0xFE, 0xFC, 0x3F, 0xFF,
  0xFF, 0xF8, 0xFF, 0x00, 0xFF, 0xF3, 0xFC, 0x00, 0x7F, 0xE7, 0xF0, 0x00,
  0x7F, 0xDF, 0xC0, 0x00, 0x7F, 0xBF, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0x7E,
  0x00, 0x00, 0xFE, 0xFC, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x07, 0xF9, 0xFC,
  0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x7F, 0xE3, 0xFE, 0x07, 0xFF, 0xC3, 0xFF,
  0xFF, 0xCF, 0x83, 0xFF, 0xFF, 0x1F, 0x03, 0xFF, 0xFC, 0x3E, 0x01, 0xFF,
  0xE0, 0x7C, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x7F, 0x80, 0x7F, 0x81, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0xFC,
  0x3F, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x1F, 0xBF,
  0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x41, 0xFE,
  0x00, 0x07, 0x03, 0xFF, 0x03, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xE0, 0x0F, 0xF8, 0xE0, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x7C, 0x0F, 0xFF,
  0xF0, 0xF8, 0x3F, 0xFF, 0xF9, 0xF0, 0xFF, 0xFF, 0xFB, 0xE3, 0xFC, 0x03,
  0xFF, 0xCF, 0xF0, 0x01, 0xFF, 0x9F, 0xC0, 0x01, 0xFF, 0x7F, 0x00, 0x01,
  0xFE, 0xFC, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x03, 0xFB, 0xF0,
  0x00, 0x07, 0xF7, 0xF0, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x7F, 0xCF, 0xF0,
  0x01, 0xFF, 0x8F, 0xF8, 0x0F, 0xFF, 0x0F, 0xFF, 0xFF, 0x7E, 0x0F, 0xFF,
  0xFC, 0xFC, 0x0F, 0xFF, 0xF1, 0xF8, 0x07, 0xFF, 0x83, 0xF0, 0x00, 0x70,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xE2, 0x00, 0x00, 0x3F, 0x87, 0x00, 0x00, 0xFF,
  0x0F, 0xE0, 0x07, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x1F, 0xE0, 0x1F, 0x07, 0xFF, 0xE0, 0xF8, 0xFF,
  0xFF, 0x87, 0xCF, 0xFF, 0xFF, 0x3E, 0xFF, 0xFF, 0xF9, 0xFF, 0xC0, 0x1F,
  0xEF, 0xF8, 0x00, 0x7F, 0x7F, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xC0, 0x10, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C,
  0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F,
  0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0x00, 0x08, 0x00,
  0x3E, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3E, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x81, 0xFE, 0xFF, 0xFC, 0xFF,
  0xF8, 0xFF, 0xF8, 0xFF, 0xE0, 0x3F, 0x80, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x5F, 0x00, 0x01, 0xFC, 0xF8, 0x00, 0x1F, 0xC7, 0xC0, 0x01, 0xFC,
  0x3E, 0x00, 0x1F, 0xC1, 0xF0, 0x01, 0xFC, 0x0F, 0x80, 0x1F, 0xC0, 0x7C,
  0x01, 0xFC, 0x03, 0xE0, 0x1F, 0xC0, 0x1F, 0x01, 0xFC, 0x00, 0xF8, 0x0F,
  0xC0, 0x07, 0xC0, 0xFC, 0x00, 0x3E, 0x0F, 0xC0, 0x01, 0xF0, 0xFC, 0x00,
  0x0F, 0x8F, 0xE0, 0x00, 0x7C, 0xFE, 0x00, 0x03, 0xEF, 0xF0, 0x00, 0x1F,
  0x7F, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xCF,
  0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0x7C, 0x07, 0xF0,
  0x03, 0xE0, 0x1F, 0xC0, 0x1F, 0x00, 0x7F, 0x00, 0xF8, 0x01, 0xF8, 0x07,
  0xC0, 0x0F, 0xE0, 0x3E, 0x00, 0x3F, 0x81, 0xF0, 0x00, 0xFE, 0x0F, 0x80,
  0x03, 0xF8, 0x7C, 0x00, 0x1F, 0xC3, 0xE0, 0x00, 0x7F, 0x1F, 0x00, 0x01,
  0xFC, 0xF8, 0x00, 0x07, 0xF7, 0xC0, 0x00, 0x3F, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x3C,
  0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x0F, 0x8F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE3,
  0xE7, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0xFB, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0x3F, 0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0xEF, 0xF8, 0x00, 0xFF, 0xE0, 0x03,
  0xFB, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x00, 0x07, 0xF8, 0x07, 0x81, 0xFF, 0xF8, 0x3E, 0x3F, 0xFF,
  0xF1, 0xF3, 0xFF, 0xFF, 0xCF, 0xBF, 0xFF, 0xFE, 0x7F, 0xF0, 0x07, 0xFB,
  0xFE, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xF0, 0x0F,
  0xF0, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x00, 0x00,
  0xFC, 0x7E, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00,
  0x7E, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00,
  0x7E, 0x7F, 0x00, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x80, 0x01,
  0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x07, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x01, 0xF0, 0x7F, 0xFC,
  0x03, 0xE3, 0xFF, 0xFE, 0x07, 0xCF, 0xFF, 0xFE, 0x0F, 0xBF, 0xFF, 0xFE,
  0x1F, 0xFC, 0x03, 0xFE, 0x3F, 0xE0, 0x01, 0xFC, 0x7F, 0x80, 0x01, 0xFC,
  0xFE, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x03, 0xF7,
  0xE0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x01, 0xFB, 0xF8, 0x00,
  0x07, 0xF7, 0xF0, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x3F, 0x9F, 0xF0, 0x00,
  0xFF, 0x3F, 0xF0, 0x03, 0xFC, 0x7F, 0xFC, 0x1F, 0xF0, 0xFB, 0xFF, 0xFF,
  0xC1, 0xF3, 0xFF, 0xFF, 0x03, 0xE1, 0xFF, 0xFC, 0x07, 0xC1, 0xFF, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x7C, 0x0F,
  0xFF, 0xF0, 0xF8, 0x3F, 0xFF, 0xF9, 0xF0, 0xFF, 0xFF, 0xFB, 0xE3, 0xFC,
  0x03, 0xFF, 0xCF, 0xF0, 0x01, 0xFF, 0x9F, 0xC0, 0x01, 0xFF, 0x7F, 0x00,
  0x01, 0xFE, 0xFC, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x03, 0xFB,
  0xF0, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x7F, 0xCF,
  0xF0, 0x01, 0xFF, 0x8F, 0xF8, 0x1F, 0xFF, 0x0F, 0xFF, 0xFF, 0x7E, 0x0F,
  0xFF, 0xFC, 0xFC, 0x0F, 0xFF, 0xF1, 0xF8, 0x07, 0xFF, 0x83, 0xF0, 0x00,
  0xF0, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xFF, 0x01, 0xFF, 0xF8, 0x7F, 0xFF, 0x8F, 0xFF, 0xF9,
  0xFF, 0xFF, 0xBF, 0xC3, 0xFB, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x0F,
  0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x1F,
  0xC0, 0x07, 0xC7, 0xE0, 0x00, 0x21, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xA0, 0x00, 0x07, 0xEF, 0x00, 0x03, 0xFB,
  0xF8, 0x03, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x81, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F,
  0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x38, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x1F,
  0xDF, 0x80, 0x00, 0xFF, 0x7F, 0x00, 0x07, 0xFD, 0xFE, 0x00, 0x3F, 0xF3,
  0xFE, 0x07, 0xF7, 0xC7, 0xFF, 0xFF, 0x9F, 0x1F, 0xFF, 0xFC, 0x7C, 0x1F,
  0xFF, 0xE1, 0xF0, 0x3F, 0xFE, 0x07, 0xC0, 0x07, 0x80, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xDF, 0x80, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x03, 0xF1, 0xFC,
  0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x1F, 0x81,
  0xF8, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x00, 0xFC,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x07,
  0xE0, 0x07, 0xE0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x7E,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00,
  0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x07, 0xC1, 0xF8, 0x00,
  0x01, 0xF8, 0x7C, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x0F, 0x8F, 0xC0,
  0x00, 0x03, 0xF3, 0xE0, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x00, 0x1F, 0x7E,
  0x00, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xF9, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0x9F, 0x80,
  0x03, 0xFF, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xF0, 0xFC,
  0x00, 0x7D, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x3E, 0x00, 0x3F, 0x0F,
  0xC0, 0x07, 0xCF, 0x80, 0x0F, 0x81, 0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xE0,
  0x7E, 0x00, 0xF8, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x3E, 0x1F, 0x00, 0x7E,
  0x03, 0xE0, 0x1F, 0x87, 0xC0, 0x1F, 0x00, 0xFC, 0x07, 0xE1, 0xF8, 0x0F,
  0xC0, 0x3F, 0x01, 0xF0, 0x3E, 0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x0F, 0x80,
  0xF8, 0x01, 0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x00, 0x7E, 0x0F, 0x80, 0x7C,
  0x1F, 0x80, 0x1F, 0x83, 0xE0, 0x1F, 0x07, 0xE0, 0x07, 0xE1, 0xF8, 0x07,
  0xE1, 0xF0, 0x00, 0xF8, 0x7C, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x1F, 0x00,
  0x3E, 0x3F, 0x00, 0x0F, 0xCF, 0xC0, 0x0F, 0x8F, 0xC0, 0x01, 0xF3, 0xE0,
  0x03, 0xF3, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x7D, 0xF8, 0x00, 0x1F, 0xBE,
  0x00, 0x1F, 0x7E, 0x00, 0x07, 0xEF, 0x00, 0x07, 0xDF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x1F, 0xC0,
  0x00, 0x7F, 0x07, 0xE0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x1F, 0x80, 0x07,
  0xF0, 0x1F, 0xC0, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0x7E, 0x0F, 0xC0, 0x00,
  0x3F, 0x8F, 0xC0, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x03, 0xF7, 0xE0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFB, 0xF0,
  0x00, 0x01, 0xF8, 0xFC, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0xFC, 0x1F,
  0x80, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x7F, 0x00,
  0x07, 0xF0, 0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFE, 0x3F, 0x80,
  0x00, 0x3F, 0xBF, 0x80, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0x1F, 0xDF,
  0x80, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x00, 0xFC,
  0x3F, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x07,
  0xE0, 0x7E, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0xFC, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x1F, 0x80, 0x07, 0xE0, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x0F, 0xC0, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x7E, 0x01, 0xF8, 0x00,
  0x0F, 0x80, 0x7E, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0xFC, 0x0F, 0xC0,
  0x00, 0x1F, 0x83, 0xE0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x00, 0xF8, 0x7E,
  0x00, 0x00, 0x3F, 0x1F, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x01, 0xF3,
  0xE0, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80,
  0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F,
  0x00, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x00, 0x01, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0x80, 0x07, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0xFE,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xF0,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0x80, 0x00, 0x02, 0x3F, 0xF8, 0x00, 0x04,
  0xFF, 0xFE, 0x00, 0x1B, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x60, 0x00, 0x7F, 0xFC, 0x80,
  0x00, 0x1F, 0xE0,
};

const GFXglyph NotoSans_Regular66pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 8, 48, 18, 5, -47 },
  { 49, 19, 17, 27, 4, -47 },
  { 90, 39, 47, 43, 2, -47 },
  { 320, 30, 54, 38, 4, -50 },
  { 523, 49, 49, 55, 3, -48 },
  { 824, 45, 49, 48, 3, -48 },
  { 1100, 7, 17, 15, 4, -47 },
  { 1115, 15, 57, 20, 3, -47 },
  { 1222, 15, 57, 20, 2, -47 },
  { 1329, 31, 30, 36, 3, -50 },
  { 1446, 31, 32, 38, 3, -39 },
  { 1570, 10, 17, 18, 3, -8 },
  { 1592, 16, 5, 21, 3, -20 },
  { 1602, 8, 9, 18, 5, -8 },
  { 1611, 23, 47, 25, 1, -47 },
  { 1747, 32, 49, 38, 3, -48 },
  { 1943, 17, 47, 38, 6, -47 },
  { 2043, 31, 48, 38, 3, -48 },
  { 2229, 31, 49, 38, 3, -48 },
  { 2419, 35, 47, 38, 1, -47 },
  { 2625, 30, 48, 38, 4, -47 },
  { 2805, 31, 49, 38, 4, -48 },
  { 2995, 32, 47, 38, 3, -47 },
  { 3183, 31, 49, 38, 3, -48 },
  { 3373, 31, 49, 38, 3, -48 },
  { 3563, 8, 37, 18, 5, -36 },
  { 3600, 11, 45, 18, 2, -36 },
  { 3662, 31, 32, 38, 3, -40 },
  { 3786, 30, 18, 38, 4, -32 },
  { 3854, 31, 32, 38, 3, -40 },
  { 3978, 26, 49, 29, 1, -48 },
  { 4138, 52, 53, 59, 4, -47 },
  { 4483, 42, 47, 42, 0, -47 },
  { 4730, 33, 47, 43, 6, -47 },
  { 4924, 36, 49, 42, 4, -48 },
  { 5145, 38, 47, 48, 6, -47 },
  { 5369, 27, 47, 37, 6, -47 },
  { 5528, 27, 47, 34, 6, -47 },
  { 5687, 39, 49, 48, 4, -48 },
  { 5926, 36, 47, 49, 6, -47 },
  { 6138, 17, 47, 22, 3, -47 },
  { 6238, 17, 60, 18, -5, -47 },
  { 6366, 35, 47, 41, 6, -47 },
  { 6572, 27, 47, 35, 6, -47 },
  { 6731, 47, 47, 60, 6, -47 },
  { 7008, 38, 47, 50, 6, -47 },
  { 7232, 44, 49, 52, 4, -48 },
  { 7502, 31, 47, 40, 6, -47 },
  { 7685, 44, 59, 52, 4, -48 },
  { 8010, 34, 47, 41, 6, -47 },
  { 8210, 30, 49, 36, 3, -48 },
  { 8394, 35, 47, 37, 1, -47 },
  { 8600, 36, 48, 48, 6, -47 },
  { 8816, 40, 47, 40, 0, -47 },
  { 9051, 60, 47, 61, 1, -47 },
  { 9404, 38, 47, 39, 0, -47 },
  { 9628, 37, 47, 37, 0, -47 },
  { 9846, 32, 47, 38, 3, -47 },
  { 10034, 15, 57, 22, 5, -47 },
  { 10141, 23, 47, 25, 1, -47 },
  { 10277, 14, 57, 22, 2, -47 },
  { 10377, 32, 29, 38, 3, -47 },
  { 10493, 29, 4, 29, 0, 6 },
  { 10508, 13, 11, 19, 3, -51 },
  { 10526, 29, 37, 37, 3, -36 },
  { 10661, 31, 51, 41, 6, -50 },
  { 10859, 26, 37, 32, 4, -36 },
  { 10980, 31, 51, 41, 4, -50 },
  { 11178, 30, 37, 37, 4, -36 },
  { 11317, 25, 50, 23, 1, -50 },
  { 11474, 31, 52, 41, 4, -36 },
  { 11676, 29, 50, 41, 6, -50 },
  { 11858, 7, 49, 17, 5, -49 },
  { 11901, 16, 65, 17, -4, -49 },
  { 12031, 29, 50, 35, 6, -50 },
  { 12213, 5, 50, 17, 6, -50 },
  { 12245, 50, 36, 62, 6, -36 },
  { 12470, 29, 36, 41, 6, -36 },
  { 12601, 32, 37, 40, 4, -36 },
  { 12749, 31, 52, 41, 6, -36 },
  { 12951, 31, 52, 41, 4, -36 },
  { 13153, 20, 36, 27, 6, -36 },
  { 13243, 26, 37, 32, 3, -36 },
  { 13364, 21, 45, 24, 1, -44 },
  { 13483, 30, 36, 41, 5, -35 },
  { 13618, 34, 35, 34, 0, -35 },
  { 13767, 50, 35, 52, 1, -35 },
  { 13986, 33, 35, 35, 1, -35 },
  { 14131, 34, 51, 34, 0, -35 },
  { 14348, 25, 35, 31, 3, -35 },
  { 14458, 21, 57, 25, 2, -47 },
  { 14608, 5, 66, 36, 16, -50 },
  { 14650, 21, 57, 25, 2, -47 },
  { 14800, 31, 9, 38, 3, -28 },
};

const GFXfont NotoSans_Regular66pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Regular66pt7bBitmaps,
  (GFXglyph *)NotoSans_Regular66pt7bGlyphs,
  0x20, 0x7E, 90
};

#endif // _NOTOSANS_REGULAR66PT7B_H_
