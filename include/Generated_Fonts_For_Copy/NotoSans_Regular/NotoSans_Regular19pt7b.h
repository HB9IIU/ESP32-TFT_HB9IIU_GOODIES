#ifndef _NOTOSANS_REGULAR19PT7B_H_
#define _NOTOSANS_REGULAR19PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Regular.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Regular19pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0x24, 0x92, 0x48, 0x0F, 0xC0, 0xCF, 0x2C, 0xB2, 0x48, 0x04,
  0x40, 0x44, 0x0C, 0xC0, 0x8C, 0x7F, 0xF7, 0xFF, 0x08, 0x81, 0x98, 0x19,
  0x8F, 0xFE, 0x11, 0x01, 0x10, 0x33, 0x03, 0x30, 0x08, 0x1F, 0x1F, 0xD9,
  0x0C, 0x86, 0x41, 0xE0, 0x3E, 0x0B, 0x84, 0xC2, 0x7D, 0xEF, 0xE0, 0x40,
  0x20, 0x30, 0x21, 0x61, 0x8C, 0x84, 0x23, 0x30, 0x8C, 0x82, 0x36, 0x0C,
  0x97, 0x96, 0x92, 0x36, 0xCC, 0x13, 0x30, 0xCC, 0xC2, 0x33, 0x18, 0x48,
  0xC1, 0xE0, 0x1C, 0x01, 0xF8, 0x18, 0xC0, 0xC6, 0x02, 0x30, 0x1B, 0x00,
  0x70, 0x0F, 0x86, 0x66, 0x36, 0x19, 0x30, 0x79, 0x81, 0x86, 0x3E, 0x1F,
  0x1C, 0xFF, 0x40, 0x32, 0x64, 0xCC, 0xCC, 0x88, 0xCC, 0xC4, 0x66, 0x30,
  0x8C, 0x66, 0x23, 0x33, 0x33, 0x33, 0x26, 0x64, 0xC0, 0x18, 0x0C, 0x22,
  0x5F, 0xF1, 0x81, 0xA0, 0x98, 0xCC, 0x08, 0x04, 0x02, 0x01, 0x0F, 0xF8,
  0x40, 0x20, 0x10, 0x08, 0x00, 0x7B, 0x40, 0xFF, 0xFC, 0x06, 0x08, 0x30,
  0x60, 0x83, 0x06, 0x08, 0x30, 0x61, 0x83, 0x04, 0x18, 0x00, 0x1C, 0x3F,
  0x18, 0xD8, 0x2C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x68, 0x26,
  0x31, 0xF0, 0x19, 0xDF, 0xB1, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x3C,
  0x7F, 0x90, 0xC0, 0x20, 0x10, 0x18, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C,
  0x0F, 0xFF, 0xFC, 0x3C, 0x7F, 0xA0, 0xC0, 0x20, 0x10, 0x18, 0xF8, 0x7C,
  0x03, 0x00, 0xC0, 0x60, 0x3C, 0x77, 0xF0, 0x01, 0x80, 0xE0, 0x78, 0x16,
  0x09, 0x86, 0x63, 0x18, 0x86, 0x61, 0xBF, 0xFF, 0xFC, 0x06, 0x01, 0x80,
  0x60, 0x7F, 0x3F, 0x90, 0x08, 0x04, 0x02, 0x01, 0xF8, 0x06, 0x01, 0x80,
  0xC0, 0x60, 0x2C, 0x77, 0xF0, 0x0F, 0x1F, 0x98, 0x0C, 0x04, 0x06, 0x23,
  0xFD, 0xC3, 0xC1, 0xE0, 0xF0, 0x68, 0x36, 0x31, 0xF0, 0xFF, 0xFF, 0xC0,
  0x60, 0x60, 0x30, 0x10, 0x18, 0x08, 0x0C, 0x04, 0x06, 0x03, 0x03, 0x01,
  0x80, 0x1C, 0x3F, 0x90, 0x58, 0x24, 0x13, 0x18, 0xF0, 0x7C, 0x63, 0x60,
  0xF0, 0x78, 0x3E, 0x33, 0xF0, 0x1C, 0x3F, 0x30, 0xD8, 0x2C, 0x1E, 0x0F,
  0x06, 0xCF, 0x3D, 0x80, 0xC0, 0x40, 0x60, 0x63, 0xE0, 0xFC, 0x00, 0x00,
  0xFC, 0xFC, 0x00, 0x00, 0xDB, 0x40, 0x00, 0x80, 0xC1, 0xC3, 0x86, 0x06,
  0x01, 0xE0, 0x1C, 0x03, 0x80, 0x40, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8,
  0x80, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x38, 0x70, 0xE0, 0x40, 0x00,
  0x3C, 0xFE, 0x83, 0x03, 0x03, 0x06, 0x0C, 0x18, 0x10, 0x10, 0x00, 0x00,
  0x38, 0x30, 0x01, 0x80, 0x1F, 0xE0, 0x60, 0x61, 0x00, 0x66, 0x3E, 0x68,
  0xCC, 0xF3, 0x18, 0xE4, 0x31, 0x88, 0x63, 0x98, 0xCF, 0x32, 0x92, 0x3D,
  0xC6, 0x00, 0x06, 0x00, 0x07, 0xF8, 0x03, 0xC0, 0x06, 0x00, 0x60, 0x0F,
  0x00, 0xF0, 0x09, 0x01, 0x98, 0x18, 0x81, 0x0C, 0x3F, 0xC3, 0xFC, 0x60,
  0x66, 0x06, 0x40, 0x3C, 0x03, 0xF8, 0x7F, 0xB0, 0xF8, 0x3C, 0x1E, 0x0B,
  0xF9, 0xFE, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x7F, 0xF0, 0x07, 0x87, 0xF3,
  0x01, 0x80, 0x40, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x06, 0x01, 0x80,
  0x38, 0x47, 0xF0, 0xF8, 0x1F, 0xE3, 0x06, 0x60, 0x6C, 0x0D, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0B, 0x03, 0x60, 0xCC, 0xF9, 0xFC, 0x00, 0xFF,
  0xFF, 0x06, 0x0C, 0x18, 0x3F, 0xFF, 0xC1, 0x83, 0x06, 0x0F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x06, 0x0C, 0x18, 0x30, 0x7F, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x00, 0x07, 0xC3, 0xFC, 0xC0, 0xB0, 0x04, 0x01, 0x80, 0x30, 0x06, 0x0F,
  0xC0, 0x38, 0x05, 0x80, 0xB0, 0x13, 0x86, 0x3F, 0xC0, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x30, 0xFF, 0x98, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x7C,
  0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x13, 0xFC, 0xC0, 0xF0, 0x6C,
  0x33, 0x18, 0xCC, 0x36, 0x0F, 0x03, 0xE0, 0xCC, 0x33, 0x0C, 0x63, 0x0C,
  0xC1, 0xB0, 0x70, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x0F, 0xFF, 0xC0, 0xC0, 0x1F, 0x01, 0xE8, 0x0F, 0x60, 0x5B, 0x06,
  0xC8, 0x26, 0x61, 0x33, 0x19, 0x88, 0x8C, 0x6C, 0x61, 0x63, 0x0E, 0x18,
  0x70, 0xC1, 0x04, 0xC0, 0x78, 0x0F, 0x81, 0xD8, 0x3B, 0x07, 0x30, 0xE3,
  0x1C, 0x63, 0x86, 0x70, 0x6E, 0x0D, 0xC0, 0xF8, 0x0F, 0x01, 0xC0, 0x0F,
  0x81, 0xFE, 0x1C, 0x18, 0xC0, 0x6C, 0x03, 0x60, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0x98, 0x0C, 0xC0, 0x63, 0x8E, 0x0F, 0xE0, 0xF8, 0x7F,
  0x30, 0xD8, 0x2C, 0x1E, 0x0B, 0x0D, 0xFC, 0xF8, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x00, 0x0F, 0x81, 0xFE, 0x1C, 0x18, 0xC0, 0x6C, 0x03, 0x60, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0x98, 0x0C, 0xC0, 0x63, 0x8E, 0x0F,
  0xE0, 0x06, 0x00, 0x18, 0x00, 0x70, 0xF8, 0x3F, 0x8C, 0x33, 0x04, 0xC1,
  0xB0, 0x4C, 0x33, 0xF8, 0xCC, 0x31, 0x8C, 0x63, 0x0C, 0xC1, 0xB0, 0x70,
  0x1E, 0x3F, 0xB0, 0x18, 0x0C, 0x03, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0x80,
  0x60, 0x2C, 0x77, 0xF0, 0xFF, 0xFF, 0xF0, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x3C, 0x0F,
  0x03, 0x63, 0x8F, 0xC0, 0xC0, 0x38, 0x0D, 0x81, 0xB0, 0x26, 0x0C, 0x61,
  0x8C, 0x60, 0x8C, 0x19, 0x83, 0x60, 0x2C, 0x07, 0x00, 0xE0, 0x0C, 0x00,
  0xC0, 0xC0, 0xA0, 0x60, 0xD8, 0x70, 0x6C, 0x3C, 0x36, 0x16, 0x11, 0x19,
  0x18, 0xCC, 0x8C, 0x64, 0x66, 0x32, 0x32, 0x0B, 0x0B, 0x07, 0x87, 0x83,
  0x83, 0x81, 0xC0, 0xC0, 0x60, 0x60, 0xC0, 0x6C, 0x18, 0xC2, 0x18, 0xC1,
  0xB0, 0x14, 0x03, 0x80, 0x70, 0x0B, 0x03, 0x60, 0xC6, 0x10, 0x46, 0x0D,
  0x80, 0xC0, 0xC0, 0x68, 0x19, 0x83, 0x10, 0xC3, 0x18, 0x36, 0x06, 0x80,
  0x70, 0x0C, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x00, 0xFF, 0xFF,
  0xC0, 0xC0, 0x60, 0x60, 0x20, 0x30, 0x30, 0x10, 0x18, 0x18, 0x08, 0x0F,
  0xFF, 0xFC, 0xFF, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0xF0, 0xC0,
  0x81, 0x83, 0x02, 0x06, 0x0C, 0x08, 0x18, 0x10, 0x30, 0x60, 0x40, 0xC0,
  0xFF, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0xF8, 0x08,
  0x0C, 0x07, 0x06, 0x82, 0x63, 0x11, 0x0D, 0x82, 0x81, 0x80, 0xFF, 0xCC,
  0x70, 0x7E, 0x43, 0x03, 0x03, 0x3F, 0xE3, 0xC3, 0xC3, 0xC7, 0x7D, 0x80,
  0x40, 0x20, 0x10, 0x0B, 0xE6, 0x1B, 0x05, 0x03, 0x81, 0xC0, 0xE0, 0x78,
  0x6E, 0x75, 0xF0, 0x3F, 0x62, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x62,
  0x3E, 0x01, 0x80, 0xC0, 0x60, 0x33, 0xFB, 0x1F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x36, 0x39, 0xF4, 0x3E, 0x31, 0xB0, 0x78, 0x3F, 0xFE, 0x03,
  0x00, 0x80, 0x71, 0x1F, 0x80, 0x04, 0x3C, 0xC1, 0x83, 0x1F, 0x8C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x00, 0x3E, 0xB1, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0x63, 0x9F, 0xC0, 0x60, 0x38, 0x1B, 0xF8, 0x70,
  0x80, 0x80, 0x80, 0x80, 0xBE, 0xC3, 0xC3, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x70, 0x55, 0x55, 0x50, 0x13, 0x00, 0x11, 0x11, 0x11, 0x11,
  0x11, 0x11, 0x3F, 0x40, 0x80, 0x80, 0x80, 0x81, 0x86, 0x8C, 0x98, 0xB0,
  0xF0, 0xD8, 0x98, 0x8C, 0x86, 0x83, 0xFF, 0xFC, 0xBE, 0xFB, 0x1E, 0x3C,
  0x30, 0xE0, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x10, 0xBE, 0xC3, 0xC3, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x3F, 0x31, 0xF0, 0x78, 0x1C, 0x0E, 0x07, 0x02, 0x83, 0x63, 0x1F, 0x00,
  0xBE, 0x61, 0xB0, 0xD0, 0x38, 0x1C, 0x0E, 0x07, 0x86, 0xE7, 0x5F, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x00, 0x3E, 0xB1, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0x63, 0x9F, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0xBF, 0x8C,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x00, 0x7F, 0x87, 0x07, 0x07, 0x83, 0xC1,
  0x81, 0x87, 0xF8, 0x20, 0x82, 0x3F, 0x20, 0x82, 0x08, 0x20, 0x82, 0x0C,
  0x1C, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x06, 0x83, 0x63, 0x9F,
  0x40, 0xC0, 0xD0, 0x66, 0x19, 0x84, 0x23, 0x0C, 0x81, 0x60, 0x78, 0x1C,
  0x03, 0x00, 0xC3, 0x86, 0x87, 0x09, 0x8A, 0x33, 0x36, 0x66, 0x6C, 0x84,
  0x89, 0x0F, 0x16, 0x1E, 0x3C, 0x18, 0x70, 0x30, 0x60, 0x61, 0xCC, 0xC3,
  0x30, 0x78, 0x0C, 0x03, 0x81, 0xE0, 0xCC, 0x61, 0xB8, 0x70, 0xC0, 0xD0,
  0x66, 0x19, 0x84, 0x33, 0x0C, 0xC1, 0x20, 0x78, 0x0C, 0x03, 0x00, 0xC0,
  0x20, 0x18, 0x3C, 0x04, 0x00, 0xFE, 0x0C, 0x30, 0x41, 0x86, 0x18, 0x30,
  0xC1, 0xFC, 0x04, 0x73, 0x0C, 0x30, 0xC2, 0x18, 0xC3, 0x82, 0x0C, 0x30,
  0xC3, 0x0E, 0x1C, 0xFF, 0xFF, 0xE0, 0x83, 0x86, 0x08, 0x20, 0x82, 0x0C,
  0x1C, 0xE2, 0x08, 0x20, 0x82, 0x18, 0xC0, 0x70, 0xEF, 0xE0, 0x80,
};

const GFXglyph NotoSans_Regular19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 3, 14, 5, 1, -14 },
  { 7, 6, 5, 8, 1, -14 },
  { 11, 12, 14, 12, 0, -14 },
  { 32, 9, 15, 11, 1, -14 },
  { 49, 14, 14, 16, 1, -14 },
  { 74, 13, 14, 14, 1, -14 },
  { 97, 2, 5, 4, 1, -14 },
  { 99, 4, 17, 6, 1, -14 },
  { 108, 4, 17, 6, 1, -14 },
  { 117, 9, 8, 10, 1, -14 },
  { 126, 9, 9, 11, 1, -11 },
  { 137, 3, 4, 5, 1, -2 },
  { 139, 4, 2, 6, 1, -6 },
  { 140, 3, 2, 5, 1, -2 },
  { 141, 7, 14, 7, 0, -14 },
  { 154, 9, 14, 11, 1, -14 },
  { 170, 5, 14, 11, 2, -14 },
  { 179, 9, 14, 11, 1, -14 },
  { 195, 9, 14, 11, 1, -14 },
  { 211, 10, 14, 11, 0, -14 },
  { 229, 9, 14, 11, 1, -14 },
  { 245, 9, 14, 11, 1, -14 },
  { 261, 9, 14, 11, 1, -14 },
  { 277, 9, 14, 11, 1, -14 },
  { 293, 9, 14, 11, 1, -14 },
  { 309, 3, 10, 5, 1, -10 },
  { 313, 3, 12, 5, 1, -10 },
  { 318, 9, 10, 11, 1, -12 },
  { 330, 9, 5, 11, 1, -9 },
  { 336, 9, 10, 11, 1, -12 },
  { 348, 8, 14, 8, 0, -14 },
  { 362, 15, 16, 17, 1, -14 },
  { 392, 12, 14, 12, 0, -14 },
  { 413, 9, 14, 12, 2, -14 },
  { 429, 10, 14, 12, 1, -14 },
  { 447, 11, 14, 14, 2, -14 },
  { 467, 7, 14, 11, 2, -14 },
  { 480, 7, 14, 10, 2, -14 },
  { 493, 11, 14, 14, 1, -14 },
  { 513, 10, 14, 14, 2, -14 },
  { 531, 5, 14, 6, 1, -14 },
  { 540, 4, 18, 5, -1, -14 },
  { 549, 10, 14, 12, 2, -14 },
  { 567, 7, 14, 10, 2, -14 },
  { 580, 13, 14, 17, 2, -14 },
  { 603, 11, 14, 14, 2, -14 },
  { 623, 13, 14, 15, 1, -14 },
  { 646, 9, 14, 12, 2, -14 },
  { 662, 13, 17, 15, 1, -14 },
  { 690, 10, 14, 12, 2, -14 },
  { 708, 9, 14, 10, 1, -14 },
  { 724, 10, 14, 11, 0, -14 },
  { 742, 10, 14, 14, 2, -14 },
  { 760, 11, 14, 11, 0, -14 },
  { 780, 17, 14, 18, 0, -14 },
  { 810, 11, 14, 11, 0, -14 },
  { 830, 11, 14, 11, 0, -14 },
  { 850, 9, 14, 11, 1, -14 },
  { 866, 4, 17, 6, 2, -14 },
  { 875, 7, 14, 7, 0, -14 },
  { 888, 5, 17, 6, 0, -14 },
  { 899, 9, 9, 11, 1, -14 },
  { 910, 8, 1, 8, 0, 2 },
  { 911, 4, 3, 5, 1, -15 },
  { 913, 8, 10, 11, 1, -10 },
  { 923, 9, 14, 12, 2, -14 },
  { 939, 8, 10, 9, 1, -10 },
  { 949, 9, 14, 12, 1, -14 },
  { 965, 9, 10, 11, 1, -10 },
  { 977, 7, 15, 7, 0, -15 },
  { 991, 9, 15, 12, 1, -10 },
  { 1008, 8, 14, 12, 2, -14 },
  { 1022, 2, 14, 5, 1, -14 },
  { 1026, 4, 19, 5, -1, -14 },
  { 1036, 8, 14, 10, 2, -14 },
  { 1050, 1, 14, 5, 2, -14 },
  { 1052, 14, 10, 18, 2, -10 },
  { 1070, 8, 10, 12, 2, -10 },
  { 1080, 9, 10, 12, 1, -10 },
  { 1092, 9, 15, 12, 2, -10 },
  { 1109, 9, 15, 12, 1, -10 },
  { 1126, 6, 10, 8, 2, -10 },
  { 1134, 7, 10, 9, 1, -10 },
  { 1143, 6, 13, 7, 0, -13 },
  { 1153, 9, 10, 12, 1, -10 },
  { 1165, 10, 10, 10, 0, -10 },
  { 1178, 15, 10, 15, 0, -10 },
  { 1197, 10, 10, 10, 0, -10 },
  { 1210, 10, 15, 10, 0, -10 },
  { 1229, 7, 10, 9, 1, -10 },
  { 1238, 6, 17, 7, 1, -14 },
  { 1251, 1, 19, 10, 5, -14 },
  { 1254, 6, 17, 7, 1, -14 },
  { 1267, 9, 3, 11, 1, -8 },
};

const GFXfont NotoSans_Regular19pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Regular19pt7bBitmaps,
  (GFXglyph *)NotoSans_Regular19pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _NOTOSANS_REGULAR19PT7B_H_
