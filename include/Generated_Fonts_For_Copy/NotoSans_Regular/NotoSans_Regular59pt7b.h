#ifndef _NOTOSANS_REGULAR59PT7B_H_
#define _NOTOSANS_REGULAR59PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Regular.ttf
// Size: 59pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Regular59pt7bBitmaps[] PROGMEM = {
  0x00, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7C, 0x7C, 0x7C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x7E, 0xFE, 0xFF, 0xFF, 0xFE, 0x7E, 0x3C, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0x78, 0x1F, 0x78, 0x1F, 0x78, 0x1E, 0x78, 0x0E, 0x70, 0x0E, 0x70, 0x0E,
  0x70, 0x0E, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x00, 0x7C, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x3C, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x7C,
  0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x00, 0xF0,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00,
  0x3C, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x00, 0x3C, 0x03, 0xE0,
  0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x3C, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x7C, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x0F, 0x00, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x1E, 0x00,
  0x00, 0x3E, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x3C, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xC7, 0xF1, 0xE1, 0xF3, 0xF0,
  0x78, 0x0C, 0xF8, 0x1E, 0x00, 0x3E, 0x07, 0x80, 0x0F, 0x81, 0xE0, 0x03,
  0xE0, 0x78, 0x00, 0xF8, 0x1E, 0x00, 0x3E, 0x07, 0x80, 0x0F, 0xC1, 0xE0,
  0x01, 0xFC, 0x78, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80,
  0x01, 0xFF, 0xF8, 0x00, 0x79, 0xFE, 0x00, 0x1E, 0x1F, 0xC0, 0x07, 0x83,
  0xF0, 0x01, 0xE0, 0x7C, 0x00, 0x78, 0x1F, 0x00, 0x1E, 0x07, 0xC0, 0x07,
  0x81, 0xF0, 0x01, 0xE0, 0x7E, 0x00, 0x78, 0x3F, 0xF0, 0x1E, 0x3F, 0xBF,
  0xF7, 0xFF, 0xEF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3C, 0x00, 0x7F, 0xF0,
  0x00, 0x0F, 0x80, 0x1F, 0xFF, 0x00, 0x03, 0xE0, 0x03, 0xE3, 0xF0, 0x00,
  0x78, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x00, 0x1E, 0x03, 0xC0, 0x03, 0xC0,
  0x07, 0xC0, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x07, 0x80, 0x1E, 0x00, 0x1E,
  0x00, 0xF0, 0x07, 0xC0, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x00, 0x78, 0x03,
  0xC0, 0x3E, 0x00, 0x0F, 0x00, 0x78, 0x0F, 0x80, 0x01, 0xE0, 0x0F, 0x01,
  0xE0, 0x00, 0x3C, 0x01, 0xE0, 0x7C, 0x00, 0x07, 0x80, 0x3C, 0x0F, 0x00,
  0x00, 0xF0, 0x07, 0x83, 0xE0, 0x00, 0x1E, 0x00, 0xF0, 0x78, 0x1F, 0x03,
  0xE0, 0x1E, 0x1F, 0x0F, 0xF8, 0x3C, 0x07, 0xC3, 0xC3, 0xFF, 0x87, 0x80,
  0xF0, 0xF8, 0xFF, 0xF8, 0xF8, 0x3E, 0x3E, 0x3E, 0x1F, 0x0F, 0x8F, 0xC7,
  0x87, 0x81, 0xF1, 0xFF, 0xF1, 0xF1, 0xF0, 0x1E, 0x1F, 0xFC, 0x3C, 0x3E,
  0x03, 0xE1, 0xFF, 0x0F, 0x87, 0x80, 0x7C, 0x0F, 0x01, 0xE0, 0xF0, 0x07,
  0x80, 0x00, 0x7C, 0x1E, 0x00, 0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x1E, 0x00,
  0x03, 0xE0, 0x78, 0x03, 0xC0, 0x00, 0xF8, 0x0F, 0x00, 0x78, 0x00, 0x1F,
  0x01, 0xE0, 0x0F, 0x00, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x00, 0x3E, 0x00, 0xF0, 0x07, 0x80, 0x07, 0x80, 0x1E, 0x01,
  0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x07, 0x80,
  0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x03, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x7C,
  0x00, 0x0F, 0xFF, 0x80, 0x1F, 0x00, 0x00, 0xFF, 0xE0, 0x03, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xE0, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x1F, 0x80,
  0x00, 0x07, 0xC0, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x00, 0x03,
  0xF0, 0xFE, 0x00, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0xF8, 0x0F, 0xE7, 0xF0, 0x00, 0xF8, 0x1F, 0xC3, 0xF8, 0x00,
  0xF8, 0x3F, 0x81, 0xFC, 0x01, 0xF0, 0x7F, 0x00, 0xFE, 0x01, 0xF0, 0x7E,
  0x00, 0x7F, 0x03, 0xF0, 0x7C, 0x00, 0x3F, 0x83, 0xE0, 0xFC, 0x00, 0x1F,
  0xC7, 0xE0, 0xFC, 0x00, 0x0F, 0xE7, 0xC0, 0xFC, 0x00, 0x07, 0xFF, 0xC0,
  0xFC, 0x00, 0x03, 0xFF, 0x80, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0x00, 0x7E, 0x00, 0x03, 0xFF,
  0x80, 0x7F, 0x00, 0x07, 0xFF, 0xC0, 0x3F, 0xC0, 0x3F, 0xEF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xC7, 0xF0, 0x0F, 0xFF, 0xFF, 0x83, 0xFC, 0x07, 0xFF, 0xFE,
  0x01, 0xFE, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7B, 0xDE, 0xF7, 0x39, 0xC0, 0x00, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xE0,
  0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x0F, 0xC0, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0,
  0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0xC0, 0x7E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x3F,
  0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x3E, 0x03,
  0xE0, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x40, 0x0F, 0x00, 0x27, 0xC0,
  0xF0, 0x1E, 0x7F, 0x8F, 0x1F, 0xE7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xDE, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x0F, 0x8F,
  0x80, 0x01, 0xF0, 0xFC, 0x00, 0x3F, 0x07, 0xC0, 0x07, 0xE0, 0x7E, 0x00,
  0xFE, 0x07, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x40,
  0x10, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF1, 0xF8, 0xFC,
  0x7C, 0x3E, 0x1E, 0x1F, 0x0F, 0x87, 0x83, 0xC3, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0x7E, 0xFE, 0xFF, 0xFF, 0xFE, 0x7E,
  0x3C, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x1F, 0x83, 0xF0,
  0x00, 0xF8, 0x3E, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x07,
  0xC7, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E, 0xFC,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xE7, 0xC0,
  0x00, 0x3E, 0x7C, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x07,
  0xC3, 0xE0, 0x00, 0xFC, 0x1F, 0x00, 0x0F, 0x81, 0xF8, 0x01, 0xF8, 0x0F,
  0xE0, 0x7F, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x3F,
  0x00, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x0F, 0xFF, 0x1F, 0xDF, 0x3F, 0x9F,
  0xFF, 0x1F, 0x7C, 0x1F, 0x38, 0x1F, 0x30, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0x0F, 0xF8, 0x07, 0xF0, 0x7C, 0x00, 0x1F, 0x83, 0x80, 0x01, 0xF8,
  0x10, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFE, 0x00, 0xFF, 0x1E,
  0x00, 0x07, 0xE1, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFD, 0x80, 0x00, 0x3F, 0xBE,
  0x00, 0x1F, 0xE7, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x01, 0xF7, 0x80,
  0x00, 0x01, 0xE7, 0x80, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x07, 0xC7, 0x80,
  0x00, 0x0F, 0x8F, 0x80, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x1F, 0x0F, 0x80,
  0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7C, 0x0F, 0x80,
  0x00, 0xF8, 0x0F, 0x80, 0x00, 0xF8, 0x0F, 0x80, 0x01, 0xF0, 0x0F, 0x80,
  0x03, 0xE0, 0x0F, 0x80, 0x07, 0xC0, 0x0F, 0x80, 0x07, 0xC0, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x0F, 0x80,
  0x3E, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x0F, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x3F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFA, 0x00, 0x00, 0x7E, 0xC0, 0x00, 0x7F, 0x3E, 0x00, 0x7F, 0x8F,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC1, 0xFF, 0x80, 0x7C, 0x7F, 0xFE, 0x07, 0xCF,
  0xFF, 0xF0, 0xF9, 0xFF, 0xFF, 0x8F, 0xBE, 0x01, 0xFC, 0xFF, 0x80, 0x0F,
  0xCF, 0xF0, 0x00, 0x7E, 0xFE, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xF7, 0xC0, 0x00,
  0x1F, 0x7C, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x01, 0xF7,
  0xC0, 0x00, 0x3F, 0x3E, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x3E, 0x1F, 0x00,
  0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x28, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xFF, 0x80,
  0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x83, 0xF8,
  0x03, 0xF8, 0x3F, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x7C, 0x7E, 0x00, 0x07,
  0xC7, 0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x7C, 0x7E,
  0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x3F, 0x00, 0x0F, 0xC1, 0xF0, 0x01,
  0xF8, 0x1F, 0xC0, 0x3F, 0x00, 0xFF, 0x0F, 0xE0, 0x07, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0xFF, 0x3F, 0xE0, 0x1F, 0xC0, 0xFF, 0x03, 0xF8, 0x03, 0xF8,
  0x3E, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xEF, 0x80,
  0x00, 0x3E, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3E, 0x7C,
  0x00, 0x07, 0xE7, 0xE0, 0x00, 0xFC, 0x3F, 0x80, 0x1F, 0xC3, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00,
  0x01, 0x60, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x03, 0xFC, 0x07, 0xF0,
  0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0xC7, 0xC0,
  0x00, 0x7C, 0xFC, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03,
  0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xF7, 0xC0, 0x00,
  0x7F, 0x7E, 0x00, 0x0F, 0xF7, 0xF0, 0x01, 0xFF, 0x3F, 0x80, 0x7F, 0xF1,
  0xFF, 0xFF, 0xBE, 0x0F, 0xFF, 0xF3, 0xE0, 0x7F, 0xFE, 0x3E, 0x01, 0xFF,
  0x83, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x7E, 0x7E, 0xFE, 0xFF, 0xFF, 0x7E, 0x7E, 0x10, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x7E, 0xFE, 0xFF, 0xFF, 0xFE, 0x7E, 0x3C, 0x1F, 0x1F,
  0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0x7E, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xC7, 0xE7, 0xE3, 0xF1, 0xF8, 0xF8, 0x7C, 0x7E, 0x3E,
  0x1F, 0x0F, 0x07, 0x87, 0xC3, 0xC1, 0xE0, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x1F, 0xFF, 0x81, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0x8F, 0x80, 0x3F, 0x98, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC1, 0xF0, 0x01, 0xFF, 0xF8, 0x07,
  0x83, 0xC0, 0x0F, 0xFF, 0xF8, 0x0F, 0x8F, 0x80, 0x3F, 0xFF, 0xF0, 0x0F,
  0x1E, 0x00, 0xFE, 0x03, 0xE0, 0x1E, 0x3C, 0x03, 0xF0, 0x07, 0xC0, 0x3C,
  0xF8, 0x07, 0xC0, 0x0F, 0x80, 0x79, 0xF0, 0x1F, 0x00, 0x1E, 0x00, 0xFB,
  0xC0, 0x3E, 0x00, 0x3C, 0x01, 0xF7, 0x80, 0x78, 0x00, 0x78, 0x03, 0xEF,
  0x01, 0xF0, 0x00, 0xF0, 0x07, 0xDE, 0x03, 0xE0, 0x01, 0xE0, 0x0F, 0xFC,
  0x07, 0xC0, 0x03, 0xC0, 0x1E, 0xF8, 0x0F, 0x80, 0x07, 0x80, 0x3D, 0xF0,
  0x1F, 0x00, 0x1F, 0x00, 0x7B, 0xE0, 0x3E, 0x00, 0x3E, 0x00, 0xF7, 0xC0,
  0x7C, 0x00, 0x7C, 0x03, 0xE7, 0x80, 0x78, 0x00, 0xF8, 0x07, 0x8F, 0x00,
  0xF8, 0x03, 0xF0, 0x1F, 0x1E, 0x01, 0xF8, 0x0F, 0xF0, 0x3C, 0x3C, 0x01,
  0xF8, 0x3D, 0xF1, 0xF8, 0x7C, 0x01, 0xFF, 0xF9, 0xFF, 0xE0, 0xF8, 0x01,
  0xFF, 0xE1, 0xFF, 0x80, 0xF0, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xF0, 0x00,
  0x20, 0x00, 0x60, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x3D, 0xF0, 0x00, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x00,
  0x07, 0xCF, 0x80, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0xF8,
  0x00, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0x00,
  0x7C, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0xF8,
  0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0xF8,
  0x03, 0xE0, 0x00, 0x03, 0xF0, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x7E, 0x00,
  0x00, 0x1F, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x00, 0x0F, 0xC7, 0xE0, 0x00,
  0x00, 0x1F, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00, 0x00, 0xFB,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x0F, 0x80, 0x7F, 0xFC, 0x7C,
  0x00, 0x0F, 0xF3, 0xE0, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0xFC, 0xF8, 0x00,
  0x03, 0xF7, 0xC0, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x07,
  0xEF, 0x80, 0x00, 0x3F, 0x7C, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x1F, 0x9F,
  0x00, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0xC7, 0xC0, 0x07, 0xFC, 0x3F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xC3, 0xE0, 0x01, 0xFF, 0x1F, 0x00, 0x01, 0xFC, 0xF8, 0x00, 0x07, 0xF7,
  0xC0, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFD,
  0xF0, 0x00, 0x0F, 0xEF, 0x80, 0x00, 0xFE, 0x7C, 0x01, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xC0,
  0x1F, 0x81, 0xFE, 0x00, 0x07, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x81, 0xFF, 0xC0, 0x3F, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0x80, 0x7F,
  0xFE, 0x07, 0xC0, 0x00, 0xFF, 0x83, 0xE0, 0x00, 0x1F, 0xE1, 0xF0, 0x00,
  0x03, 0xF8, 0xF8, 0x00, 0x00, 0xFE, 0x7C, 0x00, 0x00, 0x3F, 0x3E, 0x00,
  0x00, 0x1F, 0xDF, 0x00, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x03, 0xF7, 0xC0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x00,
  0xFD, 0xF0, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x00, 0xFE, 0x7C, 0x00, 0x00,
  0xFE, 0x3E, 0x00, 0x00, 0xFF, 0x1F, 0x00, 0x01, 0xFF, 0x0F, 0x80, 0x03,
  0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xBE, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07,
  0xFE, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x00, 0xC0, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F,
  0xDF, 0x80, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00,
  0x07, 0xE7, 0xE0, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x00, 0x1F, 0x8F, 0xE0,
  0x00, 0x03, 0xF0, 0xFE, 0x00, 0x00, 0x7E, 0x0F, 0xF0, 0x00, 0x0F, 0xC1,
  0xFF, 0xC0, 0x07, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xF8, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x3F, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E,
  0x00, 0xFE, 0xF7, 0xFC, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xE0, 0x7F, 0x80,
  0xF8, 0x00, 0x01, 0xFD, 0xF0, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x1F, 0xC7,
  0xC0, 0x00, 0x7F, 0x0F, 0x80, 0x00, 0xFC, 0x1F, 0x00, 0x03, 0xF0, 0x3E,
  0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0xFC, 0x01, 0xF0,
  0x03, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x07, 0xC0, 0x3F, 0x00, 0x0F, 0x80,
  0xFC, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x7C, 0x1F,
  0x80, 0x00, 0xF8, 0x7E, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x03, 0xE7, 0xE0,
  0x00, 0x07, 0xDF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x3F, 0xEF, 0xC0, 0x00, 0x7F, 0x8F, 0xC0, 0x00, 0xFC, 0x1F, 0xC0,
  0x01, 0xF0, 0x1F, 0x80, 0x03, 0xE0, 0x1F, 0x80, 0x07, 0xC0, 0x1F, 0x80,
  0x0F, 0x80, 0x3F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3F, 0x00,
  0x7C, 0x00, 0x7F, 0x00, 0xF8, 0x00, 0x7F, 0x01, 0xF0, 0x00, 0x7E, 0x03,
  0xE0, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0xFE, 0x0F, 0x80, 0x00, 0xFE, 0x1F,
  0x00, 0x00, 0xFC, 0x3E, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0x01, 0xFC, 0xF8,
  0x00, 0x01, 0xF9, 0xF0, 0x00, 0x01, 0xFC, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFD, 0xF0,
  0x00, 0x00, 0x3F, 0xFF, 0x7C, 0x00, 0x00, 0x1F, 0x7F, 0xDF, 0x00, 0x00,
  0x07, 0xDF, 0xF3, 0xE0, 0x00, 0x01, 0xE7, 0xFC, 0xF8, 0x00, 0x00, 0xF9,
  0xFF, 0xBF, 0x00, 0x00, 0x3E, 0x7F, 0xE7, 0xC0, 0x00, 0x0F, 0x1F, 0xF9,
  0xF0, 0x00, 0x07, 0xC7, 0xFE, 0x3E, 0x00, 0x01, 0xF1, 0xFF, 0x8F, 0x80,
  0x00, 0xF8, 0x7F, 0xE3, 0xE0, 0x00, 0x3E, 0x1F, 0xF8, 0x7C, 0x00, 0x0F,
  0x07, 0xFE, 0x1F, 0x00, 0x07, 0xC1, 0xFF, 0x87, 0xE0, 0x01, 0xF0, 0x7F,
  0xE0, 0xF8, 0x00, 0xF8, 0x1F, 0xF8, 0x3E, 0x00, 0x3E, 0x07, 0xFE, 0x07,
  0xC0, 0x0F, 0x01, 0xFF, 0x81, 0xF0, 0x07, 0xC0, 0x7F, 0xE0, 0x7C, 0x01,
  0xF0, 0x1F, 0xF8, 0x0F, 0x80, 0x78, 0x07, 0xFE, 0x03, 0xE0, 0x3E, 0x01,
  0xFF, 0x80, 0xFC, 0x0F, 0x80, 0x7F, 0xE0, 0x1F, 0x07, 0xC0, 0x1F, 0xF8,
  0x07, 0xC1, 0xF0, 0x07, 0xFE, 0x00, 0xF8, 0x78, 0x01, 0xFF, 0x80, 0x3E,
  0x3E, 0x00, 0x7F, 0xE0, 0x0F, 0x8F, 0x80, 0x1F, 0xF8, 0x01, 0xF7, 0xC0,
  0x07, 0xFE, 0x00, 0x7D, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x7F,
  0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x1F, 0xC0, 0x01, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xEF, 0xC0, 0x00, 0x1F, 0xF7, 0xE0,
  0x00, 0x0F, 0xF9, 0xF8, 0x00, 0x07, 0xFC, 0x7E, 0x00, 0x03, 0xFE, 0x3F,
  0x00, 0x01, 0xFF, 0x0F, 0xC0, 0x00, 0xFF, 0x83, 0xF0, 0x00, 0x7F, 0xE1,
  0xF8, 0x00, 0x3F, 0xF0, 0x7E, 0x00, 0x1F, 0xF8, 0x3F, 0x80, 0x0F, 0xFC,
  0x0F, 0xC0, 0x07, 0xFE, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFC, 0x01, 0xFF,
  0x80, 0x7E, 0x00, 0xFF, 0xC0, 0x1F, 0x80, 0x7F, 0xE0, 0x0F, 0xC0, 0x3F,
  0xF0, 0x03, 0xF0, 0x1F, 0xF8, 0x00, 0xFC, 0x0F, 0xFC, 0x00, 0x7E, 0x07,
  0xFE, 0x00, 0x1F, 0x83, 0xFF, 0x00, 0x07, 0xE1, 0xFF, 0x80, 0x03, 0xF0,
  0xFF, 0xC0, 0x00, 0xFC, 0x7F, 0xE0, 0x00, 0x3F, 0x3F, 0xF0, 0x00, 0x1F,
  0x9F, 0xF8, 0x00, 0x07, 0xEF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0xFD, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x00, 0x3F, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x00,
  0x03, 0xEF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x00, 0x0F, 0x9F, 0x80,
  0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x0F,
  0xC3, 0xF8, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x1F, 0xE0,
  0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x2C, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0x0F, 0x80, 0xFF, 0xF1, 0xF0, 0x00, 0xFF, 0x3E, 0x00, 0x07, 0xF7,
  0xC0, 0x00, 0x7E, 0xF8, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0xFB, 0xE0, 0x00,
  0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xDF, 0x00, 0x01,
  0xFB, 0xE0, 0x00, 0x7E, 0x7C, 0x00, 0x1F, 0xCF, 0x80, 0x1F, 0xF1, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFD, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xF0,
  0x03, 0xFE, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x0F, 0xC3, 0xF0, 0x00,
  0x00, 0x3F, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x01, 0xF9,
  0xF0, 0x00, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x00,
  0x0F, 0x9F, 0x80, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0xFC,
  0x00, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x01,
  0xF8, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x7F,
  0xE0, 0x1F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x2F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xC0, 0xF8, 0x0F, 0xFF, 0x83, 0xE0, 0x01, 0xFE, 0x0F, 0x80, 0x01, 0xFC,
  0x3E, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1F, 0x8F,
  0x80, 0x00, 0x7E, 0x3E, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x07, 0xE3, 0xE0,
  0x00, 0x1F, 0x8F, 0x80, 0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF0, 0xF8, 0x00,
  0x0F, 0xC3, 0xE0, 0x00, 0x7E, 0x0F, 0x80, 0x03, 0xF8, 0x3E, 0x00, 0x3F,
  0xC0, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xE0, 0x0F, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0xFC, 0x03, 0xE0,
  0x03, 0xF0, 0x0F, 0x80, 0x07, 0xE0, 0x3E, 0x00, 0x1F, 0x80, 0xF8, 0x00,
  0x3F, 0x03, 0xE0, 0x00, 0x7E, 0x0F, 0x80, 0x01, 0xF8, 0x3E, 0x00, 0x03,
  0xF0, 0xF8, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0x3F,
  0x3E, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x7F, 0x80, 0x3F, 0x0F, 0xC0, 0x00, 0xC3,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFD, 0xC0, 0x00, 0x7F, 0x3F, 0x80, 0x3F, 0xE7,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0x3E,
  0x7E, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x1F,
  0x87, 0xF0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0xC0, 0x3F,
  0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x00, 0x1F, 0x3F,
  0x00, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x1F,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00,
  0x1F, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x00, 0xFC, 0x07, 0xE0,
  0x00, 0x1F, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x0F, 0x80, 0x00, 0xFC, 0x01,
  0xF8, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x07, 0xE0, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0x01, 0xF0, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0xF8, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x7C, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0xF8, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0x1F, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0xF8, 0x00, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0x07, 0xC7,
  0xC0, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x01,
  0xF7, 0xC0, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7C, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x3F,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0x87, 0xC0, 0x00, 0xFB, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0xDF, 0x00,
  0x07, 0xE1, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3F, 0x07, 0xC0, 0x03, 0xE7,
  0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x1E, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0xF8, 0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0x87, 0xC0, 0x07, 0xC0, 0x3E,
  0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x01, 0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xF0,
  0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x3E, 0x00,
  0xF8, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x0F, 0x80, 0x7C, 0x07,
  0xC0, 0x3E, 0x00, 0x7E, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x03, 0xF0, 0x3E,
  0x01, 0xF8, 0x1F, 0x00, 0x0F, 0x81, 0xF0, 0x07, 0xC0, 0xF8, 0x00, 0x7C,
  0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x03, 0xF0, 0xF8, 0x01, 0xF0, 0x7E, 0x00,
  0x1F, 0x87, 0xC0, 0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x1F,
  0x00, 0x03, 0xE3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x9F, 0x00, 0x07,
  0xCF, 0x80, 0x00, 0x7C, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xE7, 0xC0,
  0x01, 0xF3, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0xFB,
  0xE0, 0x00, 0x3D, 0xF0, 0x00, 0x03, 0xDF, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00,
  0x07, 0xC1, 0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x0F, 0xC0,
  0x00, 0x7C, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x0F,
  0xC0, 0x07, 0xC0, 0x01, 0xF0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0xF8, 0x00,
  0x0F, 0xC0, 0x7C, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x00, 0x7E, 0x0F, 0x80,
  0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x00, 0x7E, 0xF8,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x1F, 0xBE, 0x00, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x03, 0xE1, 0xF0, 0x00,
  0x01, 0xF8, 0x7E, 0x00, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x3F, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x7E, 0x00, 0x07, 0xC0, 0x0F, 0xC0, 0x03, 0xF0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x3F, 0x00,
  0x03, 0xF0, 0x0F, 0x80, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x0F, 0x83, 0xF0,
  0x00, 0x03, 0xF0, 0xF8, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x1F, 0xBF,
  0x00, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x0F,
  0xDF, 0x80, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x01,
  0xF0, 0x07, 0xC0, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x7E, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x7E,
  0x1F, 0x00, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x03,
  0xEF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xDE, 0x00, 0x00,
  0x1E, 0x7C, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0x78, 0x0F, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x0F, 0x80,
  0x78, 0x00, 0x3C, 0x01, 0xE0, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x3E, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x78, 0x07, 0xC0, 0x00, 0xF0,
  0x1E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x1F, 0x0F,
  0x00, 0x00, 0x3C, 0x7C, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x01, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1E,
  0x00, 0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xE0, 0xFC, 0x07, 0xF0, 0x70, 0x01, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x9F, 0xE0, 0x07, 0xDF, 0xC0,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFF,
  0x00, 0x1F, 0xFF, 0xC0, 0x3F, 0xF7, 0xFF, 0xFF, 0x79, 0xFF, 0xFF, 0x3C,
  0x7F, 0xFE, 0x1E, 0x1F, 0xFE, 0x0F, 0x00, 0x60, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x81, 0xFE, 0x00, 0xF8,
  0xFF, 0xFC, 0x0F, 0x9F, 0xFF, 0xE0, 0xFB, 0xFF, 0xFF, 0x0F, 0xFE, 0x07,
  0xF8, 0xFF, 0x80, 0x1F, 0xCF, 0xF0, 0x00, 0xFC, 0xFE, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3E, 0xFC, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x7E, 0xFE,
  0x00, 0x0F, 0xCF, 0xF0, 0x01, 0xFC, 0xFF, 0xC0, 0x3F, 0x8F, 0xBF, 0xFF,
  0xF0, 0xF1, 0xFF, 0xFE, 0x0F, 0x0F, 0xFF, 0xC0, 0xF0, 0x7F, 0xF0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF0, 0xFF, 0x8F, 0xC3, 0xF8, 0x00, 0x8F, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x08, 0xFF, 0x00, 0xF0,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x3F, 0xFC, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x07, 0xFC, 0x1F, 0x01, 0xFF, 0xF1, 0xF0, 0x7F, 0xFF, 0x9F, 0x0F, 0xFF,
  0xFD, 0xF1, 0xFE, 0x07, 0xFF, 0x1F, 0x80, 0x1F, 0xF3, 0xF0, 0x00, 0x7F,
  0x3F, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xF7, 0xC0,
  0x00, 0x3F, 0x7C, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xF7, 0xC0, 0x00,
  0x1F, 0x7C, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xF7,
  0xE0, 0x00, 0x3F, 0x3F, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0xFF, 0x1F, 0xC0,
  0x1F, 0xF0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0xF0, 0x3F, 0xFF, 0x0F,
  0x00, 0xFF, 0xE0, 0xF0, 0x00, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0xFE, 0x07, 0xF0,
  0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF1, 0xF0, 0x00, 0x3E, 0x3E, 0x00,
  0x07, 0xCF, 0x80, 0x00, 0xFD, 0xF0, 0x00, 0x0F, 0xBE, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x01, 0x07, 0xF8, 0x03, 0xE0, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFC,
  0x18, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0xFF, 0x87, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0xF0, 0x1F, 0xFF, 0x0F, 0x07, 0xFF,
  0xF8, 0xF0, 0xFF, 0xFF, 0xCF, 0x1F, 0xF0, 0x7F, 0xF1, 0xFC, 0x01, 0xFF,
  0x3F, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x7F, 0x7E, 0x00, 0x03, 0xF7, 0xE0,
  0x00, 0x3F, 0x7C, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x1F, 0x7C, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x01, 0xF7,
  0xE0, 0x00, 0x3F, 0x3E, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x7F, 0x3F, 0x80,
  0x0F, 0xF1, 0xFC, 0x01, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xDF,
  0x03, 0xFF, 0xF1, 0xF0, 0x0F, 0xFE, 0x1F, 0x00, 0x0C, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE2, 0x00, 0x00, 0x7E, 0x18,
  0x00, 0x0F, 0xE1, 0xFC, 0x07, 0xFC, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x3F, 0xE0, 0x3E, 0x1F, 0xFF, 0x07, 0xCF,
  0xFF, 0xF8, 0xFB, 0xFF, 0xFF, 0x9F, 0xFC, 0x0F, 0xF3, 0xFE, 0x00, 0x7F,
  0x7F, 0x80, 0x07, 0xEF, 0xE0, 0x00, 0x7D, 0xF8, 0x00, 0x0F, 0xBF, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x3E, 0xFB, 0xEF, 0xFF, 0xF9, 0xC0, 0x00, 0x00, 0x00,
  0x3E, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF,
  0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF,
  0x80, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x83, 0xF3, 0xFF, 0xCF,
  0xFE, 0x3F, 0xF0, 0xFF, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x07, 0xEF, 0x80, 0x03, 0xF3, 0xE0, 0x01, 0xF8, 0xF8, 0x00, 0xFC,
  0x3E, 0x00, 0x7E, 0x0F, 0x80, 0x3F, 0x03, 0xE0, 0x1F, 0x80, 0xF8, 0x0F,
  0xC0, 0x3E, 0x07, 0xE0, 0x0F, 0x83, 0xF0, 0x03, 0xE1, 0xFC, 0x00, 0xF8,
  0x7E, 0x00, 0x3E, 0x3F, 0x00, 0x0F, 0x9F, 0x80, 0x03, 0xEF, 0xE0, 0x00,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xF7, 0xE0, 0x03, 0xF8, 0xFC,
  0x00, 0xFC, 0x3F, 0x80, 0x3E, 0x07, 0xE0, 0x0F, 0x80, 0xFC, 0x03, 0xE0,
  0x1F, 0x80, 0xF8, 0x07, 0xF0, 0x3E, 0x00, 0xFC, 0x0F, 0x80, 0x1F, 0x83,
  0xE0, 0x03, 0xF0, 0xF8, 0x00, 0xFE, 0x3E, 0x00, 0x1F, 0x8F, 0x80, 0x03,
  0xF3, 0xE0, 0x00, 0x7E, 0xF8, 0x00, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xF0, 0x3F, 0xE0, 0x03, 0xFF, 0x07, 0x87, 0xFF, 0xC0, 0x7F, 0xFE,
  0x3E, 0x7F, 0xFF, 0x87, 0xFF, 0xF9, 0xF7, 0xFF, 0xFC, 0x7F, 0xFF, 0xEF,
  0xFE, 0x0F, 0xF7, 0xE0, 0xFF, 0x7F, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xFC,
  0x00, 0x7F, 0xC0, 0x07, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1E, 0x0F, 0xFF, 0x83, 0xE7, 0xFF, 0xFC, 0x7D,
  0xFF, 0xFF, 0xCF, 0xFE, 0x07, 0xF9, 0xFF, 0x00, 0x3F, 0xBF, 0xC0, 0x03,
  0xF7, 0xF0, 0x00, 0x3E, 0xFC, 0x00, 0x07, 0xDF, 0x80, 0x00, 0xFF, 0xF0,
  0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x00, 0x3F, 0x83,
  0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0xFC, 0x7E, 0x00, 0x01, 0xF1, 0xF8,
  0x00, 0x07, 0xE7, 0xC0, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0x3E, 0xFC, 0x00,
  0x00, 0xFB, 0xF0, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x0F, 0xBF, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x0F,
  0xBF, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x07, 0xE7,
  0xE0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x7C, 0x3E, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x0F, 0x81, 0xF8, 0x00, 0x7E, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x03, 0x00, 0x00, 0xF0, 0x3F, 0xF0, 0x0F, 0x0F, 0xFF, 0xC0,
  0xF9, 0xFF, 0xFE, 0x0F, 0xBF, 0xFF, 0xF0, 0xFF, 0xE0, 0x7F, 0x8F, 0xF8,
  0x01, 0xFC, 0xFF, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0x3E, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xEF, 0xC0, 0x00, 0x7E, 0xFE, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0xFC,
  0xFF, 0x00, 0x1F, 0xCF, 0xFC, 0x03, 0xF8, 0xFB, 0xFF, 0xFF, 0x0F, 0x9F,
  0xFF, 0xF0, 0xF8, 0xFF, 0xFC, 0x0F, 0x83, 0xFF, 0x80, 0xF8, 0x03, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0xF0, 0x1F, 0xFF, 0x0F, 0x07, 0xFF, 0xF8, 0xF0, 0xFF, 0xFF, 0xCF,
  0x1F, 0xE0, 0x7F, 0xF1, 0xF8, 0x01, 0xFF, 0x3F, 0x00, 0x07, 0xF3, 0xF0,
  0x00, 0x7F, 0x7E, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0x7C, 0x00, 0x03,
  0xF7, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x01, 0xF7,
  0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0x7E, 0x00,
  0x03, 0xF3, 0xF0, 0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xF1, 0xFC, 0x01, 0xFF,
  0x0F, 0xFF, 0xFD, 0xF0, 0x7F, 0xFF, 0xDF, 0x03, 0xFF, 0xF1, 0xF0, 0x0F,
  0xFE, 0x1F, 0x00, 0x0C, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0xF0, 0x1F, 0xFC, 0x1F, 0xFF, 0x0F, 0xFF, 0xE7, 0xFF,
  0xFB, 0xFF, 0xFF, 0xF0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF1,
  0xFF, 0xFF, 0xC7, 0xF0, 0x1F, 0x9F, 0x80, 0x02, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0xFA, 0x00, 0x01, 0xF7, 0x80, 0x0F, 0xEF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x00,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x1F, 0xF8, 0x00,
  0x38, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x07, 0xFF, 0xE0, 0x03, 0xFD, 0xFC, 0x03, 0xFF, 0x7F, 0xFF, 0xFB, 0xCF,
  0xFF, 0xFC, 0xF1, 0xFF, 0xFE, 0x3C, 0x1F, 0xFE, 0x0F, 0x00, 0x38, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x0F,
  0x9F, 0x80, 0x00, 0x7E, 0x3E, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x07, 0xC3,
  0xF0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0xF8, 0x1F, 0x00, 0x07, 0xE0, 0x7E,
  0x00, 0x1F, 0x80, 0xF8, 0x00, 0x7C, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0xF8, 0x07,
  0xC0, 0x03, 0xE0, 0x1F, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x1F, 0x03, 0xE0,
  0x00, 0x7C, 0x0F, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x03, 0xE1, 0xF0, 0x00,
  0x0F, 0x8F, 0xC0, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00,
  0xF3, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xBF, 0x00, 0x07, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xE7,
  0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x3E, 0x00, 0x1F, 0xF0, 0x01, 0xF1, 0xF8,
  0x01, 0xFF, 0x80, 0x0F, 0x87, 0xC0, 0x0F, 0xBC, 0x00, 0x7C, 0x3E, 0x00,
  0x79, 0xF0, 0x07, 0xC1, 0xF0, 0x03, 0xCF, 0x80, 0x3E, 0x0F, 0xC0, 0x3E,
  0x7C, 0x01, 0xF0, 0x3E, 0x01, 0xF1, 0xE0, 0x1F, 0x81, 0xF0, 0x0F, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xC0, 0x3E, 0x07, 0xC1, 0xE0,
  0x3E, 0x01, 0xF0, 0x3C, 0x0F, 0x83, 0xF0, 0x0F, 0x83, 0xE0, 0x7C, 0x1F,
  0x00, 0x7C, 0x1F, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0xF8, 0x0F, 0x87, 0xC0,
  0x0F, 0x8F, 0x80, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x03, 0xE3, 0xE0, 0x03,
  0xE3, 0xE0, 0x0F, 0x1F, 0x00, 0x0F, 0x9E, 0x00, 0x7C, 0xF8, 0x00, 0x7D,
  0xF0, 0x03, 0xEF, 0x80, 0x03, 0xEF, 0x80, 0x0F, 0x7C, 0x00, 0x0F, 0x78,
  0x00, 0x7B, 0xE0, 0x00, 0x7B, 0xC0, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xF8,
  0x3F, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x7C, 0x00, 0x7C, 0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xC3,
  0xE0, 0x00, 0x3E, 0x3E, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0xFC, 0x7E, 0x00, 0x07, 0xC1, 0xF0,
  0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0x3F, 0x00, 0x3E, 0x00, 0xFC, 0x03,
  0xF0, 0x07, 0xE0, 0x3F, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x7E, 0x1F, 0x80,
  0x01, 0xF1, 0xF8, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0xFD, 0xF0, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x7E,
  0x3E, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3F, 0x07,
  0xC0, 0x00, 0xF8, 0x1F, 0x80, 0x03, 0xE0, 0x3E, 0x00, 0x1F, 0x80, 0xF8,
  0x00, 0x7C, 0x01, 0xF0, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3E, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0xF8, 0x07, 0xC0, 0x01, 0xF0, 0x1F,
  0x00, 0x07, 0xC0, 0xFC, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x3E, 0x0F, 0x80,
  0x00, 0xF8, 0x7C, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x07, 0xC7, 0xC0, 0x00,
  0x1F, 0x3E, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03,
  0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xF0, 0x03, 0xF8,
  0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xC0, 0x03, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x00, 0x1F, 0x80, 0x03,
  0xFC, 0x00, 0x7F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x3F, 0x80, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x03, 0xFC, 0x00, 0x1F, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x00, 0x1F, 0xC0, 0x03, 0xFE,
  0x00, 0x7F, 0xE0, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x07, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0xFC, 0x00, 0xFF, 0x80, 0x3F,
  0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x07, 0xF8, 0x07, 0xFE, 0x00,
  0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x13,
  0xFF, 0x80, 0x03, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0xC0, 0x03, 0xFF, 0xC8, 0x00, 0x07, 0xF0,
};

const GFXglyph NotoSans_Regular59pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 8, 43, 16, 4, -42 },
  { 44, 16, 15, 24, 4, -42 },
  { 74, 36, 42, 38, 1, -42 },
  { 263, 26, 48, 34, 4, -45 },
  { 419, 43, 44, 49, 3, -43 },
  { 656, 40, 44, 43, 3, -43 },
  { 876, 5, 15, 13, 4, -42 },
  { 886, 14, 51, 18, 2, -42 },
  { 976, 13, 51, 18, 2, -42 },
  { 1059, 28, 27, 33, 2, -45 },
  { 1154, 28, 28, 34, 3, -35 },
  { 1252, 9, 15, 16, 2, -7 },
  { 1269, 15, 4, 19, 2, -18 },
  { 1277, 8, 8, 16, 4, -7 },
  { 1285, 20, 42, 22, 1, -42 },
  { 1390, 28, 44, 34, 3, -43 },
  { 1544, 16, 42, 34, 5, -42 },
  { 1628, 28, 43, 34, 3, -43 },
  { 1779, 27, 44, 34, 3, -43 },
  { 1928, 32, 42, 34, 1, -42 },
  { 2096, 26, 43, 34, 4, -42 },
  { 2236, 28, 44, 34, 3, -43 },
  { 2390, 28, 42, 34, 3, -42 },
  { 2537, 28, 44, 34, 3, -43 },
  { 2691, 28, 44, 34, 3, -43 },
  { 2845, 8, 33, 16, 4, -32 },
  { 2878, 9, 40, 16, 2, -32 },
  { 2923, 28, 29, 34, 3, -36 },
  { 3025, 27, 16, 34, 3, -29 },
  { 3079, 28, 29, 34, 3, -36 },
  { 3181, 23, 44, 26, 1, -43 },
  { 3308, 47, 47, 53, 3, -42 },
  { 3585, 38, 42, 38, 0, -42 },
  { 3785, 29, 42, 38, 6, -42 },
  { 3938, 31, 44, 37, 4, -43 },
  { 4109, 33, 42, 43, 6, -42 },
  { 4283, 23, 42, 33, 6, -42 },
  { 4404, 23, 42, 31, 6, -42 },
  { 4525, 35, 44, 43, 4, -43 },
  { 4718, 32, 42, 44, 6, -42 },
  { 4886, 16, 42, 20, 2, -42 },
  { 4970, 16, 53, 16, -5, -42 },
  { 5076, 31, 42, 37, 6, -42 },
  { 5239, 23, 42, 31, 6, -42 },
  { 5360, 42, 42, 54, 6, -42 },
  { 5581, 33, 42, 45, 6, -42 },
  { 5755, 38, 44, 46, 4, -43 },
  { 5964, 27, 42, 36, 6, -42 },
  { 6106, 38, 53, 46, 4, -43 },
  { 6358, 30, 42, 37, 6, -42 },
  { 6516, 27, 44, 32, 3, -43 },
  { 6665, 31, 42, 33, 1, -42 },
  { 6828, 33, 43, 43, 5, -42 },
  { 7006, 35, 42, 35, 0, -42 },
  { 7190, 53, 42, 55, 1, -42 },
  { 7469, 34, 42, 35, 0, -42 },
  { 7648, 33, 42, 33, 0, -42 },
  { 7822, 29, 42, 34, 2, -42 },
  { 7975, 13, 51, 19, 5, -42 },
  { 8058, 20, 42, 22, 1, -42 },
  { 8163, 14, 51, 19, 1, -42 },
  { 8253, 30, 26, 34, 2, -42 },
  { 8351, 26, 4, 26, 0, 5 },
  { 8364, 12, 9, 17, 2, -45 },
  { 8378, 25, 33, 33, 3, -32 },
  { 8482, 28, 46, 36, 5, -45 },
  { 8643, 23, 33, 28, 3, -32 },
  { 8738, 28, 46, 36, 3, -45 },
  { 8899, 27, 33, 33, 3, -32 },
  { 9011, 22, 45, 20, 1, -45 },
  { 9135, 28, 46, 36, 3, -32 },
  { 9296, 27, 45, 36, 5, -45 },
  { 9448, 6, 43, 15, 5, -43 },
  { 9481, 14, 57, 15, -3, -43 },
  { 9581, 26, 45, 32, 5, -45 },
  { 9728, 5, 45, 15, 5, -45 },
  { 9757, 45, 32, 55, 5, -32 },
  { 9937, 27, 32, 36, 5, -32 },
  { 10045, 30, 33, 36, 3, -32 },
  { 10169, 28, 46, 36, 5, -32 },
  { 10330, 28, 46, 36, 3, -32 },
  { 10491, 18, 32, 24, 5, -32 },
  { 10563, 23, 33, 28, 3, -32 },
  { 10658, 19, 40, 21, 1, -39 },
  { 10753, 26, 33, 36, 5, -32 },
  { 10861, 30, 32, 30, 0, -32 },
  { 10981, 45, 32, 46, 1, -32 },
  { 11161, 29, 32, 31, 1, -32 },
  { 11277, 30, 46, 30, 0, -32 },
  { 11450, 23, 32, 28, 2, -32 },
  { 11542, 19, 51, 22, 2, -42 },
  { 11664, 4, 59, 33, 14, -45 },
  { 11694, 19, 51, 22, 2, -42 },
  { 11816, 28, 8, 34, 3, -25 },
};

const GFXfont NotoSans_Regular59pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Regular59pt7bBitmaps,
  (GFXglyph *)NotoSans_Regular59pt7bGlyphs,
  0x20, 0x7E, 80
};

#endif // _NOTOSANS_REGULAR59PT7B_H_
