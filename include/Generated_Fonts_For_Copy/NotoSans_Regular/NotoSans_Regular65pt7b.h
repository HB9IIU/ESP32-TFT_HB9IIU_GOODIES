#ifndef _NOTOSANS_REGULAR65PT7B_H_
#define _NOTOSANS_REGULAR65PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Regular.ttf
// Size: 65pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Regular65pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0xFE, 0xFE, 0xFE, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C,
  0x7C, 0x7C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0xFE, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0x3C,
  0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFD, 0xF0, 0x3F, 0x7C, 0x07, 0xDF,
  0x01, 0xF7, 0xC0, 0x7D, 0xF0, 0x1F, 0x7C, 0x07, 0xDF, 0x01, 0xF7, 0xC0,
  0x79, 0xE0, 0x1E, 0x78, 0x07, 0x9E, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x1E,
  0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0xF0, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x07, 0x80, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x01, 0xE0, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x78,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF0, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x78, 0x00, 0x00, 0x78, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xF9, 0xFE, 0x1F, 0xC3, 0xE0, 0x78,
  0x7E, 0x0F, 0x80, 0x23, 0xF0, 0x3E, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x3F,
  0x03, 0xE0, 0x00, 0xFC, 0x0F, 0x80, 0x03, 0xF0, 0x3E, 0x00, 0x0F, 0xC0,
  0xF8, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x7F, 0x0F, 0x80, 0x01, 0xFF, 0xBE,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3E, 0xFF, 0xC0, 0x00, 0xF8, 0x7F, 0x80,
  0x03, 0xE0, 0x7E, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x3E, 0x03, 0xE0, 0x00,
  0xF8, 0x0F, 0xC0, 0x03, 0xE0, 0x3F, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x3E,
  0x07, 0xE8, 0x00, 0xF8, 0x3F, 0xBC, 0x03, 0xE1, 0xFC, 0xFF, 0x8F, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x7C, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x3F, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x7C, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x78, 0x03,
  0xE0, 0x03, 0xE0, 0x00, 0x78, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0xF8, 0x03,
  0xE0, 0x07, 0xC0, 0x00, 0xF8, 0x01, 0xE0, 0x0F, 0x80, 0x00, 0xF8, 0x01,
  0xE0, 0x0F, 0x80, 0x00, 0xF8, 0x01, 0xE0, 0x1F, 0x00, 0x00, 0xF8, 0x01,
  0xE0, 0x1F, 0x00, 0x00, 0xF8, 0x01, 0xE0, 0x3E, 0x00, 0x00, 0xF8, 0x01,
  0xE0, 0x3E, 0x00, 0x00, 0xF8, 0x01, 0xE0, 0x7C, 0x00, 0x00, 0xF8, 0x03,
  0xE0, 0xF8, 0x00, 0x00, 0x78, 0x03, 0xE0, 0xF8, 0x3F, 0xC0, 0x78, 0x03,
  0xE1, 0xF0, 0xFF, 0xF0, 0x7C, 0x03, 0xE1, 0xF1, 0xFF, 0xF8, 0x7C, 0x07,
  0xC3, 0xE1, 0xFF, 0xF8, 0x3E, 0x07, 0xC3, 0xE3, 0xF0, 0x7C, 0x3F, 0x0F,
  0x87, 0xC3, 0xE0, 0x7C, 0x1F, 0xFF, 0x87, 0xC7, 0xC0, 0x3E, 0x0F, 0xFF,
  0x0F, 0x87, 0xC0, 0x3E, 0x07, 0xFE, 0x1F, 0x07, 0xC0, 0x1E, 0x03, 0xF8,
  0x1F, 0x07, 0xC0, 0x1E, 0x00, 0x00, 0x3E, 0x07, 0x80, 0x1F, 0x00, 0x00,
  0x3E, 0x07, 0x80, 0x1F, 0x00, 0x00, 0x7C, 0x07, 0x80, 0x1F, 0x00, 0x00,
  0x7C, 0x07, 0x80, 0x1F, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x1F, 0x00, 0x00,
  0xF8, 0x07, 0x80, 0x1F, 0x00, 0x01, 0xF0, 0x07, 0x80, 0x1F, 0x00, 0x03,
  0xE0, 0x07, 0x80, 0x1F, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x07,
  0xC0, 0x07, 0xC0, 0x1E, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xC0, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x3E, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x7C, 0x00, 0x1F, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x3E,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x7C,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC7, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x04, 0x03, 0xFF,
  0xF8, 0x00, 0x0F, 0x80, 0xFF, 0x9F, 0xC0, 0x01, 0xF8, 0x1F, 0xE0, 0xFE,
  0x00, 0x1F, 0x81, 0xFC, 0x07, 0xF0, 0x01, 0xF8, 0x3F, 0x80, 0x3F, 0x80,
  0x3F, 0x07, 0xF0, 0x01, 0xFC, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xF0, 0x3E,
  0x07, 0xE0, 0x00, 0x7F, 0x87, 0xE0, 0x7E, 0x00, 0x03, 0xFC, 0xFE, 0x0F,
  0xC0, 0x00, 0x1F, 0xEF, 0xC0, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x0F, 0xC0,
  0x00, 0x07, 0xFF, 0x80, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x07, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xF0, 0x07, 0xF0, 0x00, 0x07,
  0xFF, 0x80, 0x7F, 0x80, 0x00, 0xFF, 0xFC, 0x03, 0xFC, 0x00, 0x3F, 0xFF,
  0xE0, 0x1F, 0xFC, 0xFF, 0xFC, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x87, 0xF8,
  0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xC0, 0x3F, 0xFF, 0xF8, 0x01, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDE, 0x79, 0xE7, 0x9E, 0x00, 0xFE,
  0x01, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x07,
  0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF0,
  0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xC0,
  0x1F, 0x80, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x1E, 0x00, 0xEF, 0xE0, 0x78, 0x3F, 0xBF, 0xF9, 0xE7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xDF, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x07,
  0xE1, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xF0,
  0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x70, 0x03,
  0x80, 0x00, 0x40, 0x08, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x8F, 0xC7,
  0xE7, 0xF3, 0xF9, 0xF8, 0xFC, 0x7E, 0x7E, 0x3F, 0x1F, 0x0F, 0x87, 0xC7,
  0xC3, 0xE1, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3C, 0xFE, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0x3C, 0x00, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF0,
  0x01, 0xF8, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x7E, 0x00,
  0x03, 0xF0, 0xFC, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x07, 0xC7, 0xE0, 0x00,
  0x0F, 0xCF, 0xC0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x3F, 0x3E, 0x00, 0x00,
  0x3E, 0x7C, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x1F, 0xBE,
  0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x01, 0xF9, 0xF8,
  0x00, 0x03, 0xF1, 0xF0, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x0F, 0x87, 0xE0,
  0x00, 0x3F, 0x07, 0xC0, 0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0xC0,
  0x07, 0xF0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xE0, 0xFF, 0x80, 0x1F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0,
  0x3F, 0xF0, 0x3F, 0xF8, 0x3F, 0xFC, 0x7F, 0xBE, 0x7F, 0x9F, 0x7F, 0x8F,
  0xFF, 0x07, 0xDF, 0x07, 0xEF, 0x03, 0xF3, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFC, 0x0F, 0xF8, 0x03, 0xFC, 0x1F, 0xC0, 0x03, 0xFC, 0x1E, 0x00,
  0x03, 0xF8, 0x18, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xE1, 0xFE, 0x00, 0x7F, 0x87, 0xE0, 0x00, 0x7F,
  0x0E, 0x00, 0x00, 0xFC, 0x10, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7E, 0xC0, 0x00, 0x03, 0xFB, 0xC0, 0x00, 0x3F, 0xCF,
  0xF8, 0x07, 0xFF, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x00, 0xFD,
  0xF0, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x01,
  0xF8, 0xF8, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x0F, 0x83, 0xE0, 0x00,
  0x03, 0xF0, 0x7C, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x1F, 0x01, 0xF0,
  0x00, 0x07, 0xE0, 0x3E, 0x00, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0xF8, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x03, 0xF0, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x0F, 0xC0, 0x00, 0xF8,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x1F, 0x80, 0x00,
  0x7C, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0x07, 0xFF, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xD8, 0x00, 0x01,
  0xFC, 0xF0, 0x00, 0x1F, 0xE7, 0xFC, 0x0F, 0xFE, 0x3F, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x03,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0xFF, 0x80, 0x3F, 0x0F, 0xFF, 0xC0, 0xFC, 0xFF, 0xFF, 0x83, 0xE7, 0xFF,
  0xFF, 0x0F, 0xBF, 0xEF, 0xFE, 0x3F, 0xF8, 0x03, 0xFC, 0xFF, 0x80, 0x03,
  0xF3, 0xFC, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x0F, 0xDF, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0xFD, 0xF8, 0x00,
  0x03, 0xE3, 0xE0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x03,
  0xF0, 0x7F, 0x00, 0x3F, 0xC0, 0xFF, 0x83, 0xFE, 0x01, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xFC, 0x01,
  0xFE, 0x07, 0xE0, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x01,
  0xF8, 0x7C, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x07,
  0xC3, 0xE0, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x1F, 0xC0, 0x0F, 0xC0,
  0x3F, 0xC0, 0x7F, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x0F, 0xF9, 0xFF, 0x80, 0x3F, 0xC0, 0xFF, 0x80, 0xFE,
  0x00, 0x7F, 0x83, 0xF8, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x3F, 0x9F, 0x80,
  0x00, 0x3F, 0x3F, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x1F, 0x3F, 0x00, 0x00,
  0x7E, 0x7F, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x07, 0xF0, 0xFF, 0x80, 0x3F,
  0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x05, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x1F,
  0x80, 0x01, 0xF8, 0x7F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF1, 0xF8,
  0x00, 0x03, 0xE3, 0xE0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x0F, 0xDF, 0x80,
  0x00, 0x0F, 0xBF, 0x00, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x3E, 0xFC, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFB, 0xE0, 0x00,
  0x07, 0xF7, 0xE0, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x3F, 0xCF, 0xC0, 0x00,
  0xFF, 0x9F, 0xC0, 0x03, 0xFF, 0x1F, 0xE0, 0x1F, 0x7E, 0x3F, 0xFF, 0xFE,
  0xFC, 0x3F, 0xFF, 0xF9, 0xF0, 0x1F, 0xFF, 0xC3, 0xE0, 0x0F, 0xFF, 0x07,
  0xC0, 0x01, 0xE0, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x20, 0x0F, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x38, 0x7E, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0xFE, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFE, 0x3C, 0x07, 0x03, 0xF8, 0x7F, 0x0F, 0xF1, 0xFE, 0x3F, 0xC7,
  0xF0, 0xFE, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x3F, 0x87, 0xF0, 0xFC, 0x1F,
  0x87, 0xF0, 0xFC, 0x1F, 0x83, 0xF0, 0x7C, 0x1F, 0x83, 0xE0, 0x7C, 0x0F,
  0x83, 0xE0, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x1F, 0x80,
  0x3F, 0xC7, 0x80, 0x03, 0xF9, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0xFF, 0xF0, 0x1F, 0x0F,
  0xC0, 0x07, 0xFF, 0xFC, 0x01, 0xE1, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x3E,
  0x3E, 0x00, 0xFF, 0x87, 0xF0, 0x07, 0xCF, 0x80, 0x1F, 0x80, 0x3E, 0x00,
  0x79, 0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0x3E, 0x01, 0xF8, 0x00, 0xF8,
  0x01, 0xEF, 0x80, 0x3E, 0x00, 0x1F, 0x00, 0x3F, 0xF0, 0x07, 0xC0, 0x03,
  0xE0, 0x07, 0xFE, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0xFF, 0xC0, 0x3E, 0x00,
  0x0F, 0x80, 0x1F, 0xF8, 0x07, 0xC0, 0x01, 0xF0, 0x03, 0xFF, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x7F, 0xC0, 0x1F, 0x00, 0x07, 0xC0, 0x0F, 0x78, 0x03,
  0xE0, 0x00, 0xF8, 0x01, 0xEF, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x7D, 0xE0,
  0x0F, 0x80, 0x07, 0xE0, 0x0F, 0xBE, 0x01, 0xF0, 0x00, 0xFC, 0x01, 0xE7,
  0xC0, 0x3F, 0x00, 0x1F, 0x80, 0x7C, 0xF8, 0x03, 0xE0, 0x07, 0xF0, 0x0F,
  0x9F, 0x00, 0x7E, 0x01, 0xEF, 0x03, 0xE3, 0xE0, 0x07, 0xF0, 0xFD, 0xF0,
  0xF8, 0x3E, 0x00, 0xFF, 0xFF, 0x3F, 0xFF, 0x07, 0xC0, 0x0F, 0xFF, 0xC3,
  0xFF, 0xC0, 0xF8, 0x00, 0x7F, 0xF0, 0x3F, 0xE0, 0x0F, 0x80, 0x03, 0xF0,
  0x01, 0xF0, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x00, 0x01, 0xF7, 0xE0, 0x00,
  0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x00, 0x00,
  0x7C, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x81, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x03,
  0xE0, 0x00, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xFF, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x00, 0x07, 0xE7,
  0xE0, 0x00, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x7E, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x87,
  0xE0, 0x00, 0x3F, 0xE3, 0xF0, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x01, 0xFC,
  0xFC, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x1F,
  0x9F, 0x80, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x03,
  0xF3, 0xF0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00,
  0xFC, 0x7E, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x01, 0xFC, 0x1F, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0xFC, 0x00, 0x1F, 0xF8, 0x7E, 0x00,
  0x01, 0xFE, 0x3F, 0x00, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x0F, 0xEF, 0xC0,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xF7,
  0xE0, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x03, 0xFD, 0xF8, 0x00, 0x03, 0xFC,
  0xFC, 0x00, 0x07, 0xFC, 0x7F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0x80, 0x7F, 0x80, 0xFF, 0x80, 0x00, 0xE0, 0x3F, 0xC0, 0x00, 0x04,
  0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x70, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFA, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7E, 0x00, 0x03, 0xFF, 0x03, 0xF0,
  0x00, 0x07, 0xFC, 0x1F, 0x80, 0x00, 0x0F, 0xF0, 0xFC, 0x00, 0x00, 0x3F,
  0xC7, 0xE0, 0x00, 0x00, 0xFF, 0x3F, 0x00, 0x00, 0x03, 0xF9, 0xF8, 0x00,
  0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x01, 0xFB,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7E, 0xFC,
  0x00, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x03,
  0xF9, 0xF8, 0x00, 0x00, 0x3F, 0xCF, 0xC0, 0x00, 0x03, 0xFC, 0x7E, 0x00,
  0x00, 0x3F, 0xC3, 0xF0, 0x00, 0x03, 0xFC, 0x1F, 0x80, 0x00, 0x7F, 0xE0,
  0xFC, 0x00, 0x3F, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0xC0,
  0x00, 0x3C, 0x03, 0xFE, 0x00, 0x00, 0x08, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x00, 0x1F, 0xBF,
  0x00, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00,
  0x00, 0xFC, 0xFC, 0x00, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x00, 0x03, 0xF1,
  0xF8, 0x00, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x00, 0x0F, 0xC3, 0xF8, 0x00,
  0x00, 0x1F, 0x87, 0xF8, 0x00, 0x00, 0x3F, 0x07, 0xFC, 0x00, 0x00, 0x7E,
  0x07, 0xFE, 0x00, 0x00, 0xFC, 0x07, 0xFF, 0xF1, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFC, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0,
  0x0F, 0xE7, 0xFF, 0xF3, 0xFF, 0xF1, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0xE0,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xCF, 0xC0, 0x00,
  0x0F, 0xE3, 0xF0, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x03, 0xF8, 0x3F, 0x00,
  0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x3F, 0x00, 0x0F, 0xE0, 0x0F, 0xC0, 0x07, 0xF0, 0x03,
  0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0xFE, 0x00,
  0x0F, 0xC0, 0x7F, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x00, 0xFC, 0x0F, 0xC0,
  0x00, 0x3F, 0x07, 0xE0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x03, 0xF1, 0xF8,
  0x00, 0x00, 0xFC, 0xFF, 0x00, 0x00, 0x3F, 0x7F, 0xC0, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xDF, 0xE0, 0x00, 0x3F,
  0xE3, 0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00,
  0xFC, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x0F, 0xE0,
  0x03, 0xF0, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x0F,
  0xE0, 0x0F, 0xC0, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0xFC, 0x00,
  0x0F, 0xE0, 0x3F, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x83, 0xF0,
  0x00, 0x07, 0xF0, 0xFC, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x00, 0x3F, 0x8F,
  0xC0, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x00, 0x3F,
  0xBF, 0x00, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x7C, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0xFD, 0xF8, 0x00, 0x00, 0x0F, 0xBF, 0xF9, 0xF0,
  0x00, 0x00, 0x1F, 0x7F, 0xFB, 0xF0, 0x00, 0x00, 0x7E, 0xFF, 0xF7, 0xE0,
  0x00, 0x00, 0xF9, 0xFF, 0xE7, 0xC0, 0x00, 0x03, 0xF3, 0xFF, 0xCF, 0xC0,
  0x00, 0x07, 0xC7, 0xFF, 0x8F, 0x80, 0x00, 0x0F, 0x8F, 0xFF, 0x1F, 0x80,
  0x00, 0x3F, 0x1F, 0xFE, 0x3F, 0x00, 0x00, 0x7C, 0x3F, 0xFC, 0x3E, 0x00,
  0x00, 0xF8, 0x7F, 0xF8, 0x7E, 0x00, 0x03, 0xE0, 0xFF, 0xF0, 0xFC, 0x00,
  0x07, 0xC1, 0xFF, 0xE0, 0xF8, 0x00, 0x1F, 0x83, 0xFF, 0xC1, 0xF8, 0x00,
  0x3E, 0x07, 0xFF, 0x81, 0xF0, 0x00, 0x7C, 0x0F, 0xFF, 0x03, 0xF0, 0x01,
  0xF8, 0x1F, 0xFE, 0x07, 0xE0, 0x03, 0xE0, 0x3F, 0xFC, 0x07, 0xC0, 0x07,
  0xC0, 0x7F, 0xF8, 0x0F, 0xC0, 0x1F, 0x00, 0xFF, 0xF0, 0x1F, 0x80, 0x3E,
  0x01, 0xFF, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0x01, 0xF0,
  0x07, 0xFF, 0x80, 0x3E, 0x03, 0xE0, 0x0F, 0xFF, 0x00, 0x7E, 0x0F, 0xC0,
  0x1F, 0xFE, 0x00, 0xFC, 0x1F, 0x00, 0x3F, 0xFC, 0x00, 0xF8, 0x7E, 0x00,
  0x7F, 0xF8, 0x01, 0xF8, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xF1, 0xF0, 0x01,
  0xFF, 0xE0, 0x03, 0xE7, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xEF, 0x80, 0x07,
  0xFF, 0x80, 0x07, 0xDF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFF,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFB, 0xF8, 0x00, 0x00, 0xFF,
  0xCF, 0xC0, 0x00, 0x07, 0xFE, 0x7F, 0x00, 0x00, 0x3F, 0xF1, 0xFC, 0x00,
  0x01, 0xFF, 0x87, 0xE0, 0x00, 0x0F, 0xFE, 0x3F, 0x80, 0x00, 0x7F, 0xF0,
  0xFE, 0x00, 0x03, 0xFF, 0x83, 0xF0, 0x00, 0x1F, 0xFC, 0x1F, 0xC0, 0x00,
  0xFF, 0xE0, 0x7F, 0x00, 0x07, 0xFF, 0x01, 0xF8, 0x00, 0x3F, 0xF8, 0x0F,
  0xE0, 0x01, 0xFF, 0xC0, 0x3F, 0x80, 0x0F, 0xFE, 0x01, 0xFC, 0x00, 0x7F,
  0xF0, 0x07, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0x80, 0x1F, 0xFC, 0x00, 0xFE,
  0x00, 0xFF, 0xE0, 0x03, 0xF8, 0x07, 0xFF, 0x00, 0x0F, 0xC0, 0x3F, 0xF8,
  0x00, 0x7F, 0x01, 0xFF, 0xC0, 0x01, 0xFC, 0x0F, 0xFE, 0x00, 0x07, 0xE0,
  0x7F, 0xF0, 0x00, 0x3F, 0x83, 0xFF, 0x80, 0x00, 0xFE, 0x1F, 0xFC, 0x00,
  0x03, 0xF0, 0xFF, 0xE0, 0x00, 0x1F, 0xC7, 0xFF, 0x00, 0x00, 0x7F, 0x3F,
  0xF8, 0x00, 0x03, 0xF9, 0xFF, 0xC0, 0x00, 0x0F, 0xEF, 0xFE, 0x00, 0x00,
  0x3F, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x00,
  0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xF3,
  0xF0, 0x00, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xDF, 0xC0,
  0x00, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x00,
  0x03, 0xF3, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x00, 0x1F,
  0xCF, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x00, 0x07, 0xFF, 0xC7, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xE3, 0xF0, 0x00, 0x7F, 0xCF, 0xC0, 0x00, 0x7F, 0xBF,
  0x00, 0x00, 0xFE, 0xFC, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0xFE,
  0xFC, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x7F, 0xCF, 0xC0, 0x0F, 0xFE, 0x3F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x00, 0x01,
  0xFC, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xF3, 0xF0,
  0x00, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xDF, 0xC0, 0x00,
  0x00, 0x01, 0xFB, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0xFD, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x00, 0x03,
  0xF3, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xCF,
  0xE0, 0x00, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00,
  0x07, 0xFF, 0xC7, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xE0,
  0x00, 0xFF, 0x83, 0xF0, 0x00, 0x1F, 0xE1, 0xF8, 0x00, 0x07, 0xF0, 0xFC,
  0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0x3F, 0x1F,
  0x80, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x07, 0xE3,
  0xF0, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x01, 0xFC,
  0x7E, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0xFF, 0x07, 0xE0, 0x03, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x0F,
  0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0xFC, 0x01, 0xF8, 0x00,
  0x7F, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x0F, 0xE0, 0x3F, 0x00,
  0x03, 0xF0, 0x1F, 0x80, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x7F, 0x07, 0xE0,
  0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x01, 0xFC, 0x7E, 0x00, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0x1F, 0x9F,
  0x80, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xC0, 0x3F, 0x83, 0xFC,
  0x00, 0x0E, 0x0F, 0xC0, 0x00, 0x08, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0xC0, 0x00, 0x07, 0xF3, 0xE0, 0x00,
  0x7F, 0xCF, 0xFF, 0x3F, 0xFE, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x00,
  0x7E, 0xFC, 0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0x7E, 0x7E, 0x00,
  0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0x1F, 0xC3,
  0xFC, 0x00, 0x03, 0xF8, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0xFF, 0xF9, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x01, 0xF9, 0xF8, 0x00,
  0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x00, 0x1F,
  0x87, 0xE0, 0x00, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x00, 0x3F,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0xFC, 0x00,
  0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xF9,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xE1, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x07, 0xE0, 0x7E,
  0x00, 0x07, 0xCF, 0x80, 0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xF9, 0xF8, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x07,
  0xC3, 0xE0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0xF8, 0x7E, 0x00, 0x1F, 0x80,
  0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE0, 0x0F, 0xC0, 0x07, 0xE0, 0xF8,
  0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x1F, 0x00, 0x1F, 0x80, 0x1F, 0x80,
  0x3F, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x80, 0x07, 0xC0, 0x1F, 0x00,
  0xFC, 0x03, 0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x00, 0x1F,
  0x80, 0xFC, 0x01, 0xF0, 0x1F, 0x80, 0x03, 0xF0, 0x1F, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x3E, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x7C, 0x0F, 0x80, 0x00, 0xFC, 0x1F, 0x00, 0x0F, 0x83, 0xF0, 0x00,
  0x1F, 0x83, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x3F,
  0x0F, 0xC0, 0x00, 0x3F, 0x1F, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0x07, 0xE3,
  0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x0F, 0xCF, 0xC0,
  0x00, 0x0F, 0x9F, 0x80, 0x00, 0xF9, 0xF8, 0x00, 0x01, 0xFB, 0xE0, 0x00,
  0x1F, 0x3E, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x03,
  0xEF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00, 0x1F, 0x81, 0xFC,
  0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0xFE,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x03, 0xF0,
  0x00, 0x0F, 0xE0, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x7E, 0x00,
  0x00, 0x03, 0xF1, 0xF0, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xF3,
  0xF0, 0x00, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x00, 0x7E, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x0F, 0xE0, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x00,
  0x7F, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x03, 0xFB, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x00,
  0x3F, 0x8F, 0xC0, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x1F, 0xC1, 0xF8,
  0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x00, 0x7E,
  0x01, 0xFC, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x3F, 0x80,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x3F, 0x00, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x00, 0x3F, 0x1F, 0x80,
  0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x3E, 0x7C, 0x00,
  0x00, 0x1F, 0x1E, 0x00, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x0F, 0x83, 0xC0,
  0x00, 0x0F, 0x81, 0xF0, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x03, 0xC0, 0x3E,
  0x00, 0x03, 0xE0, 0x0F, 0x00, 0x01, 0xE0, 0x07, 0xC0, 0x01, 0xF0, 0x01,
  0xE0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x3E, 0x00, 0x03, 0xE0, 0x3E, 0x00,
  0x00, 0xF8, 0x1F, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x1F, 0x0F, 0x80,
  0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x01, 0xF7, 0xE0,
  0x00, 0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0x7E,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x1E,
  0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFC, 0x07, 0xF0, 0x3F, 0xE0, 0x78, 0x00, 0xFE, 0x04, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFC, 0x01, 0xF3, 0xFC, 0x00, 0x1F, 0x7F, 0x00,
  0x01, 0xF7, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xF7, 0xE0, 0x03, 0xFF, 0x7F, 0x80, 0xFD,
  0xF3, 0xFF, 0xFF, 0x9F, 0x3F, 0xFF, 0xF1, 0xF0, 0xFF, 0xFE, 0x0F, 0x07,
  0xFF, 0x80, 0xF0, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x81,
  0xFF, 0x80, 0x3E, 0x1F, 0xFF, 0x80, 0xF9, 0xFF, 0xFF, 0x83, 0xEF, 0xFF,
  0xFF, 0x0F, 0xFF, 0x87, 0xFE, 0x3F, 0xF0, 0x03, 0xFC, 0xFF, 0x00, 0x07,
  0xF3, 0xF8, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7E,
  0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7E,
  0xFE, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x7F, 0x3F,
  0xE0, 0x03, 0xFC, 0xFF, 0xF0, 0x3F, 0xE3, 0xEF, 0xFF, 0xFF, 0x0F, 0x1F,
  0xFF, 0xF8, 0x3C, 0x3F, 0xFF, 0xC0, 0xF0, 0x3F, 0xFC, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0x00, 0x38, 0xFE, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x08,
  0x7F, 0xF0, 0xFC, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0x80, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0,
  0x0F, 0xFE, 0x07, 0xC0, 0x7F, 0xFE, 0x1F, 0x07, 0xFF, 0xFE, 0x7C, 0x3F,
  0xFF, 0xFD, 0xF1, 0xFF, 0x87, 0xFF, 0xCF, 0xF0, 0x03, 0xFF, 0x3F, 0x80,
  0x03, 0xFD, 0xFC, 0x00, 0x0F, 0xF7, 0xE0, 0x00, 0x1F, 0xDF, 0x80, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xDF, 0x80, 0x00,
  0x3F, 0x7E, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x3F,
  0xCF, 0xF0, 0x01, 0xFF, 0x1F, 0xF0, 0x3F, 0xFC, 0x3F, 0xFF, 0xFD, 0xF0,
  0x7F, 0xFF, 0xE7, 0xC0, 0xFF, 0xFF, 0x0F, 0x00, 0xFF, 0xF0, 0x3C, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0x07, 0xFC, 0x0F, 0xE0, 0x07,
  0xF0, 0xFE, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x03, 0xF3,
  0xF0, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0x0F, 0xF0, 0x00, 0x38, 0x3F, 0xF0, 0x1F, 0xC0, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x00,
  0x7F, 0xFE, 0x00, 0xFF, 0xFE, 0x01, 0xFE, 0x06, 0x01, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF8, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x3C,
  0x07, 0xFF, 0xE0, 0xF0, 0x7F, 0xFF, 0xE7, 0xC3, 0xFF, 0xFF, 0xDF, 0x1F,
  0xF8, 0xFF, 0xFC, 0x7F, 0x00, 0x3F, 0xF3, 0xF8, 0x00, 0x3F, 0xDF, 0xC0,
  0x00, 0xFF, 0x7E, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x03, 0xF7, 0xE0, 0x00,
  0x1F, 0xDF, 0xC0, 0x00, 0x7F, 0x3F, 0x80, 0x03, 0xFC, 0xFF, 0x00, 0x1F,
  0xF1, 0xFF, 0x01, 0xFF, 0xC3, 0xFF, 0xFF, 0xDF, 0x07, 0xFF, 0xFE, 0x7C,
  0x0F, 0xFF, 0xF1, 0xF0, 0x0F, 0xFF, 0x07, 0xC0, 0x07, 0xC0, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0x88, 0x00, 0x00, 0xFE, 0x3C, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x7F, 0xF0, 0x1F, 0x0F, 0xFF, 0xE0, 0xF9, 0xFF, 0xFF, 0xC7, 0xDF, 0xFF,
  0xFE, 0x3E, 0xFF, 0x0F, 0xF9, 0xFF, 0x80, 0x1F, 0xEF, 0xF0, 0x00, 0x7F,
  0x7F, 0x80, 0x01, 0xFB, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x01, 0xF8, 0x38, 0xFB, 0xFF, 0xFF, 0xFF, 0x9F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9,
  0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E,
  0x00, 0x1C, 0x00, 0x3E, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0xC1, 0xFC, 0xFF, 0xFC,
  0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0x0C, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x0F,
  0xEF, 0x80, 0x01, 0xFC, 0xF8, 0x00, 0x3F, 0x8F, 0x80, 0x07, 0xF0, 0xF8,
  0x00, 0xFE, 0x0F, 0x80, 0x1F, 0xC0, 0xF8, 0x03, 0xF8, 0x0F, 0x80, 0x7F,
  0x00, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0xFC, 0x00, 0xF8, 0x1F, 0x80, 0x0F,
  0x83, 0xF0, 0x00, 0xF8, 0x7E, 0x00, 0x0F, 0x8F, 0xE0, 0x00, 0xF9, 0xFC,
  0x00, 0x0F, 0xBF, 0x80, 0x00, 0xFB, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xF3, 0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xC1,
  0xFC, 0x00, 0xF8, 0x0F, 0xE0, 0x0F, 0x80, 0x7E, 0x00, 0xF8, 0x07, 0xF0,
  0x0F, 0x80, 0x3F, 0x80, 0xF8, 0x01, 0xFC, 0x0F, 0x80, 0x0F, 0xC0, 0xF8,
  0x00, 0xFE, 0x0F, 0x80, 0x07, 0xF0, 0xF8, 0x00, 0x3F, 0x8F, 0x80, 0x01,
  0xF8, 0xF8, 0x00, 0x1F, 0xCF, 0x80, 0x00, 0xFE, 0xF8, 0x00, 0x07, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF0, 0x3F, 0xF8, 0x00, 0xFF,
  0xE0, 0x3C, 0x1F, 0xFF, 0x80, 0xFF, 0xFE, 0x0F, 0x9F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xE3, 0xEF, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFB, 0xF8, 0xFF, 0xDF,
  0xC1, 0xFF, 0x3F, 0xE0, 0x07, 0xFF, 0xC0, 0x1F, 0xCF, 0xF0, 0x00, 0xFF,
  0xC0, 0x03, 0xFB, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7E, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xEF, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3F, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3F, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0xF0, 0x1F,
  0xFC, 0x07, 0x83, 0xFF, 0xF8, 0x3E, 0x7F, 0xFF, 0xF1, 0xF7, 0xFF, 0xFF,
  0xCF, 0xBF, 0x83, 0xFE, 0x7F, 0xE0, 0x07, 0xFB, 0xFC, 0x00, 0x1F, 0xDF,
  0xE0, 0x00, 0x7E, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xF8, 0x7F,
  0xF0, 0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x00, 0x01,
  0xFC, 0x7E, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00,
  0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x7E, 0xFC, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00,
  0xFE, 0x7E, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x03,
  0xF8, 0x1F, 0xC0, 0x07, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x07, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x1F, 0xFC, 0x03, 0xC1, 0xFF, 0xFC,
  0x0F, 0x9F, 0xFF, 0xF8, 0x3E, 0xFF, 0xFF, 0xF0, 0xFB, 0xF8, 0x7F, 0xE3,
  0xFF, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0xFE, 0xFE,
  0x00, 0x01, 0xFB, 0xF0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x1F, 0xBF, 0x80,
  0x00, 0xFE, 0xFF, 0x00, 0x07, 0xF3, 0xFE, 0x00, 0x3F, 0xCF, 0xFF, 0x03,
  0xFE, 0x3E, 0xFF, 0xFF, 0xF0, 0xF9, 0xFF, 0xFF, 0x83, 0xE3, 0xFF, 0xFC,
  0x0F, 0x83, 0xFF, 0xC0, 0x3E, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x3C, 0x07, 0xFF, 0xE0,
  0xF0, 0x7F, 0xFF, 0xE7, 0xC3, 0xFF, 0xFF, 0xDF, 0x1F, 0xF0, 0x7F, 0x7C,
  0x7F, 0x00, 0x3F, 0xF3, 0xF8, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0xFF, 0x7E,
  0x00, 0x01, 0xFD, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0xFD, 0xF8, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x1F, 0xDF, 0xC0,
  0x00, 0x7F, 0x3F, 0x80, 0x03, 0xFC, 0xFF, 0x00, 0x1F, 0xF1, 0xFF, 0x03,
  0xFF, 0xC3, 0xFF, 0xFF, 0xDF, 0x07, 0xFF, 0xFE, 0x7C, 0x0F, 0xFF, 0xF1,
  0xF0, 0x0F, 0xFF, 0x07, 0xC0, 0x03, 0x80, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0xFF,
  0xFF, 0x9F, 0xFE, 0xFB, 0xFF, 0xEF, 0xBF, 0x00, 0xFF, 0xC0, 0x0F, 0xF8,
  0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE7, 0xFC, 0x0F,
  0xE3, 0xF0, 0x00, 0x71, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFB, 0xF8, 0x03, 0xFD, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x1F,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x83, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xF0, 0x20, 0x7F, 0xFF, 0x01,
  0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x0F, 0x00, 0xFC, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x3F, 0xDF, 0x80, 0x00, 0xFF, 0x7F, 0x00, 0x07, 0xFD, 0xFE,
  0x00, 0x3F, 0xF3, 0xFE, 0x07, 0xFF, 0xCF, 0xFF, 0xFF, 0xBF, 0x1F, 0xFF,
  0xFC, 0x7C, 0x3F, 0xFF, 0xE1, 0xF0, 0x3F, 0xFE, 0x07, 0xC0, 0x07, 0x80,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x1F, 0xDF, 0x80, 0x00,
  0x0F, 0xCF, 0xC0, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x07, 0xE1, 0xF8, 0x00,
  0x03, 0xF0, 0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x1F, 0x80,
  0x00, 0xFC, 0x07, 0xC0, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x7E, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x0F, 0xC0, 0x03, 0xF0, 0x07, 0xE0, 0x00,
  0xF8, 0x03, 0xE0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x3F, 0x01, 0xF8, 0x00,
  0x0F, 0x80, 0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00,
  0x00, 0xF8, 0x3E, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x1F, 0x1F, 0x00,
  0x00, 0x0F, 0x8F, 0x80, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x01, 0xF7, 0xC0,
  0x00, 0x00, 0xFB, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x01, 0xFF,
  0x00, 0x03, 0xE7, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xF3, 0xF0, 0x00, 0x7F,
  0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x3E,
  0xF8, 0x00, 0x7C, 0x3F, 0x00, 0x1F, 0x7C, 0x00, 0x7E, 0x1F, 0x80, 0x0F,
  0xBF, 0x00, 0x3F, 0x07, 0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x83, 0xF0, 0x07,
  0xC7, 0xC0, 0x0F, 0x81, 0xF8, 0x03, 0xE3, 0xF0, 0x0F, 0xC0, 0xFC, 0x03,
  0xF1, 0xF8, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0x1F, 0x80,
  0xF8, 0x3E, 0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x1F, 0x81, 0xF8, 0x07, 0xE0,
  0x7C, 0x07, 0xC0, 0xFC, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x00, 0xFC,
  0x3F, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0x00, 0x7C, 0x3F, 0x00, 0x1F,
  0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x0F, 0x8F, 0xC0, 0x1F, 0x8F, 0x80, 0x07,
  0xE7, 0xC0, 0x07, 0xCF, 0xC0, 0x03, 0xF3, 0xE0, 0x03, 0xE7, 0xE0, 0x00,
  0xF9, 0xF0, 0x01, 0xF3, 0xE0, 0x00, 0x7C, 0xF0, 0x00, 0xFD, 0xF0, 0x00,
  0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x7E, 0x00, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00,
  0xFC, 0x1F, 0xC0, 0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xF8, 0x07, 0xE0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x01, 0xF8, 0x1F,
  0xC0, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x7E, 0x7F,
  0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0xFE, 0x3F,
  0x00, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x0F,
  0xC0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x0F, 0xC0, 0x03,
  0xF0, 0x1F, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xFC, 0x3F, 0x00, 0x00,
  0xFC, 0x7F, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x1F, 0xBF, 0x00, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x0F, 0xCF, 0xC0, 0x00,
  0x07, 0xE3, 0xF0, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x00,
  0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0xFC, 0x07, 0xE0,
  0x00, 0x7E, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07,
  0xE0, 0x0F, 0xC0, 0x01, 0xF0, 0x07, 0xE0, 0x00, 0xFC, 0x03, 0xF0, 0x00,
  0x7E, 0x03, 0xF0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x0F, 0xC0, 0xF8, 0x00,
  0x03, 0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0xFC, 0x3E, 0x00,
  0x00, 0x3E, 0x3F, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x07, 0xCF, 0x80,
  0x00, 0x03, 0xEF, 0xC0, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0xC0,
  0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x07,
  0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xE0,
  0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xE0, 0x03,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00,
  0x03, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x0F,
  0xFC, 0x01, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x7F, 0xE0, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x02, 0x7F, 0xFE, 0x00, 0x0D, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xB0, 0x00, 0x7F, 0xFE,
  0x40, 0x00, 0x1F, 0xF0,
};

const GFXglyph NotoSans_Regular65pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 8, 47, 17, 5, -46 },
  { 48, 18, 16, 27, 4, -46 },
  { 84, 38, 46, 42, 2, -46 },
  { 303, 30, 53, 37, 4, -49 },
  { 502, 48, 48, 54, 3, -47 },
  { 790, 44, 48, 48, 3, -47 },
  { 1054, 6, 16, 15, 4, -46 },
  { 1066, 15, 56, 20, 3, -46 },
  { 1171, 15, 56, 20, 2, -46 },
  { 1276, 30, 29, 36, 3, -49 },
  { 1385, 31, 32, 37, 3, -39 },
  { 1509, 9, 16, 17, 3, -8 },
  { 1527, 15, 5, 21, 3, -20 },
  { 1537, 8, 9, 17, 5, -8 },
  { 1546, 23, 46, 24, 1, -46 },
  { 1679, 31, 48, 37, 3, -47 },
  { 1865, 17, 46, 37, 6, -46 },
  { 1963, 31, 47, 37, 3, -47 },
  { 2146, 30, 48, 37, 3, -47 },
  { 2326, 35, 47, 37, 1, -47 },
  { 2532, 29, 47, 37, 4, -46 },
  { 2703, 30, 48, 37, 4, -47 },
  { 2883, 31, 46, 37, 3, -46 },
  { 3062, 31, 48, 37, 3, -47 },
  { 3248, 31, 48, 37, 3, -47 },
  { 3434, 8, 37, 17, 5, -36 },
  { 3471, 11, 44, 17, 2, -36 },
  { 3532, 31, 32, 37, 3, -40 },
  { 3656, 29, 18, 37, 4, -32 },
  { 3722, 31, 32, 37, 3, -40 },
  { 3846, 26, 48, 28, 1, -47 },
  { 4002, 51, 52, 58, 4, -46 },
  { 4334, 41, 47, 42, 0, -47 },
  { 4575, 33, 46, 42, 6, -46 },
  { 4765, 35, 48, 41, 4, -47 },
  { 4975, 37, 46, 47, 6, -46 },
  { 5188, 26, 46, 36, 6, -46 },
  { 5338, 26, 46, 34, 6, -46 },
  { 5488, 39, 48, 47, 4, -47 },
  { 5722, 36, 46, 48, 6, -46 },
  { 5929, 16, 46, 22, 3, -46 },
  { 6021, 17, 58, 18, -5, -46 },
  { 6145, 34, 46, 40, 6, -46 },
  { 6341, 26, 46, 34, 6, -46 },
  { 6491, 47, 46, 59, 6, -46 },
  { 6762, 37, 46, 49, 6, -46 },
  { 6975, 43, 48, 51, 4, -47 },
  { 7233, 30, 46, 39, 6, -46 },
  { 7406, 43, 58, 51, 4, -47 },
  { 7718, 33, 46, 40, 6, -46 },
  { 7908, 30, 48, 36, 3, -47 },
  { 8088, 34, 46, 36, 1, -46 },
  { 8284, 36, 47, 48, 6, -46 },
  { 8496, 39, 46, 39, 0, -46 },
  { 8721, 59, 46, 60, 1, -46 },
  { 9061, 38, 46, 38, 0, -46 },
  { 9280, 37, 46, 37, 0, -46 },
  { 9493, 33, 46, 37, 2, -46 },
  { 9683, 15, 56, 21, 5, -46 },
  { 9788, 23, 46, 24, 1, -46 },
  { 9921, 14, 56, 21, 2, -46 },
  { 10019, 33, 30, 37, 2, -47 },
  { 10143, 29, 4, 29, 0, 6 },
  { 10158, 13, 11, 18, 3, -50 },
  { 10176, 28, 36, 36, 3, -35 },
  { 10302, 30, 50, 40, 6, -49 },
  { 10490, 25, 36, 31, 4, -35 },
  { 10603, 30, 50, 40, 4, -49 },
  { 10791, 29, 36, 37, 4, -35 },
  { 10922, 24, 50, 22, 1, -50 },
  { 11072, 30, 51, 40, 4, -35 },
  { 11264, 29, 49, 40, 6, -49 },
  { 11442, 7, 48, 17, 5, -48 },
  { 11484, 16, 64, 17, -4, -48 },
  { 11612, 28, 49, 35, 6, -49 },
  { 11784, 5, 49, 17, 6, -49 },
  { 11815, 50, 35, 61, 6, -35 },
  { 12034, 29, 35, 40, 6, -35 },
  { 12161, 32, 36, 39, 4, -35 },
  { 12305, 30, 51, 40, 6, -35 },
  { 12497, 30, 51, 40, 4, -35 },
  { 12689, 20, 35, 27, 6, -35 },
  { 12777, 25, 36, 31, 3, -35 },
  { 12890, 21, 44, 23, 1, -43 },
  { 13006, 30, 36, 40, 5, -35 },
  { 13141, 33, 35, 33, 0, -35 },
  { 13286, 49, 35, 51, 1, -35 },
  { 13501, 32, 35, 34, 1, -35 },
  { 13641, 33, 51, 33, 0, -35 },
  { 13852, 25, 35, 31, 3, -35 },
  { 13962, 21, 56, 25, 2, -46 },
  { 14109, 4, 65, 36, 16, -49 },
  { 14142, 21, 56, 25, 2, -46 },
  { 14289, 31, 8, 37, 3, -27 },
};

const GFXfont NotoSans_Regular65pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Regular65pt7bBitmaps,
  (GFXglyph *)NotoSans_Regular65pt7bGlyphs,
  0x20, 0x7E, 89
};

#endif // _NOTOSANS_REGULAR65PT7B_H_
