#ifndef _NOTOSANS_REGULAR6PT7B_H_
#define _NOTOSANS_REGULAR6PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Regular.ttf
// Size: 6pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Regular6pt7bBitmaps[] PROGMEM = {
  0x00, 0xF0, 0xC0, 0x6F, 0xFA, 0x55, 0x3E, 0xD5, 0x9A, 0xB0, 0xE4, 0xBF,
  0x80, 0xEA, 0x40, 0x95, 0x80, 0x5D, 0x80, 0x5D, 0x00, 0xC0, 0xC0, 0x80,
  0x5A, 0xF6, 0xF0, 0xF0, 0xE5, 0x70, 0xEC, 0xF0, 0x2F, 0x90, 0xF8, 0xF0,
  0xFE, 0xB0, 0xE5, 0x20, 0xEE, 0xF0, 0xF5, 0xB0, 0xA0, 0xB0, 0x39, 0x80,
  0xFC, 0x8F, 0x00, 0xD5, 0x7F, 0xF7, 0x47, 0x00, 0x46, 0x69, 0xFA, 0xE0,
  0x78, 0x87, 0xF6, 0xE0, 0xFB, 0xFA, 0x7A, 0x97, 0xBE, 0xD0, 0xD7, 0xF8,
  0xF3, 0x50, 0xAB, 0x9B, 0xBD, 0xB7, 0xD0, 0x79, 0x97, 0xFA, 0x79, 0x97,
  0x10, 0xDB, 0x50, 0xE8, 0xF0, 0xE9, 0x20, 0xB6, 0xF0, 0x9A, 0x64, 0xA6,
  0xE5, 0x92, 0xA9, 0xD0, 0xA9, 0x20, 0xE9, 0x70, 0xEA, 0xC0, 0xA5, 0xD5,
  0xC0, 0x54, 0xE0, 0x80, 0x7F, 0x80, 0xAF, 0xC0, 0xF3, 0x80, 0x2E, 0xDE,
  0xFD, 0x80, 0x7A, 0x80, 0xF6, 0xB0, 0xAF, 0xC0, 0xF0, 0xF8, 0xAE, 0xC0,
  0xF8, 0xFD, 0xD0, 0xFC, 0xF7, 0x80, 0xFE, 0xF7, 0x90, 0xE0, 0xEB, 0x80,
  0xEB, 0xB7, 0x80, 0xB5, 0x00, 0xAF, 0x94, 0xAA, 0x80, 0xB5, 0x60, 0xEB,
  0x80, 0x59, 0x40, 0xFC, 0xD5, 0x80, 0xE0,
};

const GFXglyph NotoSans_Regular6pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 4, 2, 0, -4 },
  { 2, 2, 1, 2, 0, -4 },
  { 3, 4, 4, 4, 0, -4 },
  { 5, 3, 5, 3, 0, -5 },
  { 7, 5, 4, 5, 0, -4 },
  { 10, 4, 4, 4, 0, -4 },
  { 12, 1, 1, 1, 0, -4 },
  { 13, 2, 5, 2, 0, -4 },
  { 15, 2, 5, 2, 0, -4 },
  { 17, 3, 3, 3, 0, -5 },
  { 19, 3, 3, 3, 0, -4 },
  { 21, 1, 2, 2, 0, -1 },
  { 22, 2, 1, 2, 0, -2 },
  { 23, 1, 1, 2, 0, -1 },
  { 24, 2, 4, 2, 0, -4 },
  { 25, 3, 4, 3, 0, -4 },
  { 27, 1, 4, 3, 1, -4 },
  { 28, 3, 4, 3, 0, -4 },
  { 30, 3, 4, 3, 0, -4 },
  { 32, 3, 4, 3, 0, -4 },
  { 34, 3, 4, 3, 0, -4 },
  { 36, 3, 4, 3, 0, -4 },
  { 38, 3, 4, 3, 0, -4 },
  { 40, 3, 4, 3, 0, -4 },
  { 42, 3, 4, 3, 0, -4 },
  { 44, 1, 3, 2, 0, -3 },
  { 45, 1, 4, 2, 0, -3 },
  { 46, 3, 3, 3, 0, -4 },
  { 48, 3, 2, 3, 0, -3 },
  { 49, 3, 3, 3, 0, -4 },
  { 51, 2, 4, 3, 0, -4 },
  { 52, 5, 5, 5, 0, -4 },
  { 56, 4, 4, 4, 0, -4 },
  { 58, 3, 4, 4, 1, -4 },
  { 60, 4, 4, 4, 0, -4 },
  { 62, 3, 4, 4, 1, -4 },
  { 64, 2, 4, 3, 1, -4 },
  { 65, 2, 4, 3, 1, -4 },
  { 66, 4, 4, 4, 0, -4 },
  { 68, 3, 4, 4, 1, -4 },
  { 70, 2, 4, 2, 0, -4 },
  { 71, 1, 5, 2, 0, -4 },
  { 72, 3, 4, 4, 1, -4 },
  { 74, 2, 4, 3, 1, -4 },
  { 75, 4, 4, 5, 1, -4 },
  { 77, 3, 4, 5, 1, -4 },
  { 79, 4, 4, 5, 0, -4 },
  { 81, 2, 4, 4, 1, -4 },
  { 82, 4, 5, 5, 0, -4 },
  { 85, 3, 4, 4, 1, -4 },
  { 87, 3, 4, 3, 0, -4 },
  { 89, 3, 4, 3, 0, -4 },
  { 91, 3, 4, 4, 1, -4 },
  { 93, 4, 4, 4, 0, -4 },
  { 95, 6, 4, 6, 0, -4 },
  { 98, 3, 4, 4, 0, -4 },
  { 100, 3, 4, 3, 0, -4 },
  { 102, 3, 4, 3, 0, -4 },
  { 104, 2, 5, 2, 0, -4 },
  { 106, 2, 4, 2, 0, -4 },
  { 107, 2, 5, 2, 0, -4 },
  { 109, 3, 2, 3, 0, -4 },
  { 110, 3, 1, 3, 0, 0 },
  { 111, 1, 1, 2, 0, -5 },
  { 112, 3, 3, 3, 0, -3 },
  { 114, 2, 5, 4, 1, -5 },
  { 116, 3, 3, 3, 0, -3 },
  { 118, 3, 5, 4, 0, -5 },
  { 120, 3, 3, 3, 0, -3 },
  { 122, 2, 5, 2, 0, -5 },
  { 124, 3, 4, 4, 0, -3 },
  { 126, 2, 5, 4, 1, -5 },
  { 128, 1, 4, 2, 0, -4 },
  { 129, 1, 5, 2, 0, -4 },
  { 130, 2, 5, 3, 1, -5 },
  { 132, 1, 5, 2, 0, -5 },
  { 133, 4, 3, 6, 1, -3 },
  { 135, 2, 3, 4, 1, -3 },
  { 136, 3, 3, 4, 0, -3 },
  { 138, 2, 4, 4, 1, -3 },
  { 139, 3, 4, 4, 0, -3 },
  { 141, 1, 3, 2, 1, -3 },
  { 142, 3, 3, 3, 0, -3 },
  { 144, 2, 4, 2, 0, -4 },
  { 145, 3, 3, 4, 0, -3 },
  { 147, 3, 3, 3, 0, -3 },
  { 149, 5, 3, 5, 0, -3 },
  { 151, 3, 3, 3, 0, -3 },
  { 153, 3, 4, 3, 0, -3 },
  { 155, 3, 3, 3, 0, -3 },
  { 157, 2, 5, 2, 0, -4 },
  { 159, 1, 6, 3, 1, -5 },
  { 160, 2, 5, 2, 0, -4 },
  { 162, 3, 1, 3, 0, -3 },
};

const GFXfont NotoSans_Regular6pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Regular6pt7bBitmaps,
  (GFXglyph *)NotoSans_Regular6pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _NOTOSANS_REGULAR6PT7B_H_
