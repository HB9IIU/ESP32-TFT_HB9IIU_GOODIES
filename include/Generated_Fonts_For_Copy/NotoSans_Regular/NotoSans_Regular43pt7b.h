#ifndef _NOTOSANS_REGULAR43PT7B_H_
#define _NOTOSANS_REGULAR43PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Regular.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Regular43pt7bBitmaps[] PROGMEM = {
  0x00, 0xFB, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xB9, 0xCE, 0x73,
  0x9C, 0xE7, 0x18, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE4, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xEE, 0x0E, 0xE0, 0xEE, 0x0E, 0xE0, 0xE6, 0x0E,
  0x60, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x1E, 0x07, 0x00, 0x07, 0x01, 0xC0,
  0x01, 0xC0, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x1C, 0x0E, 0x00, 0x0F, 0x03,
  0x80, 0x03, 0x80, 0xE0, 0x00, 0xE0, 0x70, 0x0F, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x01, 0xC0, 0x70, 0x00, 0x70, 0x38, 0x00,
  0x1C, 0x0E, 0x00, 0x07, 0x03, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0xE0, 0x38,
  0x00, 0x38, 0x1C, 0x03, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xC0, 0x70, 0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x03, 0x80, 0x01,
  0xC0, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x3C, 0x0E, 0x00, 0x0E, 0x07, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x7F, 0xC0, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3,
  0xFF, 0x7E, 0xF8, 0xE0, 0x9E, 0x1C, 0x03, 0x83, 0x80, 0x70, 0x70, 0x0F,
  0x0E, 0x01, 0xE1, 0xC0, 0x3F, 0x38, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x0E, 0x7C, 0x01, 0xC3, 0xC0,
  0x38, 0x78, 0x07, 0x0F, 0x00, 0xE1, 0xE0, 0x1C, 0x3E, 0x03, 0x8F, 0xFF,
  0x7F, 0xEF, 0xFF, 0xF9, 0xFF, 0xFC, 0x07, 0xFC, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x80, 0x01,
  0xC0, 0x3F, 0xC0, 0x03, 0x80, 0x3F, 0xE0, 0x07, 0x80, 0x70, 0xF0, 0x07,
  0x00, 0x70, 0x70, 0x0F, 0x00, 0xF0, 0x70, 0x0E, 0x00, 0xE0, 0x78, 0x1E,
  0x00, 0xE0, 0x38, 0x1C, 0x00, 0xE0, 0x38, 0x3C, 0x00, 0xE0, 0x38, 0x38,
  0x00, 0xE0, 0x38, 0x70, 0x00, 0xE0, 0x38, 0xF0, 0x00, 0xE0, 0x78, 0xE1,
  0xE0, 0xF0, 0x71, 0xE7, 0xF8, 0x70, 0x71, 0xCF, 0xFC, 0x70, 0xF3, 0xCF,
  0x1C, 0x3F, 0xE3, 0x8E, 0x0E, 0x3F, 0xE7, 0x9C, 0x0E, 0x0F, 0x87, 0x1C,
  0x0E, 0x00, 0x0E, 0x1C, 0x0E, 0x00, 0x0E, 0x1C, 0x0F, 0x00, 0x1C, 0x1C,
  0x0F, 0x00, 0x3C, 0x1C, 0x0F, 0x00, 0x38, 0x1C, 0x0F, 0x00, 0x78, 0x1C,
  0x0E, 0x00, 0x70, 0x1C, 0x0E, 0x00, 0xF0, 0x1E, 0x0E, 0x00, 0xE0, 0x0E,
  0x1E, 0x01, 0xC0, 0x0F, 0x3C, 0x01, 0xC0, 0x07, 0xFC, 0x03, 0x80, 0x03,
  0xF8, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x1F, 0x0F, 0x80, 0x01, 0xE0, 0x3C, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x78,
  0x07, 0x80, 0x03, 0xC0, 0x38, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x78, 0x1E,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0x0F, 0x3E, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x02, 0x1F,
  0xFC, 0x01, 0xE1, 0xF1, 0xF0, 0x0F, 0x1F, 0x07, 0xE0, 0x78, 0xF0, 0x1F,
  0x87, 0x87, 0x80, 0x7E, 0x3C, 0x78, 0x01, 0xFB, 0xC3, 0xC0, 0x03, 0xFE,
  0x1E, 0x00, 0x0F, 0xE0, 0xF0, 0x00, 0x3E, 0x03, 0xC0, 0x01, 0xF8, 0x1F,
  0x00, 0x3F, 0xE0, 0xFC, 0x07, 0xEF, 0x83, 0xFF, 0xFE, 0x3E, 0x0F, 0xFF,
  0xE0, 0xF8, 0x1F, 0xF8, 0x03, 0xE0, 0xFF, 0xFF, 0xFE, 0xEE, 0xE6, 0x60,
  0x03, 0xC1, 0xE0, 0xF0, 0x3C, 0x1E, 0x07, 0x03, 0xC0, 0xF0, 0x78, 0x1E,
  0x07, 0x81, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x01, 0xE0, 0x78,
  0x1E, 0x03, 0xC0, 0xF0, 0x1C, 0x07, 0x80, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0xF0, 0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x01,
  0xE0, 0x78, 0x1E, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x78, 0x1E, 0x07,
  0x81, 0xE0, 0xF0, 0x3C, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x78, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x80, 0xE0, 0x2F, 0x8E, 0x1E, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0x00, 0x1F, 0x00, 0x03, 0xF8, 0x00, 0x3B, 0xC0, 0x07,
  0x9E, 0x00, 0xF1, 0xE0, 0x1F, 0x0F, 0x01, 0xE0, 0xF8, 0x0E, 0x07, 0x00,
  0x20, 0x40, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x3C, 0xF7, 0xDE, 0x79, 0xE7,
  0x3C, 0xE3, 0x8E, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x90,
  0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x81, 0xF0, 0x7C,
  0x3E, 0x03, 0xC3, 0xC0, 0x1E, 0x78, 0x01, 0xE7, 0x80, 0x0E, 0x78, 0x00,
  0xF7, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xF7, 0x00, 0x0F, 0x78, 0x00, 0xF7,
  0x80, 0x0F, 0x78, 0x01, 0xE3, 0xC0, 0x1E, 0x3C, 0x03, 0xE1, 0xE0, 0x7C,
  0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x00, 0xE0, 0x3C, 0x1F,
  0x87, 0xF1, 0xEE, 0xF9, 0xFE, 0x3F, 0x87, 0x60, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x03, 0xFC, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x8F, 0xE0,
  0xFC, 0x78, 0x03, 0xC2, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFC, 0x01,
  0xFF, 0xF0, 0x7F, 0xFF, 0x8F, 0xC0, 0xFC, 0x70, 0x03, 0xE2, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x0F, 0xF0, 0x07, 0xFC, 0x00, 0x7F,
  0xE0, 0x07, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x1F, 0x80, 0x03, 0xEE, 0x00, 0x7E, 0xFF, 0xFF, 0xCF, 0xFF, 0xF0,
  0x3F, 0xFC, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xB8, 0x00, 0x0E, 0x70, 0x00,
  0x3C, 0xE0, 0x00, 0xF1, 0xC0, 0x01, 0xC3, 0x80, 0x07, 0x87, 0x00, 0x1E,
  0x0E, 0x00, 0x38, 0x1C, 0x00, 0xF0, 0x38, 0x03, 0xC0, 0x70, 0x07, 0x00,
  0xE0, 0x1E, 0x01, 0xC0, 0x78, 0x03, 0x80, 0xE0, 0x07, 0x03, 0x80, 0x0E,
  0x0F, 0x00, 0x1C, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x3F, 0xFF, 0x8F,
  0xFF, 0xF1, 0xFF, 0xFE, 0x3F, 0xFF, 0xC7, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x7F, 0x00, 0xFF, 0xFC, 0x3F, 0xFF, 0xC1, 0xE3, 0xFC, 0x00,
  0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7A, 0x00,
  0x1F, 0x70, 0x07, 0xCF, 0xFF, 0xF1, 0xFF, 0xFC, 0x1F, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xC0, 0x00, 0xF8, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x0F, 0xF0, 0x39, 0xFF, 0xC3,
  0xDF, 0xFF, 0x1F, 0xE0, 0x7C, 0xFC, 0x01, 0xF7, 0xC0, 0x07, 0xBE, 0x00,
  0x3D, 0xE0, 0x00, 0xEF, 0x00, 0x07, 0xB8, 0x00, 0x3D, 0xC0, 0x01, 0xEF,
  0x00, 0x0E, 0x78, 0x00, 0xF1, 0xE0, 0x07, 0x8F, 0x80, 0x78, 0x3E, 0x07,
  0xC0, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x0E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xE0,
  0x7C, 0x3C, 0x01, 0xE7, 0x80, 0x1E, 0x78, 0x00, 0xE7, 0x80, 0x0E, 0x78,
  0x00, 0xE7, 0x80, 0x1E, 0x3C, 0x01, 0xE3, 0xE0, 0x3C, 0x1F, 0x8F, 0x80,
  0xFF, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x81, 0xF0, 0xFC,
  0x3C, 0x03, 0xE7, 0x80, 0x1F, 0x70, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0x78, 0x00, 0xF7, 0xC0,
  0x3E, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0xFF, 0xE0, 0x1F, 0xFF, 0x83, 0xF0, 0xFC, 0x7C, 0x03, 0xC7, 0x80, 0x1E,
  0x70, 0x01, 0xEF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xF7, 0x00, 0x0F, 0x78, 0x01, 0xF7, 0xC0,
  0x3F, 0x3F, 0xBF, 0xF1, 0xFF, 0xEF, 0x07, 0xFC, 0xF0, 0x0C, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xC0,
  0x3F, 0xF0, 0x00, 0x37, 0xFF, 0xFF, 0xBC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x20, 0x0C, 0x7C, 0xF9, 0xF3, 0xE3,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xF3, 0xE7, 0x8F, 0x1E, 0x78, 0xF1, 0xC3, 0x87, 0x1C, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x07, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F,
  0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x1F, 0xF0, 0x7F, 0xFE, 0x3F, 0xFF, 0x9F, 0x07, 0xE4, 0x00,
  0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x04, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03,
  0xF8, 0x0F, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x07, 0x80,
  0x78, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x07,
  0x87, 0x00, 0xFF, 0xC0, 0xE3, 0x80, 0xFF, 0xF8, 0x38, 0xE0, 0x7E, 0x3E,
  0x07, 0x78, 0x1E, 0x07, 0x81, 0xDC, 0x0F, 0x01, 0xE0, 0x77, 0x03, 0x80,
  0x78, 0x1D, 0xC1, 0xE0, 0x1E, 0x07, 0x70, 0x78, 0x07, 0x01, 0xDC, 0x1E,
  0x01, 0xC0, 0x7F, 0x07, 0x00, 0x70, 0x1F, 0xC1, 0xC0, 0x1C, 0x07, 0x70,
  0x78, 0x07, 0x03, 0x9C, 0x0E, 0x03, 0xC0, 0xE7, 0x03, 0xC1, 0xF8, 0x79,
  0xC0, 0xFD, 0xEF, 0x3C, 0x70, 0x1F, 0xF9, 0xFE, 0x0E, 0x03, 0xF8, 0x3F,
  0x03, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x04, 0x00, 0x0F, 0xC0,
  0x1F, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x77, 0x80, 0x00,
  0x0E, 0xF0, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x1E, 0x3C,
  0x00, 0x03, 0xC3, 0x80, 0x00, 0x70, 0x78, 0x00, 0x1E, 0x07, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0xF0, 0x1E, 0x00, 0x1E, 0x01, 0xC0, 0x03, 0x80, 0x3C,
  0x00, 0xF0, 0x07, 0x80, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x07, 0x80, 0x03, 0xC0, 0xF0, 0x00, 0x3C,
  0x1C, 0x00, 0x07, 0x87, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x3C, 0x00,
  0x01, 0xE7, 0x80, 0x00, 0x3C, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x78,
  0xFF, 0xE8, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xF0,
  0x03, 0xF3, 0xC0, 0x03, 0xCF, 0x00, 0x0F, 0x3C, 0x00, 0x1E, 0xF0, 0x00,
  0x7B, 0xC0, 0x03, 0xCF, 0x00, 0x0F, 0x3C, 0x00, 0x3C, 0xF0, 0x01, 0xE3,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xE3, 0xC0,
  0x07, 0xCF, 0x00, 0x0F, 0xBC, 0x00, 0x1E, 0xF0, 0x00, 0x7B, 0xC0, 0x01,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7B, 0xC0, 0x03, 0xEF,
  0x00, 0x1F, 0xBC, 0x03, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F,
  0x83, 0xE1, 0xF8, 0x00, 0xC7, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0x00, 0xE0, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0x00, 0x3F, 0x87,
  0x80, 0x07, 0xE3, 0xC0, 0x00, 0xF9, 0xE0, 0x00, 0x3C, 0xF0, 0x00, 0x1F,
  0x78, 0x00, 0x07, 0xBC, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x7B, 0xC0, 0x00, 0x7D, 0xE0, 0x00, 0x3C, 0xF0,
  0x00, 0x3E, 0x78, 0x00, 0x7E, 0x3C, 0x00, 0x7E, 0x1E, 0x03, 0xFE, 0x0F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0x07, 0xE1, 0xFC, 0x00,
  0x20, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x07, 0xFF, 0xF0,
  0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3D, 0xE0, 0x00, 0x1E, 0xF8, 0x00, 0x0F,
  0x3C, 0x00, 0x07, 0x9F, 0x00, 0x03, 0xC7, 0xE0, 0x01, 0xE1, 0xFC, 0x00,
  0xF0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x07, 0xFD, 0xFF,
  0xFF, 0xF8, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x7C, 0x0F, 0x47, 0xEF, 0xF9, 0xFE, 0x3F, 0x00, 0xF0, 0x00, 0x7D, 0xE0,
  0x00, 0xF3, 0xC0, 0x03, 0xC7, 0x80, 0x0F, 0x0F, 0x00, 0x3C, 0x1E, 0x00,
  0xF0, 0x3C, 0x03, 0xE0, 0x78, 0x0F, 0x80, 0xF0, 0x3E, 0x01, 0xE0, 0xF8,
  0x03, 0xC3, 0xE0, 0x07, 0x87, 0x80, 0x0F, 0x1E, 0x00, 0x1E, 0x78, 0x00,
  0x3D, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF0, 0x01, 0xF9, 0xF0, 0x03,
  0xE1, 0xE0, 0x07, 0x81, 0xE0, 0x0F, 0x03, 0xE0, 0x1E, 0x03, 0xE0, 0x3C,
  0x03, 0xC0, 0x78, 0x07, 0xC0, 0xF0, 0x07, 0xC1, 0xE0, 0x07, 0xC3, 0xC0,
  0x07, 0x87, 0x80, 0x0F, 0x8F, 0x00, 0x0F, 0x9E, 0x00, 0x0F, 0xBC, 0x00,
  0x0F, 0x80, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFC, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFE,
  0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFD, 0xC0, 0x00, 0x77, 0xFB,
  0xC0, 0x01, 0xEF, 0xF7, 0x80, 0x03, 0x9F, 0xE7, 0x00, 0x07, 0x3F, 0xCF,
  0x00, 0x1E, 0x7F, 0x9E, 0x00, 0x38, 0xFF, 0x1C, 0x00, 0xF1, 0xFE, 0x3C,
  0x01, 0xE3, 0xFC, 0x38, 0x03, 0x87, 0xF8, 0x78, 0x0F, 0x0F, 0xF0, 0xF0,
  0x1C, 0x1F, 0xE0, 0xE0, 0x38, 0x3F, 0xC1, 0xE0, 0xF0, 0x7F, 0x83, 0xC1,
  0xC0, 0xFF, 0x03, 0x87, 0x81, 0xFE, 0x07, 0x8F, 0x03, 0xFC, 0x07, 0x1C,
  0x07, 0xF8, 0x0F, 0x78, 0x0F, 0xF0, 0x1E, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0,
  0x3F, 0xC0, 0x3F, 0x80, 0x7F, 0x80, 0x7E, 0x00, 0xFF, 0x00, 0x7C, 0x01,
  0xFE, 0x00, 0xF0, 0x03, 0xFC, 0x00, 0xE0, 0x07, 0x80, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0x7F, 0xF8, 0x00, 0x3F, 0xBE, 0x00, 0x1F, 0xEF, 0x00, 0x0F, 0xF7, 0xC0,
  0x07, 0xF9, 0xF0, 0x03, 0xFC, 0x78, 0x01, 0xFE, 0x3E, 0x00, 0xFF, 0x0F,
  0x80, 0x7F, 0x83, 0xC0, 0x3F, 0xC1, 0xF0, 0x1F, 0xE0, 0x78, 0x0F, 0xF0,
  0x1E, 0x07, 0xF8, 0x0F, 0x83, 0xFC, 0x03, 0xC1, 0xFE, 0x00, 0xF0, 0xFF,
  0x00, 0x7C, 0x7F, 0x80, 0x1E, 0x3F, 0xC0, 0x07, 0x9F, 0xE0, 0x03, 0xEF,
  0xF0, 0x00, 0xF7, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0xFE, 0x07, 0xF0,
  0x1F, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x07, 0xC7, 0x80,
  0x00, 0x3C, 0x78, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x1E, 0xF0, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xEF,
  0x80, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x3E, 0x7C, 0x00,
  0x03, 0xC3, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x81, 0xFC, 0x03, 0xF0,
  0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xF0, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xF0, 0x07, 0xEF,
  0x00, 0x3E, 0xF0, 0x01, 0xEF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x07,
  0xCF, 0x03, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xE0, 0xFF, 0xF0, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFF, 0x80,
  0x07, 0xFF, 0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x1F, 0x00, 0x1F, 0x83, 0xE0,
  0x00, 0x78, 0x3C, 0x00, 0x07, 0xC7, 0x80, 0x00, 0x3C, 0x78, 0x00, 0x01,
  0xEF, 0x80, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x1E, 0x78, 0x00,
  0x01, 0xE7, 0x80, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x7C,
  0x1F, 0x00, 0x0F, 0x81, 0xFC, 0x03, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xF0, 0x07, 0xE3, 0xC0, 0x07, 0x8F, 0x00,
  0x1F, 0x3C, 0x00, 0x3C, 0xF0, 0x00, 0xF3, 0xC0, 0x03, 0xCF, 0x00, 0x0F,
  0x3C, 0x00, 0x7C, 0xF0, 0x01, 0xE3, 0xC0, 0x0F, 0x8F, 0x00, 0xFC, 0x3F,
  0xFF, 0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0x03, 0xC0, 0x3C, 0x07,
  0x80, 0xF0, 0x1F, 0x03, 0xC0, 0x3C, 0x0F, 0x00, 0x78, 0x3C, 0x01, 0xE0,
  0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x8F, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0xF0,
  0x00, 0xFB, 0xC0, 0x01, 0xEF, 0x00, 0x07, 0xC0, 0x03, 0xFF, 0x00, 0xFF,
  0xFE, 0x1F, 0xFF, 0xE3, 0xF0, 0xFC, 0x7C, 0x00, 0x47, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00,
  0x1E, 0x80, 0x03, 0xEF, 0x00, 0x7C, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0x7F,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78,
  0x00, 0x3C, 0x7C, 0x00, 0x7C, 0x3F, 0x01, 0xF8, 0x1F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xE0, 0x03, 0xFF, 0x80, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x79, 0xE0, 0x00, 0x1E, 0x7C, 0x00, 0x0F, 0x0F, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x78, 0x1E, 0x00, 0x1E, 0x07, 0x80,
  0x0F, 0x80, 0xF0, 0x03, 0xC0, 0x3C, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x01,
  0xE0, 0x1E, 0x00, 0x78, 0x07, 0x80, 0x1E, 0x03, 0xC0, 0x03, 0xC0, 0xF0,
  0x00, 0xF0, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x87, 0x80, 0x01, 0xE1,
  0xE0, 0x00, 0x3C, 0xF0, 0x00, 0x0F, 0x3C, 0x00, 0x03, 0xCF, 0x00, 0x00,
  0x77, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3F, 0xC0, 0x03, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x03,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x78, 0x00, 0xFC, 0x00, 0x79, 0xE0, 0x07,
  0xF0, 0x01, 0xE7, 0x80, 0x1F, 0xE0, 0x07, 0x9E, 0x00, 0x77, 0x80, 0x1E,
  0x3C, 0x03, 0xCE, 0x00, 0xF0, 0xF0, 0x0F, 0x3C, 0x03, 0xC3, 0xC0, 0x3C,
  0xF0, 0x0F, 0x0F, 0x00, 0xE1, 0xC0, 0x38, 0x1E, 0x07, 0x87, 0x81, 0xE0,
  0x78, 0x1E, 0x1E, 0x07, 0x81, 0xE0, 0x70, 0x78, 0x1E, 0x03, 0x83, 0xC0,
  0xE0, 0x70, 0x0F, 0x0F, 0x03, 0xC3, 0xC0, 0x3C, 0x38, 0x0F, 0x0F, 0x00,
  0xF0, 0xE0, 0x1C, 0x3C, 0x01, 0xC7, 0x80, 0x78, 0xE0, 0x07, 0x9E, 0x01,
  0xE7, 0x80, 0x1E, 0x70, 0x03, 0x9E, 0x00, 0x7B, 0xC0, 0x0E, 0x78, 0x00,
  0xEF, 0x00, 0x3D, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x8F, 0x00, 0x07, 0x83,
  0xC0, 0x07, 0x80, 0xF0, 0x03, 0xC0, 0x78, 0x03, 0xC0, 0x1E, 0x03, 0xC0,
  0x0F, 0x81, 0xE0, 0x03, 0xC1, 0xE0, 0x00, 0xF1, 0xE0, 0x00, 0x78, 0xF0,
  0x00, 0x1E, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3D,
  0xE0, 0x00, 0x3C, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x0F,
  0x07, 0xC0, 0x0F, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3E, 0x07,
  0x80, 0x0F, 0x07, 0x80, 0x07, 0xC3, 0xC0, 0x01, 0xE3, 0xC0, 0x00, 0x7B,
  0xE0, 0x00, 0x3E, 0xF0, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x1E,
  0x3C, 0x00, 0x3E, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x7C, 0x1E, 0x00, 0x78,
  0x0F, 0x00, 0xF0, 0x0F, 0x80, 0xF0, 0x07, 0x81, 0xE0, 0x07, 0xC1, 0xE0,
  0x03, 0xC3, 0xC0, 0x01, 0xE3, 0xC0, 0x01, 0xE7, 0x80, 0x00, 0xF7, 0x80,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1C, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80,
  0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0,
  0x00, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x60, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x01, 0xCE, 0x00, 0x0E, 0x70, 0x00, 0xE1, 0xC0, 0x07, 0x0E, 0x00,
  0x70, 0x38, 0x03, 0x81, 0xC0, 0x3C, 0x07, 0x01, 0xC0, 0x38, 0x1E, 0x00,
  0xE0, 0xE0, 0x07, 0x0F, 0x00, 0x1C, 0x70, 0x00, 0xE3, 0x80, 0x03, 0xB8,
  0x00, 0x1D, 0xC0, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xF0, 0xF8, 0x7C, 0x3C, 0x1E, 0x0F, 0x07, 0x07, 0xFE, 0x03, 0xFF,
  0xF0, 0x7F, 0xFF, 0x0E, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x1F, 0xFC, 0x3F, 0xFF, 0x9F, 0xFF,
  0xF7, 0xE0, 0x1E, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x03,
  0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xFC, 0x07, 0xF7, 0xFF, 0xDE, 0x7F, 0xF1,
  0xC7, 0xFC, 0x38, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE3, 0xFE, 0x0E, 0x7F, 0xF0, 0xEF, 0xFF, 0x8F,
  0xC0, 0x7C, 0xF8, 0x03, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xEF, 0x80,
  0x1E, 0xF8, 0x03, 0xEF, 0xC0, 0x7C, 0xEF, 0xFF, 0x8E, 0x7F, 0xF0, 0xE3,
  0xFE, 0x00, 0x03, 0xFF, 0x87, 0xFF, 0xC7, 0xFF, 0xE7, 0xE0, 0x23, 0xC0,
  0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xE0, 0x31, 0xFF, 0xF8, 0x7F,
  0xFC, 0x0F, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0xFF, 0x1E, 0x1F, 0xFE, 0xF1, 0xFF,
  0xFF, 0x9F, 0x01, 0xFC, 0xF0, 0x07, 0xEF, 0x80, 0x1F, 0x78, 0x00, 0xFB,
  0xC0, 0x03, 0xDE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0x70, 0x00, 0x7B, 0xC0, 0x03, 0xDE,
  0x00, 0x3E, 0xF0, 0x01, 0xF3, 0xC0, 0x1F, 0x9F, 0x01, 0xFC, 0x7F, 0xFF,
  0xE1, 0xFF, 0xEF, 0x03, 0xFC, 0x38, 0x03, 0xFE, 0x00, 0xFF, 0xF8, 0x1F,
  0xFF, 0xC1, 0xE0, 0x3C, 0x3C, 0x01, 0xE7, 0x80, 0x1E, 0x78, 0x00, 0xF7,
  0x80, 0x0F, 0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x06, 0x1F, 0xFF, 0xE0, 0x7F,
  0xFE, 0x03, 0xFF, 0xC0, 0x00, 0xFC, 0x03, 0xFF, 0x07, 0xFE, 0x07, 0xC6,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x3F, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x03, 0xFC,
  0x38, 0x7F, 0xFB, 0xC7, 0xFF, 0xFE, 0x7C, 0x07, 0xF3, 0xC0, 0x1F, 0xBE,
  0x00, 0x7D, 0xE0, 0x03, 0xEF, 0x00, 0x0F, 0x78, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3D, 0xC0,
  0x01, 0xEF, 0x00, 0x0F, 0x78, 0x00, 0x7B, 0xC0, 0x07, 0xCF, 0x00, 0x7E,
  0x7C, 0x07, 0xF1, 0xFF, 0xFF, 0x87, 0xFF, 0xBC, 0x0F, 0xF1, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE2,
  0x00, 0x1F, 0x1C, 0x01, 0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xF0, 0x0F, 0xFF,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x8F, 0xF8, 0x73, 0xFF, 0xCE, 0xFF, 0xFD, 0xF8, 0x0F, 0xBE, 0x00,
  0xFF, 0xC0, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xE0, 0x23, 0xFF, 0xF7, 0x00,
  0x00, 0x03, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x39, 0xCE, 0x01, 0x00, 0xF0, 0x7C, 0x1F, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x81, 0xE0, 0x7B, 0xFE, 0xFF, 0x3F, 0x80, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x1F, 0x70,
  0x07, 0x8E, 0x01, 0xF1, 0xC0, 0x7C, 0x38, 0x1F, 0x07, 0x07, 0xC0, 0xE1,
  0xF0, 0x1C, 0x7C, 0x03, 0x9F, 0x00, 0x73, 0xC0, 0x0E, 0xF8, 0x01, 0xFF,
  0x80, 0x3F, 0xF8, 0x07, 0xCF, 0x00, 0xE0, 0xF0, 0x1C, 0x1F, 0x03, 0x81,
  0xF0, 0x70, 0x1E, 0x0E, 0x01, 0xE1, 0xC0, 0x3E, 0x38, 0x03, 0xE7, 0x00,
  0x3C, 0xE0, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xE3, 0xFE, 0x07, 0xF8, 0x73, 0xFF, 0x8F,
  0xFF, 0x3B, 0xFF, 0xEF, 0xFF, 0xDF, 0x81, 0xFF, 0x03, 0xEF, 0x80, 0x7F,
  0x00, 0xF7, 0x80, 0x1F, 0x00, 0x3F, 0xC0, 0x0F, 0x80, 0x1F, 0xE0, 0x07,
  0x80, 0x0F, 0xF0, 0x03, 0xC0, 0x07, 0xF0, 0x01, 0xE0, 0x03, 0xF8, 0x00,
  0xF0, 0x01, 0xFC, 0x00, 0x78, 0x00, 0xFE, 0x00, 0x3C, 0x00, 0x7F, 0x00,
  0x1E, 0x00, 0x3F, 0x80, 0x0F, 0x00, 0x1F, 0xC0, 0x07, 0x80, 0x0F, 0xE0,
  0x03, 0xC0, 0x07, 0xF0, 0x01, 0xE0, 0x03, 0xF8, 0x00, 0xF0, 0x01, 0xFC,
  0x00, 0x78, 0x00, 0xFE, 0x00, 0x3C, 0x00, 0x7F, 0x00, 0x1E, 0x00, 0x3F,
  0x80, 0x0F, 0x00, 0x1E, 0xE3, 0xFF, 0x1C, 0xFF, 0xF3, 0xBF, 0xFF, 0x7E,
  0x03, 0xEF, 0x80, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x78, 0x03,
  0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFE, 0x0F, 0xC0, 0xF8, 0x3C, 0x00,
  0xF1, 0xF0, 0x03, 0xE7, 0x80, 0x07, 0x9E, 0x00, 0x1E, 0x78, 0x00, 0x3B,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xF7, 0x80, 0x07, 0x9E, 0x00, 0x1E, 0x78, 0x00, 0x78, 0xF0, 0x03,
  0xE3, 0xC0, 0x0F, 0x07, 0xC0, 0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0xFE, 0x00,
  0x3F, 0xF0, 0x00, 0xE3, 0xFE, 0x0E, 0x7F, 0xF0, 0xEF, 0xFF, 0x8F, 0xC0,
  0x7C, 0xF8, 0x03, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x0F, 0xF0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xEF, 0x80, 0x1E,
  0xF8, 0x03, 0xEF, 0xC0, 0x7C, 0xEF, 0xFF, 0x8E, 0x7F, 0xF0, 0xE3, 0xFE,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0xFC, 0x38, 0x7F, 0xFB, 0xC7, 0xFF, 0xFE, 0x7C, 0x07,
  0xF3, 0xC0, 0x1F, 0xBE, 0x00, 0x7D, 0xE0, 0x03, 0xEF, 0x00, 0x0F, 0x78,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3D, 0xE0, 0x01, 0xEF, 0x00, 0x0F, 0x78, 0x00, 0xFB, 0xC0,
  0x07, 0xCF, 0x00, 0x7E, 0x7C, 0x07, 0xF1, 0xFF, 0xFF, 0x87, 0xFF, 0x3C,
  0x1F, 0xF1, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0xE1, 0xFF, 0x3F, 0xFB, 0xFF, 0xDE, 0x0F,
  0xC0, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x00, 0x0F, 0xFE, 0x1F, 0xFF, 0x9F,
  0xFF, 0xCF, 0x00, 0xCF, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00,
  0x7E, 0x00, 0x1F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x01,
  0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xDC,
  0x01, 0xEF, 0xFF, 0xE7, 0xFF, 0xE1, 0xFF, 0xE0, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x07, 0x80, 0x1E, 0x01, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1F, 0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0xFF, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x01, 0xF7, 0x80, 0x1F, 0x78, 0x03, 0xF7, 0xC0, 0x7F, 0x3F,
  0xFF, 0xF1, 0xFF, 0xE7, 0x0F, 0xF8, 0x70, 0xF0, 0x00, 0x3D, 0xE0, 0x01,
  0xE7, 0x80, 0x07, 0x9E, 0x00, 0x1E, 0x3C, 0x00, 0xF0, 0xF0, 0x03, 0xC3,
  0xC0, 0x1E, 0x07, 0x80, 0x78, 0x1E, 0x01, 0xE0, 0x38, 0x0F, 0x00, 0xF0,
  0x3C, 0x03, 0xC0, 0xE0, 0x07, 0x87, 0x80, 0x1E, 0x1E, 0x00, 0x38, 0x70,
  0x00, 0xF3, 0xC0, 0x03, 0xCF, 0x00, 0x07, 0x38, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0x80, 0x00, 0xF8,
  0x01, 0xE0, 0x07, 0xBC, 0x01, 0xF0, 0x03, 0xDE, 0x00, 0xFC, 0x01, 0xEF,
  0x00, 0x7E, 0x00, 0xE3, 0xC0, 0x7F, 0x00, 0xF1, 0xE0, 0x3B, 0xC0, 0x78,
  0xF0, 0x1C, 0xE0, 0x3C, 0x38, 0x1E, 0x70, 0x3C, 0x1E, 0x0F, 0x3C, 0x1E,
  0x0F, 0x07, 0x1E, 0x0F, 0x07, 0x83, 0x87, 0x07, 0x01, 0xC3, 0xC3, 0xC7,
  0x80, 0xF1, 0xC1, 0xE3, 0xC0, 0x78, 0xE0, 0x71, 0xE0, 0x3C, 0xF0, 0x38,
  0xE0, 0x0E, 0x70, 0x1E, 0xF0, 0x07, 0xB8, 0x07, 0x78, 0x03, 0xDC, 0x03,
  0xB8, 0x00, 0xFE, 0x01, 0xDC, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0x07, 0x80, 0x0F, 0x80, 0xF8, 0x00,
  0xFB, 0xE0, 0x0F, 0x0F, 0x00, 0x78, 0x3C, 0x07, 0x81, 0xF0, 0x78, 0x07,
  0x83, 0xC0, 0x1E, 0x3C, 0x00, 0xFB, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0x78, 0x00, 0xF1, 0xE0, 0x0F, 0x8F, 0x00, 0x78, 0x3C, 0x07, 0x80, 0xF0,
  0x78, 0x07, 0x83, 0xC0, 0x1E, 0x3C, 0x00, 0x7B, 0xC0, 0x03, 0xE0, 0xF0,
  0x00, 0x3D, 0xE0, 0x01, 0xE7, 0x80, 0x07, 0x9E, 0x00, 0x1E, 0x3C, 0x00,
  0xF0, 0xF0, 0x03, 0xC1, 0xE0, 0x1E, 0x07, 0x80, 0x78, 0x1E, 0x01, 0xE0,
  0x3C, 0x0F, 0x00, 0xF0, 0x3C, 0x01, 0xC0, 0xF0, 0x07, 0x87, 0x80, 0x1E,
  0x1E, 0x00, 0x3C, 0x70, 0x00, 0xF3, 0xC0, 0x01, 0xCF, 0x00, 0x07, 0xB8,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x0F, 0xFC, 0x00,
  0x3F, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF,
  0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0C, 0x01, 0xF0, 0x1F,
  0xC0, 0xFE, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F,
  0x83, 0xFC, 0x0F, 0xC0, 0x3F, 0x00, 0xFF, 0x00, 0x3C, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0xFC,
  0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x03, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x01, 0xFC, 0x0F, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x07, 0xF0, 0x3F, 0x80, 0xFC, 0x03,
  0x80, 0x00, 0x1F, 0x80, 0x17, 0xFE, 0x01, 0xFF, 0xFE, 0xFE, 0x1F, 0xFF,
  0x80, 0x3F, 0xE8, 0x00, 0x38,
};

const GFXglyph NotoSans_Regular43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 5, 32, 12, 3, -31 },
  { 21, 12, 11, 18, 3, -31 },
  { 38, 26, 31, 28, 1, -31 },
  { 139, 19, 36, 25, 3, -33 },
  { 225, 32, 31, 36, 2, -31 },
  { 349, 29, 31, 31, 2, -31 },
  { 462, 4, 11, 10, 3, -31 },
  { 468, 10, 38, 13, 2, -31 },
  { 516, 10, 38, 13, 1, -31 },
  { 564, 20, 20, 24, 2, -33 },
  { 614, 20, 21, 25, 2, -26 },
  { 667, 6, 11, 12, 2, -5 },
  { 676, 10, 3, 14, 2, -13 },
  { 680, 5, 6, 12, 3, -5 },
  { 684, 16, 31, 16, 0, -31 },
  { 746, 20, 31, 25, 2, -31 },
  { 824, 11, 31, 25, 4, -31 },
  { 867, 20, 31, 25, 2, -31 },
  { 945, 20, 31, 25, 2, -31 },
  { 1023, 23, 31, 25, 1, -31 },
  { 1113, 19, 31, 25, 3, -31 },
  { 1187, 21, 31, 25, 2, -31 },
  { 1269, 20, 31, 25, 2, -31 },
  { 1347, 20, 31, 25, 2, -31 },
  { 1425, 20, 31, 25, 2, -31 },
  { 1503, 5, 25, 12, 3, -24 },
  { 1519, 7, 30, 12, 1, -24 },
  { 1546, 20, 21, 25, 2, -26 },
  { 1599, 20, 12, 25, 2, -21 },
  { 1629, 20, 21, 25, 2, -26 },
  { 1682, 17, 32, 19, 1, -31 },
  { 1750, 34, 35, 39, 2, -31 },
  { 1899, 27, 31, 27, 0, -31 },
  { 2004, 22, 31, 28, 4, -31 },
  { 2090, 23, 31, 27, 3, -31 },
  { 2180, 25, 31, 31, 4, -31 },
  { 2277, 17, 31, 24, 4, -31 },
  { 2343, 17, 31, 22, 4, -31 },
  { 2409, 25, 31, 31, 3, -31 },
  { 2506, 24, 31, 32, 4, -31 },
  { 2599, 11, 31, 15, 2, -31 },
  { 2642, 11, 39, 12, -3, -31 },
  { 2696, 23, 31, 27, 4, -31 },
  { 2786, 17, 31, 23, 4, -31 },
  { 2852, 31, 31, 39, 4, -31 },
  { 2973, 25, 31, 33, 4, -31 },
  { 3070, 28, 31, 34, 3, -31 },
  { 3179, 20, 31, 26, 4, -31 },
  { 3257, 28, 38, 34, 3, -31 },
  { 3390, 22, 31, 27, 4, -31 },
  { 3476, 20, 31, 24, 2, -31 },
  { 3554, 23, 31, 24, 0, -31 },
  { 3644, 24, 31, 31, 4, -31 },
  { 3737, 26, 31, 26, 0, -31 },
  { 3838, 38, 31, 40, 1, -31 },
  { 3986, 25, 31, 25, 0, -31 },
  { 4083, 24, 31, 24, 0, -31 },
  { 4176, 21, 31, 25, 2, -31 },
  { 4258, 10, 38, 14, 3, -31 },
  { 4306, 16, 31, 16, 0, -31 },
  { 4368, 10, 38, 14, 1, -31 },
  { 4416, 21, 20, 25, 2, -31 },
  { 4469, 19, 3, 19, 0, 4 },
  { 4477, 8, 7, 12, 2, -33 },
  { 4484, 19, 23, 24, 2, -23 },
  { 4539, 20, 33, 26, 4, -33 },
  { 4622, 17, 23, 21, 2, -23 },
  { 4671, 21, 33, 26, 2, -33 },
  { 4758, 20, 23, 24, 2, -23 },
  { 4816, 16, 33, 15, 1, -33 },
  { 4882, 21, 33, 26, 2, -23 },
  { 4969, 19, 33, 27, 4, -33 },
  { 5048, 5, 32, 11, 3, -32 },
  { 5068, 10, 42, 11, -2, -32 },
  { 5121, 19, 33, 23, 4, -33 },
  { 5200, 3, 33, 11, 4, -33 },
  { 5213, 33, 23, 40, 4, -23 },
  { 5308, 19, 23, 27, 4, -23 },
  { 5363, 22, 23, 26, 2, -23 },
  { 5427, 20, 33, 26, 4, -23 },
  { 5510, 21, 33, 26, 2, -23 },
  { 5597, 13, 23, 18, 4, -23 },
  { 5635, 17, 23, 21, 2, -23 },
  { 5684, 14, 28, 16, 1, -28 },
  { 5733, 20, 23, 27, 3, -23 },
  { 5791, 22, 23, 22, 0, -23 },
  { 5855, 33, 23, 34, 0, -23 },
  { 5950, 21, 23, 23, 1, -23 },
  { 6011, 22, 33, 22, 0, -23 },
  { 6102, 17, 23, 20, 2, -23 },
  { 6151, 14, 38, 16, 1, -31 },
  { 6218, 3, 43, 24, 10, -33 },
  { 6235, 14, 38, 16, 1, -31 },
  { 6302, 20, 6, 25, 2, -18 },
};

const GFXfont NotoSans_Regular43pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Regular43pt7bBitmaps,
  (GFXglyph *)NotoSans_Regular43pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _NOTOSANS_REGULAR43PT7B_H_
