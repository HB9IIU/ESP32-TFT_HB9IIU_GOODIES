#ifndef _NOTOSANS_REGULAR10PT7B_H_
#define _NOTOSANS_REGULAR10PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Regular.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Regular10pt7bBitmaps[] PROGMEM = {
  0x00, 0xFA, 0xF0, 0x28, 0xA7, 0xCA, 0xFD, 0x45, 0x00, 0x47, 0xCC, 0x65,
  0xD6, 0x40, 0x66, 0x94, 0x9A, 0x6D, 0x15, 0x15, 0x26, 0xF2, 0x46, 0x39,
  0x96, 0x2F, 0x40, 0xC0, 0x69, 0x49, 0x12, 0x20, 0xC9, 0x12, 0x52, 0x80,
  0x21, 0x3E, 0x65, 0x00, 0x21, 0x3E, 0x42, 0x00, 0x60, 0xE0, 0x80, 0x32,
  0x24, 0x44, 0x80, 0x72, 0x63, 0x18, 0xA5, 0xC0, 0x74, 0x92, 0x48, 0x78,
  0x42, 0x22, 0x23, 0xE0, 0xF8, 0x42, 0x60, 0x87, 0xC0, 0x10, 0xA2, 0x92,
  0xFC, 0x20, 0x80, 0xF8, 0x8F, 0x11, 0xE0, 0x78, 0xE9, 0x99, 0xF0, 0xF8,
  0x44, 0x22, 0x11, 0x80, 0x7A, 0x52, 0x64, 0xC5, 0xE0, 0x74, 0x62, 0xF0,
  0x85, 0xC0, 0xC4, 0x50, 0x18, 0x09, 0xB0, 0x60, 0x80, 0xF0, 0xF0, 0xC1,
  0x82, 0x6C, 0x00, 0xF1, 0x12, 0x40, 0x40, 0x7D, 0x06, 0xED, 0x5C, 0xB6,
  0xE0, 0x3C, 0x10, 0xC2, 0x92, 0x79, 0x18, 0x40, 0xF4, 0x63, 0xE8, 0xC7,
  0xC0, 0x7C, 0x21, 0x08, 0x41, 0xE0, 0xF2, 0x28, 0x61, 0x86, 0x2F, 0x00,
  0xF8, 0x8F, 0x88, 0xF0, 0xF8, 0x8F, 0x88, 0x80, 0x7A, 0x08, 0x27, 0x86,
  0x17, 0xC0, 0x8C, 0x63, 0xF8, 0xC6, 0x20, 0xE9, 0x24, 0xB8, 0x24, 0x92,
  0x49, 0xC0, 0x9C, 0xA9, 0xCA, 0x4A, 0x20, 0x88, 0x88, 0x88, 0xF0, 0xC3,
  0x8F, 0x1D, 0x5A, 0xB5, 0x64, 0x80, 0x87, 0x1A, 0x69, 0x96, 0x38, 0xC0,
  0x7A, 0x18, 0x61, 0x86, 0x17, 0x80, 0xF4, 0x63, 0xE8, 0x42, 0x00, 0x7A,
  0x18, 0x61, 0x86, 0x17, 0x82, 0x0C, 0xF4, 0x65, 0xE9, 0x4A, 0x20, 0xF8,
  0x86, 0x11, 0xE0, 0xF9, 0x08, 0x42, 0x10, 0x80, 0x8C, 0x63, 0x18, 0xC5,
  0xE0, 0x85, 0x24, 0x92, 0x30, 0xC3, 0x00, 0x88, 0xA6, 0x55, 0x2A, 0xA5,
  0x31, 0x18, 0x88, 0xCD, 0x23, 0x0C, 0x31, 0x28, 0xC0, 0x8D, 0x25, 0x0C,
  0x20, 0x82, 0x00, 0xF8, 0x44, 0x42, 0x23, 0xE0, 0xEA, 0xAA, 0xC0, 0x84,
  0x44, 0x22, 0x10, 0xD5, 0x55, 0xC0, 0x21, 0x93, 0x90, 0xF0, 0xD0, 0x78,
  0x5F, 0x17, 0x80, 0x84, 0x29, 0xA8, 0xC6, 0x5E, 0xF2, 0x4E, 0x11, 0x5B,
  0x99, 0x9F, 0xF9, 0xE8, 0xF0, 0x34, 0x6C, 0x44, 0x44, 0xF9, 0x99, 0xF1,
  0xF0, 0x88, 0xAD, 0x99, 0x99, 0xBE, 0x20, 0x92, 0x49, 0xE0, 0x88, 0x9A,
  0xCC, 0xA9, 0xFF, 0xFE, 0x91, 0x91, 0x91, 0x91, 0xF9, 0x99, 0x90, 0xF4,
  0xA3, 0x2F, 0x00, 0xF4, 0x63, 0x2F, 0x42, 0x00, 0xF9, 0x99, 0xF1, 0x10,
  0xF2, 0x48, 0xF1, 0x9E, 0x4F, 0x24, 0x98, 0x99, 0x99, 0xF0, 0x8A, 0x94,
  0xA2, 0x00, 0x99, 0x5A, 0x6A, 0x66, 0x64, 0xD9, 0x88, 0xAC, 0x80, 0x8A,
  0x94, 0xA2, 0x13, 0x00, 0x72, 0x24, 0xF0, 0x29, 0x2C, 0x91, 0x20, 0xFF,
  0xC0, 0xC4, 0x44, 0x34, 0x44, 0x80, 0xF8,
};

const GFXglyph NotoSans_Regular10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 1, 7, 3, 1, -7 },
  { 2, 2, 2, 4, 1, -7 },
  { 3, 6, 7, 6, 0, -7 },
  { 9, 4, 9, 6, 1, -8 },
  { 14, 8, 7, 8, 0, -7 },
  { 21, 6, 7, 7, 1, -7 },
  { 27, 1, 2, 2, 1, -7 },
  { 28, 3, 9, 3, 0, -7 },
  { 32, 3, 9, 3, 0, -7 },
  { 36, 5, 5, 6, 0, -8 },
  { 40, 5, 5, 6, 0, -6 },
  { 44, 2, 2, 3, 0, -1 },
  { 45, 3, 1, 3, 0, -3 },
  { 46, 1, 1, 3, 1, -1 },
  { 47, 4, 7, 4, 0, -7 },
  { 51, 5, 7, 6, 0, -7 },
  { 56, 3, 7, 6, 1, -7 },
  { 59, 5, 7, 6, 0, -7 },
  { 64, 5, 7, 6, 0, -7 },
  { 69, 6, 7, 6, 0, -7 },
  { 75, 4, 7, 6, 1, -7 },
  { 79, 4, 7, 6, 1, -7 },
  { 83, 5, 7, 6, 0, -7 },
  { 88, 5, 7, 6, 0, -7 },
  { 93, 5, 7, 6, 0, -7 },
  { 98, 1, 6, 3, 1, -6 },
  { 99, 2, 7, 3, 0, -6 },
  { 101, 5, 5, 6, 0, -6 },
  { 105, 4, 3, 6, 1, -5 },
  { 107, 5, 5, 6, 0, -6 },
  { 111, 4, 7, 4, 0, -7 },
  { 115, 7, 8, 9, 1, -7 },
  { 122, 6, 7, 6, 0, -7 },
  { 128, 5, 7, 7, 1, -7 },
  { 133, 5, 7, 6, 1, -7 },
  { 138, 6, 7, 7, 1, -7 },
  { 144, 4, 7, 6, 1, -7 },
  { 148, 4, 7, 5, 1, -7 },
  { 152, 6, 7, 7, 1, -7 },
  { 158, 5, 7, 7, 1, -7 },
  { 163, 3, 7, 3, 0, -7 },
  { 166, 3, 9, 3, -1, -7 },
  { 170, 5, 7, 6, 1, -7 },
  { 175, 4, 7, 5, 1, -7 },
  { 179, 7, 7, 9, 1, -7 },
  { 186, 6, 7, 8, 1, -7 },
  { 192, 6, 7, 8, 1, -7 },
  { 198, 5, 7, 6, 1, -7 },
  { 203, 6, 9, 8, 1, -7 },
  { 210, 5, 7, 6, 1, -7 },
  { 215, 4, 7, 5, 1, -7 },
  { 219, 5, 7, 6, 0, -7 },
  { 224, 5, 7, 7, 1, -7 },
  { 229, 6, 7, 6, 0, -7 },
  { 235, 9, 7, 9, 0, -7 },
  { 243, 6, 7, 6, 0, -7 },
  { 249, 6, 7, 6, 0, -7 },
  { 255, 5, 7, 6, 0, -7 },
  { 260, 2, 9, 3, 1, -7 },
  { 263, 4, 7, 4, 0, -7 },
  { 267, 2, 9, 3, 0, -7 },
  { 270, 5, 4, 6, 0, -7 },
  { 273, 4, 1, 4, 0, 1 },
  { 274, 2, 2, 3, 0, -8 },
  { 275, 5, 5, 6, 0, -5 },
  { 279, 5, 8, 6, 1, -8 },
  { 284, 3, 5, 5, 1, -5 },
  { 286, 4, 8, 6, 1, -8 },
  { 290, 4, 5, 6, 1, -5 },
  { 293, 4, 8, 3, 0, -8 },
  { 297, 4, 7, 6, 1, -5 },
  { 301, 4, 8, 6, 1, -8 },
  { 305, 1, 7, 3, 1, -7 },
  { 306, 3, 9, 3, -1, -7 },
  { 310, 4, 8, 5, 1, -8 },
  { 314, 1, 8, 3, 1, -8 },
  { 315, 8, 5, 9, 1, -5 },
  { 320, 4, 5, 6, 1, -5 },
  { 323, 5, 5, 6, 1, -5 },
  { 327, 5, 7, 6, 1, -5 },
  { 332, 4, 7, 6, 1, -5 },
  { 336, 3, 5, 4, 1, -5 },
  { 338, 3, 5, 5, 1, -5 },
  { 340, 3, 7, 4, 0, -7 },
  { 343, 4, 5, 6, 1, -5 },
  { 346, 5, 5, 5, 0, -5 },
  { 350, 8, 5, 8, 0, -5 },
  { 355, 5, 5, 5, 0, -5 },
  { 359, 5, 7, 5, 0, -5 },
  { 364, 4, 5, 5, 0, -5 },
  { 367, 3, 9, 4, 0, -7 },
  { 371, 1, 10, 6, 2, -8 },
  { 373, 4, 9, 4, 0, -7 },
  { 378, 5, 1, 6, 0, -4 },
};

const GFXfont NotoSans_Regular10pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Regular10pt7bBitmaps,
  (GFXglyph *)NotoSans_Regular10pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _NOTOSANS_REGULAR10PT7B_H_
