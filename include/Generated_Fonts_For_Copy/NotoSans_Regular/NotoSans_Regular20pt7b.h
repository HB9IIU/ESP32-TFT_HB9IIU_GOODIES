#ifndef _NOTOSANS_REGULAR20PT7B_H_
#define _NOTOSANS_REGULAR20PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Regular.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Regular20pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB6, 0x92, 0x48, 0x0E, 0xC0, 0xCF, 0x34, 0xD3, 0x48, 0x04,
  0x60, 0x44, 0x0C, 0x40, 0xC4, 0x7F, 0xF0, 0x8C, 0x08, 0x81, 0x88, 0xFF,
  0xFF, 0xFF, 0x11, 0x81, 0x10, 0x11, 0x03, 0x30, 0x08, 0x04, 0x1F, 0xED,
  0x2C, 0x86, 0x41, 0xE0, 0x7C, 0x0F, 0x04, 0xC2, 0x21, 0x3F, 0xFB, 0xF0,
  0x20, 0x10, 0x78, 0x31, 0x98, 0x43, 0x31, 0x84, 0x66, 0x08, 0xC8, 0x19,
  0xB7, 0x33, 0x5F, 0x3D, 0xA2, 0x02, 0x46, 0x0C, 0x8C, 0x11, 0x18, 0x62,
  0x21, 0x86, 0x42, 0x07, 0x80, 0x04, 0x00, 0xFC, 0x03, 0x30, 0x18, 0x60,
  0x21, 0x00, 0xCC, 0x01, 0xE0, 0x0F, 0x00, 0x76, 0x1B, 0x0C, 0xCC, 0x1B,
  0x30, 0x38, 0xC0, 0xE1, 0xCE, 0xC3, 0xF1, 0xC0, 0xF5, 0x40, 0x32, 0x64,
  0xCC, 0xCC, 0xCC, 0xCC, 0xC4, 0x62, 0x30, 0xC6, 0x62, 0x33, 0x33, 0x33,
  0x33, 0x32, 0x64, 0xC0, 0x18, 0x04, 0x02, 0x1D, 0x77, 0xF0, 0xA0, 0xD8,
  0xC6, 0x22, 0x00, 0x08, 0x04, 0x02, 0x01, 0x0F, 0xFF, 0xFC, 0x20, 0x10,
  0x08, 0x04, 0x00, 0x6B, 0x68, 0xF8, 0xEC, 0x06, 0x0C, 0x30, 0x60, 0x83,
  0x06, 0x08, 0x30, 0x60, 0x83, 0x04, 0x18, 0x00, 0x08, 0x1F, 0x98, 0xC8,
  0x3C, 0x1E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x36, 0x1B, 0x98,
  0xF8, 0x1B, 0xF7, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x7F, 0x61,
  0x80, 0x60, 0x30, 0x18, 0x18, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0F,
  0xFF, 0xFC, 0x7F, 0x61, 0xC0, 0x60, 0x30, 0x18, 0x18, 0xF0, 0x0E, 0x01,
  0x80, 0xC0, 0x60, 0x3C, 0x37, 0xF0, 0x01, 0x80, 0x70, 0x1E, 0x06, 0xC0,
  0x98, 0x33, 0x0C, 0x61, 0x0C, 0x61, 0x9F, 0xFF, 0xFF, 0x80, 0xC0, 0x18,
  0x03, 0x00, 0x7F, 0x30, 0x18, 0x08, 0x04, 0x03, 0xE1, 0xFC, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x3C, 0x77, 0xF0, 0x1F, 0x0C, 0x06, 0x01, 0x00, 0xC0,
  0x37, 0x8F, 0x3B, 0x86, 0xC0, 0xB0, 0x3C, 0x09, 0x86, 0x73, 0x8F, 0xC0,
  0xFF, 0x80, 0xC0, 0x60, 0x20, 0x30, 0x10, 0x18, 0x0C, 0x0C, 0x06, 0x06,
  0x03, 0x03, 0x01, 0x80, 0x3F, 0x30, 0xF0, 0x78, 0x36, 0x19, 0xB8, 0x70,
  0xEE, 0xC1, 0xE0, 0x70, 0x38, 0x36, 0x39, 0xF8, 0x3E, 0x31, 0xB0, 0x78,
  0x3C, 0x0E, 0x0F, 0x06, 0xFD, 0x19, 0x80, 0xC0, 0x60, 0x64, 0x63, 0xE0,
  0x7D, 0x00, 0x00, 0x1D, 0x80, 0x7D, 0x00, 0x00, 0x0F, 0x69, 0x00, 0x00,
  0x81, 0xC3, 0x87, 0x0E, 0x07, 0x00, 0xF0, 0x1E, 0x01, 0x80, 0x40, 0xFF,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x18,
  0x1C, 0x38, 0x70, 0xE0, 0x40, 0x00, 0xFE, 0x43, 0x03, 0x03, 0x03, 0x06,
  0x0C, 0x18, 0x10, 0x10, 0x00, 0x00, 0x38, 0x38, 0x07, 0xF0, 0x1C, 0x1C,
  0x30, 0x06, 0x60, 0x02, 0x43, 0xE2, 0x46, 0x23, 0xCC, 0x23, 0xCC, 0x23,
  0xCC, 0x23, 0xCC, 0x62, 0xC6, 0xF6, 0x43, 0x9C, 0x60, 0x00, 0x30, 0x00,
  0x1F, 0xF0, 0x07, 0xC0, 0x07, 0x00, 0x38, 0x03, 0x40, 0x1B, 0x00, 0x98,
  0x0C, 0x40, 0x63, 0x02, 0x18, 0x3F, 0xE1, 0xFF, 0x18, 0x08, 0xC0, 0x64,
  0x03, 0x60, 0x0C, 0xFF, 0x30, 0xEC, 0x1B, 0x02, 0xC1, 0xB0, 0xEF, 0xE3,
  0x0E, 0xC0, 0xF0, 0x3C, 0x0F, 0x07, 0xFF, 0xBF, 0xC0, 0x1F, 0xE7, 0x09,
  0xC0, 0x30, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80,
  0x38, 0x03, 0xC4, 0x3F, 0x80, 0xFF, 0x18, 0x73, 0x03, 0x60, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0xE0, 0xEF, 0xF9, 0xFC,
  0x00, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xFF, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x0F, 0xF3, 0x82, 0x70, 0x06, 0x00, 0x40,
  0x0C, 0x00, 0xC1, 0xFC, 0x1F, 0xC0, 0x36, 0x03, 0x60, 0x37, 0x03, 0x3C,
  0x70, 0xFF, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xFF, 0xFE,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xC0, 0xFB, 0x18,
  0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x7C, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC6, 0xFB, 0xC0, 0xC1, 0xF0, 0xEC,
  0x33, 0x18, 0xCC, 0x36, 0x0F, 0x83, 0xF0, 0xCC, 0x31, 0x8C, 0x33, 0x0E,
  0xC1, 0xB0, 0x30, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xFF, 0xFF, 0xE0, 0x1E, 0x80, 0x7F, 0x03, 0x7C, 0x0F,
  0xD0, 0x2F, 0x61, 0xBD, 0x86, 0xF3, 0x13, 0xCC, 0xCF, 0x12, 0x3C, 0x78,
  0xF1, 0xE3, 0xC3, 0x0F, 0x0C, 0x30, 0xE0, 0x3C, 0x06, 0xC0, 0xF8, 0x1D,
  0x83, 0x98, 0x73, 0x0E, 0x31, 0xC3, 0x38, 0x67, 0x06, 0xE0, 0x7C, 0x0F,
  0x80, 0xC0, 0x02, 0x00, 0xFF, 0x0E, 0x1C, 0xC0, 0x66, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xD0, 0x06, 0xC0, 0x37, 0x03, 0x1C,
  0x70, 0x3F, 0x00, 0xFE, 0x63, 0xB0, 0x78, 0x3C, 0x1E, 0x0F, 0x0D, 0xFC,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x00, 0x02, 0x00, 0xFF, 0x0E, 0x1C,
  0xC0, 0x66, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xD0,
  0x06, 0xC0, 0x37, 0x03, 0x1C, 0x70, 0x3F, 0x00, 0x18, 0x00, 0xE0, 0x03,
  0xC0, 0xFE, 0x30, 0xEC, 0x1B, 0x06, 0xC1, 0xB0, 0x6C, 0x73, 0xF0, 0xC6,
  0x31, 0x8C, 0x33, 0x06, 0xC1, 0xB0, 0x30, 0x7F, 0xB0, 0xB0, 0x18, 0x0C,
  0x03, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0xC0, 0x60, 0x3C, 0x77, 0xF0, 0xFF,
  0xE0, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x00, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x67,
  0x1C, 0x7E, 0x00, 0xC0, 0x36, 0x06, 0x60, 0x66, 0x06, 0x30, 0xC3, 0x0C,
  0x30, 0xC1, 0x98, 0x19, 0x81, 0x98, 0x0F, 0x00, 0xF0, 0x06, 0x00, 0x60,
  0xC0, 0xC0, 0xD8, 0x38, 0x36, 0x1E, 0x0D, 0x86, 0x82, 0x21, 0xB1, 0x8C,
  0x4C, 0x63, 0x33, 0x18, 0xCC, 0x6C, 0x12, 0x1B, 0x07, 0x86, 0xC1, 0xE0,
  0xA0, 0x78, 0x38, 0x0C, 0x0E, 0x03, 0x01, 0x80, 0xE0, 0x62, 0x0C, 0x30,
  0x81, 0x98, 0x1B, 0x00, 0xF0, 0x06, 0x00, 0xF0, 0x0B, 0x01, 0x98, 0x31,
  0x83, 0x0C, 0x60, 0x6C, 0x07, 0xC0, 0x6C, 0x18, 0x83, 0x18, 0xC1, 0x18,
  0x36, 0x03, 0xC0, 0x70, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x00, 0xFF, 0x80, 0x60, 0x38, 0x0C, 0x06, 0x01, 0x80, 0xC0, 0x60, 0x18,
  0x0C, 0x06, 0x01, 0x80, 0xFF, 0xFF, 0xF0, 0xF8, 0x88, 0x88, 0x88, 0x88,
  0x88, 0x88, 0x88, 0xF0, 0xC0, 0xC1, 0x81, 0x03, 0x06, 0x04, 0x0C, 0x18,
  0x18, 0x30, 0x20, 0x60, 0xC0, 0xF8, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6,
  0x31, 0x8C, 0x63, 0xF8, 0x08, 0x07, 0x01, 0x40, 0xC8, 0x23, 0x18, 0x44,
  0x1B, 0x02, 0x80, 0xC0, 0xFF, 0x80, 0xC6, 0x30, 0x3E, 0x3F, 0x80, 0x40,
  0x30, 0x1B, 0xFF, 0x07, 0x83, 0xC3, 0xF3, 0xDF, 0x60, 0x80, 0x40, 0x20,
  0x10, 0x09, 0xE5, 0xFB, 0x07, 0x83, 0xC1, 0xC0, 0xE0, 0x78, 0x3C, 0x1F,
  0x1A, 0xF8, 0x1F, 0x7F, 0x60, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x60, 0x71,
  0x3F, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x1C, 0xDF, 0xF6, 0x1F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0x61, 0xDC, 0xF3, 0xEC, 0x1E, 0x3F, 0x98, 0x78,
  0x3C, 0x1F, 0xFF, 0x01, 0x80, 0x60, 0x38, 0xCF, 0xE0, 0x1F, 0x18, 0x30,
  0x30, 0x7E, 0xFE, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30,
  0x1C, 0xDF, 0xF6, 0x1F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x61, 0xDC,
  0xF3, 0xEC, 0x03, 0x00, 0xA0, 0x67, 0xF8, 0xF8, 0x80, 0x40, 0x20, 0x10,
  0x09, 0xE5, 0xFB, 0x07, 0x83, 0xC1, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x06, 0xB8, 0xAA, 0xAA, 0xA8, 0x10, 0xC4, 0x01, 0x08, 0x42, 0x10, 0x84,
  0x21, 0x08, 0x42, 0x10, 0xBD, 0xC0, 0x80, 0x40, 0x20, 0x10, 0x08, 0x34,
  0x32, 0x31, 0x30, 0xB0, 0x78, 0x36, 0x11, 0x88, 0x64, 0x32, 0x0E, 0xFF,
  0xFE, 0x9E, 0x39, 0x7F, 0xFF, 0x0E, 0x1E, 0x18, 0x38, 0x10, 0x70, 0x20,
  0xE0, 0x41, 0xC0, 0x83, 0x81, 0x07, 0x02, 0x0E, 0x04, 0x18, 0x9E, 0x5F,
  0xB0, 0x78, 0x3C, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x60, 0x1E,
  0x1F, 0xE6, 0x1B, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x60, 0x9C, 0xE3,
  0xF0, 0x9E, 0x5F, 0xB0, 0x78, 0x3C, 0x1C, 0x0E, 0x07, 0x83, 0xC1, 0xF1,
  0xAF, 0x90, 0x08, 0x04, 0x02, 0x01, 0x00, 0x1C, 0xDF, 0xF6, 0x1F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x61, 0xDC, 0xF3, 0xEC, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x9E, 0xFE, 0x30, 0xC2, 0x08, 0x20, 0x82, 0x08, 0x00,
  0x3E, 0xFE, 0xC0, 0xC0, 0x70, 0x3C, 0x0E, 0x03, 0x03, 0xC6, 0xFC, 0x30,
  0x61, 0xFF, 0xF3, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x81, 0xE0, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0xC3, 0xE3, 0xDF, 0x60,
  0xC0, 0xF0, 0x36, 0x19, 0x86, 0x21, 0x8C, 0xC3, 0x30, 0x48, 0x1E, 0x07,
  0x80, 0xC0, 0xC1, 0x83, 0x41, 0x86, 0x63, 0xC6, 0x62, 0xC6, 0x62, 0xC4,
  0x26, 0x4C, 0x36, 0x6C, 0x34, 0x68, 0x3C, 0x28, 0x1C, 0x38, 0x18, 0x38,
  0x60, 0xD8, 0x63, 0x10, 0x6C, 0x0E, 0x03, 0x00, 0xE0, 0x6C, 0x31, 0x18,
  0x6E, 0x0C, 0xC0, 0xD0, 0x36, 0x09, 0x86, 0x31, 0x8C, 0xC1, 0x30, 0x68,
  0x1E, 0x03, 0x80, 0xC0, 0x30, 0x0C, 0x06, 0x0F, 0x03, 0x80, 0xFE, 0xFE,
  0x06, 0x0C, 0x08, 0x18, 0x30, 0x60, 0x60, 0xC0, 0xFF, 0x1C, 0xE3, 0x0C,
  0x30, 0xC3, 0x18, 0xC1, 0x83, 0x0C, 0x30, 0xC3, 0x0E, 0x1C, 0xFF, 0xFF,
  0xF0, 0xE1, 0x83, 0x0C, 0x30, 0xC3, 0x0E, 0x0C, 0xC3, 0x0C, 0x30, 0xC3,
  0x18, 0xC0, 0xFC, 0xC7, 0xC0,
};

const GFXglyph NotoSans_Regular20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 3, 14, 5, 1, -14 },
  { 7, 6, 5, 8, 1, -14 },
  { 11, 12, 14, 13, 0, -14 },
  { 32, 9, 16, 11, 1, -15 },
  { 50, 15, 14, 17, 1, -14 },
  { 77, 14, 15, 15, 1, -15 },
  { 104, 2, 5, 5, 1, -14 },
  { 106, 4, 17, 6, 1, -14 },
  { 115, 4, 17, 6, 1, -14 },
  { 124, 9, 9, 11, 1, -15 },
  { 135, 9, 10, 11, 1, -12 },
  { 147, 3, 5, 5, 1, -2 },
  { 149, 5, 1, 6, 1, -6 },
  { 150, 3, 2, 5, 1, -2 },
  { 151, 7, 14, 7, 0, -14 },
  { 164, 9, 15, 11, 1, -15 },
  { 181, 5, 14, 11, 2, -14 },
  { 190, 9, 14, 11, 1, -14 },
  { 206, 9, 14, 11, 1, -14 },
  { 222, 11, 14, 11, 0, -14 },
  { 242, 9, 14, 11, 1, -14 },
  { 258, 10, 14, 11, 1, -14 },
  { 276, 9, 14, 11, 1, -14 },
  { 292, 9, 14, 11, 1, -14 },
  { 308, 9, 14, 11, 1, -14 },
  { 324, 3, 11, 5, 1, -11 },
  { 329, 3, 14, 5, 1, -11 },
  { 335, 9, 10, 11, 1, -12 },
  { 347, 9, 6, 11, 1, -10 },
  { 354, 9, 10, 11, 1, -12 },
  { 366, 8, 14, 9, 0, -14 },
  { 380, 16, 16, 18, 1, -14 },
  { 412, 13, 14, 13, 0, -14 },
  { 435, 10, 14, 13, 2, -14 },
  { 453, 11, 14, 13, 1, -14 },
  { 473, 11, 14, 15, 2, -14 },
  { 493, 8, 14, 11, 2, -14 },
  { 507, 8, 14, 10, 2, -14 },
  { 521, 12, 14, 15, 1, -14 },
  { 542, 11, 14, 15, 2, -14 },
  { 562, 5, 14, 7, 1, -14 },
  { 571, 6, 18, 5, -2, -14 },
  { 585, 10, 14, 12, 2, -14 },
  { 603, 8, 14, 10, 2, -14 },
  { 617, 14, 14, 18, 2, -14 },
  { 642, 11, 14, 15, 2, -14 },
  { 662, 13, 15, 16, 1, -15 },
  { 687, 9, 14, 12, 2, -14 },
  { 703, 13, 18, 16, 1, -15 },
  { 733, 10, 14, 12, 2, -14 },
  { 751, 9, 14, 11, 1, -14 },
  { 767, 11, 14, 11, 0, -14 },
  { 787, 11, 14, 15, 2, -14 },
  { 807, 12, 14, 12, 0, -14 },
  { 828, 18, 14, 19, 0, -14 },
  { 860, 12, 14, 12, 0, -14 },
  { 881, 11, 14, 11, 0, -14 },
  { 901, 10, 14, 11, 1, -14 },
  { 919, 4, 17, 7, 2, -14 },
  { 928, 7, 14, 7, 0, -14 },
  { 941, 5, 17, 7, 0, -14 },
  { 952, 10, 9, 11, 1, -14 },
  { 964, 9, 1, 9, 0, 2 },
  { 966, 4, 3, 6, 1, -15 },
  { 968, 9, 11, 11, 1, -11 },
  { 981, 9, 15, 12, 2, -15 },
  { 998, 8, 11, 10, 1, -11 },
  { 1009, 10, 15, 12, 1, -15 },
  { 1028, 9, 11, 11, 1, -11 },
  { 1041, 8, 15, 7, 0, -15 },
  { 1056, 10, 16, 12, 1, -11 },
  { 1076, 9, 15, 12, 2, -15 },
  { 1093, 2, 15, 5, 2, -15 },
  { 1097, 5, 20, 5, -1, -15 },
  { 1110, 9, 15, 11, 2, -15 },
  { 1127, 1, 15, 5, 2, -15 },
  { 1129, 15, 11, 19, 2, -11 },
  { 1150, 9, 11, 12, 2, -11 },
  { 1163, 10, 11, 12, 1, -11 },
  { 1177, 9, 16, 12, 2, -11 },
  { 1195, 10, 16, 12, 1, -11 },
  { 1215, 6, 11, 8, 2, -11 },
  { 1224, 8, 11, 10, 1, -11 },
  { 1235, 7, 13, 7, 0, -13 },
  { 1247, 9, 11, 12, 2, -11 },
  { 1260, 10, 11, 10, 0, -11 },
  { 1274, 16, 11, 16, 0, -11 },
  { 1296, 10, 11, 11, 0, -11 },
  { 1310, 10, 16, 10, 0, -11 },
  { 1330, 8, 11, 9, 1, -11 },
  { 1341, 6, 17, 8, 1, -14 },
  { 1354, 1, 20, 11, 5, -15 },
  { 1357, 6, 17, 8, 1, -14 },
  { 1370, 9, 2, 11, 1, -8 },
};

const GFXfont NotoSans_Regular20pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Regular20pt7bBitmaps,
  (GFXglyph *)NotoSans_Regular20pt7bGlyphs,
  0x20, 0x7E, 27
};

#endif // _NOTOSANS_REGULAR20PT7B_H_
