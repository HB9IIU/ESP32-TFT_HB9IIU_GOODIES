#ifndef _NOTOSANS_REGULAR46PT7B_H_
#define _NOTOSANS_REGULAR46PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Regular.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Regular46pt7bBitmaps[] PROGMEM = {
  0x00, 0x7D, 0xF7, 0xDE, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x00, 0x00, 0x04, 0x7B, 0xFF,
  0xFF, 0x7C, 0xC0, 0xF0, 0xFF, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0x78,
  0x3B, 0xC1, 0xCE, 0x0E, 0x70, 0x73, 0x83, 0x9C, 0x1C, 0xC0, 0xE0, 0x00,
  0x3C, 0x0F, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x38, 0x0E, 0x00, 0x03, 0x80,
  0xE0, 0x00, 0x38, 0x0E, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x78, 0x1C, 0x00,
  0x07, 0x01, 0xC0, 0x00, 0x70, 0x1C, 0x00, 0x07, 0x01, 0xC0, 0x3F, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF0, 0x0E, 0x03, 0x80,
  0x00, 0xE0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0x70, 0x00, 0x1C,
  0x07, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x1C, 0x07, 0x00, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xC0, 0x38, 0x0E, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x38, 0x1E, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x70, 0x1C,
  0x00, 0x07, 0x01, 0xC0, 0x00, 0x70, 0x1C, 0x00, 0x07, 0x03, 0xC0, 0x00,
  0xF0, 0x38, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFC, 0x78, 0x70, 0xE7, 0x83, 0x80, 0x3C, 0x1C, 0x01,
  0xE0, 0xE0, 0x0F, 0x07, 0x00, 0x78, 0x38, 0x03, 0xE1, 0xC0, 0x0F, 0xEE,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x39, 0xF8, 0x01, 0xC3, 0xC0, 0x0E, 0x1F, 0x00, 0x70,
  0x78, 0x03, 0x83, 0xC0, 0x1C, 0x3F, 0x00, 0xE1, 0xEE, 0x07, 0x3F, 0x7F,
  0xFF, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xE0, 0x03, 0xF0, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x0F,
  0xC0, 0x00, 0xF0, 0x0F, 0xF8, 0x00, 0x38, 0x03, 0xFF, 0x00, 0x1E, 0x01,
  0xE1, 0xE0, 0x07, 0x00, 0x70, 0x38, 0x03, 0xC0, 0x1C, 0x0E, 0x01, 0xE0,
  0x0F, 0x03, 0xC0, 0x70, 0x03, 0xC0, 0xF0, 0x3C, 0x00, 0xF0, 0x3C, 0x0E,
  0x00, 0x3C, 0x0F, 0x07, 0x80, 0x0F, 0x03, 0xC1, 0xC0, 0x03, 0xC0, 0xF0,
  0xF0, 0x00, 0xF0, 0x3C, 0x38, 0x00, 0x1C, 0x0F, 0x1E, 0x3F, 0x07, 0x03,
  0x8F, 0x1F, 0xE1, 0xC0, 0xE3, 0x8F, 0xFC, 0x78, 0x79, 0xE7, 0x87, 0x8F,
  0xFC, 0x71, 0xE0, 0xE1, 0xFE, 0x3C, 0x70, 0x38, 0x3F, 0x0E, 0x1C, 0x0F,
  0x00, 0x07, 0x8F, 0x03, 0xC0, 0x01, 0xC3, 0xC0, 0x70, 0x00, 0xF0, 0xF0,
  0x1C, 0x00, 0x78, 0x3C, 0x07, 0x00, 0x1E, 0x0F, 0x01, 0xC0, 0x0F, 0x03,
  0xC0, 0xF0, 0x03, 0x80, 0x70, 0x3C, 0x01, 0xE0, 0x1C, 0x0F, 0x00, 0x70,
  0x07, 0x03, 0x80, 0x3C, 0x01, 0xE1, 0xE0, 0x0E, 0x00, 0x3F, 0xF0, 0x07,
  0x80, 0x07, 0xFC, 0x03, 0xC0, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0x83, 0xE0, 0x00,
  0x0F, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x03, 0xCF, 0x80, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x04, 0x0F, 0xFF, 0x00, 0x78, 0x1F, 0x1F, 0x80, 0x78,
  0x3E, 0x0F, 0xC0, 0x78, 0x7C, 0x07, 0xE0, 0xF0, 0x78, 0x03, 0xF0, 0xF0,
  0x78, 0x01, 0xF9, 0xE0, 0xF8, 0x00, 0xFD, 0xE0, 0xF8, 0x00, 0x7F, 0xC0,
  0xF8, 0x00, 0x3F, 0xC0, 0x78, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x3F, 0xC0,
  0x7E, 0x00, 0x7F, 0xE0, 0x3F, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0xF8,
  0x0F, 0xFF, 0xE0, 0x7C, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xF7,
  0x77, 0x76, 0x03, 0xC0, 0xF0, 0x78, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0xF0,
  0x3C, 0x1F, 0x07, 0x81, 0xE0, 0x78, 0x3E, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x01,
  0xE0, 0x78, 0x1E, 0x07, 0x80, 0xF0, 0x3C, 0x0F, 0x81, 0xE0, 0x78, 0x0F,
  0x01, 0xE0, 0x78, 0x0F, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xE0, 0x1E,
  0x03, 0xC0, 0x7C, 0x07, 0x80, 0xF0, 0x1F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x81, 0xF0, 0x3C,
  0x07, 0x81, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x02, 0x01, 0xC0, 0x3E, 0x0E, 0x0F, 0xFF, 0x77, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xEF, 0x00,
  0x0F, 0x78, 0x00, 0xF1, 0xE0, 0x0F, 0x8F, 0x80, 0x78, 0x3E, 0x07, 0xC1,
  0xF0, 0x0E, 0x07, 0x00, 0x20, 0x20, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x78, 0xF3, 0xE7,
  0x8F, 0x1E, 0x38, 0xF1, 0xE3, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x31,
  0xEF, 0xFF, 0xFD, 0xF3, 0x00, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC,
  0x07, 0xE1, 0xF8, 0x3E, 0x01, 0xF0, 0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x9E,
  0x00, 0x1E, 0x78, 0x00, 0x79, 0xE0, 0x01, 0xE7, 0x80, 0x03, 0xDE, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3D, 0xE0, 0x00, 0xF7, 0x80, 0x03, 0xDE, 0x00, 0x1E, 0x78, 0x00,
  0x79, 0xE0, 0x01, 0xE3, 0xC0, 0x0F, 0x8F, 0x00, 0x3C, 0x1E, 0x01, 0xF0,
  0x7E, 0x0F, 0x80, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x00,
  0x70, 0x1F, 0x03, 0xF0, 0x7F, 0x1F, 0x73, 0xEF, 0x7C, 0xFF, 0x8F, 0x70,
  0xF2, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xFC, 0x1F, 0xC1, 0xF8,
  0x78, 0x01, 0xF0, 0xC0, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0x00, 0x7F,
  0xFF, 0x07, 0xFF, 0xFE, 0x3F, 0x81, 0xF8, 0x78, 0x01, 0xF0, 0x80, 0x03,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x7F,
  0xF8, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3E, 0x80, 0x01, 0xF3, 0xE0, 0x1F, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0,
  0x3F, 0xFF, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x1E, 0xF0,
  0x00, 0x3C, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0xF0, 0xF0,
  0x01, 0xE0, 0xF0, 0x01, 0xE0, 0xF0, 0x03, 0xC0, 0xF0, 0x07, 0x80, 0xF0,
  0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1E, 0x00, 0xF0, 0x3C, 0x00, 0xF0,
  0x3C, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8,
  0x38, 0x3F, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE8, 0x00, 0x3E, 0x78, 0x07,
  0xE3, 0xFF, 0xFF, 0x1F, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xE0,
  0x0F, 0xFF, 0x01, 0xFF, 0xF8, 0x1F, 0xC0, 0x41, 0xF8, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x01, 0x00, 0x78, 0xFF, 0x83, 0xDF, 0xFF,
  0x1F, 0xFF, 0xFC, 0xFE, 0x03, 0xF7, 0xE0, 0x07, 0xBE, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xDE, 0x00, 0x3E, 0xF8, 0x01, 0xE3, 0xC0,
  0x1F, 0x1F, 0x81, 0xF0, 0x7F, 0xFF, 0x01, 0xFF, 0xF0, 0x03, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFF,
  0x01, 0xFF, 0xFE, 0x0F, 0xC0, 0xFC, 0x3E, 0x00, 0xF0, 0xF0, 0x03, 0xE7,
  0x80, 0x07, 0x9E, 0x00, 0x1E, 0x78, 0x00, 0x78, 0xF0, 0x01, 0xE3, 0xC0,
  0x0F, 0x0F, 0x80, 0x7C, 0x1F, 0x03, 0xE0, 0x3F, 0x3F, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x3F, 0xFF, 0x01, 0xF0, 0x7E, 0x0F,
  0x80, 0x7C, 0x7C, 0x00, 0xF9, 0xE0, 0x01, 0xEF, 0x80, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xDE, 0x00, 0x1F,
  0x7C, 0x00, 0xF8, 0xF8, 0x07, 0xE3, 0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x07,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xE1,
  0xF8, 0x3E, 0x01, 0xF1, 0xF0, 0x03, 0xC7, 0x80, 0x0F, 0x9E, 0x00, 0x1E,
  0xF0, 0x00, 0x7B, 0xC0, 0x00, 0xEF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3D, 0xE0, 0x01, 0xF7, 0x80, 0x07, 0xDF, 0x00, 0x3F, 0x3E, 0x01,
  0xFC, 0xFF, 0x7E, 0xF1, 0xFF, 0xF3, 0xC1, 0xFF, 0x8F, 0x00, 0xF0, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E,
  0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x7B, 0xFF, 0xFF,
  0x7C, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x7B, 0xFF, 0xFF, 0x7C, 0xC0, 0x1E, 0x3F, 0x3F, 0x3F, 0x1F, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x3E, 0x3E, 0x3C, 0x3C, 0x3C, 0x78, 0x78, 0x78, 0x70, 0xF0,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x70, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0xFC,
  0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0xF8, 0x00, 0x03, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xF0,
  0xFE, 0x60, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0xC0,
  0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F,
  0xE0, 0x3F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x0F, 0x80, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00,
  0x03, 0xC3, 0xC0, 0x0F, 0xE0, 0x1C, 0x38, 0x07, 0xFF, 0xC1, 0xE7, 0x80,
  0xFF, 0xFC, 0x0E, 0x70, 0x1F, 0x03, 0xC0, 0xE7, 0x03, 0xE0, 0x3C, 0x0E,
  0xF0, 0x3C, 0x03, 0x80, 0xFE, 0x07, 0x80, 0x38, 0x0F, 0xE0, 0x78, 0x03,
  0x80, 0xFE, 0x07, 0x80, 0x38, 0x0F, 0xE0, 0x78, 0x03, 0x80, 0xFE, 0x07,
  0x00, 0x38, 0x0E, 0xE0, 0x70, 0x07, 0x80, 0xEE, 0x07, 0x80, 0x78, 0x0E,
  0xE0, 0x78, 0x07, 0x81, 0xEE, 0x03, 0x80, 0xF8, 0x1C, 0xE0, 0x3C, 0x1D,
  0xC3, 0xCF, 0x01, 0xFF, 0xDF, 0xF8, 0x70, 0x0F, 0xF8, 0xFF, 0x07, 0x80,
  0x7E, 0x07, 0xC0, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x20, 0x00, 0x7F, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x07, 0x9C,
  0x00, 0x00, 0x38, 0xF0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x1E, 0x1E, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x78, 0x1E, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0x3C, 0x03, 0xC0, 0x03, 0xC0, 0x1E, 0x00, 0x1E, 0x00,
  0xF0, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xE0, 0x00, 0xF8, 0x1E,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x78, 0x78, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x03,
  0xCF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x78, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xCF, 0x80, 0x1F, 0xDF, 0x00,
  0x0F, 0xBE, 0x00, 0x0F, 0x7C, 0x00, 0x1E, 0xF8, 0x00, 0x3D, 0xF0, 0x00,
  0x7B, 0xE0, 0x00, 0xF7, 0xC0, 0x03, 0xEF, 0x80, 0x07, 0x9F, 0x00, 0x3E,
  0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF3,
  0xE0, 0x03, 0xF7, 0xC0, 0x01, 0xEF, 0x80, 0x03, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x0F, 0xDF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0x87, 0xE0, 0xFC, 0x00, 0x60, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0xF0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFE, 0x0F, 0x80, 0x1F, 0xE1, 0xF0, 0x00, 0xFE, 0x3E,
  0x00, 0x07, 0xC7, 0xC0, 0x00, 0x7C, 0xF8, 0x00, 0x07, 0x9F, 0x00, 0x00,
  0xFB, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x3D, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x3D, 0xF0, 0x00, 0x07, 0xBE, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3E,
  0xF8, 0x00, 0x0F, 0x9F, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x7C, 0x7C, 0x00,
  0x3F, 0x0F, 0x80, 0x1F, 0xC1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFB, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0x0F, 0xE0, 0xFE,
  0x00, 0x18, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xDE,
  0x00, 0x00, 0x7B, 0xC0, 0x00, 0x0F, 0x7C, 0x00, 0x01, 0xE7, 0xC0, 0x00,
  0x3C, 0xF8, 0x00, 0x07, 0x8F, 0x80, 0x00, 0xF1, 0xFC, 0x00, 0x1E, 0x1F,
  0xF0, 0x0F, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0xFF, 0xEF,
  0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x3E,
  0xFF, 0xEF, 0xFC, 0xFF, 0x87, 0xC0, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3E,
  0xF8, 0x00, 0x7C, 0xF8, 0x00, 0xF8, 0xF8, 0x01, 0xF0, 0xF8, 0x03, 0xE0,
  0xF8, 0x07, 0xC0, 0xF8, 0x07, 0x80, 0xF8, 0x0F, 0x00, 0xF8, 0x1E, 0x00,
  0xF8, 0x3E, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0xF8, 0x00, 0xF9, 0xF0, 0x00,
  0xFB, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00,
  0xFE, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x1F, 0x00,
  0xF8, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0xF8, 0x07, 0xC0, 0xF8, 0x03, 0xE0,
  0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0x7C,
  0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xBC, 0x00, 0x03, 0xFF, 0xDE, 0x00, 0x01, 0xDF, 0xEF, 0x00, 0x01,
  0xEF, 0xF3, 0xC0, 0x00, 0xF7, 0xF9, 0xE0, 0x00, 0x73, 0xFC, 0xF0, 0x00,
  0x79, 0xFE, 0x3C, 0x00, 0x3C, 0xFF, 0x1E, 0x00, 0x3C, 0x7F, 0x87, 0x80,
  0x1E, 0x3F, 0xC3, 0xC0, 0x0E, 0x1F, 0xE1, 0xE0, 0x0F, 0x0F, 0xF0, 0x78,
  0x07, 0x87, 0xF8, 0x3C, 0x03, 0x83, 0xFC, 0x0E, 0x03, 0xC1, 0xFE, 0x07,
  0x81, 0xE0, 0xFF, 0x03, 0xC1, 0xE0, 0x7F, 0x80, 0xF0, 0xF0, 0x3F, 0xC0,
  0x78, 0x70, 0x1F, 0xE0, 0x3C, 0x78, 0x0F, 0xF0, 0x0F, 0x3C, 0x07, 0xF8,
  0x07, 0xBC, 0x03, 0xFC, 0x01, 0xDE, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x00, 0x7F, 0x80, 0x1F, 0x80, 0x3F, 0xC0, 0x0F, 0x80, 0x1F,
  0xE0, 0x07, 0xC0, 0x0F, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFD, 0xE0, 0x00, 0x7F, 0xBE, 0x00, 0x0F,
  0xF3, 0xE0, 0x01, 0xFE, 0x3C, 0x00, 0x3F, 0xC7, 0xC0, 0x07, 0xF8, 0x7C,
  0x00, 0xFF, 0x0F, 0x80, 0x1F, 0xE0, 0xF8, 0x03, 0xFC, 0x0F, 0x00, 0x7F,
  0x81, 0xF0, 0x0F, 0xF0, 0x1F, 0x01, 0xFE, 0x01, 0xE0, 0x3F, 0xC0, 0x3E,
  0x07, 0xF8, 0x03, 0xE0, 0xFF, 0x00, 0x3C, 0x1F, 0xE0, 0x07, 0xC3, 0xFC,
  0x00, 0x7C, 0x7F, 0x80, 0x07, 0x8F, 0xF0, 0x00, 0xF9, 0xFE, 0x00, 0x0F,
  0xBF, 0xC0, 0x01, 0xF7, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0,
  0x03, 0xFE, 0x1F, 0xF0, 0x1F, 0x80, 0x0F, 0xC0, 0x7C, 0x00, 0x0F, 0x83,
  0xE0, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x3C, 0x7C, 0x00, 0x00, 0xF9, 0xE0,
  0x00, 0x01, 0xEF, 0x80, 0x00, 0x07, 0xBE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0xF9, 0xF0,
  0x00, 0x03, 0xC3, 0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x1F, 0x80,
  0x07, 0xE0, 0x3F, 0xC0, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF1, 0xFF, 0xFF, 0xCF, 0x80, 0x3F, 0x7C, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xDF, 0x00, 0x7E, 0xF8,
  0x1F, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF, 0xE1, 0xFF, 0xF8, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFE, 0x1F, 0xF0, 0x1F,
  0x80, 0x0F, 0xC0, 0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x1F, 0x0F, 0x00,
  0x00, 0x3C, 0x7C, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x01, 0xEF, 0x80, 0x00,
  0x07, 0xBE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0x9E, 0x00,
  0x00, 0x1E, 0x7C, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x03, 0xC3, 0xE0, 0x00,
  0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0x3F, 0xC0, 0xFF,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xF8, 0x03, 0xF0, 0xF8, 0x00, 0xF8,
  0xF8, 0x00, 0xF8, 0xF8, 0x00, 0x78, 0xF8, 0x00, 0x78, 0xF8, 0x00, 0x78,
  0xF8, 0x00, 0x78, 0xF8, 0x00, 0x78, 0xF8, 0x00, 0x78, 0xF8, 0x00, 0xF8,
  0xF8, 0x01, 0xF0, 0xF8, 0x07, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80,
  0xFF, 0xFE, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x0F, 0x00, 0xF8, 0x0F, 0x80,
  0xF8, 0x07, 0xC0, 0xF8, 0x03, 0xC0, 0xF8, 0x03, 0xE0, 0xF8, 0x01, 0xE0,
  0xF8, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0x7C,
  0xF8, 0x00, 0x3C, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0x03, 0xFF, 0x80,
  0x7F, 0xFF, 0x87, 0xFF, 0xFC, 0x7F, 0x0F, 0xE3, 0xE0, 0x06, 0x3E, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xFC, 0x00,
  0x1F, 0x7E, 0x03, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xF0, 0x3F, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xBC, 0x00, 0x03, 0xDF, 0x00, 0x03, 0xEF, 0x80, 0x03, 0xE3,
  0xE0, 0x03, 0xF0, 0xFE, 0x07, 0xF0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0,
  0x01, 0xFF, 0xC0, 0x00, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1E, 0x78,
  0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0x7C, 0x3E, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x0F, 0x81,
  0xF0, 0x00, 0xF0, 0x0F, 0x00, 0x0F, 0x00, 0xF0, 0x01, 0xF0, 0x0F, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0x7C, 0x03, 0xC0,
  0x03, 0xC0, 0x7C, 0x00, 0x3C, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x1E,
  0x0F, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF1, 0xF0,
  0x00, 0x0F, 0x1E, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x07, 0xBE, 0x00, 0x00,
  0x7B, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xC0, 0x01, 0xE7, 0x80, 0x07, 0xF0,
  0x00, 0xF3, 0xC0, 0x03, 0xF8, 0x00, 0xF9, 0xE0, 0x03, 0xDC, 0x00, 0x7C,
  0x78, 0x01, 0xEF, 0x00, 0x3C, 0x3C, 0x00, 0xE7, 0x80, 0x1E, 0x1E, 0x00,
  0xF3, 0xC0, 0x1F, 0x0F, 0x80, 0x78, 0xE0, 0x0F, 0x03, 0xC0, 0x3C, 0x78,
  0x07, 0x81, 0xE0, 0x3C, 0x3C, 0x03, 0xC0, 0xF0, 0x1E, 0x1E, 0x03, 0xE0,
  0x7C, 0x0F, 0x07, 0x81, 0xE0, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x0F, 0x07,
  0x81, 0xE0, 0x78, 0x07, 0x83, 0xC0, 0x78, 0x7C, 0x03, 0xE1, 0xE0, 0x3C,
  0x3C, 0x00, 0xF1, 0xE0, 0x1E, 0x1E, 0x00, 0x78, 0xF0, 0x07, 0x8F, 0x00,
  0x3C, 0x78, 0x03, 0xCF, 0x80, 0x1F, 0x38, 0x01, 0xE7, 0x80, 0x07, 0xBC,
  0x00, 0xF3, 0xC0, 0x03, 0xDE, 0x00, 0x3D, 0xE0, 0x01, 0xEF, 0x00, 0x1E,
  0xE0, 0x00, 0x77, 0x00, 0x0F, 0xF0, 0x00, 0x3B, 0x80, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x07, 0xC7, 0x80, 0x00, 0xF0, 0xF8, 0x00, 0x3C,
  0x0F, 0x80, 0x07, 0x80, 0xF0, 0x01, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xE0,
  0x0F, 0x00, 0x1E, 0x03, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x3C, 0x1E, 0x00,
  0x03, 0xC7, 0x80, 0x00, 0x7D, 0xF0, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x0F, 0x3E,
  0x00, 0x03, 0xE3, 0xC0, 0x00, 0x78, 0x3C, 0x00, 0x1E, 0x07, 0xC0, 0x03,
  0xC0, 0x78, 0x00, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0x80, 0x0F,
  0x01, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x0F, 0x00, 0x01, 0xE3, 0xC0,
  0x00, 0x3E, 0xF8, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0xDE, 0x00, 0x01,
  0xE7, 0xC0, 0x00, 0xF8, 0xF0, 0x00, 0x3C, 0x3E, 0x00, 0x1F, 0x07, 0x80,
  0x07, 0x81, 0xF0, 0x03, 0xE0, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x01,
  0xE0, 0x1E, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x03, 0xC0, 0x01, 0xE1, 0xE0,
  0x00, 0x7C, 0xF8, 0x00, 0x0F, 0x3C, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x70, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3B,
  0xC0, 0x00, 0xF3, 0x80, 0x01, 0xC7, 0x80, 0x07, 0x87, 0x00, 0x0E, 0x0F,
  0x00, 0x1C, 0x0E, 0x00, 0x70, 0x1E, 0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x3C,
  0x07, 0x00, 0x38, 0x1E, 0x00, 0x78, 0x38, 0x00, 0x70, 0xF0, 0x00, 0xF1,
  0xC0, 0x00, 0xE7, 0x80, 0x01, 0xEE, 0x00, 0x01, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF8, 0x3E, 0x0F, 0x07, 0xC1, 0xF0, 0x38,
  0x0E, 0x01, 0xFE, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xC1, 0xF8, 0x7E, 0x08,
  0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x7F, 0xF0, 0x7F, 0xFF, 0x1F, 0xFF, 0xF3, 0xF8, 0x0F,
  0x7C, 0x00, 0xF7, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01,
  0xFF, 0x00, 0x1F, 0xF8, 0x03, 0xF7, 0xC0, 0xFF, 0x7F, 0xFE, 0x73, 0xFF,
  0xC7, 0x0F, 0xF8, 0x70, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x0F, 0xE0, 0x3C, 0xFF,
  0xE0, 0xF7, 0xFF, 0xC3, 0xFE, 0x1F, 0x8F, 0xC0, 0x1F, 0x3E, 0x00, 0x3C,
  0xF8, 0x00, 0xFB, 0xE0, 0x01, 0xEF, 0x00, 0x07, 0xBC, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xBE, 0x00, 0x1E, 0xF8, 0x00, 0x7B,
  0xE0, 0x03, 0xEF, 0xC0, 0x1F, 0x3F, 0xC0, 0xFC, 0xEF, 0xFF, 0xE3, 0x8F,
  0xFF, 0x0E, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0xF1, 0xFF, 0xF8,
  0xFF, 0x3E, 0x3E, 0x00, 0x9F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0xE1, 0xFF, 0xF8, 0x3F, 0xFE, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0xFE, 0x1E, 0x1F, 0xFC, 0xF1, 0xFF, 0xF3,
  0x9F, 0x87, 0xDD, 0xF0, 0x07, 0xEF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0xC0,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xBC, 0x00, 0x7D, 0xF0, 0x07, 0xE7,
  0xC0, 0x7F, 0x3F, 0xFF, 0xB8, 0x7F, 0xF9, 0xC1, 0xFF, 0x0E, 0x01, 0xFC,
  0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0x1F, 0x83, 0xC0, 0x3E, 0x3C,
  0x00, 0xF9, 0xE0, 0x03, 0xDE, 0x00, 0x1E, 0xF0, 0x00, 0xF7, 0x80, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xE0, 0x01, 0x1F, 0x80, 0x78, 0x7F, 0xFF, 0xC1, 0xFF,
  0xFE, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0xF8,
  0x20, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x07, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0xC0, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x03, 0xF8, 0x38, 0x7F, 0xF1,
  0xC7, 0xFF, 0xCE, 0x7F, 0x1F, 0x77, 0xE0, 0x1F, 0xBE, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x1E, 0xF0, 0x01, 0xF7,
  0xC0, 0x1F, 0x9F, 0x01, 0xFC, 0x7F, 0xFF, 0xE1, 0xFF, 0xEF, 0x07, 0xFC,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x03, 0xEC, 0x00, 0x3E, 0x7F, 0x0F, 0xE3, 0xFF, 0xFF,
  0x0F, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x3F, 0xC1, 0xE7,
  0xFF, 0x8F, 0x7F, 0xFE, 0x7F, 0xC3, 0xFB, 0xF8, 0x07, 0xDF, 0x80, 0x1E,
  0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x1E, 0x6F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xC0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x03, 0xF8, 0xFB, 0xFF, 0x7F, 0xCF, 0xE0, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x01,
  0xEF, 0x00, 0x3C, 0xF0, 0x07, 0x8F, 0x00, 0xF0, 0xF0, 0x1F, 0x0F, 0x03,
  0xE0, 0xF0, 0x7C, 0x0F, 0x0F, 0x80, 0xF1, 0xF0, 0x0F, 0x3E, 0x00, 0xF7,
  0xC0, 0x0F, 0x7C, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFD, 0xF0, 0x0F,
  0x0F, 0x80, 0xF0, 0x7C, 0x0F, 0x03, 0xE0, 0xF0, 0x3E, 0x0F, 0x01, 0xF0,
  0xF0, 0x0F, 0x8F, 0x00, 0x7C, 0xF0, 0x07, 0xCF, 0x00, 0x3E, 0xF0, 0x01,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0xFE, 0x01, 0xFE, 0x1C,
  0x7F, 0xF0, 0xFF, 0xF3, 0xDF, 0xFF, 0x3F, 0xFF, 0x7F, 0xC7, 0xFF, 0x87,
  0xEF, 0xC0, 0x3F, 0xC0, 0x3F, 0xF0, 0x03, 0xF0, 0x03, 0xFE, 0x00, 0x7C,
  0x00, 0x7F, 0xC0, 0x0F, 0x80, 0x0F, 0xF0, 0x00, 0xF0, 0x01, 0xFE, 0x00,
  0x1E, 0x00, 0x3F, 0xC0, 0x03, 0xC0, 0x07, 0xF8, 0x00, 0x78, 0x00, 0xFF,
  0x00, 0x0F, 0x00, 0x1F, 0xE0, 0x01, 0xE0, 0x03, 0xFC, 0x00, 0x3C, 0x00,
  0x7F, 0x80, 0x07, 0x80, 0x0F, 0xF0, 0x00, 0xF0, 0x01, 0xFE, 0x00, 0x1E,
  0x00, 0x3F, 0xC0, 0x03, 0xC0, 0x07, 0xF8, 0x00, 0x78, 0x00, 0xFF, 0x00,
  0x0F, 0x00, 0x1F, 0xE0, 0x01, 0xE0, 0x03, 0xFC, 0x00, 0x3C, 0x00, 0x7F,
  0x80, 0x07, 0x80, 0x0F, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0xE0, 0xFF, 0x07,
  0x1F, 0xFE, 0x3D, 0xFF, 0xF9, 0xFF, 0x0F, 0xEF, 0xE0, 0x1F, 0x7E, 0x00,
  0x7B, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x78, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F,
  0xE1, 0xF8, 0x3E, 0x01, 0xF1, 0xF0, 0x03, 0xE7, 0x80, 0x07, 0xBE, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x01, 0xF7, 0x80, 0x07, 0x9E, 0x00, 0x3E, 0x3C, 0x00,
  0xF0, 0xFC, 0x0F, 0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x00,
  0xE0, 0xFE, 0x03, 0x8F, 0xFE, 0x0F, 0x7F, 0xFC, 0x3F, 0xE1, 0xF8, 0xFE,
  0x01, 0xF3, 0xF0, 0x03, 0xCF, 0x80, 0x0F, 0xBE, 0x00, 0x1E, 0xF0, 0x00,
  0x7B, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7B, 0xE0,
  0x01, 0xEF, 0x80, 0x0F, 0xBE, 0x00, 0x3E, 0xFC, 0x01, 0xF3, 0xFC, 0x0F,
  0x8F, 0xFF, 0xFE, 0x3C, 0xFF, 0xF0, 0xF1, 0xFF, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xF8, 0x38, 0x7F, 0xF1, 0xC7, 0xFF, 0xCE, 0x7E,
  0x1F, 0x77, 0xE0, 0x1F, 0xBE, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFE, 0x00, 0x1E, 0xF0, 0x01, 0xF7, 0xC0, 0x1F, 0x9F, 0x01,
  0xFC, 0x7F, 0xFF, 0xE1, 0xFF, 0xEF, 0x07, 0xFC, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0xE0, 0xFF, 0x87, 0xFE, 0x3F, 0xFD, 0xFF, 0xFF, 0x03, 0xF0,
  0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x07, 0xFE,
  0x07, 0xFF, 0xE3, 0xFF, 0xF9, 0xF8, 0x3E, 0x78, 0x01, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x80, 0x03, 0xFC, 0x00, 0x7F,
  0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xF8, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x07, 0xFC, 0x03, 0xEF,
  0xFF, 0xFB, 0xFF, 0xF8, 0x3F, 0xFC, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x01, 0xE0, 0x07, 0xFF, 0xBF, 0xFF, 0x7F, 0xFE, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7F, 0xF0,
  0x7F, 0xE0, 0x7F, 0xC0, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x80, 0x3F, 0xBE,
  0x03, 0xFD, 0xFF, 0xFD, 0xE7, 0xFF, 0xCF, 0x0F, 0xF8, 0x78, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x3D, 0xE0, 0x00, 0xFB, 0xC0, 0x01, 0xE3, 0xC0, 0x03,
  0xC7, 0x80, 0x0F, 0x0F, 0x80, 0x1E, 0x0F, 0x00, 0x7C, 0x1E, 0x00, 0xF0,
  0x3E, 0x01, 0xE0, 0x3C, 0x07, 0xC0, 0x78, 0x0F, 0x00, 0x78, 0x1E, 0x00,
  0xF0, 0x78, 0x01, 0xE0, 0xF0, 0x01, 0xE1, 0xE0, 0x03, 0xC7, 0x80, 0x03,
  0x8F, 0x00, 0x07, 0x9C, 0x00, 0x0F, 0x78, 0x00, 0x0E, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00,
  0xF0, 0x01, 0xF7, 0x80, 0x0F, 0x80, 0x1E, 0x78, 0x01, 0xF8, 0x01, 0xE7,
  0xC0, 0x1F, 0x80, 0x1E, 0x3C, 0x01, 0xFC, 0x03, 0xC3, 0xC0, 0x3F, 0xC0,
  0x3C, 0x3C, 0x03, 0xDC, 0x03, 0xC3, 0xE0, 0x39, 0xE0, 0x3C, 0x1E, 0x07,
  0x9E, 0x07, 0x81, 0xE0, 0x79, 0xE0, 0x78, 0x1E, 0x07, 0x0E, 0x07, 0x80,
  0xF0, 0xF0, 0xF0, 0x78, 0x0F, 0x0F, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x70,
  0xF0, 0x0F, 0x1E, 0x07, 0x8F, 0x00, 0x79, 0xE0, 0x78, 0xE0, 0x07, 0x9E,
  0x07, 0x9E, 0x00, 0x79, 0xC0, 0x3D, 0xE0, 0x07, 0xBC, 0x03, 0xDE, 0x00,
  0x3F, 0xC0, 0x3D, 0xC0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0xF0, 0xF0, 0x03, 0xE1,
  0xF0, 0x0F, 0x81, 0xF0, 0x1E, 0x01, 0xE0, 0x78, 0x01, 0xE1, 0xF0, 0x03,
  0xE3, 0xC0, 0x03, 0xCF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x80, 0x03, 0xCF, 0x00, 0x0F, 0x8F, 0x00, 0x3E, 0x1F, 0x00, 0x78, 0x1F,
  0x01, 0xF0, 0x1E, 0x07, 0xC0, 0x1E, 0x0F, 0x00, 0x3E, 0x3C, 0x00, 0x3C,
  0xF8, 0x00, 0x3E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x3D, 0xE0, 0x00, 0xFB,
  0xE0, 0x01, 0xE3, 0xC0, 0x03, 0xC7, 0x80, 0x0F, 0x87, 0x80, 0x1E, 0x0F,
  0x00, 0x3C, 0x1E, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x07, 0xC0, 0x3C,
  0x0F, 0x00, 0x78, 0x1E, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0xF0, 0x01, 0xE1,
  0xE0, 0x01, 0xC7, 0x80, 0x03, 0xCF, 0x00, 0x07, 0x9E, 0x00, 0x07, 0x78,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x87,
  0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFC, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0E, 0x00, 0xFC,
  0x03, 0xF8, 0x0F, 0xF0, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x07, 0xC0, 0x1F, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xC0, 0x1F,
  0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x01, 0xF8, 0x03, 0xFC, 0x03, 0xFC,
  0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0xC0, 0x07, 0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x1F, 0xC0, 0x7C,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C,
  0x01, 0xF8, 0x1F, 0xE0, 0x3F, 0x80, 0x7C, 0x00, 0x1F, 0xC0, 0x05, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xC0, 0x1F, 0xFA, 0x00, 0x0F,
  0x00,
};

const GFXglyph NotoSans_Regular46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 6, 34, 12, 3, -33 },
  { 27, 13, 12, 19, 3, -33 },
  { 47, 28, 33, 30, 1, -33 },
  { 163, 21, 38, 26, 3, -35 },
  { 263, 34, 33, 38, 2, -33 },
  { 404, 32, 33, 34, 2, -33 },
  { 536, 4, 12, 10, 3, -33 },
  { 542, 10, 40, 14, 2, -33 },
  { 592, 11, 40, 14, 1, -33 },
  { 647, 21, 21, 25, 2, -35 },
  { 703, 22, 22, 26, 2, -27 },
  { 764, 7, 11, 12, 2, -5 },
  { 774, 11, 3, 15, 2, -14 },
  { 779, 6, 7, 12, 3, -6 },
  { 785, 17, 33, 17, 0, -33 },
  { 856, 22, 33, 26, 2, -33 },
  { 947, 12, 33, 26, 4, -33 },
  { 997, 22, 33, 26, 2, -33 },
  { 1088, 22, 33, 26, 2, -33 },
  { 1179, 24, 33, 26, 1, -33 },
  { 1278, 21, 33, 26, 3, -33 },
  { 1365, 21, 33, 26, 3, -33 },
  { 1452, 22, 33, 26, 2, -33 },
  { 1543, 22, 33, 26, 2, -33 },
  { 1634, 22, 33, 26, 2, -33 },
  { 1725, 6, 26, 12, 3, -25 },
  { 1745, 8, 31, 12, 1, -25 },
  { 1776, 22, 23, 26, 2, -28 },
  { 1840, 21, 12, 26, 3, -22 },
  { 1872, 22, 23, 26, 2, -28 },
  { 1936, 18, 34, 20, 1, -33 },
  { 2013, 36, 37, 41, 3, -33 },
  { 2180, 29, 33, 29, 0, -33 },
  { 2300, 23, 33, 30, 4, -33 },
  { 2395, 25, 33, 29, 3, -33 },
  { 2499, 27, 33, 34, 4, -33 },
  { 2611, 19, 33, 26, 4, -33 },
  { 2690, 19, 33, 24, 4, -33 },
  { 2769, 27, 33, 33, 3, -33 },
  { 2881, 26, 33, 34, 4, -33 },
  { 2989, 12, 33, 16, 2, -33 },
  { 3039, 12, 42, 13, -4, -33 },
  { 3102, 24, 33, 28, 4, -33 },
  { 3201, 19, 33, 24, 4, -33 },
  { 3280, 33, 33, 42, 4, -33 },
  { 3417, 27, 33, 35, 4, -33 },
  { 3529, 30, 33, 36, 3, -33 },
  { 3653, 21, 33, 28, 4, -33 },
  { 3740, 30, 41, 36, 3, -33 },
  { 3894, 24, 33, 29, 4, -33 },
  { 3993, 21, 33, 25, 2, -33 },
  { 4080, 25, 33, 26, 0, -33 },
  { 4184, 25, 33, 34, 4, -33 },
  { 4288, 28, 33, 28, 0, -33 },
  { 4404, 41, 33, 43, 1, -33 },
  { 4574, 27, 33, 27, 0, -33 },
  { 4686, 26, 33, 26, 0, -33 },
  { 4794, 23, 33, 26, 2, -33 },
  { 4889, 10, 40, 15, 4, -33 },
  { 4939, 17, 33, 17, 0, -33 },
  { 5010, 10, 40, 15, 1, -33 },
  { 5060, 23, 21, 26, 2, -33 },
  { 5121, 21, 3, 20, 0, 4 },
  { 5129, 9, 7, 13, 2, -35 },
  { 5137, 20, 25, 26, 2, -25 },
  { 5200, 22, 35, 28, 4, -35 },
  { 5297, 18, 25, 22, 3, -25 },
  { 5354, 21, 35, 28, 3, -35 },
  { 5446, 21, 25, 26, 3, -25 },
  { 5512, 17, 35, 16, 1, -35 },
  { 5587, 21, 36, 28, 3, -25 },
  { 5682, 21, 35, 28, 4, -35 },
  { 5774, 4, 34, 12, 4, -34 },
  { 5791, 11, 45, 12, -3, -34 },
  { 5853, 20, 35, 25, 4, -35 },
  { 5941, 4, 35, 12, 4, -35 },
  { 5959, 35, 25, 43, 4, -25 },
  { 6069, 21, 25, 28, 4, -25 },
  { 6135, 22, 25, 28, 3, -25 },
  { 6204, 22, 36, 28, 4, -25 },
  { 6303, 21, 36, 28, 3, -25 },
  { 6398, 14, 25, 19, 4, -25 },
  { 6442, 18, 25, 22, 2, -25 },
  { 6499, 15, 30, 17, 1, -30 },
  { 6556, 21, 25, 28, 4, -25 },
  { 6622, 23, 25, 23, 0, -25 },
  { 6694, 36, 25, 36, 0, -25 },
  { 6807, 23, 25, 24, 1, -25 },
  { 6879, 23, 36, 23, 0, -25 },
  { 6983, 18, 25, 22, 2, -25 },
  { 7040, 15, 40, 17, 1, -33 },
  { 7115, 3, 46, 25, 11, -35 },
  { 7133, 15, 40, 17, 1, -33 },
  { 7208, 22, 6, 26, 2, -19 },
};

const GFXfont NotoSans_Regular46pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Regular46pt7bBitmaps,
  (GFXglyph *)NotoSans_Regular46pt7bGlyphs,
  0x20, 0x7E, 63
};

#endif // _NOTOSANS_REGULAR46PT7B_H_
