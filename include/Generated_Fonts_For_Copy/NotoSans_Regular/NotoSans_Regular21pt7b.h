#ifndef _NOTOSANS_REGULAR21PT7B_H_
#define _NOTOSANS_REGULAR21PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Regular.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Regular21pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xE8, 0xBC, 0xCF, 0x34, 0xD3, 0x44, 0x0C, 0x40, 0x8C,
  0x08, 0xC0, 0x8C, 0xFF, 0xFF, 0xFF, 0x11, 0x81, 0x18, 0x11, 0x8F, 0xFE,
  0xFF, 0xE2, 0x30, 0x23, 0x02, 0x30, 0x62, 0x00, 0x0C, 0x03, 0x03, 0xF9,
  0xFE, 0xCC, 0x33, 0x0E, 0xC1, 0xF0, 0x1F, 0x03, 0xE0, 0xCC, 0x33, 0x8C,
  0xFF, 0xE7, 0xE0, 0x30, 0x0C, 0x00, 0x78, 0x18, 0x98, 0x63, 0x10, 0x86,
  0x23, 0x0C, 0x44, 0x18, 0x98, 0x31, 0x6F, 0x26, 0xD3, 0x7B, 0x62, 0x04,
  0xC4, 0x19, 0x88, 0x23, 0x10, 0xC6, 0x21, 0x04, 0xC6, 0x0F, 0x00, 0x1F,
  0x00, 0xCE, 0x02, 0x18, 0x08, 0x60, 0x31, 0x80, 0xFC, 0x01, 0xE0, 0x0F,
  0x82, 0x67, 0x1B, 0x0E, 0x6C, 0x1F, 0x30, 0x3C, 0xC0, 0xF1, 0xCF, 0xE3,
  0xF1, 0xC0, 0xF5, 0x40, 0x19, 0x98, 0xC4, 0x63, 0x18, 0xC6, 0x31, 0x8C,
  0x61, 0x8C, 0x31, 0xC0, 0xC4, 0x62, 0x33, 0x31, 0x11, 0x13, 0x33, 0x36,
  0x6C, 0x0C, 0x03, 0x00, 0xC3, 0x26, 0xFF, 0xC7, 0x01, 0x60, 0xCC, 0x73,
  0x00, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x3F, 0xF0, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x6F, 0x68, 0xF8, 0xBC, 0x03, 0x06, 0x06, 0x0C, 0x0C,
  0x0C, 0x18, 0x18, 0x10, 0x30, 0x30, 0x20, 0x60, 0x60, 0xC0, 0x3F, 0x1C,
  0xE6, 0x1B, 0x02, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0D,
  0x03, 0x61, 0x9C, 0xE3, 0xF0, 0x19, 0xDB, 0x90, 0x84, 0x21, 0x08, 0x42,
  0x10, 0x84, 0x20, 0x3F, 0x3C, 0xE4, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x3F, 0xFF, 0xFC, 0x7F, 0x38,
  0xE8, 0x18, 0x06, 0x01, 0x80, 0x63, 0xF0, 0xFC, 0x03, 0x80, 0x30, 0x0C,
  0x03, 0x01, 0xB0, 0xEF, 0xF0, 0x01, 0x80, 0x38, 0x02, 0x80, 0x68, 0x0C,
  0x80, 0x88, 0x18, 0x83, 0x08, 0x60, 0x86, 0x08, 0xFF, 0xFF, 0xFF, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x7F, 0x9F, 0xE6, 0x01, 0x80, 0x60, 0x18, 0x07,
  0xF1, 0x8E, 0x01, 0xC0, 0x30, 0x0C, 0x03, 0x01, 0xB8, 0xE7, 0xE0, 0x0F,
  0x8E, 0x23, 0x01, 0x80, 0x40, 0x30, 0x0D, 0xF3, 0xC6, 0xC0, 0xF0, 0x3C,
  0x0D, 0x03, 0x60, 0xCC, 0xE1, 0xF0, 0xFF, 0xFF, 0xF0, 0x0C, 0x06, 0x01,
  0x80, 0xC0, 0x30, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x60, 0x18, 0x06, 0x03,
  0x00, 0x3F, 0x1C, 0xE6, 0x19, 0x02, 0x61, 0x98, 0x63, 0xF0, 0xF8, 0x73,
  0xB0, 0x7C, 0x0F, 0x03, 0xC0, 0xD8, 0x63, 0xF0, 0x3E, 0x1C, 0xEC, 0x1B,
  0x03, 0xC0, 0xF0, 0x3C, 0x0D, 0x87, 0x3E, 0xC0, 0x30, 0x08, 0x06, 0x03,
  0x91, 0xC7, 0xC0, 0xBC, 0x00, 0x2F, 0x5D, 0x80, 0x00, 0x01, 0xED, 0xA0,
  0x00, 0x40, 0x70, 0x78, 0x70, 0x70, 0x30, 0x07, 0x00, 0x78, 0x07, 0x80,
  0x30, 0x04, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x80, 0x38, 0x07,
  0x80, 0x78, 0x03, 0x80, 0x30, 0x38, 0x78, 0x78, 0x30, 0x08, 0x00, 0x7E,
  0x73, 0x80, 0x40, 0x30, 0x10, 0x18, 0x18, 0x18, 0x18, 0x0C, 0x04, 0x00,
  0x01, 0x01, 0xC0, 0x60, 0x03, 0xF0, 0x07, 0x9E, 0x06, 0x01, 0x86, 0x00,
  0x66, 0x1F, 0x12, 0x19, 0x89, 0x18, 0xC7, 0x88, 0x63, 0xCC, 0x31, 0xE6,
  0x18, 0xB1, 0x0C, 0x58, 0xFB, 0xC4, 0x38, 0xC3, 0x00, 0x00, 0xC0, 0x00,
  0x3F, 0xF0, 0x07, 0xE0, 0x00, 0x03, 0x00, 0x38, 0x01, 0xE0, 0x1B, 0x00,
  0xC8, 0x06, 0x60, 0x63, 0x03, 0x08, 0x10, 0x61, 0xFF, 0x0C, 0x0C, 0xC0,
  0x66, 0x03, 0x20, 0x0F, 0x00, 0x60, 0xFF, 0x1F, 0xF3, 0x03, 0x60, 0x6C,
  0x0D, 0x81, 0xBF, 0xE7, 0xF8, 0xC1, 0xD8, 0x1B, 0x03, 0xE0, 0x6C, 0x0D,
  0xFF, 0xBF, 0xC0, 0x0F, 0xF1, 0xEE, 0x30, 0x06, 0x00, 0x60, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0xEE,
  0x0F, 0xE0, 0xFF, 0x0F, 0xFC, 0xC0, 0xEC, 0x06, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x06, 0xC0, 0xEF, 0xF8, 0xFF,
  0x00, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF,
  0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x0F, 0xF8, 0xF3, 0x8C, 0x00,
  0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x18, 0x1F, 0xC0, 0xFE, 0x00, 0xD8,
  0x06, 0xC0, 0x33, 0x01, 0x9F, 0x3C, 0x3F, 0xE0, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x30, 0xF9, 0x8C, 0x63, 0x18, 0xC6,
  0x31, 0x8C, 0x63, 0x1B, 0xE0, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0F, 0xEF, 0x00, 0xC0, 0xF8, 0x33, 0x0C,
  0x63, 0x8C, 0x61, 0x98, 0x36, 0x07, 0xE0, 0xEC, 0x18, 0xC3, 0x1C, 0x61,
  0x8C, 0x19, 0x81, 0xB0, 0x38, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xFF, 0xE0, 0x0F, 0xC0, 0x1F,
  0xC0, 0x7F, 0x80, 0xFD, 0x81, 0x7B, 0x06, 0xF6, 0x09, 0xE6, 0x33, 0xCC,
  0x67, 0x88, 0x8F, 0x1B, 0x1E, 0x36, 0x3C, 0x38, 0x78, 0x70, 0xF0, 0xC1,
  0x80, 0xE0, 0x3E, 0x03, 0xF0, 0x3F, 0x03, 0xD8, 0x3C, 0xC3, 0xCC, 0x3C,
  0x63, 0xC3, 0x3C, 0x33, 0xC1, 0xBC, 0x1F, 0xC0, 0xFC, 0x07, 0xC0, 0x70,
  0x0F, 0xE0, 0xF3, 0xC3, 0x03, 0x98, 0x06, 0x60, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x36, 0x00, 0xD8, 0x06, 0x30, 0x38, 0xF3,
  0xC0, 0xFE, 0x00, 0xFE, 0x3F, 0xEC, 0x1B, 0x03, 0xC0, 0xF0, 0x3C, 0x1B,
  0x3E, 0xFE, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x00, 0x0F, 0xE0,
  0xF3, 0xC3, 0x03, 0x98, 0x06, 0x60, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x36, 0x00, 0xD8, 0x06, 0x30, 0x38, 0xF3, 0xC0, 0xFE,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0xFE, 0x1F, 0xF3, 0x06,
  0x60, 0x6C, 0x0D, 0x81, 0x30, 0x67, 0xF8, 0xFE, 0x18, 0xC3, 0x0C, 0x61,
  0xCC, 0x19, 0x81, 0xB0, 0x38, 0x3F, 0x9C, 0xEC, 0x03, 0x00, 0xC0, 0x18,
  0x07, 0x80, 0x78, 0x07, 0x80, 0x60, 0x0C, 0x03, 0x01, 0xB9, 0xEF, 0xE0,
  0xFF, 0xFF, 0xFC, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x36, 0x06, 0xF3, 0x8F, 0xE0, 0xC0, 0x3A, 0x01, 0x98, 0x0C, 0xC0,
  0xC3, 0x06, 0x18, 0x30, 0xC3, 0x03, 0x18, 0x18, 0xC0, 0xCC, 0x03, 0x60,
  0x1A, 0x00, 0xF0, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x60, 0x6C, 0x1C, 0x0D,
  0x83, 0x81, 0xB0, 0x58, 0x66, 0x1B, 0x0C, 0x63, 0x21, 0x8C, 0x66, 0x31,
  0x88, 0xCC, 0x33, 0x19, 0x83, 0x61, 0xB0, 0x68, 0x34, 0x0F, 0x07, 0x80,
  0xE0, 0x70, 0x1C, 0x0E, 0x03, 0x01, 0x80, 0xE0, 0x36, 0x06, 0x30, 0xC1,
  0x8C, 0x19, 0x80, 0xF0, 0x07, 0x00, 0x60, 0x0F, 0x00, 0x98, 0x19, 0x83,
  0x0C, 0x30, 0x66, 0x06, 0xC0, 0x30, 0xC0, 0x36, 0x06, 0x60, 0x63, 0x0C,
  0x31, 0x81, 0x98, 0x0B, 0x00, 0xF0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0xFF, 0xFF, 0xF0, 0x18, 0x0E, 0x03, 0x01,
  0x80, 0xE0, 0x30, 0x18, 0x06, 0x03, 0x01, 0x80, 0x60, 0x3F, 0xFF, 0xFC,
  0xFF, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x8F, 0xC0, 0x60, 0x60,
  0x20, 0x30, 0x30, 0x10, 0x18, 0x18, 0x0C, 0x0C, 0x0C, 0x06, 0x06, 0x03,
  0xFF, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x3F, 0x0C, 0x03, 0x01,
  0xE0, 0x48, 0x33, 0x08, 0x46, 0x19, 0x02, 0xC0, 0xC0, 0xFF, 0x80, 0xC6,
  0x30, 0x7F, 0x10, 0xC0, 0x60, 0x31, 0xFB, 0xFF, 0x07, 0x83, 0xC1, 0xF3,
  0xDF, 0x20, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x3F, 0xCE, 0x3B, 0x06,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x6F, 0x3A, 0x7C, 0x3F, 0x71,
  0x60, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x60, 0x71, 0x3F, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xCF, 0xF7, 0x1D, 0x83, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xD8, 0x37, 0x3C, 0xF9, 0x3F, 0x18, 0x66, 0x0B, 0x03, 0xFF, 0xFF,
  0xFC, 0x03, 0x00, 0x60, 0x1E, 0x61, 0xF8, 0x0F, 0x1D, 0x30, 0x30, 0x30,
  0xFE, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x3F,
  0x5C, 0x76, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x60, 0xDC, 0xF3,
  0xEC, 0x03, 0x00, 0xC0, 0x37, 0xF9, 0xFC, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x07, 0xFB, 0x87, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xF0, 0xFF, 0xFF, 0xFC, 0x18, 0xC0, 0x01, 0x8C, 0x63, 0x18, 0xC6,
  0x31, 0x8C, 0x63, 0x18, 0xFD, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x0E,
  0x1B, 0x19, 0x98, 0xD8, 0x78, 0x3E, 0x1B, 0x8C, 0xC6, 0x33, 0x0D, 0x87,
  0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0x7E, 0xE3, 0xC7, 0xC1, 0x83, 0xC1, 0x83,
  0xC1, 0x83, 0xC1, 0x83, 0xC1, 0x83, 0xC1, 0x83, 0xC1, 0x83, 0xC1, 0x83,
  0xC1, 0x83, 0xBF, 0x70, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x60, 0x3F, 0x8E, 0x31, 0x83, 0x60, 0x6C, 0x07, 0x80, 0xF0,
  0x1E, 0x06, 0x60, 0xCE, 0x30, 0x7C, 0x00, 0xBF, 0x38, 0xEC, 0x1B, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC1, 0xBC, 0xED, 0xF3, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0x3F, 0x58, 0x76, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0x60, 0xDC, 0xF3, 0xEC, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x9E,
  0xCC, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x00, 0x7F, 0xC2, 0xC0, 0xC0,
  0x78, 0x1E, 0x07, 0x03, 0x03, 0xC7, 0xFE, 0x10, 0x60, 0xC7, 0xF3, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0xA3, 0xC0, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xF3, 0xDF, 0x20, 0xC0, 0xEC, 0x19,
  0x83, 0x30, 0xC3, 0x18, 0x62, 0x04, 0xC0, 0xD8, 0x1A, 0x01, 0xC0, 0x38,
  0x00, 0xC1, 0xC3, 0x61, 0xC3, 0x63, 0xC3, 0x63, 0x46, 0x22, 0x66, 0x36,
  0x66, 0x36, 0x24, 0x36, 0x3C, 0x14, 0x3C, 0x1C, 0x1C, 0x1C, 0x18, 0x60,
  0xE6, 0x30, 0x66, 0x0D, 0x80, 0xE0, 0x1C, 0x03, 0xC0, 0xD8, 0x31, 0x8C,
  0x1B, 0x83, 0x80, 0xC0, 0xEC, 0x19, 0x83, 0x10, 0xC3, 0x18, 0x63, 0x06,
  0xC0, 0xD8, 0x0A, 0x01, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x30, 0x2E, 0x07,
  0x80, 0xFF, 0x03, 0x06, 0x0C, 0x0C, 0x18, 0x30, 0x60, 0x60, 0xC0, 0xFF,
  0x0C, 0x73, 0x0C, 0x30, 0xC3, 0x0C, 0xE3, 0x83, 0x0C, 0x30, 0xC3, 0x0C,
  0x38, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC3, 0x83, 0x0C, 0x30,
  0xC3, 0x0C, 0x1C, 0x73, 0x0C, 0x30, 0xC3, 0x0C, 0x73, 0x80, 0x70, 0x7F,
  0xF8, 0x78,
};

const GFXglyph NotoSans_Regular21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 2, 15, 6, 2, -15 },
  { 5, 6, 5, 9, 1, -15 },
  { 9, 12, 15, 14, 1, -15 },
  { 32, 10, 17, 12, 1, -16 },
  { 54, 15, 15, 17, 1, -15 },
  { 83, 14, 15, 15, 1, -15 },
  { 110, 2, 5, 5, 1, -15 },
  { 112, 5, 18, 6, 1, -15 },
  { 124, 4, 18, 6, 1, -15 },
  { 133, 10, 9, 12, 1, -16 },
  { 145, 10, 11, 12, 1, -13 },
  { 159, 3, 5, 6, 1, -2 },
  { 161, 5, 1, 7, 1, -6 },
  { 162, 2, 3, 6, 2, -3 },
  { 163, 8, 15, 8, 0, -15 },
  { 178, 10, 15, 12, 1, -15 },
  { 197, 5, 15, 12, 2, -15 },
  { 207, 10, 15, 12, 1, -15 },
  { 226, 10, 15, 12, 1, -15 },
  { 245, 12, 15, 12, 0, -15 },
  { 268, 10, 15, 12, 1, -15 },
  { 287, 10, 15, 12, 1, -15 },
  { 306, 10, 15, 12, 1, -15 },
  { 325, 10, 15, 12, 1, -15 },
  { 344, 10, 15, 12, 1, -15 },
  { 363, 2, 12, 6, 2, -12 },
  { 366, 3, 15, 6, 1, -12 },
  { 372, 10, 11, 12, 1, -13 },
  { 386, 10, 5, 12, 1, -10 },
  { 393, 10, 11, 12, 1, -13 },
  { 407, 9, 15, 9, 0, -15 },
  { 424, 17, 17, 19, 1, -15 },
  { 461, 13, 15, 13, 0, -15 },
  { 486, 11, 15, 14, 2, -15 },
  { 507, 12, 15, 13, 1, -15 },
  { 530, 12, 15, 15, 2, -15 },
  { 553, 8, 15, 12, 2, -15 },
  { 568, 8, 15, 11, 2, -15 },
  { 583, 13, 15, 15, 1, -15 },
  { 608, 12, 15, 16, 2, -15 },
  { 631, 5, 15, 7, 1, -15 },
  { 641, 6, 19, 6, -2, -15 },
  { 656, 11, 15, 13, 2, -15 },
  { 677, 8, 15, 11, 2, -15 },
  { 692, 15, 15, 19, 2, -15 },
  { 721, 12, 15, 16, 2, -15 },
  { 744, 14, 15, 16, 1, -15 },
  { 771, 10, 15, 13, 2, -15 },
  { 790, 14, 19, 16, 1, -15 },
  { 824, 11, 15, 13, 2, -15 },
  { 845, 10, 15, 12, 1, -15 },
  { 864, 11, 15, 12, 0, -15 },
  { 885, 11, 15, 15, 2, -15 },
  { 906, 13, 15, 13, 0, -15 },
  { 931, 19, 15, 20, 0, -15 },
  { 967, 12, 15, 12, 0, -15 },
  { 990, 12, 15, 12, 0, -15 },
  { 1013, 10, 15, 12, 1, -15 },
  { 1032, 4, 18, 7, 2, -15 },
  { 1041, 8, 15, 8, 0, -15 },
  { 1056, 4, 18, 7, 1, -15 },
  { 1065, 10, 9, 12, 1, -15 },
  { 1077, 9, 1, 9, 0, 2 },
  { 1079, 4, 3, 6, 1, -16 },
  { 1081, 9, 11, 12, 1, -11 },
  { 1094, 10, 16, 13, 2, -16 },
  { 1114, 8, 11, 10, 1, -11 },
  { 1125, 10, 16, 13, 1, -16 },
  { 1145, 10, 11, 12, 1, -11 },
  { 1159, 8, 16, 7, 0, -16 },
  { 1175, 10, 16, 13, 1, -11 },
  { 1195, 9, 16, 13, 2, -16 },
  { 1213, 2, 15, 5, 2, -15 },
  { 1217, 5, 20, 5, -1, -15 },
  { 1230, 9, 16, 11, 2, -16 },
  { 1248, 2, 16, 5, 2, -16 },
  { 1252, 16, 11, 20, 2, -11 },
  { 1274, 9, 11, 13, 2, -11 },
  { 1287, 11, 11, 13, 1, -11 },
  { 1303, 10, 16, 13, 2, -11 },
  { 1323, 10, 16, 13, 1, -11 },
  { 1343, 6, 11, 9, 2, -11 },
  { 1352, 8, 11, 10, 1, -11 },
  { 1363, 7, 14, 8, 0, -14 },
  { 1376, 9, 11, 13, 2, -11 },
  { 1389, 11, 11, 11, 0, -11 },
  { 1405, 16, 11, 17, 0, -11 },
  { 1427, 11, 11, 11, 0, -11 },
  { 1443, 11, 16, 11, 0, -11 },
  { 1465, 8, 11, 10, 1, -11 },
  { 1476, 6, 18, 8, 1, -15 },
  { 1490, 2, 21, 12, 5, -16 },
  { 1496, 6, 18, 8, 1, -15 },
  { 1510, 10, 3, 12, 1, -9 },
};

const GFXfont NotoSans_Regular21pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Regular21pt7bBitmaps,
  (GFXglyph *)NotoSans_Regular21pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _NOTOSANS_REGULAR21PT7B_H_
