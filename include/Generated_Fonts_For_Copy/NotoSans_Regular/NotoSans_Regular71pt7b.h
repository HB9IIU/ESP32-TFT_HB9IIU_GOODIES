#ifndef _NOTOSANS_REGULAR71PT7B_H_
#define _NOTOSANS_REGULAR71PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Regular.ttf
// Size: 71pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Regular71pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F,
  0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x3F, 0x1F, 0x8F, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC1, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x0F, 0xE7, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xC7, 0xC0,
  0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F,
  0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF,
  0xF0, 0x1F, 0xFE, 0x03, 0xF7, 0x80, 0x3C, 0xF0, 0x07, 0x9E, 0x00, 0xF3,
  0xC0, 0x1E, 0x78, 0x03, 0xCF, 0x00, 0x79, 0xE0, 0x0F, 0x00, 0x00, 0x00,
  0xF8, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x80, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x07, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7C, 0x00, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x1F, 0x80, 0x00, 0x03,
  0xE0, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x0F, 0xC0,
  0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x07, 0xE0, 0x00, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFF, 0x83, 0xFC, 0x3E, 0x0F, 0xC3, 0xF8, 0x1F, 0x00, 0xC1,
  0xF8, 0x0F, 0x80, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0xFE, 0x03, 0xE0, 0x00,
  0x7F, 0x01, 0xF0, 0x00, 0x3F, 0x80, 0xF8, 0x00, 0x1F, 0xC0, 0x7C, 0x00,
  0x07, 0xE0, 0x3E, 0x00, 0x03, 0xF8, 0x1F, 0x00, 0x01, 0xFE, 0x0F, 0x80,
  0x00, 0x7F, 0xC7, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x03, 0xEF, 0xFE, 0x00, 0x01, 0xF0, 0xFF, 0x80, 0x00,
  0xF8, 0x3F, 0xC0, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x3E, 0x03, 0xF8, 0x00,
  0x1F, 0x01, 0xFC, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x07, 0xC0, 0x7F, 0x00,
  0x03, 0xE0, 0x3F, 0x00, 0x01, 0xF0, 0x1F, 0xA0, 0x00, 0xF8, 0x1F, 0xDE,
  0x00, 0x7C, 0x3F, 0xCF, 0xF0, 0x3E, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x1F,
  0x81, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x7E,
  0x00, 0x03, 0xE0, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x3E, 0x00,
  0x3F, 0x00, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x03, 0xE0, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x7E, 0x00,
  0x00, 0x1F, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x01, 0xF0, 0x3F,
  0x00, 0x00, 0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x3F, 0x80, 0x3E, 0x00, 0x7C,
  0x1F, 0x87, 0xFF, 0x01, 0xF0, 0x03, 0xE0, 0xF8, 0x7F, 0xFE, 0x0F, 0xC0,
  0x3E, 0x0F, 0x87, 0xFF, 0xF0, 0x3E, 0x01, 0xF0, 0xFC, 0x3F, 0x9F, 0xC1,
  0xF8, 0x1F, 0x87, 0xC3, 0xF0, 0x3F, 0x07, 0xE1, 0xF8, 0x7E, 0x1F, 0x00,
  0xF8, 0x3F, 0xFF, 0xC3, 0xE1, 0xF8, 0x07, 0xC0, 0xFF, 0xFC, 0x3F, 0x0F,
  0x80, 0x3F, 0x03, 0xFF, 0xC1, 0xF0, 0x7C, 0x00, 0xF8, 0x07, 0xF8, 0x1F,
  0x83, 0xE0, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0xF8, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x07, 0xC0, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x7E, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x03,
  0xF0, 0x00, 0x03, 0xE0, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x7C,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x1F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x3F, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x00, 0x01,
  0xFC, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x03, 0xF8, 0x0F, 0xF9, 0xFF, 0x00, 0x03, 0xF0, 0x1F,
  0xF0, 0xFF, 0x80, 0x03, 0xF0, 0x3F, 0xC0, 0x7F, 0xC0, 0x07, 0xF0, 0x3F,
  0x80, 0x3F, 0xE0, 0x07, 0xE0, 0x7F, 0x00, 0x1F, 0xF0, 0x07, 0xE0, 0x7F,
  0x00, 0x0F, 0xF8, 0x0F, 0xE0, 0xFE, 0x00, 0x07, 0xFC, 0x0F, 0xC0, 0xFE,
  0x00, 0x03, 0xFE, 0x1F, 0xC0, 0xFC, 0x00, 0x01, 0xFF, 0x3F, 0x80, 0xFC,
  0x00, 0x00, 0xFF, 0xBF, 0x80, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFF, 0xBF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFE, 0x1F, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xF0, 0x07,
  0xFF, 0xFF, 0xF0, 0x07, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFC, 0x00,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x79, 0xE7, 0x9E, 0x79,
  0xE7, 0x80, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00,
  0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x80, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0,
  0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x01, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x01, 0xF8,
  0x03, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0,
  0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x18, 0x00, 0xF8, 0x00, 0xCF, 0xC0, 0x7C, 0x07, 0xEF,
  0xFC, 0x3E, 0x1F, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xF7, 0xC0,
  0x00, 0x01, 0xF3, 0xF0, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x01, 0xFC, 0x7F,
  0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x03,
  0xF8, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x1F, 0x80,
  0x3F, 0x00, 0x03, 0xC0, 0x0E, 0x00, 0x00, 0x40, 0x04, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0xE3, 0xF8, 0x7F, 0x0F,
  0xE1, 0xF8, 0x7F, 0x0F, 0xE1, 0xF8, 0x3F, 0x07, 0xE1, 0xF8, 0x3F, 0x07,
  0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x18, 0x3F, 0x9F, 0xDF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x03, 0xF8, 0x1F, 0xC0,
  0x00, 0xFE, 0x07, 0xE0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0x07, 0xE7,
  0xF0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x1F,
  0x9F, 0x80, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x00,
  0x3F, 0x7E, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x03, 0xF7, 0xE0, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0x7E,
  0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00, 0xFD,
  0xF8, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x07,
  0xF7, 0xE0, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00,
  0x1F, 0x8F, 0xC0, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x03, 0xF8, 0xFC, 0x00,
  0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1F, 0xC1, 0xFC,
  0x00, 0x07, 0xE0, 0x3F, 0x80, 0x03, 0xF8, 0x0F, 0xF0, 0x01, 0xFC, 0x01,
  0xFE, 0x01, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x01, 0xFC, 0x00, 0x7F,
  0x80, 0x1F, 0xF0, 0x07, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x3F, 0xFF,
  0x1F, 0xF7, 0xE7, 0xF8, 0xFD, 0xFE, 0x1F, 0xFF, 0x83, 0xF3, 0xE0, 0x7E,
  0x78, 0x0F, 0xC4, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFC, 0x03, 0xFF, 0x03, 0xF8, 0x00, 0x3F,
  0xC0, 0x7C, 0x00, 0x07, 0xF8, 0x1C, 0x00, 0x00, 0xFE, 0x02, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xF8, 0x01, 0xFF, 0x03, 0xF0, 0x00,
  0x1F, 0xE0, 0xF0, 0x00, 0x03, 0xF8, 0x18, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF2, 0x00,
  0x00, 0x03, 0xFC, 0xE0, 0x00, 0x01, 0xFE, 0x3F, 0x80, 0x01, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xDF, 0x80, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x00, 0xF9, 0xF8,
  0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x7E, 0x00, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x3F,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00,
  0x7E, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xF7, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x07,
  0xC0, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0x90, 0x00, 0x00, 0x3F, 0xCE, 0x00, 0x00, 0x3F, 0xC7, 0xF0, 0x00,
  0x7F, 0xC3, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x20, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x1F,
  0x80, 0x07, 0xE0, 0xFF, 0xF8, 0x07, 0xF1, 0xFF, 0xFF, 0x03, 0xF1, 0xFF,
  0xFF, 0xC1, 0xF9, 0xFF, 0xFF, 0xF0, 0xFD, 0xFC, 0x0F, 0xFC, 0x7F, 0xF8,
  0x00, 0xFF, 0x3F, 0xF0, 0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x0F, 0xEF, 0xF0,
  0x00, 0x03, 0xF7, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x01, 0xFB,
  0xF0, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7F,
  0x3F, 0x00, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x1F,
  0xC3, 0xF8, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x1F,
  0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC,
  0x03, 0xFE, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x01,
  0xFC, 0x3F, 0x80, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x0F, 0xC3, 0xF0, 0x00,
  0x03, 0xF0, 0xFC, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x3F, 0x0F, 0xC0,
  0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x1F,
  0xC0, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x1F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xE0, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0xEF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xF9,
  0xFF, 0xC0, 0x07, 0xF8, 0x0F, 0xFC, 0x03, 0xFC, 0x00, 0xFF, 0x81, 0xFC,
  0x00, 0x1F, 0xF0, 0xFE, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x00, 0x3F, 0x9F,
  0xC0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x00, 0x3F,
  0x7E, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0xFD, 0xF8, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00,
  0x07, 0xF7, 0xF0, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x00, 0xFE, 0x3F, 0x80,
  0x00, 0x7F, 0x0F, 0xF8, 0x00, 0x7F, 0xC1, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0x1F,
  0xE0, 0x7F, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x00,
  0x7F, 0x3F, 0x80, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x0F, 0xCF, 0xC0, 0x00,
  0x03, 0xF7, 0xE0, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0xFD, 0xF8, 0x00,
  0x00, 0x7E, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFE, 0xFC, 0x00, 0x01, 0xFF, 0x7F,
  0x00, 0x01, 0xFF, 0x9F, 0xC0, 0x01, 0xFF, 0xCF, 0xF8, 0x03, 0xF7, 0xE3,
  0xFF, 0xFF, 0xF7, 0xF0, 0xFF, 0xFF, 0xF3, 0xF8, 0x3F, 0xFF, 0xF1, 0xF8,
  0x07, 0xFF, 0xE0, 0xFC, 0x00, 0x7F, 0xC0, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x7C, 0x7F, 0xFE, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x3F, 0xBF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFE, 0x7F, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0xFE, 0x7F, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFD, 0xFC, 0x7C, 0x07, 0xC0, 0xFE, 0x1F, 0xE1, 0xFF, 0x1F, 0xF1,
  0xFF, 0x1F, 0xF1, 0xFE, 0x0F, 0xC0, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0x0F, 0xE1, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1,
  0xF8, 0x3F, 0x83, 0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x07, 0xE0, 0x7C, 0x07,
  0xC0, 0x7C, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xC7, 0xF8,
  0x07, 0xFC, 0x7C, 0x00, 0x1F, 0xE2, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0xFC, 0x0F, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x7C, 0x1F,
  0x80, 0x07, 0xFF, 0xFF, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x7E, 0x3F, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3E, 0x3E, 0x00, 0x3F, 0x80,
  0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x7F, 0x00, 0x1F, 0x00, 0x3E, 0x7E, 0x00,
  0xFE, 0x00, 0x1F, 0x00, 0x3E, 0x7C, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x1F,
  0x7C, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x1F, 0x7C, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x1F, 0xFC, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x1F, 0xF8, 0x01, 0xF0,
  0x00, 0x3F, 0x00, 0x1F, 0xF8, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x1F, 0xF8,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x1F, 0xF8, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x3E, 0xF8, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x3E, 0xF8, 0x03, 0xF0, 0x00,
  0x3E, 0x00, 0x3E, 0xF8, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x3E, 0xF8, 0x01,
  0xF0, 0x00, 0x7E, 0x00, 0x3E, 0xF8, 0x01, 0xF0, 0x00, 0x7F, 0x00, 0x7C,
  0xFC, 0x01, 0xF8, 0x00, 0xFF, 0x00, 0x7C, 0xFC, 0x01, 0xF8, 0x00, 0xFF,
  0x00, 0xF8, 0x7C, 0x00, 0xFC, 0x01, 0xEF, 0x81, 0xF8, 0x7C, 0x00, 0xFF,
  0x07, 0xEF, 0xC7, 0xF0, 0x7C, 0x00, 0x7F, 0xFF, 0xC7, 0xFF, 0xE0, 0x7E,
  0x00, 0x3F, 0xFF, 0x87, 0xFF, 0xC0, 0x3E, 0x00, 0x1F, 0xFF, 0x03, 0xFF,
  0x80, 0x3F, 0x00, 0x07, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0xFF, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x00, 0x00, 0x7D, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00,
  0x00, 0x03, 0xF1, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x00,
  0x00, 0xFC, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x00, 0x00,
  0x7E, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xF0, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x3F, 0x00, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x1F,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xCF, 0xE0,
  0x00, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF3, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFE, 0xFF, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F,
  0x00, 0x01, 0xFF, 0xC7, 0xE0, 0x00, 0x07, 0xFC, 0xFC, 0x00, 0x00, 0x7F,
  0x9F, 0x80, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00,
  0x0F, 0xEF, 0xC0, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x00, 0x3F, 0xBF, 0x00,
  0x00, 0x07, 0xF7, 0xE0, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x1F, 0x9F,
  0x80, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x3F,
  0x8F, 0xC0, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x1F, 0xF8, 0x3F, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x7E, 0x00, 0x07, 0xFF, 0x8F,
  0xC0, 0x00, 0x0F, 0xF9, 0xF8, 0x00, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0x07,
  0xF7, 0xE0, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x7E, 0x00, 0x00, 0x3F, 0xEF, 0xC0, 0x00,
  0x0F, 0xF9, 0xF8, 0x00, 0x3F, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0x01, 0xFF, 0x00, 0x7F,
  0xF0, 0x00, 0x3E, 0x01, 0xFF, 0x00, 0x00, 0x08, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0x80, 0x3F, 0xFC, 0x00,
  0x3F, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF,
  0xF8, 0x03, 0xF0, 0x00, 0x1F, 0xFF, 0x01, 0xF8, 0x00, 0x01, 0xFF, 0xC0,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x7E, 0x00, 0x00, 0x07, 0xF8, 0x3F, 0x00,
  0x00, 0x01, 0xFE, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0xC7, 0xE0, 0x00, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x00, 0x03, 0xF9,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x7E, 0x00,
  0x00, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x00,
  0x0F, 0xEF, 0xC0, 0x00, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x00, 0x01, 0xFB,
  0xF0, 0x00, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xDF, 0x80, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0x03, 0xF7,
  0xE0, 0x00, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x00, 0x01, 0xFD, 0xF8, 0x00,
  0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x00,
  0x3F, 0xBF, 0x00, 0x00, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x00, 0x1F, 0xCF,
  0xC0, 0x00, 0x00, 0x1F, 0xE7, 0xE0, 0x00, 0x00, 0x0F, 0xE3, 0xF0, 0x00,
  0x00, 0x0F, 0xF1, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x7E, 0x00, 0x00, 0x0F, 0xF8, 0x3F, 0x00, 0x00, 0x0F, 0xF8, 0x1F,
  0x80, 0x00, 0x1F, 0xF8, 0x0F, 0xC0, 0x00, 0x7F, 0xF8, 0x07, 0xE0, 0x1F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xEF, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xC0, 0x1F,
  0xFC, 0x00, 0x01, 0xF0, 0x07, 0xFC, 0x00, 0x00, 0x0C, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xF7, 0xE0, 0x00, 0x00, 0x00, 0xFD, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x00,
  0x03, 0xF7, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0x3F, 0x80, 0x00, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x00, 0x03, 0xF1, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xC3, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x7F, 0xC0, 0x00, 0x00,
  0xFC, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xC0,
  0x7F, 0xFC, 0x00, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x01, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x07, 0xFB, 0x03, 0xFE,
  0x7F, 0xFF, 0xCF, 0xFF, 0xF1, 0xFF, 0xFC, 0x3F, 0xFE, 0x07, 0xFF, 0x80,
  0xFC, 0x00, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x00, 0x7F, 0x3F, 0x00, 0x00,
  0x07, 0xF1, 0xF8, 0x00, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x7E,
  0x00, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x07, 0xF8, 0x1F, 0x80, 0x00, 0x7F,
  0x80, 0xFC, 0x00, 0x07, 0xF8, 0x07, 0xE0, 0x00, 0x7F, 0x80, 0x3F, 0x00,
  0x03, 0xF8, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF8, 0x00,
  0x7E, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x3F,
  0x80, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x3F, 0xC0, 0x00, 0x3F,
  0x03, 0xFC, 0x00, 0x01, 0xF8, 0x3F, 0xC0, 0x00, 0x0F, 0xC1, 0xFC, 0x00,
  0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x00, 0x1F, 0x9F,
  0xF0, 0x00, 0x00, 0xFD, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xDF, 0xE0, 0x00, 0x0F, 0xFC, 0x7F,
  0x80, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0x1F,
  0x80, 0x3F, 0xC0, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x07, 0xF8,
  0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xC0,
  0x01, 0xFC, 0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x03, 0xF0, 0x00, 0x3F, 0xC0,
  0x1F, 0x80, 0x00, 0xFF, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x07, 0xE0, 0x00,
  0x1F, 0xE0, 0x3F, 0x00, 0x00, 0x7F, 0x81, 0xF8, 0x00, 0x01, 0xFC, 0x0F,
  0xC0, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x00, 0x3F, 0xC3, 0xF0, 0x00, 0x00,
  0xFF, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x00, 0x0F, 0xE7, 0xE0,
  0x00, 0x00, 0x7F, 0xBF, 0x00, 0x00, 0x01, 0xFE, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xDF, 0x80, 0x00, 0x00, 0x1F, 0xBF, 0xFB, 0xF0,
  0x00, 0x00, 0x03, 0xF7, 0xFF, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0xFF, 0xF7,
  0xE0, 0x00, 0x00, 0x1F, 0xBF, 0xFE, 0xFE, 0x00, 0x00, 0x03, 0xF7, 0xFF,
  0xCF, 0xC0, 0x00, 0x00, 0xFC, 0xFF, 0xF9, 0xF8, 0x00, 0x00, 0x1F, 0x9F,
  0xFF, 0x1F, 0x80, 0x00, 0x03, 0xE3, 0xFF, 0xE3, 0xF0, 0x00, 0x00, 0xFC,
  0x7F, 0xFC, 0x7E, 0x00, 0x00, 0x1F, 0x8F, 0xFF, 0x87, 0xE0, 0x00, 0x03,
  0xE1, 0xFF, 0xF0, 0xFC, 0x00, 0x00, 0xFC, 0x3F, 0xFE, 0x1F, 0xC0, 0x00,
  0x1F, 0x87, 0xFF, 0xC1, 0xF8, 0x00, 0x07, 0xE0, 0xFF, 0xF8, 0x3F, 0x00,
  0x00, 0xFC, 0x1F, 0xFF, 0x03, 0xF0, 0x00, 0x1F, 0x03, 0xFF, 0xE0, 0x7E,
  0x00, 0x07, 0xE0, 0x7F, 0xFC, 0x0F, 0xC0, 0x00, 0xFC, 0x0F, 0xFF, 0x80,
  0xFC, 0x00, 0x3F, 0x01, 0xFF, 0xF0, 0x1F, 0x80, 0x07, 0xE0, 0x3F, 0xFE,
  0x03, 0xF8, 0x00, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0x00, 0x3F, 0x00, 0xFF,
  0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x1F, 0xFF, 0x00, 0x7E, 0x00, 0xF8, 0x03,
  0xFF, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7F, 0xFC, 0x01, 0xF8, 0x07, 0xE0,
  0x0F, 0xFF, 0x80, 0x1F, 0x81, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xF0, 0x3F,
  0x00, 0x3F, 0xFE, 0x00, 0x7F, 0x07, 0xC0, 0x07, 0xFF, 0xC0, 0x07, 0xE1,
  0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0xFF, 0x00, 0x0F,
  0xCF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0x7F, 0xFC, 0x00,
  0x3F, 0x3F, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xF0,
  0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFB, 0xF8, 0x00, 0x00, 0x3F, 0xF9,
  0xFC, 0x00, 0x00, 0x3F, 0xF9, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0xFE, 0x00,
  0x00, 0x3F, 0xF8, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x7F, 0x00, 0x00, 0x3F,
  0xFC, 0x3F, 0x80, 0x00, 0x3F, 0xFC, 0x3F, 0xC0, 0x00, 0x3F, 0xFC, 0x1F,
  0xC0, 0x00, 0x3F, 0xFC, 0x0F, 0xE0, 0x00, 0x3F, 0xFC, 0x0F, 0xF0, 0x00,
  0x3F, 0xFC, 0x07, 0xF0, 0x00, 0x3F, 0xFC, 0x03, 0xF8, 0x00, 0x3F, 0xFC,
  0x03, 0xFC, 0x00, 0x3F, 0xFC, 0x01, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0xFE,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xFC, 0x00, 0x3F, 0x80, 0x3F, 0xFC, 0x00,
  0x1F, 0xC0, 0x3F, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0xFC, 0x00, 0x0F, 0xE0,
  0x3F, 0xFC, 0x00, 0x07, 0xF0, 0x3F, 0xFC, 0x00, 0x07, 0xF8, 0x3F, 0xFC,
  0x00, 0x03, 0xF8, 0x3F, 0xFC, 0x00, 0x01, 0xFC, 0x3F, 0xFC, 0x00, 0x01,
  0xFE, 0x3F, 0xFC, 0x00, 0x00, 0xFE, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0x3F,
  0xFC, 0x00, 0x00, 0x7F, 0xBF, 0xFC, 0x00, 0x00, 0x3F, 0xBF, 0xFC, 0x00,
  0x00, 0x3F, 0xDF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x81, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x7F, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF9, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF7, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0xBF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xF1, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xC7, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0xFE, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0xFC, 0x00, 0x1F, 0xFC, 0xFC, 0x00,
  0x07, 0xFC, 0xFC, 0x00, 0x01, 0xFE, 0xFC, 0x00, 0x00, 0xFE, 0xFC, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFE, 0xFC, 0x00,
  0x01, 0xFE, 0xFC, 0x00, 0x03, 0xFC, 0xFC, 0x00, 0x0F, 0xFC, 0xFC, 0x00,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x87, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFB, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0xDF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x00,
  0x01, 0xF9, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xE3, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x00, 0x03,
  0xF8, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFC, 0x00, 0x1F, 0xFC,
  0x0F, 0xC0, 0x00, 0x3F, 0xE0, 0xFC, 0x00, 0x01, 0xFE, 0x0F, 0xC0, 0x00,
  0x0F, 0xF0, 0xFC, 0x00, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0xFC,
  0x00, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x3F,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00,
  0x07, 0xF0, 0xFC, 0x00, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0xFC,
  0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x01, 0xFC,
  0x0F, 0xC0, 0x00, 0x7F, 0x80, 0xFC, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x7F, 0x00,
  0x0F, 0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03,
  0xF8, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0xFC,
  0x00, 0x0F, 0xE0, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x07, 0xF0,
  0x0F, 0xC0, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x03, 0xFC, 0x0F, 0xC0, 0x00,
  0x1F, 0xC0, 0xFC, 0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x0F, 0xF0, 0xFC,
  0x00, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x07, 0xF8, 0xFC, 0x00, 0x00, 0x3F,
  0x8F, 0xC0, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x00, 0x1F, 0xEF, 0xC0, 0x00,
  0x00, 0xFE, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xFC, 0x3F, 0xF8, 0x0F, 0xF8, 0x3F, 0xC0, 0x00, 0xF8, 0x7F,
  0x80, 0x00, 0x18, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x80,
  0x00, 0x01, 0xFC, 0xE0, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x1F, 0xF8, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xF7, 0xE0, 0x00,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x00, 0x3F,
  0xBF, 0x80, 0x00, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0xFF, 0x00, 0x00, 0xFF, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x01, 0xFF,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0x03, 0xF9, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x3F, 0x00,
  0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x83, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xE3, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x00, 0x1F,
  0x9F, 0xC0, 0x00, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x7E,
  0x00, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7E, 0x7F,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFC, 0x3F,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0x3F, 0xFC,
  0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x3E, 0xFC, 0x00, 0x01, 0xFC, 0x1F,
  0x80, 0x00, 0x7E, 0xFC, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x7E, 0x7C,
  0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0x7E, 0x7E, 0x00, 0x03, 0xF8, 0x1F,
  0xC0, 0x00, 0x7E, 0x7E, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0xFC, 0x7E,
  0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF0, 0x0F,
  0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x01, 0xF8, 0x3F,
  0x00, 0x07, 0xF0, 0x07, 0xE0, 0x01, 0xF8, 0x3F, 0x80, 0x07, 0xE0, 0x07,
  0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0x07, 0xF0, 0x01, 0xF8, 0x1F,
  0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x1F, 0x80, 0x0F, 0xC0, 0x03,
  0xF0, 0x03, 0xF0, 0x0F, 0xC0, 0x0F, 0xC0, 0x03, 0xF0, 0x03, 0xF0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x01,
  0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x1F, 0x80, 0x01, 0xF8, 0x07, 0xE0, 0x07,
  0xE0, 0x1F, 0x80, 0x01, 0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x1F, 0x80, 0x01,
  0xFC, 0x0F, 0xC0, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0xFC, 0x0F, 0xC0, 0x03,
  0xF0, 0x3F, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x00,
  0xFC, 0x1F, 0x80, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0xFE, 0x1F, 0x80, 0x01,
  0xF8, 0x7F, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x01, 0xF8, 0x7E, 0x00, 0x00,
  0x7E, 0x1F, 0x80, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00,
  0xFC, 0x7E, 0x00, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00,
  0x3F, 0x3F, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x3F, 0x3E, 0x00, 0x00,
  0xFC, 0xFC, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x00,
  0x3F, 0x7E, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0xFE, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0x0F, 0xC0, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x03, 0xF0, 0x00, 0x01, 0xFC,
  0x03, 0xF8, 0x00, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x81, 0xF8,
  0x00, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x00,
  0x01, 0xFC, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xBF, 0x80,
  0x00, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x00,
  0x0F, 0xE1, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0x07, 0xE0,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x07, 0xF0,
  0x00, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x01,
  0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x00, 0x0F,
  0xE0, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x7F,
  0x00, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0xFC, 0x00,
  0x00, 0x3F, 0x81, 0xFC, 0x00, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x00, 0x1F,
  0xC3, 0xF8, 0x00, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x00, 0x07, 0xE7, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x00,
  0x1F, 0x3E, 0x00, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x00, 0xF8, 0x7C, 0x00,
  0x00, 0x3E, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x01, 0xF8, 0x1F,
  0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x01, 0xF0,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x01, 0xF0,
  0x03, 0xF0, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x1F, 0x80, 0x00,
  0x3E, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x7C, 0x1F, 0x00,
  0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00, 0x1F, 0xBF,
  0x00, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xC7, 0xFF, 0x00,
  0xF8, 0x00, 0xFF, 0x01, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC7, 0xE3, 0xFF, 0x00,
  0x0F, 0xCF, 0xF0, 0x00, 0x1F, 0xBF, 0xC0, 0x00, 0x3F, 0x7F, 0x00, 0x00,
  0x7E, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F,
  0xBF, 0x00, 0x01, 0xFF, 0x7F, 0x00, 0x07, 0xFE, 0xFF, 0x00, 0x3F, 0xFC,
  0xFF, 0xC3, 0xFC, 0xF9, 0xFF, 0xFF, 0xF1, 0xF1, 0xFF, 0xFF, 0xC3, 0xE1,
  0xFF, 0xFF, 0x07, 0xC0, 0xFF, 0xF8, 0x0F, 0x80, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0xFC, 0x0F, 0xFF, 0x00, 0x3F,
  0x0F, 0xFF, 0xF0, 0x0F, 0xC7, 0xFF, 0xFF, 0x03, 0xF7, 0xFF, 0xFF, 0xE0,
  0xFD, 0xFF, 0xFF, 0xFC, 0x3F, 0xFC, 0x00, 0xFF, 0x0F, 0xFC, 0x00, 0x1F,
  0xE3, 0xFE, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x7F, 0x3F, 0xC0, 0x00,
  0x0F, 0xCF, 0xE0, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00, 0xFE, 0xFE, 0x00,
  0x00, 0x1F, 0xBF, 0x80, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x01, 0xFB, 0xF0,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x07, 0xEF, 0xE0, 0x00,
  0x03, 0xFB, 0xF8, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0x7F, 0x3F, 0xC0,
  0x00, 0x1F, 0xCF, 0xF8, 0x00, 0x0F, 0xF3, 0xFF, 0x00, 0x07, 0xF8, 0xFF,
  0xF0, 0x03, 0xFC, 0x3F, 0x7F, 0xFF, 0xFF, 0x0F, 0x9F, 0xFF, 0xFF, 0x83,
  0xE3, 0xFF, 0xFF, 0xC0, 0xF8, 0x3F, 0xFF, 0xC0, 0x3E, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFE, 0x0F, 0xF8, 0x01, 0xC1, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x20, 0xFF, 0x80, 0x1E, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x7F, 0xFC,
  0x1F, 0xC0, 0x7F, 0xFF, 0xC7, 0xF0, 0x3F, 0xFF, 0xF8, 0xFC, 0x1F, 0xFF,
  0xFF, 0x3F, 0x0F, 0xFF, 0x7F, 0xEF, 0xC7, 0xFC, 0x00, 0xFF, 0xF1, 0xFC,
  0x00, 0x0F, 0xFC, 0xFF, 0x00, 0x01, 0xFF, 0x3F, 0x80, 0x00, 0x7F, 0xDF,
  0xC0, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x03, 0xFD, 0xF8, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xF7,
  0xE0, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0x3F,
  0xCF, 0xE0, 0x00, 0x1F, 0xF3, 0xF8, 0x00, 0x07, 0xFC, 0x7F, 0x00, 0x03,
  0xFF, 0x1F, 0xF0, 0x03, 0xFF, 0xC3, 0xFF, 0xDF, 0xFB, 0xF0, 0x7F, 0xFF,
  0xFC, 0xFC, 0x0F, 0xFF, 0xFE, 0x3F, 0x01, 0xFF, 0xFF, 0x0F, 0xC0, 0x1F,
  0xFF, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xF0, 0x07, 0xFE, 0x3F, 0xF8, 0x0F, 0xF0, 0x07, 0xF8, 0x1F,
  0xC0, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0xFE, 0x3F,
  0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x3F, 0x7E,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x06, 0x0F, 0xF8, 0x00, 0x3E, 0x07,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xC0, 0x60, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0xFF, 0x01, 0xF0, 0x1F, 0xFF, 0xF0, 0xFC, 0x0F, 0xFF, 0xFE, 0x3F,
  0x07, 0xFF, 0xFF, 0xCF, 0xC3, 0xFF, 0xFF, 0xFB, 0xF1, 0xFF, 0x00, 0x3F,
  0xFC, 0x7F, 0x80, 0x07, 0xFF, 0x3F, 0xC0, 0x00, 0xFF, 0xCF, 0xE0, 0x00,
  0x1F, 0xF7, 0xF0, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0x00, 0xFF, 0x7E, 0x00,
  0x00, 0x1F, 0xDF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x01, 0xFD, 0xF8, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x1F, 0xDF, 0xC0,
  0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x01, 0xFF, 0x1F,
  0xC0, 0x00, 0xFF, 0xC7, 0xFC, 0x00, 0xFF, 0xF0, 0xFF, 0xF3, 0xFE, 0xFC,
  0x1F, 0xFF, 0xFF, 0x3F, 0x03, 0xFF, 0xFF, 0x9F, 0xC0, 0x7F, 0xFF, 0xC7,
  0xF0, 0x07, 0xFF, 0xC1, 0xFC, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x10, 0x00, 0x00, 0xFF, 0x07,
  0x80, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0xFC, 0x0F, 0xFF,
  0x80, 0xFC, 0x3F, 0xFF, 0xE0, 0xFC, 0x7F, 0xFF, 0xF0, 0xFC, 0xFF, 0xFF,
  0xF8, 0xFD, 0xFF, 0xFF, 0xFC, 0xFF, 0xF0, 0x03, 0xFE, 0xFF, 0xC0, 0x00,
  0xFE, 0xFF, 0x80, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0x7D, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF,
  0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7,
  0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD,
  0xFB, 0xF7, 0xE0, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x03, 0xF8, 0x01, 0xFD, 0x83, 0xFC, 0xFF, 0xFE, 0x7F, 0xFE, 0x3F,
  0xFE, 0x1F, 0xFE, 0x07, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xFD,
  0xF8, 0x00, 0x0F, 0xF3, 0xF0, 0x00, 0x3F, 0xC7, 0xE0, 0x00, 0x7F, 0x0F,
  0xC0, 0x01, 0xFC, 0x1F, 0x80, 0x07, 0xF0, 0x3F, 0x00, 0x1F, 0xC0, 0x7E,
  0x00, 0x7F, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x03, 0xF0,
  0x1F, 0xC0, 0x07, 0xE0, 0x7F, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x1F, 0x87,
  0xF0, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0xFC, 0xFE,
  0x00, 0x01, 0xFB, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x0F, 0xFD, 0xFC, 0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x3F, 0xC3, 0xFC,
  0x00, 0x7F, 0x03, 0xF8, 0x00, 0xFC, 0x03, 0xF8, 0x01, 0xF8, 0x07, 0xF8,
  0x03, 0xF0, 0x07, 0xF8, 0x07, 0xE0, 0x07, 0xF0, 0x0F, 0xC0, 0x07, 0xF0,
  0x1F, 0x80, 0x0F, 0xF0, 0x3F, 0x00, 0x0F, 0xF0, 0x7E, 0x00, 0x0F, 0xE0,
  0xFC, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x1F, 0xE3, 0xF0, 0x00, 0x1F, 0xE7,
  0xE0, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x3F, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x01,
  0xF0, 0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0x03, 0xE0, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x07, 0xE7, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xCF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0x1F, 0xBF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x3F, 0xF8,
  0x01, 0xFE, 0xFC, 0x01, 0xFE, 0x7F, 0xE0, 0x01, 0xFF, 0xE0, 0x01, 0xFE,
  0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFD, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFB, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0xF8, 0x0F, 0xFF, 0xC0, 0xF8, 0x3F, 0xFF, 0xE0, 0xFC, 0x7F,
  0xFF, 0xF8, 0xFC, 0xFF, 0xFF, 0xF8, 0xFD, 0xFF, 0xFF, 0xFC, 0xFF, 0xF0,
  0x03, 0xFE, 0xFF, 0xC0, 0x00, 0xFE, 0xFF, 0x80, 0x00, 0xFE, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF8,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00,
  0x7F, 0x07, 0xF0, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x00, 0x7E, 0x3F, 0x80,
  0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x1F, 0xBF,
  0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x07,
  0xE7, 0xF0, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x00, 0x3F, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0xFE, 0x00, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0xFF, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x1F, 0xFE, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x3E, 0x03, 0xFF,
  0xE0, 0x0F, 0x83, 0xFF, 0xFC, 0x03, 0xF1, 0xFF, 0xFF, 0xC0, 0xFC, 0xFF,
  0xFF, 0xF8, 0x3F, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0x00, 0x3F, 0xE3, 0xFF,
  0x00, 0x07, 0xF8, 0xFF, 0x80, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x1F, 0xCF,
  0xF0, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x3F,
  0xBF, 0x80, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00,
  0x7E, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x03, 0xFB,
  0xF8, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x1F,
  0xCF, 0xF0, 0x00, 0x07, 0xF3, 0xFE, 0x00, 0x03, 0xFC, 0xFF, 0xC0, 0x01,
  0xFE, 0x3F, 0xFC, 0x00, 0xFF, 0x0F, 0xDF, 0xFF, 0xFF, 0xC3, 0xF7, 0xFF,
  0xFF, 0xE0, 0xFC, 0xFF, 0xFF, 0xF0, 0x3F, 0x0F, 0xFF, 0xF0, 0x0F, 0xC0,
  0xFF, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x01, 0xF0,
  0x1F, 0xFF, 0xF0, 0xFC, 0x0F, 0xFF, 0xFE, 0x3F, 0x07, 0xFF, 0xFF, 0xCF,
  0xC3, 0xFF, 0xDF, 0xFB, 0xF1, 0xFF, 0x00, 0x3F, 0xFC, 0x7F, 0x00, 0x03,
  0xFF, 0x3F, 0xC0, 0x00, 0x7F, 0xCF, 0xE0, 0x00, 0x1F, 0xF7, 0xF0, 0x00,
  0x03, 0xFD, 0xFC, 0x00, 0x00, 0xFF, 0x7E, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFD, 0xF8, 0x00,
  0x00, 0x7F, 0x7F, 0x00, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0x0F, 0xF3, 0xF8,
  0x00, 0x07, 0xFC, 0xFE, 0x00, 0x01, 0xFF, 0x1F, 0xC0, 0x00, 0xFF, 0xC7,
  0xFC, 0x00, 0xFF, 0xF0, 0xFF, 0xF7, 0xFE, 0xFC, 0x1F, 0xFF, 0xFF, 0x3F,
  0x03, 0xFF, 0xFF, 0x9F, 0xC0, 0x7F, 0xFF, 0xC7, 0xF0, 0x07, 0xFF, 0xC1,
  0xFC, 0x00, 0x1E, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x01, 0xFB, 0xE0, 0x3F, 0xFF, 0x81, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0xDF, 0xC0, 0x3F, 0xFC, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0xFF, 0xE1, 0xFF, 0x3F, 0xC0, 0x03,
  0xC7, 0xE0, 0x00, 0x08, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0xC0, 0x00, 0x1F, 0xDE, 0x00, 0x07, 0xFB, 0xFE, 0x0F, 0xFE, 0x7F,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFE, 0x78, 0x0F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x01, 0xF8, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0x7F, 0x00, 0x03, 0xFF, 0x7F, 0xC0, 0x0F, 0xFF, 0x3F, 0xFD,
  0xFF, 0xBF, 0x3F, 0xFF, 0xFF, 0x3F, 0x1F, 0xFF, 0xFE, 0x3F, 0x0F, 0xFF,
  0xFC, 0x3F, 0x03, 0xFF, 0xF0, 0x1F, 0x00, 0x1F, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF7, 0xE0, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x0F, 0xE7,
  0xF0, 0x00, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x01,
  0xFC, 0x3F, 0x80, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x01, 0xF8, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0xFC, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x01, 0xF8, 0x01, 0xF8, 0x00,
  0x1F, 0xC0, 0x3F, 0x80, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x3F,
  0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x7F,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0xFC, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x01, 0xF9, 0xF8,
  0x00, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0x9F, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0x7E, 0x7E, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xF9, 0xFC,
  0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x3F,
  0x0F, 0xC0, 0x01, 0xF7, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xDF, 0x80,
  0x07, 0xF0, 0xFE, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0xFC,
  0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF3, 0xF0, 0x01, 0xF8, 0x1F, 0xC0,
  0x0F, 0x8F, 0xC0, 0x0F, 0xE0, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x00,
  0xFC, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xC1, 0xF8, 0x03,
  0xF0, 0x0F, 0xE0, 0x3F, 0x03, 0xE0, 0x1F, 0x80, 0x1F, 0x80, 0xFC, 0x0F,
  0xC0, 0x7E, 0x00, 0x7E, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x01, 0xF8, 0x1F,
  0x80, 0x7C, 0x0F, 0xE0, 0x07, 0xF0, 0x7E, 0x01, 0xF8, 0x3F, 0x00, 0x0F,
  0xC1, 0xF8, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x1F, 0x83, 0xF0,
  0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x01, 0xF8, 0xFC, 0x00, 0xFC,
  0x7E, 0x00, 0x07, 0xE3, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0x1F, 0x9F, 0x80,
  0x07, 0xC7, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0xF9,
  0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0xFB, 0xF0, 0x00,
  0x0F, 0xDF, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE7, 0xF0,
  0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0xFE, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0xFE, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x03,
  0xF9, 0xFC, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0xFD, 0xFC, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x0F, 0xE1, 0xF8, 0x00,
  0x03, 0xF8, 0x3F, 0x80, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x3F,
  0x80, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x0F, 0xE0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x7F,
  0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x01, 0xFD,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x07, 0xF7, 0xE0, 0x00,
  0x00, 0x7F, 0x7F, 0x00, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00, 0xFE, 0x3F,
  0x00, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0x1F,
  0xC1, 0xFC, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0xFC, 0x00,
  0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x07,
  0xF0, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x1F, 0xC0, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x00,
  0xFE, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x7E, 0x07, 0xF0,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0xFE, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00,
  0x0F, 0x9F, 0x80, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x0F, 0xDF, 0x80,
  0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x08, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x0E, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x03, 0xFF,
  0x80, 0x1F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x00,
  0x0F, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF,
  0xC0, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00,
  0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x8F, 0xFF, 0x00, 0x00, 0x5F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFD, 0x80, 0x03, 0xFF, 0xFC, 0x80, 0x00, 0x3F, 0xF8, 0x40, 0x00,
  0x00, 0xE0, 0x00,
};

const GFXglyph NotoSans_Regular71pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 9, 52, 19, 5, -51 },
  { 60, 19, 19, 29, 5, -51 },
  { 106, 42, 51, 46, 2, -51 },
  { 374, 33, 58, 41, 4, -54 },
  { 614, 53, 52, 59, 3, -51 },
  { 959, 48, 52, 52, 4, -51 },
  { 1271, 6, 19, 16, 5, -51 },
  { 1286, 16, 62, 21, 3, -51 },
  { 1410, 16, 62, 21, 2, -51 },
  { 1534, 33, 32, 39, 3, -54 },
  { 1666, 33, 34, 41, 4, -42 },
  { 1807, 11, 17, 19, 3, -8 },
  { 1831, 17, 6, 23, 3, -22 },
  { 1844, 9, 10, 19, 5, -9 },
  { 1856, 25, 51, 26, 1, -51 },
  { 2016, 34, 52, 41, 3, -51 },
  { 2237, 19, 51, 41, 6, -51 },
  { 2359, 34, 51, 41, 3, -51 },
  { 2576, 34, 52, 41, 3, -51 },
  { 2797, 38, 51, 41, 1, -51 },
  { 3040, 33, 52, 41, 4, -51 },
  { 3255, 33, 52, 41, 4, -51 },
  { 3470, 34, 51, 41, 3, -51 },
  { 3687, 34, 52, 41, 3, -51 },
  { 3908, 33, 52, 41, 4, -51 },
  { 4123, 9, 40, 19, 5, -39 },
  { 4168, 12, 48, 19, 2, -39 },
  { 4240, 33, 35, 41, 4, -43 },
  { 4385, 33, 20, 41, 4, -35 },
  { 4468, 33, 35, 41, 4, -43 },
  { 4613, 28, 52, 31, 1, -51 },
  { 4795, 56, 57, 64, 4, -51 },
  { 5194, 45, 51, 45, 0, -51 },
  { 5481, 35, 51, 46, 7, -51 },
  { 5705, 39, 52, 45, 4, -51 },
  { 5959, 41, 51, 52, 7, -51 },
  { 6221, 28, 51, 39, 7, -51 },
  { 6400, 28, 51, 37, 7, -51 },
  { 6579, 42, 52, 52, 4, -51 },
  { 6852, 39, 51, 53, 7, -51 },
  { 7101, 18, 51, 24, 3, -51 },
  { 7216, 19, 64, 19, -6, -51 },
  { 7368, 37, 51, 44, 7, -51 },
  { 7604, 28, 51, 37, 7, -51 },
  { 7783, 51, 51, 64, 7, -51 },
  { 8109, 40, 51, 54, 7, -51 },
  { 8364, 47, 52, 55, 4, -51 },
  { 8670, 32, 51, 43, 7, -51 },
  { 8874, 47, 63, 55, 4, -51 },
  { 9245, 36, 51, 44, 7, -51 },
  { 9475, 32, 52, 39, 4, -51 },
  { 9683, 38, 51, 39, 1, -51 },
  { 9926, 39, 52, 52, 6, -51 },
  { 10180, 43, 51, 43, 0, -51 },
  { 10455, 64, 51, 66, 1, -51 },
  { 10863, 41, 51, 42, 0, -51 },
  { 11125, 40, 51, 40, 0, -51 },
  { 11380, 35, 51, 41, 3, -51 },
  { 11604, 16, 62, 23, 6, -51 },
  { 11728, 25, 51, 26, 1, -51 },
  { 11888, 16, 62, 23, 2, -51 },
  { 12012, 35, 32, 41, 3, -51 },
  { 12152, 32, 5, 32, 0, 6 },
  { 12172, 14, 11, 20, 3, -54 },
  { 12192, 31, 40, 40, 3, -39 },
  { 12347, 34, 55, 44, 6, -54 },
  { 12581, 28, 40, 34, 4, -39 },
  { 12721, 34, 55, 44, 4, -54 },
  { 12955, 32, 40, 40, 4, -39 },
  { 13115, 26, 54, 24, 1, -54 },
  { 13291, 34, 56, 44, 4, -39 },
  { 13529, 32, 54, 44, 6, -54 },
  { 13745, 7, 52, 18, 6, -52 },
  { 13791, 17, 69, 18, -4, -52 },
  { 13938, 31, 54, 38, 6, -54 },
  { 14148, 6, 54, 18, 6, -54 },
  { 14189, 55, 39, 66, 6, -39 },
  { 14458, 32, 39, 44, 6, -39 },
  { 14614, 35, 40, 43, 4, -39 },
  { 14789, 34, 56, 44, 6, -39 },
  { 15027, 34, 56, 44, 4, -39 },
  { 15265, 22, 39, 29, 6, -39 },
  { 15373, 27, 40, 34, 4, -39 },
  { 15508, 23, 48, 26, 1, -47 },
  { 15646, 32, 39, 44, 6, -38 },
  { 15802, 36, 38, 36, 0, -38 },
  { 15973, 54, 38, 56, 1, -38 },
  { 16230, 35, 38, 38, 1, -38 },
  { 16397, 36, 55, 36, 0, -38 },
  { 16645, 28, 38, 33, 3, -38 },
  { 16778, 23, 62, 27, 2, -51 },
  { 16957, 5, 71, 39, 17, -54 },
  { 17002, 23, 62, 27, 2, -51 },
  { 17181, 33, 10, 41, 4, -30 },
};

const GFXfont NotoSans_Regular71pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Regular71pt7bBitmaps,
  (GFXglyph *)NotoSans_Regular71pt7bGlyphs,
  0x20, 0x7E, 97
};

#endif // _NOTOSANS_REGULAR71PT7B_H_
