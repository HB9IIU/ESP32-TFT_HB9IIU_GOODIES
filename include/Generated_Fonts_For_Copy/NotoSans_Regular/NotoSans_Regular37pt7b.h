#ifndef _NOTOSANS_REGULAR37PT7B_H_
#define _NOTOSANS_REGULAR37PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Regular.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Regular37pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x66, 0x66, 0x66, 0x66, 0x60, 0x00,
  0xFF, 0xFF, 0x40, 0xF1, 0xEE, 0x3D, 0xC7, 0x38, 0xE7, 0x0C, 0xC1, 0x98,
  0x33, 0x06, 0x60, 0xC0, 0x00, 0xE0, 0xE0, 0x03, 0x03, 0x00, 0x0C, 0x0C,
  0x00, 0x70, 0x70, 0x01, 0xC1, 0xC0, 0x07, 0x07, 0x00, 0x1C, 0x18, 0x1F,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF0, 0x38, 0x38, 0x00, 0xE0,
  0xC0, 0x03, 0x03, 0x00, 0x0C, 0x1C, 0x00, 0x70, 0x70, 0x01, 0xC1, 0xC0,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xE0, 0x60, 0xE0, 0x03, 0x83, 0x80, 0x0E,
  0x0E, 0x00, 0x38, 0x38, 0x00, 0xC0, 0xC0, 0x03, 0x07, 0x00, 0x1C, 0x1C,
  0x00, 0x70, 0x70, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0xFF,
  0x01, 0xFF, 0xF1, 0xFF, 0xF9, 0xE7, 0x1D, 0xE3, 0x80, 0xF1, 0xC0, 0x78,
  0xE0, 0x3C, 0x70, 0x0F, 0x38, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0xE0,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0xE7, 0xC0, 0x71, 0xE0, 0x38, 0x70, 0x1C,
  0x38, 0x0E, 0x3F, 0x07, 0x3D, 0xFF, 0xFE, 0xFF, 0xFE, 0x1F, 0xF8, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0xF0, 0x03, 0x81, 0xFE, 0x00, 0xE0, 0x30, 0xE0, 0x1C, 0x0E, 0x0C, 0x07,
  0x01, 0xC1, 0x80, 0xC0, 0x38, 0x38, 0x38, 0x07, 0x07, 0x0E, 0x00, 0xE0,
  0xE1, 0xC0, 0x1C, 0x1C, 0x70, 0x03, 0x83, 0x8E, 0x00, 0x70, 0x73, 0x8F,
  0x8E, 0x0C, 0x73, 0xF8, 0xC3, 0x9C, 0xE3, 0x9F, 0xE3, 0x18, 0x71, 0xFC,
  0xE7, 0x07, 0x0E, 0x38, 0xE0, 0xE0, 0x07, 0x1C, 0x1C, 0x01, 0xC3, 0x83,
  0x80, 0x38, 0x70, 0x70, 0x0E, 0x0E, 0x0E, 0x01, 0xC1, 0xC1, 0xC0, 0x70,
  0x38, 0x38, 0x0C, 0x03, 0x06, 0x03, 0x80, 0x71, 0xC0, 0xE0, 0x07, 0xF0,
  0x1C, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF,
  0x80, 0x03, 0xC3, 0xC0, 0x01, 0xC0, 0xF0, 0x01, 0xE0, 0x78, 0x00, 0xF0,
  0x3C, 0x00, 0x38, 0x1C, 0x00, 0x1C, 0x1E, 0x00, 0x0F, 0x1E, 0x00, 0x03,
  0xDE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7B, 0xC0, 0x38, 0x78, 0xF0, 0x1C, 0x78, 0x3C, 0x1E, 0x78, 0x0F, 0x0E,
  0x3C, 0x03, 0xCF, 0x1C, 0x00, 0xF7, 0x0E, 0x00, 0x3F, 0x87, 0x80, 0x0F,
  0x83, 0xC0, 0x07, 0xC0, 0xF0, 0x0F, 0xF0, 0x7F, 0xFF, 0xBC, 0x1F, 0xFF,
  0x0F, 0x03, 0xFE, 0x03, 0xC0, 0xF7, 0x77, 0x76, 0x66, 0x60, 0x07, 0x87,
  0x83, 0x83, 0xC1, 0xC1, 0xE0, 0xE0, 0x70, 0x78, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x83, 0xC1, 0xE0, 0xF0, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xE0,
  0xF0, 0x38, 0x1E, 0x07, 0x03, 0x80, 0xE0, 0x70, 0x1C, 0x07, 0xF0, 0x3C,
  0x0E, 0x07, 0x81, 0xC0, 0xF0, 0x38, 0x1C, 0x0F, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xE0, 0x70, 0x38, 0x3C,
  0x1E, 0x0E, 0x07, 0x07, 0x83, 0x83, 0xC1, 0xC1, 0xC1, 0xC0, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x06, 0x0C, 0x1B, 0xE6,
  0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0x01, 0xE0, 0x01, 0xF8, 0x01, 0xCE, 0x00,
  0xE7, 0x80, 0xF1, 0xC0, 0xF0, 0xF0, 0x38, 0x30, 0x04, 0x10, 0x00, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x7B, 0xDC, 0xEF, 0x73, 0x98, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0x40, 0x00, 0x38, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x0F, 0x00,
  0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x78,
  0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03,
  0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x00, 0x03, 0xE0,
  0x07, 0xFC, 0x07, 0xFF, 0x07, 0x83, 0xC7, 0x80, 0xF3, 0x80, 0x39, 0xC0,
  0x1D, 0xE0, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFE, 0x00, 0x77, 0x00, 0x7B, 0x80, 0x39, 0xE0, 0x3C, 0x70,
  0x1C, 0x3F, 0x7E, 0x0F, 0xFE, 0x01, 0xFE, 0x00, 0x03, 0xC1, 0xF0, 0xFC,
  0xFF, 0x79, 0xFC, 0x76, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x03, 0xE0, 0x0F, 0xFC, 0x1F, 0xFF, 0x1F,
  0x03, 0xC6, 0x00, 0xF2, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x07, 0xC0, 0x1F, 0xFC, 0x3F, 0xFF, 0x9F, 0x03, 0xC6,
  0x00, 0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07,
  0x80, 0x07, 0x80, 0x0F, 0x80, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xF8, 0x00,
  0x3E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x3C, 0x00, 0x1F, 0x00, 0x1E, 0xFC, 0xFE, 0x7F, 0xFE, 0x1F, 0xFC,
  0x00, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07,
  0x70, 0x00, 0xEE, 0x00, 0x3B, 0xC0, 0x0E, 0x78, 0x01, 0xCF, 0x00, 0x71,
  0xE0, 0x1C, 0x3C, 0x07, 0x87, 0x80, 0xE0, 0xF0, 0x38, 0x1E, 0x0E, 0x03,
  0xC1, 0xC0, 0x78, 0x70, 0x0F, 0x1C, 0x01, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x3F, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF,
  0x87, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1F, 0xFC, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0x00, 0xF8,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x78, 0x00, 0x3B, 0x00, 0x3D, 0xF9, 0xFC, 0xFF, 0xFC, 0x1F,
  0xF8, 0x00, 0x00, 0x7E, 0x01, 0xFF, 0x01, 0xFF, 0x81, 0xF0, 0x01, 0xE0,
  0x01, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C,
  0x18, 0x1C, 0x7F, 0x8E, 0xFF, 0xE7, 0x70, 0x7B, 0xE0, 0x1F, 0xE0, 0x07,
  0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x77, 0x00, 0x3B, 0x80,
  0x1D, 0xE0, 0x1E, 0x78, 0x1E, 0x1F, 0x3F, 0x07, 0xFF, 0x01, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00,
  0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00,
  0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0,
  0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C,
  0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x0F, 0xFE,
  0x0F, 0xFF, 0x8F, 0x83, 0xE7, 0x00, 0x73, 0x80, 0x39, 0xC0, 0x1C, 0xE0,
  0x0E, 0x70, 0x07, 0x3C, 0x07, 0x8F, 0x07, 0x83, 0xEF, 0x80, 0xFF, 0x00,
  0x3F, 0x80, 0x7F, 0xF0, 0x78, 0x7C, 0x78, 0x0F, 0x78, 0x03, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0x7C,
  0x1F, 0x1F, 0xFF, 0x03, 0xFE, 0x00, 0x03, 0xE0, 0x0F, 0xFC, 0x0F, 0xFF,
  0x0F, 0x83, 0xC7, 0x80, 0xF7, 0x80, 0x3B, 0x80, 0x1D, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0x7B, 0xC0, 0x7D,
  0xFD, 0xEE, 0x7F, 0xE7, 0x0F, 0xE3, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x78, 0x00, 0x78, 0x21, 0xF8, 0x1F,
  0xF8, 0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0x40, 0x3C, 0xF3, 0xCF, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0xE3, 0x9E, 0x71, 0xC7, 0x38, 0xE0, 0x00, 0x00,
  0x80, 0x00, 0xC0, 0x01, 0xE0, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0x80, 0x00,
  0xC0, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x80, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x01,
  0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x00, 0xF8,
  0x00, 0x70, 0x00, 0x20, 0x00, 0x00, 0x07, 0xC0, 0x7F, 0xF3, 0xFF, 0xF3,
  0xC1, 0xE4, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xC0,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x1E, 0x00, 0x10, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x70, 0x70, 0x00, 0x01,
  0xC7, 0x01, 0xFF, 0x0E, 0x30, 0x3F, 0xF8, 0x3B, 0x83, 0xC1, 0xC1, 0xDC,
  0x1C, 0x0E, 0x0E, 0xC1, 0xC0, 0x70, 0x7E, 0x0E, 0x03, 0x81, 0xF0, 0x70,
  0x1C, 0x1F, 0x83, 0x00, 0xE0, 0xFC, 0x18, 0x07, 0x07, 0xE0, 0xE0, 0x38,
  0x3F, 0x07, 0x03, 0xC1, 0xB8, 0x38, 0x1E, 0x1C, 0xC0, 0xF3, 0xB9, 0xC7,
  0x07, 0xF8, 0xFC, 0x38, 0x0F, 0x83, 0xC0, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x20, 0x01, 0xF8, 0x1F,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0xE7, 0x00, 0x00, 0xE7, 0x00, 0x01, 0xC7, 0x00,
  0x01, 0xC3, 0x80, 0x03, 0xC3, 0x80, 0x03, 0x83, 0xC0, 0x03, 0x81, 0xC0,
  0x07, 0x81, 0xC0, 0x07, 0x01, 0xE0, 0x0F, 0x00, 0xE0, 0x0F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1C, 0x00, 0x78, 0x1C, 0x00, 0x38,
  0x38, 0x00, 0x38, 0x38, 0x00, 0x3C, 0x78, 0x00, 0x1C, 0x70, 0x00, 0x1E,
  0x70, 0x00, 0x0E, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0x8E, 0x0F,
  0xF3, 0x80, 0x3E, 0xE0, 0x07, 0xB8, 0x00, 0xEE, 0x00, 0x3B, 0x80, 0x0E,
  0xE0, 0x07, 0xB8, 0x01, 0xCE, 0x01, 0xE3, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F,
  0xFF, 0xCE, 0x00, 0x7B, 0x80, 0x0E, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xEE, 0x00, 0xFB, 0xFF, 0xFC,
  0xFF, 0xFE, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0xFF, 0x07, 0xFF,
  0xF0, 0xFC, 0x0E, 0x1F, 0x00, 0x23, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x01, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x01, 0xFF,
  0xE0, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x38, 0x3F, 0xE1, 0xC0, 0x0F, 0x8E,
  0x00, 0x3E, 0x70, 0x00, 0xF3, 0x80, 0x03, 0xDC, 0x00, 0x1E, 0xE0, 0x00,
  0x77, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x77, 0x00, 0x07,
  0xB8, 0x00, 0x3D, 0xC0, 0x03, 0xCE, 0x00, 0x1E, 0x70, 0x03, 0xE3, 0x80,
  0x7E, 0x1F, 0xFF, 0xE0, 0xFF, 0xFC, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0xE0,
  0x3F, 0xFF, 0xC3, 0xF8, 0x1E, 0x1F, 0x00, 0x08, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC,
  0x01, 0xFF, 0xF0, 0x00, 0x1D, 0xC0, 0x00, 0x77, 0x00, 0x01, 0xDE, 0x00,
  0x07, 0x78, 0x00, 0x1C, 0xF0, 0x00, 0x71, 0xE0, 0x01, 0xC7, 0xE0, 0x07,
  0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x7C, 0xFF, 0xFF, 0xF0, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x81,
  0xEF, 0xF3, 0xFC, 0xFC, 0x00, 0xE0, 0x03, 0xFC, 0x00, 0xF3, 0x80, 0x3C,
  0x70, 0x0F, 0x0E, 0x03, 0xC1, 0xC0, 0xF0, 0x38, 0x3C, 0x07, 0x07, 0x00,
  0xE1, 0xC0, 0x1C, 0x70, 0x03, 0x9E, 0x00, 0x77, 0x80, 0x0F, 0xF8, 0x01,
  0xFF, 0x80, 0x3C, 0xF8, 0x07, 0x0F, 0x00, 0xE0, 0xF0, 0x1C, 0x0F, 0x03,
  0x81, 0xE0, 0x70, 0x1E, 0x0E, 0x01, 0xE1, 0xC0, 0x1E, 0x38, 0x03, 0xC7,
  0x00, 0x3C, 0xE0, 0x03, 0xDC, 0x00, 0x3C, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0x70, 0x00, 0x3F, 0xFC, 0x00, 0x1D, 0xFB, 0x80, 0x07,
  0x7E, 0xE0, 0x03, 0x9F, 0xB8, 0x00, 0xE7, 0xE7, 0x00, 0x39, 0xF9, 0xC0,
  0x1C, 0x7E, 0x78, 0x07, 0x1F, 0x8E, 0x01, 0xC7, 0xE3, 0x80, 0xE1, 0xF8,
  0x70, 0x38, 0x7E, 0x1C, 0x1C, 0x1F, 0x87, 0x87, 0x07, 0xE0, 0xE1, 0xC1,
  0xF8, 0x38, 0xE0, 0x7E, 0x0F, 0x38, 0x1F, 0x81, 0xDC, 0x07, 0xE0, 0x77,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x80, 0xF8, 0x07, 0xE0,
  0x1E, 0x01, 0xF8, 0x07, 0x00, 0x70, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0xFD, 0xE0, 0x07, 0xEF, 0x00, 0x3F, 0x3C, 0x01,
  0xFC, 0xF0, 0x0F, 0xE7, 0x80, 0x7F, 0x1E, 0x03, 0xF8, 0x70, 0x1F, 0xC3,
  0xC0, 0xFE, 0x0F, 0x07, 0xF0, 0x38, 0x3F, 0x81, 0xE1, 0xFC, 0x07, 0x8F,
  0xE0, 0x1C, 0x7F, 0x00, 0xF3, 0xF8, 0x03, 0xCF, 0xC0, 0x1E, 0x7E, 0x00,
  0x7B, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFC,
  0x01, 0xF8, 0x3F, 0x01, 0xE0, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0xE0, 0x00,
  0x78, 0xF0, 0x00, 0x1E, 0x78, 0x00, 0x0F, 0x38, 0x00, 0x03, 0xBC, 0x00,
  0x01, 0xDE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0x38, 0x00, 0x03, 0x9C,
  0x00, 0x01, 0xCF, 0x00, 0x01, 0xE7, 0x80, 0x00, 0xE1, 0xE0, 0x00, 0xF0,
  0xF8, 0x00, 0xF0, 0x3E, 0x00, 0xF8, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xF0,
  0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF0, 0x7F, 0xFE, 0x38, 0x7F, 0x9C, 0x03,
  0xEE, 0x00, 0xF7, 0x00, 0x3B, 0x80, 0x1D, 0xC0, 0x0F, 0xE0, 0x07, 0x70,
  0x03, 0xB8, 0x03, 0xDC, 0x03, 0xCE, 0x07, 0xE7, 0xFF, 0xE3, 0xFF, 0xC1,
  0xFF, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x01, 0xF8, 0x3F,
  0x01, 0xE0, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0xE0, 0x00, 0x78, 0xF0, 0x00,
  0x1E, 0x78, 0x00, 0x0F, 0x38, 0x00, 0x03, 0xBC, 0x00, 0x01, 0xDE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0x38, 0x00, 0x03, 0x9C, 0x00, 0x01, 0xCF,
  0x00, 0x01, 0xE7, 0x80, 0x00, 0xE1, 0xE0, 0x00, 0xF0, 0xF8, 0x00, 0xF0,
  0x3E, 0x00, 0xF8, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0xFF, 0xF0, 0x3F, 0xFF,
  0x0E, 0x1F, 0xE3, 0x80, 0x7C, 0xE0, 0x0F, 0x38, 0x01, 0xCE, 0x00, 0x73,
  0x80, 0x1E, 0xE0, 0x07, 0x38, 0x01, 0xCE, 0x00, 0xF3, 0x80, 0x78, 0xFF,
  0xFC, 0x3F, 0xFE, 0x0F, 0xFE, 0x03, 0x83, 0xC0, 0xE0, 0x78, 0x38, 0x0E,
  0x0E, 0x03, 0xC3, 0x80, 0x70, 0xE0, 0x1E, 0x38, 0x03, 0xCE, 0x00, 0x73,
  0x80, 0x1E, 0xE0, 0x03, 0xF8, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0xFF, 0x8F,
  0xFF, 0xCF, 0xC1, 0xC7, 0x80, 0x27, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xC0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1D, 0x00, 0x3E, 0xFF, 0xFE,
  0x7F, 0xFE, 0x1F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1E,
  0xE0, 0x00, 0xE7, 0x00, 0x07, 0x3C, 0x00, 0x78, 0xF0, 0x07, 0x83, 0xFF,
  0xF8, 0x0F, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0xF0, 0x00, 0x3D, 0xC0, 0x00,
  0xF7, 0x80, 0x03, 0x9E, 0x00, 0x1E, 0x38, 0x00, 0x70, 0xF0, 0x01, 0xC3,
  0xC0, 0x0F, 0x07, 0x00, 0x38, 0x1E, 0x00, 0xE0, 0x38, 0x07, 0x80, 0xE0,
  0x1C, 0x03, 0xC0, 0xF0, 0x07, 0x03, 0xC0, 0x1C, 0x0E, 0x00, 0x78, 0x78,
  0x00, 0xE1, 0xE0, 0x03, 0x87, 0x00, 0x0F, 0x3C, 0x00, 0x1C, 0xE0, 0x00,
  0x73, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xDC,
  0x00, 0x78, 0x00, 0xE7, 0x80, 0x3F, 0x00, 0x39, 0xE0, 0x0F, 0xC0, 0x1E,
  0x38, 0x03, 0xF0, 0x07, 0x8E, 0x00, 0xEE, 0x01, 0xC3, 0xC0, 0x73, 0x80,
  0x70, 0x70, 0x1C, 0xE0, 0x3C, 0x1C, 0x07, 0x38, 0x0F, 0x07, 0x03, 0xC7,
  0x03, 0x81, 0xE0, 0xE1, 0xC0, 0xE0, 0x38, 0x38, 0x70, 0x78, 0x0E, 0x0E,
  0x0E, 0x1E, 0x03, 0x87, 0x03, 0x87, 0x00, 0xF1, 0xC0, 0xE1, 0xC0, 0x1C,
  0x70, 0x3C, 0xF0, 0x07, 0x3C, 0x07, 0x38, 0x01, 0xCE, 0x01, 0xCE, 0x00,
  0x7B, 0x80, 0x73, 0x80, 0x0E, 0xE0, 0x0F, 0xE0, 0x03, 0xF0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x07,
  0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0xF0, 0x03, 0xC1, 0xC0, 0x0E, 0x07, 0x80, 0x70, 0x0E, 0x03, 0xC0,
  0x1C, 0x0E, 0x00, 0x78, 0x70, 0x00, 0xE3, 0xC0, 0x03, 0xCE, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x77, 0x80, 0x03, 0xCF, 0x00, 0x0E, 0x1C, 0x00,
  0x70, 0x78, 0x03, 0xC0, 0xE0, 0x0E, 0x03, 0xC0, 0x70, 0x07, 0x83, 0xC0,
  0x0E, 0x0E, 0x00, 0x3C, 0x78, 0x00, 0x7B, 0xC0, 0x01, 0xF0, 0xF0, 0x00,
  0x7B, 0xC0, 0x07, 0x8E, 0x00, 0x38, 0x78, 0x03, 0xC1, 0xC0, 0x1C, 0x0F,
  0x01, 0xE0, 0x38, 0x0E, 0x01, 0xE0, 0xF0, 0x07, 0x07, 0x00, 0x3C, 0x78,
  0x00, 0xE3, 0x80, 0x07, 0xB8, 0x00, 0x1F, 0xC0, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9,
  0xFF, 0xFF, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0x80,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x0E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x03,
  0x80, 0x0E, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xC0, 0x0E,
  0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0E, 0x00, 0x78,
  0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xC0,
  0xFF, 0xFF, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xC0, 0x00, 0x1C,
  0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x3B, 0x00, 0x06, 0x70, 0x01, 0xC6,
  0x00, 0x38, 0xE0, 0x0E, 0x0C, 0x01, 0xC1, 0xC0, 0x70, 0x18, 0x0E, 0x03,
  0x81, 0x80, 0x30, 0x70, 0x07, 0x0C, 0x00, 0x63, 0x80, 0x0E, 0xF0, 0x00,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF8, 0x38, 0x3C, 0x1E,
  0x0E, 0x03, 0x0F, 0xF8, 0x3F, 0xFC, 0x3F, 0x7E, 0x10, 0x0E, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x03, 0xFF, 0x1F, 0xFF, 0x7F, 0x87,
  0xF8, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x1F,
  0xF8, 0xF7, 0x7F, 0xE7, 0x3F, 0xC7, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE3, 0xF8, 0x39, 0xFF, 0x8E, 0xFF, 0xF3, 0xE0, 0x3C, 0xF8, 0x07, 0xBC,
  0x00, 0xEF, 0x00, 0x3B, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xEF, 0x00, 0x3B, 0xC0, 0x1E,
  0xF8, 0x0F, 0x3F, 0xCF, 0xCE, 0xFF, 0xE3, 0x8F, 0xE0, 0x07, 0xFE, 0x1F,
  0xF8, 0xFF, 0xF1, 0xE0, 0x27, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0x3C, 0x00, 0x7C, 0x02, 0x7F, 0x78, 0x7F, 0xF0, 0x3F, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x07, 0xF3, 0xC7, 0xFE, 0xF3, 0xFF, 0xDD,
  0xF0, 0x3F, 0x78, 0x07, 0xDC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xF7, 0x00, 0x3D, 0xE0, 0x1F, 0x78, 0x07, 0xCF, 0x8F, 0x71, 0xFF, 0x9C,
  0x3F, 0xC7, 0x07, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x87, 0x81, 0xE7, 0x80,
  0x73, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x01, 0x1F, 0xCF, 0x87, 0xFF, 0xC0, 0xFF, 0xC0, 0x03, 0xF8, 0x3F,
  0xC3, 0xE6, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x3F, 0xE7,
  0xFF, 0x3F, 0xF8, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0x07, 0xF1, 0xC7, 0xFE, 0x73,
  0xFF, 0xDC, 0xF0, 0x3F, 0x78, 0x07, 0xDC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xF7, 0x00, 0x3D, 0xE0, 0x1F, 0x78, 0x07, 0xCF, 0xCF, 0xF1,
  0xFF, 0xBC, 0x3F, 0xCF, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x07, 0x8C, 0x03, 0xC3, 0xFF, 0xF0, 0xFF, 0xF0, 0x07, 0xF0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE3, 0xF8, 0x73, 0xFF, 0x3B, 0xFF,
  0xDF, 0x81, 0xEF, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x70, 0xEF, 0xF6, 0x00, 0x0E, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE,
  0xEE, 0xEE, 0xE0, 0x07, 0x03, 0xC1, 0xE0, 0x60, 0x00, 0x00, 0x00, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x0F, 0x7F, 0xBF, 0x9F, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x0F, 0xE0, 0x1E, 0xE0, 0x3C, 0xE0, 0x78, 0xE0, 0xF0, 0xE1, 0xE0,
  0xE3, 0xC0, 0xE7, 0x80, 0xEF, 0x00, 0xEF, 0x80, 0xFF, 0x80, 0xFB, 0xC0,
  0xF1, 0xE0, 0xE0, 0xF0, 0xE0, 0xF0, 0xE0, 0x78, 0xE0, 0x3C, 0xE0, 0x1E,
  0xE0, 0x1E, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xE3, 0xF8, 0x3F, 0xC7, 0x3F, 0xE3, 0xFF, 0x3B, 0xFF,
  0xBF, 0xFD, 0xF0, 0x1F, 0x81, 0xEF, 0x80, 0xF8, 0x07, 0x78, 0x03, 0xC0,
  0x3F, 0xC0, 0x1C, 0x01, 0xFE, 0x00, 0xE0, 0x0F, 0xE0, 0x07, 0x00, 0x7F,
  0x00, 0x38, 0x03, 0xF8, 0x01, 0xC0, 0x1F, 0xC0, 0x0E, 0x00, 0xFE, 0x00,
  0x70, 0x07, 0xF0, 0x03, 0x80, 0x3F, 0x80, 0x1C, 0x01, 0xFC, 0x00, 0xE0,
  0x0F, 0xE0, 0x07, 0x00, 0x7F, 0x00, 0x38, 0x03, 0xF8, 0x01, 0xC0, 0x1F,
  0xC0, 0x0E, 0x00, 0xF0, 0xE3, 0xFC, 0x73, 0xFF, 0x3B, 0xFF, 0xDF, 0x81,
  0xEF, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x70, 0x07,
  0xF8, 0x03, 0xFF, 0x83, 0xFF, 0xF0, 0xF0, 0x1E, 0x78, 0x03, 0x9C, 0x00,
  0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x77, 0x00, 0x3D, 0xE0, 0x0E, 0x3C,
  0x07, 0x8F, 0xC7, 0xC1, 0xFF, 0xE0, 0x1F, 0xE0, 0xE3, 0xF8, 0x39, 0xFF,
  0x8E, 0xFF, 0xF3, 0xF0, 0x3C, 0xF8, 0x07, 0xBC, 0x01, 0xEF, 0x00, 0x3B,
  0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xEF, 0x00, 0x3B, 0xC0, 0x1E, 0xF8, 0x0F, 0x3F, 0xCF,
  0xCE, 0xFF, 0xE3, 0x8F, 0xE0, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0xF1, 0xC7, 0xFE, 0x73, 0xFF, 0xDC, 0xF0, 0x3F, 0x78,
  0x07, 0xDC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xF7, 0x00, 0x3D,
  0xE0, 0x1F, 0x78, 0x07, 0xCF, 0x87, 0xF1, 0xFF, 0xBC, 0x3F, 0xCF, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0xE1, 0xFE, 0x7F, 0xEF,
  0xEF, 0xE0, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0x1F, 0xF1, 0xFF, 0xF7, 0xFF, 0xBC, 0x02, 0xE0, 0x03, 0x80,
  0x0F, 0x00, 0x3E, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00,
  0x7C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x80, 0x3F, 0xC1, 0xEF, 0xFF, 0x1F,
  0xF8, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x7F, 0xEF, 0xFE, 0xFF, 0xE3,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x1C, 0x01, 0xF1, 0x0F, 0xF0,
  0x7F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xBE, 0x3D, 0xCF, 0xFE, 0xE3, 0xFC, 0x70, 0xF0, 0x01, 0xFE, 0x00,
  0x39, 0xC0, 0x0F, 0x3C, 0x01, 0xE3, 0x80, 0x38, 0x70, 0x0F, 0x0F, 0x01,
  0xC0, 0xE0, 0x38, 0x1C, 0x0F, 0x01, 0xC1, 0xC0, 0x38, 0x38, 0x07, 0x8F,
  0x00, 0x71, 0xC0, 0x0E, 0x38, 0x01, 0xEE, 0x00, 0x1D, 0xC0, 0x03, 0xB8,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0xF0, 0x07, 0x00, 0x7B,
  0x80, 0x7C, 0x03, 0x9C, 0x03, 0xE0, 0x1C, 0xF0, 0x1F, 0x01, 0xE3, 0x81,
  0xDC, 0x0E, 0x1C, 0x0E, 0xE0, 0x70, 0xE0, 0x77, 0x03, 0x87, 0x87, 0x9C,
  0x3C, 0x1C, 0x38, 0xE1, 0xC0, 0xE1, 0xC7, 0x0E, 0x07, 0x0E, 0x3C, 0x70,
  0x1C, 0xE0, 0xE7, 0x80, 0xE7, 0x07, 0x38, 0x07, 0x38, 0x39, 0xC0, 0x3B,
  0x80, 0xEE, 0x00, 0xFC, 0x07, 0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x3E, 0x00,
  0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xDE,
  0x01, 0xE3, 0x80, 0xF0, 0xF0, 0x38, 0x1E, 0x1C, 0x03, 0x8F, 0x00, 0xF3,
  0x80, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0xC0,
  0x07, 0xF8, 0x03, 0xCE, 0x00, 0xE3, 0xC0, 0x70, 0x78, 0x3C, 0x0E, 0x1E,
  0x03, 0xC7, 0x00, 0x7B, 0xC0, 0x0F, 0xF0, 0x01, 0xEE, 0x00, 0x39, 0xC0,
  0x07, 0x3C, 0x01, 0xE3, 0x80, 0x38, 0x78, 0x0F, 0x07, 0x01, 0xC0, 0xE0,
  0x38, 0x1E, 0x0F, 0x01, 0xC1, 0xC0, 0x38, 0x38, 0x03, 0x8F, 0x00, 0x71,
  0xC0, 0x0F, 0x38, 0x00, 0xEE, 0x00, 0x1D, 0xC0, 0x01, 0xB8, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x00,
  0x0F, 0xC0, 0x00, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xF8, 0x00, 0xE0, 0x03,
  0x80, 0x0F, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x07, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF0, 0x3F, 0x07, 0xE0, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x0F,
  0x01, 0xE0, 0xFC, 0x0F, 0x00, 0xFC, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x80, 0x3F, 0x01, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF8, 0x0F, 0xC0, 0x3E, 0x00,
  0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0x78, 0x03, 0xF0, 0x0F, 0x03, 0xF0, 0x78, 0x07, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xE0, 0x1E, 0x0F, 0xC0, 0xF8, 0x0E, 0x00, 0x7F, 0x80, 0xFF, 0xF1, 0xF8,
  0xFF, 0xF0, 0x0F, 0xE0,
};

const GFXglyph NotoSans_Regular37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 4, 27, 10, 3, -26 },
  { 15, 11, 9, 15, 2, -26 },
  { 28, 22, 26, 24, 1, -26 },
  { 100, 17, 30, 21, 2, -28 },
  { 164, 27, 27, 31, 2, -27 },
  { 256, 25, 27, 27, 2, -27 },
  { 341, 4, 9, 8, 2, -26 },
  { 346, 9, 32, 11, 1, -26 },
  { 382, 9, 32, 11, 1, -26 },
  { 418, 17, 17, 20, 2, -28 },
  { 455, 17, 18, 21, 2, -22 },
  { 494, 5, 9, 10, 2, -4 },
  { 500, 9, 3, 12, 1, -11 },
  { 504, 4, 5, 10, 3, -4 },
  { 507, 13, 26, 14, 0, -26 },
  { 550, 17, 27, 21, 2, -27 },
  { 608, 10, 26, 21, 3, -26 },
  { 641, 17, 27, 21, 2, -27 },
  { 699, 17, 27, 21, 2, -27 },
  { 757, 19, 27, 21, 1, -27 },
  { 822, 17, 26, 21, 2, -26 },
  { 878, 17, 27, 21, 2, -27 },
  { 936, 17, 26, 21, 2, -26 },
  { 992, 17, 27, 21, 2, -27 },
  { 1050, 17, 27, 21, 2, -27 },
  { 1108, 4, 21, 10, 3, -20 },
  { 1119, 6, 25, 10, 1, -20 },
  { 1138, 17, 19, 21, 2, -23 },
  { 1179, 17, 10, 21, 2, -18 },
  { 1201, 17, 19, 21, 2, -23 },
  { 1242, 15, 28, 16, 0, -27 },
  { 1295, 29, 29, 33, 2, -26 },
  { 1401, 24, 27, 24, 0, -27 },
  { 1482, 18, 26, 24, 4, -26 },
  { 1541, 20, 27, 23, 2, -27 },
  { 1609, 21, 26, 27, 4, -26 },
  { 1678, 14, 26, 21, 4, -26 },
  { 1724, 14, 26, 19, 4, -26 },
  { 1770, 22, 27, 27, 2, -27 },
  { 1845, 20, 26, 27, 4, -26 },
  { 1910, 10, 26, 13, 1, -26 },
  { 1943, 10, 33, 10, -3, -26 },
  { 1985, 19, 26, 23, 4, -26 },
  { 2047, 14, 26, 19, 4, -26 },
  { 2093, 26, 26, 34, 4, -26 },
  { 2178, 21, 26, 28, 4, -26 },
  { 2247, 25, 27, 29, 2, -27 },
  { 2332, 17, 26, 22, 4, -26 },
  { 2388, 25, 33, 29, 2, -27 },
  { 2492, 18, 26, 23, 4, -26 },
  { 2551, 17, 27, 20, 2, -27 },
  { 2609, 20, 26, 21, 0, -26 },
  { 2674, 21, 26, 27, 3, -26 },
  { 2743, 22, 26, 22, 0, -26 },
  { 2815, 34, 26, 34, 0, -26 },
  { 2926, 22, 26, 22, 0, -26 },
  { 2998, 21, 26, 21, 0, -26 },
  { 3067, 19, 26, 21, 1, -26 },
  { 3129, 8, 32, 12, 3, -26 },
  { 3161, 13, 26, 14, 0, -26 },
  { 3204, 8, 32, 12, 1, -26 },
  { 3236, 19, 17, 21, 1, -27 },
  { 3277, 17, 3, 16, 0, 3 },
  { 3284, 8, 6, 10, 1, -28 },
  { 3290, 16, 20, 21, 2, -20 },
  { 3330, 18, 28, 23, 3, -28 },
  { 3393, 15, 20, 18, 2, -20 },
  { 3431, 18, 28, 23, 2, -28 },
  { 3494, 17, 20, 21, 2, -20 },
  { 3537, 13, 28, 13, 1, -28 },
  { 3583, 18, 29, 23, 2, -20 },
  { 3649, 17, 28, 23, 3, -28 },
  { 3709, 4, 27, 10, 3, -27 },
  { 3723, 9, 36, 10, -2, -27 },
  { 3764, 16, 28, 20, 3, -28 },
  { 3820, 3, 28, 10, 3, -28 },
  { 3831, 29, 20, 35, 3, -20 },
  { 3904, 17, 20, 23, 3, -20 },
  { 3947, 18, 20, 22, 2, -20 },
  { 3992, 18, 29, 23, 3, -20 },
  { 4058, 18, 29, 23, 2, -20 },
  { 4124, 12, 20, 15, 3, -20 },
  { 4154, 14, 20, 18, 2, -20 },
  { 4189, 12, 24, 13, 1, -24 },
  { 4225, 17, 20, 23, 3, -20 },
  { 4268, 19, 20, 19, 0, -20 },
  { 4316, 29, 20, 29, 0, -20 },
  { 4389, 18, 20, 20, 1, -20 },
  { 4434, 19, 29, 19, 0, -20 },
  { 4503, 15, 20, 17, 1, -20 },
  { 4541, 12, 32, 14, 1, -26 },
  { 4589, 3, 37, 20, 9, -28 },
  { 4603, 12, 32, 14, 1, -26 },
  { 4651, 17, 4, 21, 2, -15 },
};

const GFXfont NotoSans_Regular37pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Regular37pt7bBitmaps,
  (GFXglyph *)NotoSans_Regular37pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _NOTOSANS_REGULAR37PT7B_H_
