#ifndef _NOTOSANS_REGULAR24PT7B_H_
#define _NOTOSANS_REGULAR24PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Regular.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Regular24pt7bBitmaps[] PROGMEM = {
  0x00, 0xFB, 0x6D, 0xB6, 0xDB, 0x20, 0x37, 0xE0, 0xCF, 0x3C, 0xF3, 0xCE,
  0x30, 0x06, 0x30, 0x10, 0x80, 0xC2, 0x03, 0x18, 0x0C, 0x63, 0xFF, 0xFF,
  0xFF, 0xC6, 0x10, 0x18, 0xC0, 0x63, 0x0F, 0xFF, 0xBF, 0xFE, 0x10, 0x80,
  0xC6, 0x03, 0x18, 0x0C, 0x60, 0x31, 0x80, 0x06, 0x00, 0xC0, 0x7F, 0x3F,
  0xF6, 0x63, 0xCC, 0x19, 0x83, 0xB0, 0x3E, 0x03, 0xF0, 0x1F, 0x83, 0x30,
  0x66, 0x0C, 0xF1, 0xBF, 0xFE, 0x3F, 0x00, 0xC0, 0x18, 0x00, 0x7C, 0x0E,
  0x19, 0x83, 0x0C, 0x61, 0x83, 0x18, 0x60, 0xC2, 0x30, 0x31, 0x8C, 0x0C,
  0x66, 0x23, 0x19, 0x3E, 0x66, 0xD9, 0x9F, 0x66, 0x30, 0x19, 0x0C, 0x0C,
  0x43, 0x03, 0x10, 0xC1, 0x86, 0x30, 0x61, 0x88, 0x30, 0x66, 0x18, 0x0F,
  0x00, 0x1F, 0x80, 0x1C, 0xE0, 0x0C, 0x30, 0x06, 0x18, 0x03, 0x0C, 0x01,
  0xCE, 0x00, 0x7E, 0x00, 0x1E, 0x00, 0x3F, 0x06, 0x39, 0xC3, 0x18, 0x71,
  0x9C, 0x1D, 0x8C, 0x07, 0xC7, 0x01, 0xC1, 0x81, 0xF0, 0xFF, 0xDC, 0x3F,
  0x87, 0x80, 0xFF, 0xE0, 0x19, 0x8C, 0xC6, 0x33, 0x98, 0xC6, 0x31, 0x8C,
  0x63, 0x8C, 0x63, 0x8C, 0x71, 0x80, 0xC3, 0x18, 0x63, 0x1C, 0x63, 0x18,
  0xC6, 0x31, 0x8C, 0x67, 0x31, 0x98, 0xCC, 0x00, 0x0E, 0x00, 0xC0, 0x10,
  0x62, 0x3F, 0xFE, 0x3F, 0x02, 0x80, 0xD8, 0x39, 0x86, 0x38, 0x44, 0x00,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x61, 0xFF, 0xC1, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x00, 0x76, 0x66, 0xCC, 0xFF, 0xF0, 0xDF, 0x80, 0x03,
  0x81, 0x80, 0xC0, 0xC0, 0x60, 0x30, 0x30, 0x18, 0x18, 0x0C, 0x06, 0x06,
  0x03, 0x01, 0x81, 0x80, 0xC0, 0xE0, 0x00, 0x1F, 0x83, 0xBC, 0x70, 0xC6,
  0x06, 0x60, 0x6C, 0x06, 0xC0, 0x6C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x6C,
  0x06, 0x60, 0x66, 0x06, 0x70, 0xC3, 0xFC, 0x1F, 0x80, 0x0E, 0x3D, 0xDF,
  0x74, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E,
  0x3F, 0x9F, 0x79, 0x03, 0x00, 0x30, 0x06, 0x01, 0xC0, 0x30, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x07, 0xFF, 0xFF, 0xE0,
  0x3F, 0x9F, 0x79, 0x03, 0x80, 0x30, 0x06, 0x01, 0xC0, 0x70, 0xFC, 0x1F,
  0x80, 0x38, 0x01, 0x80, 0x30, 0x06, 0x00, 0xE0, 0x3F, 0xFE, 0xFF, 0x80,
  0x00, 0xE0, 0x0F, 0x00, 0x78, 0x06, 0xC0, 0x66, 0x03, 0x30, 0x31, 0x83,
  0x0C, 0x30, 0x61, 0x83, 0x18, 0x19, 0xFF, 0xFF, 0xFF, 0x80, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0xFF, 0xBF, 0xEC, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x83, 0xFC, 0x43, 0x80, 0x70, 0x0C, 0x03, 0x00, 0xC0, 0x38, 0x1F, 0xFE,
  0xFE, 0x00, 0x0F, 0xC1, 0xE4, 0x38, 0x07, 0x00, 0x60, 0x06, 0x00, 0x67,
  0x0D, 0xFC, 0xF0, 0xEE, 0x06, 0xE0, 0x7C, 0x07, 0x60, 0x76, 0x06, 0x70,
  0x63, 0xFC, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x0E, 0x00, 0xC0,
  0x0C, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x07, 0x00, 0x60, 0x0E, 0x00,
  0xC0, 0x1C, 0x01, 0x80, 0x38, 0x00, 0x3F, 0x87, 0x9C, 0x60, 0x66, 0x06,
  0x60, 0x66, 0x0E, 0x39, 0xC1, 0xF0, 0x1F, 0x83, 0x1C, 0x60, 0xEC, 0x06,
  0xC0, 0x7C, 0x06, 0xE0, 0x67, 0xBC, 0x3F, 0x80, 0x3F, 0x8F, 0x79, 0x83,
  0x70, 0x3C, 0x07, 0x80, 0xF0, 0x1F, 0x03, 0x71, 0xE7, 0xEC, 0x31, 0x80,
  0x30, 0x06, 0x01, 0x80, 0x73, 0x7C, 0x7E, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0x7E, 0x67, 0x60, 0x00, 0x00, 0x00, 0x66, 0x6C, 0xCC, 0x00, 0x10, 0x07,
  0x01, 0xE0, 0x78, 0x1E, 0x07, 0x80, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x7C,
  0x00, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xF8, 0x80, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x0C, 0x00, 0xFF, 0x1F, 0xE0, 0x1C, 0x03,
  0x00, 0xC0, 0x70, 0x38, 0x1C, 0x0E, 0x03, 0x01, 0x80, 0x60, 0x00, 0x00,
  0x01, 0x80, 0x70, 0x1C, 0x00, 0x01, 0xFC, 0x00, 0xFB, 0xE0, 0x70, 0x06,
  0x0C, 0x00, 0x63, 0x00, 0x0C, 0xC3, 0xF8, 0xD8, 0xE3, 0x1A, 0x18, 0x63,
  0xC6, 0x0C, 0x78, 0xC1, 0x8F, 0x18, 0x31, 0xE3, 0x0E, 0x34, 0x31, 0x4C,
  0xC7, 0xCF, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x01, 0xF7, 0xC0,
  0x1F, 0xF0, 0x00, 0x03, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x36, 0x00, 0x6C,
  0x01, 0xCC, 0x03, 0x18, 0x06, 0x18, 0x18, 0x30, 0x30, 0x60, 0x7F, 0xE1,
  0xFF, 0xC3, 0x01, 0xCE, 0x01, 0x98, 0x03, 0x30, 0x03, 0xC0, 0x06, 0xFF,
  0x8F, 0xFE, 0xC0, 0x6C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x6F, 0xFC, 0xFF,
  0xCC, 0x06, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7F, 0xFE, 0xFF,
  0x80, 0x07, 0xF8, 0xFF, 0xCE, 0x00, 0x60, 0x07, 0x00, 0x30, 0x01, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00,
  0xE0, 0x03, 0xFF, 0x07, 0xF8, 0xFF, 0x83, 0xFF, 0x8C, 0x07, 0x30, 0x0E,
  0xC0, 0x1B, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x07, 0xC0, 0x1B, 0x00, 0xEC, 0x0F, 0x3F, 0xF8, 0xFF, 0x80, 0xFF,
  0xFF, 0xFC, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0xFE, 0xFF, 0xB0, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xFF, 0xBF, 0xEC, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x00, 0x07, 0xFC, 0x3F, 0xF8, 0xF0,
  0x11, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x7F,
  0xC0, 0xFD, 0x80, 0x1B, 0x00, 0x37, 0x00, 0x66, 0x00, 0xCE, 0x01, 0x8F,
  0xFF, 0x07, 0xFC, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x18, 0xFC, 0xE3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x1E, 0xFC, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xE7, 0xF9,
  0x00, 0xC0, 0x7E, 0x03, 0x30, 0x31, 0x83, 0x0C, 0x30, 0x63, 0x03, 0x38,
  0x1B, 0x80, 0xFE, 0x07, 0x30, 0x31, 0xC1, 0x87, 0x0C, 0x1C, 0x60, 0x63,
  0x03, 0x98, 0x0E, 0xC0, 0x38, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0xFF, 0xFF, 0xC0, 0xF0, 0x03, 0xF8, 0x01, 0xFE, 0x01, 0xFB, 0x00, 0xFD,
  0x80, 0xDE, 0x60, 0x6F, 0x30, 0x37, 0x98, 0x33, 0xC6, 0x19, 0xE3, 0x0C,
  0xF1, 0xCC, 0x78, 0x66, 0x3C, 0x36, 0x1E, 0x0F, 0x0F, 0x07, 0x87, 0x83,
  0x83, 0xC0, 0xC1, 0x80, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0xF6, 0x03, 0xDC,
  0x0F, 0x30, 0x3C, 0x60, 0xF1, 0xC3, 0xC3, 0x0F, 0x06, 0x3C, 0x1C, 0xF0,
  0x33, 0xC0, 0xEF, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x1C, 0x0F, 0xF0,
  0x1F, 0xFC, 0x38, 0x0E, 0x70, 0x06, 0x60, 0x07, 0x60, 0x03, 0x60, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0x60, 0x03, 0x60, 0x03, 0x60, 0x07,
  0x30, 0x06, 0x38, 0x0E, 0x1F, 0xFC, 0x07, 0xF0, 0xFF, 0x9F, 0xFB, 0x03,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0xFF, 0xDF, 0xF3, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x00, 0x0F, 0xF0, 0x1F, 0xFC,
  0x38, 0x0E, 0x70, 0x06, 0x60, 0x07, 0x60, 0x03, 0x60, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0x60, 0x03, 0x60, 0x03, 0x60, 0x07, 0x30, 0x06,
  0x38, 0x0E, 0x1F, 0xFC, 0x07, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0xFF, 0x87, 0xFE, 0x30, 0x39, 0x80, 0xCC, 0x06, 0x60, 0x33,
  0x01, 0x98, 0x18, 0xFF, 0x87, 0xF8, 0x30, 0xE1, 0x83, 0x0C, 0x1C, 0x60,
  0x63, 0x01, 0x98, 0x0E, 0xC0, 0x38, 0x3F, 0xEF, 0xF9, 0x80, 0x70, 0x0E,
  0x00, 0xC0, 0x1C, 0x01, 0xE0, 0x0F, 0x80, 0x78, 0x03, 0x80, 0x30, 0x06,
  0x00, 0xE0, 0x3F, 0xFE, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xB0, 0x0D, 0xC0, 0xC7, 0xFE,
  0x1F, 0xC0, 0xC0, 0x0D, 0x80, 0x36, 0x01, 0x9C, 0x06, 0x30, 0x38, 0xC0,
  0xC3, 0x83, 0x06, 0x1C, 0x18, 0x60, 0x71, 0x80, 0xCE, 0x03, 0x30, 0x06,
  0xC0, 0x1F, 0x00, 0x78, 0x00, 0xE0, 0x03, 0x00, 0xE0, 0x30, 0x0D, 0x81,
  0xE0, 0x76, 0x07, 0x81, 0x98, 0x1E, 0x06, 0x30, 0x6C, 0x18, 0xC3, 0x30,
  0xE3, 0x0C, 0xC3, 0x0C, 0x33, 0x0C, 0x19, 0x86, 0x30, 0x66, 0x19, 0x81,
  0x98, 0x66, 0x06, 0x60, 0xD8, 0x0F, 0x03, 0x60, 0x3C, 0x0F, 0x00, 0xF0,
  0x1C, 0x03, 0x80, 0x70, 0x06, 0x01, 0xC0, 0xE0, 0x1C, 0xC0, 0xE3, 0x83,
  0x06, 0x18, 0x1C, 0xE0, 0x33, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0xCC, 0x03, 0x30, 0x18, 0x60, 0xE1, 0xC3, 0x03, 0x18, 0x06, 0xE0,
  0x1C, 0xE0, 0x1D, 0x80, 0xE7, 0x03, 0x0C, 0x1C, 0x38, 0x60, 0x63, 0x80,
  0xCC, 0x03, 0x60, 0x07, 0x80, 0x1C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xE0,
  0x0C, 0x01, 0xC0, 0x38, 0x03, 0x00, 0x70, 0x0E, 0x00, 0xC0, 0x1C, 0x03,
  0x80, 0x30, 0x07, 0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xF1, 0x8C,
  0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0xFF, 0x80, 0xE0,
  0x30, 0x18, 0x06, 0x03, 0x01, 0x80, 0x60, 0x30, 0x1C, 0x06, 0x03, 0x00,
  0xC0, 0x60, 0x30, 0x0C, 0x06, 0x03, 0x80, 0xFF, 0xC6, 0x31, 0x8C, 0x63,
  0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC7, 0xFF, 0x80, 0x06, 0x00, 0xE0,
  0x0B, 0x01, 0xB0, 0x19, 0x83, 0x18, 0x30, 0xC6, 0x0C, 0x60, 0x6C, 0x06,
  0xC0, 0x30, 0xFF, 0xFF, 0xFC, 0xE3, 0x8E, 0x1F, 0x87, 0xF8, 0x83, 0x00,
  0x60, 0x0E, 0x0F, 0xCF, 0xFB, 0x07, 0xC0, 0xF8, 0x1F, 0x87, 0xBB, 0xB7,
  0xE6, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x9F, 0x3F, 0xF7, 0x07,
  0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF8, 0x1F, 0x07, 0xFF,
  0xDB, 0xF0, 0x1F, 0xCF, 0xE7, 0x01, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x18, 0x07, 0x00, 0xFF, 0x1F, 0xC0, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x31, 0xF3, 0x3F, 0xB7, 0x0F, 0x60, 0x7E, 0x07, 0xE0, 0x3E,
  0x03, 0xE0, 0x3E, 0x07, 0x60, 0x77, 0x07, 0x3F, 0xB1, 0xF3, 0x1F, 0x87,
  0xF9, 0xC3, 0xB0, 0x36, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xE0, 0x0C, 0x01,
  0xC0, 0x1F, 0xF1, 0xFE, 0x0F, 0x8E, 0x46, 0x03, 0x01, 0x83, 0xFB, 0xFC,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x00, 0x1F, 0x33, 0xFB, 0x70, 0xF6, 0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x36, 0x07, 0x70, 0x73, 0xFB, 0x1F, 0x30, 0x03, 0x00, 0x70,
  0x06, 0x60, 0xE7, 0xFC, 0x1F, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x9F, 0x3F, 0xF7, 0x07, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0C, 0x7C, 0x3F, 0xFF, 0xFF, 0xF0,
  0x08, 0xC6, 0x00, 0x0C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6,
  0x31, 0x8F, 0xDC, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x83, 0xB0,
  0xE6, 0x18, 0xC6, 0x19, 0x83, 0x60, 0x7E, 0x0E, 0xC1, 0x8C, 0x31, 0xC6,
  0x1C, 0xC1, 0x98, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xCF, 0x8F, 0x9F,
  0xFF, 0xFB, 0x83, 0x83, 0x70, 0x70, 0x6C, 0x0C, 0x0D, 0x81, 0x81, 0xF0,
  0x30, 0x3E, 0x06, 0x07, 0xC0, 0xC0, 0xF8, 0x18, 0x1F, 0x03, 0x03, 0xE0,
  0x60, 0x7C, 0x0C, 0x0E, 0xCF, 0x9F, 0xFB, 0x83, 0xF0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x06, 0x1F, 0x83,
  0xFC, 0x70, 0x66, 0x07, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x36,
  0x07, 0x70, 0x63, 0xFE, 0x1F, 0x80, 0xCF, 0x9F, 0xFB, 0x83, 0xF0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x7C, 0x0F, 0x83, 0xFF, 0xED, 0xF9,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x00, 0x1F, 0x33, 0xFB,
  0x70, 0xF6, 0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x76, 0x07,
  0x70, 0x73, 0xFB, 0x1F, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0xCF, 0xDE, 0xF0, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0x3F, 0xBF, 0xF0, 0x18, 0x0E, 0x03, 0xC0, 0x7C, 0x0F,
  0x01, 0x80, 0xE0, 0x7E, 0xFF, 0xF0, 0x10, 0x10, 0x30, 0x7F, 0xFF, 0x30,
  0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x38, 0x1D, 0x1F, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x1F,
  0x83, 0xBF, 0xF3, 0xE6, 0xC0, 0x36, 0x07, 0x60, 0x66, 0x06, 0x30, 0xE3,
  0x0C, 0x38, 0xC1, 0x98, 0x19, 0x80, 0xD8, 0x0F, 0x00, 0xF0, 0x06, 0x00,
  0xE0, 0xE0, 0xEC, 0x1C, 0x19, 0x83, 0x83, 0x30, 0xD8, 0x67, 0x1B, 0x18,
  0x63, 0x63, 0x0C, 0xC6, 0x61, 0x98, 0xDC, 0x1B, 0x1B, 0x03, 0xC3, 0x60,
  0x78, 0x3C, 0x0F, 0x07, 0x00, 0xC0, 0xE0, 0x60, 0x73, 0x06, 0x38, 0xC1,
  0x9C, 0x0D, 0x80, 0xF0, 0x07, 0x00, 0xF0, 0x0D, 0x81, 0x9C, 0x38, 0xC7,
  0x06, 0xE0, 0x30, 0xC0, 0x36, 0x07, 0x60, 0x67, 0x06, 0x30, 0xE3, 0x0C,
  0x18, 0xC1, 0x98, 0x19, 0x80, 0xD8, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x60,
  0x06, 0x00, 0xC0, 0x1C, 0x0F, 0x80, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0xE0,
  0x60, 0x60, 0x70, 0x30, 0x30, 0x30, 0x38, 0x18, 0x1F, 0xFF, 0xF8, 0x0E,
  0x3C, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x31, 0xE3, 0x03, 0x83, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xF0, 0x20, 0xFF, 0xFF, 0xFF, 0xE1, 0xE0, 0xC1,
  0xC3, 0x87, 0x0E, 0x1C, 0x18, 0x3C, 0x18, 0xE1, 0x87, 0x0E, 0x1C, 0x38,
  0x60, 0xC7, 0x8C, 0x00, 0x7C, 0x1F, 0xFF, 0x83, 0xE0,
};

const GFXglyph NotoSans_Regular24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 3, 17, 6, 2, -17 },
  { 8, 6, 6, 10, 2, -17 },
  { 13, 14, 17, 16, 1, -17 },
  { 43, 11, 19, 14, 1, -18 },
  { 70, 18, 17, 20, 1, -17 },
  { 109, 17, 17, 18, 1, -17 },
  { 146, 2, 6, 5, 2, -17 },
  { 148, 5, 21, 7, 1, -17 },
  { 162, 5, 21, 7, 1, -17 },
  { 176, 11, 11, 13, 1, -18 },
  { 192, 11, 11, 14, 1, -14 },
  { 208, 4, 6, 6, 1, -3 },
  { 211, 6, 2, 8, 1, -7 },
  { 213, 3, 3, 6, 2, -3 },
  { 215, 9, 17, 9, 0, -17 },
  { 235, 12, 17, 14, 1, -17 },
  { 261, 7, 17, 14, 2, -17 },
  { 276, 11, 17, 14, 1, -17 },
  { 300, 11, 17, 14, 1, -17 },
  { 324, 13, 17, 14, 0, -17 },
  { 352, 10, 17, 14, 2, -17 },
  { 374, 12, 17, 14, 1, -17 },
  { 400, 12, 17, 14, 1, -17 },
  { 426, 12, 17, 14, 1, -17 },
  { 452, 11, 17, 14, 1, -17 },
  { 476, 3, 13, 6, 2, -13 },
  { 481, 4, 16, 6, 1, -13 },
  { 489, 12, 12, 14, 1, -15 },
  { 507, 11, 7, 14, 1, -12 },
  { 517, 12, 12, 14, 1, -15 },
  { 535, 10, 17, 10, 0, -17 },
  { 557, 19, 19, 22, 1, -17 },
  { 603, 15, 17, 15, 0, -17 },
  { 635, 12, 17, 16, 2, -17 },
  { 661, 13, 17, 15, 1, -17 },
  { 689, 14, 17, 18, 2, -17 },
  { 719, 10, 17, 13, 2, -17 },
  { 741, 10, 17, 12, 2, -17 },
  { 763, 15, 17, 17, 1, -17 },
  { 795, 13, 17, 18, 2, -17 },
  { 823, 6, 17, 8, 1, -17 },
  { 836, 6, 22, 7, -2, -17 },
  { 853, 13, 17, 15, 2, -17 },
  { 881, 10, 17, 13, 2, -17 },
  { 903, 17, 17, 22, 2, -17 },
  { 940, 14, 17, 18, 2, -17 },
  { 970, 16, 17, 19, 1, -17 },
  { 1004, 11, 17, 15, 2, -17 },
  { 1028, 16, 21, 19, 1, -17 },
  { 1070, 13, 17, 15, 2, -17 },
  { 1098, 11, 17, 13, 1, -17 },
  { 1122, 13, 17, 13, 0, -17 },
  { 1150, 13, 17, 18, 2, -17 },
  { 1178, 14, 17, 14, 0, -17 },
  { 1208, 22, 17, 22, 0, -17 },
  { 1255, 14, 17, 14, 0, -17 },
  { 1285, 14, 17, 14, 0, -17 },
  { 1315, 12, 17, 14, 1, -17 },
  { 1341, 5, 21, 8, 2, -17 },
  { 1355, 9, 17, 9, 0, -17 },
  { 1375, 5, 21, 8, 1, -17 },
  { 1389, 12, 11, 14, 1, -17 },
  { 1406, 11, 2, 11, 0, 2 },
  { 1409, 5, 3, 7, 1, -18 },
  { 1411, 11, 13, 13, 1, -13 },
  { 1429, 11, 18, 15, 2, -18 },
  { 1454, 10, 13, 12, 1, -13 },
  { 1471, 12, 18, 15, 1, -18 },
  { 1498, 11, 13, 14, 1, -13 },
  { 1516, 9, 18, 8, 0, -18 },
  { 1537, 12, 19, 15, 1, -13 },
  { 1566, 11, 18, 15, 2, -18 },
  { 1591, 2, 18, 6, 2, -18 },
  { 1596, 5, 24, 6, -1, -18 },
  { 1611, 11, 18, 13, 2, -18 },
  { 1636, 2, 18, 6, 2, -18 },
  { 1641, 19, 13, 22, 2, -13 },
  { 1672, 11, 13, 15, 2, -13 },
  { 1690, 12, 13, 15, 1, -13 },
  { 1710, 11, 19, 15, 2, -13 },
  { 1737, 12, 19, 15, 1, -13 },
  { 1766, 8, 13, 10, 2, -13 },
  { 1779, 9, 13, 12, 1, -13 },
  { 1794, 8, 16, 9, 0, -16 },
  { 1810, 11, 13, 15, 2, -13 },
  { 1828, 12, 13, 12, 0, -13 },
  { 1848, 19, 13, 19, 0, -13 },
  { 1879, 12, 13, 13, 0, -13 },
  { 1899, 12, 19, 12, 0, -13 },
  { 1928, 9, 13, 11, 1, -13 },
  { 1943, 7, 21, 9, 1, -17 },
  { 1962, 1, 24, 13, 6, -18 },
  { 1965, 7, 21, 9, 1, -17 },
  { 1984, 12, 3, 14, 1, -10 },
};

const GFXfont NotoSans_Regular24pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Regular24pt7bBitmaps,
  (GFXglyph *)NotoSans_Regular24pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _NOTOSANS_REGULAR24PT7B_H_
