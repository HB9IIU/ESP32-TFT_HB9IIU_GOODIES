#ifndef _NOTOSANS_REGULAR16PT7B_H_
#define _NOTOSANS_REGULAR16PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Regular.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Regular16pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x55, 0x3C, 0xD9, 0x99, 0x09, 0x82, 0x41, 0x91, 0xFF, 0x13,
  0x04, 0x81, 0x23, 0xFE, 0x22, 0x09, 0x82, 0x40, 0x10, 0x7B, 0xFC, 0x8D,
  0x0E, 0x0F, 0x0B, 0x13, 0x2F, 0xF0, 0x81, 0x00, 0x60, 0x0D, 0x08, 0x91,
  0x09, 0x90, 0x9A, 0x09, 0x6E, 0xD5, 0x22, 0xD2, 0x09, 0x31, 0x12, 0x11,
  0x22, 0x0E, 0x18, 0x0F, 0x81, 0x18, 0x23, 0x06, 0xC0, 0x70, 0x1E, 0x36,
  0x66, 0x86, 0x90, 0x73, 0x1E, 0x3E, 0x70, 0xEA, 0x6B, 0x49, 0x24, 0x93,
  0x26, 0x40, 0xE2, 0x23, 0x11, 0x11, 0x13, 0x32, 0x6C, 0x10, 0x22, 0x5F,
  0xF3, 0x8D, 0x93, 0x00, 0x10, 0x20, 0x40, 0x8F, 0xE2, 0x04, 0x08, 0xFA,
  0xF0, 0xF0, 0x0C, 0x21, 0x84, 0x10, 0xC2, 0x18, 0x41, 0x0C, 0x00, 0x10,
  0xFB, 0x1C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x85, 0x1B, 0xE0, 0x3F, 0xD6,
  0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0xFA, 0x18, 0x30, 0x60, 0x83, 0x0C,
  0x30, 0xC3, 0x07, 0xF0, 0x31, 0xFA, 0x18, 0x30, 0x6F, 0x9F, 0x03, 0x02,
  0x06, 0x1F, 0xE0, 0x06, 0x07, 0x02, 0x82, 0x43, 0x21, 0x11, 0x09, 0xFF,
  0x02, 0x01, 0x00, 0x80, 0x7C, 0x83, 0x06, 0x0F, 0xC0, 0xC0, 0x81, 0x03,
  0x0F, 0xF0, 0x0C, 0x7D, 0x06, 0x0C, 0x17, 0xB1, 0xC1, 0x83, 0x85, 0x19,
  0xE0, 0xFE, 0x04, 0x18, 0x20, 0xC1, 0x06, 0x08, 0x30, 0x41, 0x80, 0x18,
  0xFB, 0x1E, 0x1C, 0x6F, 0x9F, 0x63, 0x83, 0x07, 0x1B, 0xE0, 0x10, 0xFB,
  0x1C, 0x18, 0x30, 0x7B, 0x99, 0x02, 0x0C, 0x33, 0xC0, 0xF0, 0x03, 0xC0,
  0x6C, 0x00, 0x03, 0x6B, 0x00, 0x02, 0x0C, 0x63, 0x0C, 0x0E, 0x03, 0x01,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x81, 0x80, 0xC0, 0x60, 0x23, 0x9C, 0x40,
  0x31, 0xF8, 0x10, 0x30, 0x41, 0x84, 0x18, 0x20, 0x00, 0xC1, 0x80, 0x1F,
  0xC2, 0x02, 0x40, 0x1C, 0xF9, 0x98, 0x99, 0x09, 0x90, 0x99, 0x99, 0x8E,
  0xE4, 0x00, 0x60, 0x03, 0xF8, 0x0C, 0x03, 0x81, 0xA0, 0x48, 0x13, 0x0C,
  0x43, 0xF1, 0x86, 0x40, 0x90, 0x3C, 0x04, 0xFC, 0x86, 0x82, 0x86, 0xFC,
  0xFC, 0x82, 0x83, 0x82, 0x86, 0xFC, 0x0E, 0x1F, 0xD8, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x20, 0x1C, 0x27, 0xE0, 0xFE, 0x41, 0xA0, 0x50,
  0x38, 0x1C, 0x0E, 0x07, 0x02, 0x83, 0x43, 0x3F, 0x00, 0xFE, 0x08, 0x20,
  0xFF, 0xF8, 0x20, 0x82, 0x0F, 0xC0, 0xFE, 0x08, 0x20, 0x83, 0xF8, 0x20,
  0x82, 0x08, 0x00, 0x06, 0x1F, 0xD8, 0x08, 0x0C, 0x06, 0x02, 0x0F, 0x81,
  0xC0, 0xA0, 0x5C, 0x23, 0xF0, 0x81, 0x81, 0x81, 0x81, 0xFF, 0xFF, 0x81,
  0x81, 0x81, 0x81, 0x81, 0xF4, 0x44, 0x44, 0x44, 0x44, 0xF0, 0x33, 0x33,
  0x33, 0x33, 0x33, 0x33, 0x3E, 0x87, 0x8C, 0x98, 0x90, 0xA0, 0xF0, 0x98,
  0x88, 0x8C, 0x86, 0x83, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x0F,
  0xC0, 0xC0, 0xF8, 0x17, 0x82, 0xD0, 0xDB, 0x13, 0x22, 0x64, 0x8C, 0xD1,
  0x8E, 0x31, 0x86, 0x30, 0x80, 0xC1, 0xE0, 0xF8, 0x76, 0x39, 0x1C, 0xCE,
  0x37, 0x0B, 0x87, 0xC1, 0xE0, 0x60, 0x0C, 0x07, 0xF1, 0x83, 0x60, 0x6C,
  0x05, 0x80, 0xB0, 0x1E, 0x02, 0xC0, 0x48, 0x19, 0x86, 0x1F, 0x80, 0xFD,
  0x0E, 0x1C, 0x38, 0x7F, 0xB8, 0x40, 0x81, 0x02, 0x00, 0x0C, 0x07, 0xF1,
  0x83, 0x60, 0x6C, 0x05, 0x80, 0xB0, 0x1E, 0x02, 0xC0, 0x48, 0x19, 0x86,
  0x1F, 0x80, 0x30, 0x03, 0x00, 0x30, 0xFC, 0x86, 0x86, 0x86, 0x84, 0xF8,
  0x98, 0x8C, 0x84, 0x86, 0x83, 0x18, 0xFF, 0x04, 0x0C, 0x0E, 0x0F, 0x03,
  0x02, 0x06, 0x1F, 0xE0, 0xFF, 0x84, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x00, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0x40, 0xB0, 0xCF, 0x80, 0xC0, 0xD0, 0x66, 0x19, 0x84, 0x23,
  0x0C, 0x83, 0x20, 0x58, 0x1C, 0x03, 0x00, 0xC0, 0xC3, 0x06, 0x87, 0x09,
  0x0A, 0x33, 0x34, 0x66, 0x6C, 0x84, 0x89, 0x09, 0x16, 0x1E, 0x2C, 0x18,
  0x70, 0x30, 0x60, 0x60, 0xC0, 0xC1, 0x91, 0x8C, 0x82, 0x80, 0xC0, 0x60,
  0x50, 0x64, 0x23, 0x30, 0xB0, 0x60, 0xC1, 0xB1, 0x88, 0x86, 0xC1, 0x40,
  0xE0, 0x20, 0x10, 0x08, 0x04, 0x02, 0x00, 0xFE, 0x06, 0x04, 0x08, 0x18,
  0x10, 0x20, 0x60, 0x40, 0xC0, 0xFF, 0xFC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC,
  0xFF, 0xC1, 0x06, 0x08, 0x20, 0xC1, 0x06, 0x18, 0x20, 0xC0, 0xF1, 0x11,
  0x11, 0x11, 0x11, 0x11, 0xFF, 0x10, 0x10, 0x28, 0x28, 0x44, 0x44, 0x82,
  0x83, 0xFE, 0xCC, 0x38, 0xD8, 0x18, 0x37, 0xF8, 0xE1, 0xC7, 0xFA, 0xC0,
  0xC0, 0xC0, 0xDC, 0xF6, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xE2, 0xFE, 0x3D,
  0xFC, 0x20, 0x82, 0x0C, 0x11, 0x7C, 0x02, 0x04, 0x09, 0xD6, 0xF8, 0x60,
  0xC1, 0x83, 0x87, 0x1B, 0xD0, 0x38, 0xDB, 0x1C, 0x1F, 0xF0, 0x30, 0x21,
  0x3E, 0x3C, 0x82, 0x1E, 0xF8, 0x82, 0x08, 0x20, 0x82, 0x08, 0x3A, 0xDF,
  0x0C, 0x18, 0x30, 0x70, 0xE3, 0x7A, 0x04, 0x0A, 0x37, 0xC0, 0xC0, 0xC0,
  0xC0, 0xDC, 0xF6, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xF3, 0xFF,
  0xFF, 0x33, 0x03, 0x33, 0x33, 0x33, 0x33, 0x33, 0x3E, 0xC1, 0x83, 0x06,
  0x3C, 0xD9, 0x34, 0x78, 0xD9, 0x9B, 0x16, 0x30, 0xFF, 0xFF, 0xFF, 0xDC,
  0xE7, 0x3D, 0xB0, 0xC7, 0x84, 0x3C, 0x21, 0xE1, 0x0F, 0x08, 0x78, 0x43,
  0xC2, 0x18, 0xDC, 0xF6, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x38,
  0x6E, 0xC2, 0x83, 0x83, 0x83, 0xC3, 0x46, 0x3C, 0xDC, 0xF6, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xE2, 0xFE, 0xC0, 0xC0, 0xC0, 0xC0, 0x3A, 0xDF, 0x0C,
  0x18, 0x30, 0x70, 0xE3, 0x7A, 0x04, 0x08, 0x10, 0x20, 0xDF, 0xF1, 0x8C,
  0x63, 0x18, 0xC0, 0x7B, 0x38, 0x30, 0x70, 0x70, 0x63, 0xF8, 0x21, 0x1F,
  0xF6, 0x31, 0x8C, 0x61, 0x0E, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC7, 0x7F, 0xC1, 0xC3, 0x42, 0x62, 0x26, 0x24, 0x3C, 0x18, 0x18, 0xC2,
  0x1C, 0x61, 0x47, 0x34, 0x53, 0x6D, 0x22, 0x9A, 0x28, 0xE3, 0x8C, 0x30,
  0xC0, 0xC3, 0x62, 0x26, 0x1C, 0x18, 0x1C, 0x34, 0x62, 0xC3, 0xC1, 0xC3,
  0x42, 0x62, 0x26, 0x24, 0x3C, 0x18, 0x18, 0x18, 0x10, 0x30, 0xE0, 0xFF,
  0xF0, 0x84, 0x31, 0x84, 0x30, 0xFC, 0x1C, 0xC3, 0x0C, 0x30, 0xCC, 0x0C,
  0x30, 0xC3, 0x0C, 0x1C, 0x10, 0xFF, 0xFF, 0xC3, 0x18, 0xC6, 0x30, 0x64,
  0x63, 0x18, 0xCC, 0x40, 0x63, 0x7C,
};

const GFXglyph NotoSans_Regular16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 2, 11, 4, 1, -11 },
  { 4, 4, 4, 7, 1, -11 },
  { 6, 10, 11, 10, 0, -11 },
  { 20, 7, 13, 9, 1, -12 },
  { 32, 12, 12, 13, 1, -12 },
  { 50, 11, 12, 12, 1, -12 },
  { 67, 2, 4, 4, 1, -11 },
  { 68, 3, 14, 5, 1, -11 },
  { 74, 4, 14, 5, 0, -11 },
  { 81, 7, 7, 9, 1, -12 },
  { 88, 7, 8, 9, 1, -10 },
  { 95, 2, 4, 4, 1, -2 },
  { 96, 4, 1, 5, 1, -5 },
  { 97, 2, 2, 4, 1, -2 },
  { 98, 6, 11, 6, 0, -11 },
  { 107, 7, 12, 9, 1, -12 },
  { 118, 5, 11, 9, 1, -11 },
  { 125, 7, 12, 9, 1, -12 },
  { 136, 7, 12, 9, 1, -12 },
  { 147, 9, 11, 9, 0, -11 },
  { 160, 7, 11, 9, 1, -11 },
  { 170, 7, 12, 9, 1, -12 },
  { 181, 7, 11, 9, 1, -11 },
  { 191, 7, 12, 9, 1, -12 },
  { 202, 7, 12, 9, 1, -12 },
  { 213, 2, 9, 4, 1, -9 },
  { 216, 3, 11, 4, 0, -9 },
  { 221, 7, 8, 9, 1, -10 },
  { 228, 7, 5, 9, 1, -8 },
  { 233, 7, 8, 9, 1, -10 },
  { 240, 7, 12, 7, 0, -12 },
  { 251, 12, 12, 14, 1, -11 },
  { 269, 10, 11, 10, 0, -11 },
  { 283, 8, 11, 10, 2, -11 },
  { 294, 9, 12, 10, 1, -12 },
  { 308, 9, 11, 12, 2, -11 },
  { 321, 6, 11, 9, 2, -11 },
  { 330, 6, 11, 8, 2, -11 },
  { 339, 9, 12, 12, 1, -12 },
  { 353, 8, 11, 12, 2, -11 },
  { 364, 4, 11, 5, 1, -11 },
  { 370, 4, 14, 4, -1, -11 },
  { 377, 8, 11, 10, 2, -11 },
  { 388, 6, 11, 8, 2, -11 },
  { 397, 11, 11, 15, 2, -11 },
  { 413, 9, 11, 12, 2, -11 },
  { 426, 11, 12, 13, 1, -12 },
  { 443, 7, 11, 10, 2, -11 },
  { 453, 11, 15, 13, 1, -12 },
  { 474, 8, 11, 10, 2, -11 },
  { 485, 7, 12, 9, 1, -12 },
  { 496, 9, 11, 9, 0, -11 },
  { 509, 9, 11, 12, 1, -11 },
  { 522, 10, 11, 10, 0, -11 },
  { 536, 15, 11, 15, 0, -11 },
  { 557, 9, 11, 9, 0, -11 },
  { 570, 9, 11, 9, 0, -11 },
  { 583, 8, 11, 9, 1, -11 },
  { 594, 4, 14, 5, 1, -11 },
  { 601, 6, 11, 6, 0, -11 },
  { 610, 4, 14, 5, 0, -11 },
  { 617, 8, 8, 9, 1, -12 },
  { 625, 7, 1, 7, 0, 1 },
  { 626, 3, 2, 5, 1, -12 },
  { 627, 7, 9, 9, 1, -9 },
  { 635, 8, 12, 10, 1, -12 },
  { 647, 6, 9, 8, 1, -9 },
  { 654, 7, 12, 10, 1, -12 },
  { 665, 7, 9, 9, 1, -9 },
  { 673, 6, 12, 6, 0, -12 },
  { 682, 7, 13, 10, 1, -9 },
  { 694, 8, 12, 10, 1, -12 },
  { 706, 2, 12, 4, 1, -12 },
  { 709, 4, 16, 4, -1, -12 },
  { 717, 7, 12, 9, 1, -12 },
  { 728, 2, 12, 4, 1, -12 },
  { 731, 13, 9, 15, 1, -9 },
  { 746, 8, 9, 10, 1, -9 },
  { 755, 8, 9, 10, 1, -9 },
  { 764, 8, 13, 10, 1, -9 },
  { 777, 7, 13, 10, 1, -9 },
  { 789, 5, 9, 7, 1, -9 },
  { 795, 6, 9, 8, 1, -9 },
  { 802, 5, 11, 6, 0, -11 },
  { 809, 8, 9, 10, 1, -9 },
  { 818, 8, 9, 8, 0, -9 },
  { 827, 12, 9, 13, 0, -9 },
  { 841, 8, 9, 8, 0, -9 },
  { 850, 8, 13, 8, 0, -9 },
  { 863, 6, 9, 8, 1, -9 },
  { 870, 6, 14, 6, 0, -11 },
  { 881, 1, 16, 9, 4, -12 },
  { 883, 5, 14, 6, 1, -11 },
  { 892, 7, 2, 9, 1, -7 },
};

const GFXfont NotoSans_Regular16pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Regular16pt7bBitmaps,
  (GFXglyph *)NotoSans_Regular16pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _NOTOSANS_REGULAR16PT7B_H_
