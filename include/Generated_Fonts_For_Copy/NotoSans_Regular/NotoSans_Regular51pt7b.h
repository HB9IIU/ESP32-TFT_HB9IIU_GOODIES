#ifndef _NOTOSANS_REGULAR51PT7B_H_
#define _NOTOSANS_REGULAR51PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Regular.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Regular51pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xBE, 0xFB, 0xEF, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x1C, 0x71, 0xC0, 0x00, 0x00, 0x07,
  0xBF, 0xFF, 0xFF, 0xFE, 0x30, 0xF8, 0x3F, 0xF0, 0x79, 0xE0, 0xF3, 0xC1,
  0xE7, 0x83, 0xCF, 0x07, 0x9E, 0x0F, 0x3C, 0x1E, 0x70, 0x3C, 0xE0, 0x79,
  0xC0, 0xF3, 0x80, 0xE7, 0x01, 0x80, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x3C,
  0x07, 0x80, 0x00, 0x78, 0x0F, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x01, 0xC0,
  0x38, 0x00, 0x03, 0x80, 0x70, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x1E, 0x03,
  0xC0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x70, 0x0E, 0x00, 0xFF, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1C, 0x03, 0x80, 0x00, 0x38, 0x07, 0x00, 0x00, 0xF0, 0x1E, 0x00,
  0x01, 0xE0, 0x3C, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0x0E, 0x01, 0xC0, 0x00, 0x3C, 0x07, 0x80, 0x3F, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0x80, 0x70, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x78,
  0x0E, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x07, 0x80,
  0xF0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x38, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xF8, 0xFC, 0x70, 0x71, 0xE0, 0xE0, 0x07, 0xC1, 0xC0,
  0x0F, 0x83, 0x80, 0x1F, 0x07, 0x00, 0x3E, 0x0E, 0x00, 0x7C, 0x1C, 0x00,
  0x7E, 0x38, 0x00, 0xFF, 0x70, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00,
  0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x1D, 0xFE, 0x00,
  0x38, 0x7E, 0x00, 0x70, 0x7C, 0x00, 0xE0, 0x78, 0x01, 0xC0, 0xF0, 0x03,
  0x81, 0xE0, 0x07, 0x03, 0xE0, 0x0E, 0x0F, 0xF0, 0x1C, 0x3E, 0xFF, 0xBF,
  0xFD, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x81, 0xFF, 0xFC, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x78,
  0x01, 0xFF, 0x80, 0x03, 0xC0, 0x0F, 0x9F, 0x00, 0x0F, 0x00, 0x3C, 0x3C,
  0x00, 0x78, 0x01, 0xE0, 0x78, 0x01, 0xE0, 0x07, 0x81, 0xE0, 0x0F, 0x00,
  0x1C, 0x03, 0x80, 0x78, 0x00, 0x70, 0x0E, 0x01, 0xE0, 0x01, 0xC0, 0x3C,
  0x0F, 0x00, 0x0F, 0x00, 0xF0, 0x3C, 0x00, 0x3C, 0x03, 0xC1, 0xE0, 0x00,
  0x70, 0x0F, 0x07, 0x80, 0x01, 0xC0, 0x3C, 0x3C, 0x00, 0x07, 0x00, 0xE0,
  0xF0, 0x00, 0x1E, 0x03, 0x87, 0x87, 0xF0, 0x78, 0x1E, 0x3C, 0x7F, 0xE1,
  0xE0, 0x78, 0xF1, 0xFF, 0xC3, 0xC3, 0xC7, 0x8F, 0x0F, 0x0F, 0x9F, 0x1E,
  0x3C, 0x1E, 0x1F, 0xF8, 0xF1, 0xE0, 0x78, 0x3F, 0xC3, 0xC7, 0x80, 0xE0,
  0x7E, 0x1E, 0x1E, 0x03, 0xC0, 0x00, 0x78, 0x78, 0x0F, 0x00, 0x03, 0xC1,
  0xE0, 0x3C, 0x00, 0x1E, 0x07, 0x80, 0xF0, 0x00, 0x78, 0x1E, 0x03, 0xC0,
  0x03, 0xC0, 0x78, 0x0F, 0x00, 0x0F, 0x01, 0xE0, 0x3C, 0x00, 0x78, 0x07,
  0x80, 0xF0, 0x01, 0xE0, 0x1E, 0x03, 0x80, 0x0F, 0x00, 0x78, 0x1E, 0x00,
  0x3C, 0x00, 0xF0, 0x78, 0x01, 0xE0, 0x03, 0xC3, 0xE0, 0x07, 0x00, 0x07,
  0xFF, 0x00, 0x3C, 0x00, 0x1F, 0xF8, 0x01, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0x81, 0xF8,
  0x00, 0x07, 0xC0, 0x3E, 0x00, 0x01, 0xF0, 0x07, 0x80, 0x00, 0x7C, 0x01,
  0xE0, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x1E, 0x00, 0x01, 0xF0,
  0x0F, 0x80, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x01,
  0xF1, 0xF8, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x7C, 0x3F, 0x9F, 0x80, 0x1F, 0x0F, 0x83, 0xF0,
  0x07, 0x87, 0xC0, 0x7E, 0x03, 0xE3, 0xF0, 0x0F, 0xC0, 0xF8, 0xF8, 0x01,
  0xF8, 0x7C, 0x3E, 0x00, 0x3F, 0x1F, 0x0F, 0x00, 0x07, 0xEF, 0x83, 0xC0,
  0x00, 0xFF, 0xE0, 0xF0, 0x00, 0x1F, 0xF0, 0x3E, 0x00, 0x03, 0xF8, 0x0F,
  0x80, 0x00, 0xFF, 0x03, 0xF0, 0x00, 0x7F, 0xE0, 0x7E, 0x00, 0x7F, 0xFC,
  0x1F, 0xFB, 0xFF, 0x9F, 0x83, 0xFF, 0xFF, 0x83, 0xF0, 0x3F, 0xFF, 0xC0,
  0x7E, 0x07, 0xFF, 0xC0, 0x0F, 0xC0, 0x04, 0x00, 0x00, 0x00, 0xFF, 0xDE,
  0xF7, 0xBD, 0xEF, 0x73, 0x9C, 0xE7, 0x00, 0x01, 0xF0, 0x3C, 0x07, 0xC0,
  0x78, 0x0F, 0x80, 0xF0, 0x1F, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x07,
  0xC0, 0x7C, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0x78, 0x07, 0x80, 0x7C, 0x07, 0xC0, 0x7C, 0x03, 0xC0, 0x3E, 0x03,
  0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x03, 0xE0,
  0x1F, 0xF8, 0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x7C,
  0x0F, 0x80, 0xF0, 0x1F, 0x03, 0xE0, 0x3C, 0x07, 0x80, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1E, 0x07, 0xC0, 0xF0, 0x3E, 0x07, 0xC1, 0xF0, 0x3C, 0x0F, 0x81, 0xE0,
  0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x40,
  0x3C, 0x02, 0x78, 0x3C, 0x1E, 0xFF, 0xB9, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0x01,
  0xEF, 0x80, 0x01, 0xE7, 0x80, 0x03, 0xC7, 0xC0, 0x07, 0xC3, 0xE0, 0x0F,
  0xC3, 0xF0, 0x1F, 0x81, 0xF8, 0x07, 0x81, 0xE0, 0x01, 0x00, 0x80, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x1F,
  0x3F, 0x3E, 0x3E, 0x3E, 0x3C, 0x7C, 0x7C, 0x78, 0x78, 0x70, 0xF0, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7B, 0xFF, 0xFF, 0xFF, 0xE3, 0x00,
  0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0,
  0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03,
  0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xE0, 0x01,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xF8, 0x1F, 0x80, 0xF8, 0x03, 0xE0,
  0xF8, 0x00, 0xF0, 0x7C, 0x00, 0x7C, 0x3C, 0x00, 0x1E, 0x3E, 0x00, 0x0F,
  0x9F, 0x00, 0x07, 0xCF, 0x80, 0x01, 0xE7, 0x80, 0x00, 0xF3, 0xC0, 0x00,
  0x79, 0xE0, 0x00, 0x3C, 0xF0, 0x00, 0x1F, 0x78, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xF7, 0x80, 0x00, 0xFB, 0xC0,
  0x00, 0x7D, 0xE0, 0x00, 0x3E, 0xF0, 0x00, 0x1E, 0x78, 0x00, 0x0F, 0x3C,
  0x00, 0x07, 0x9F, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xE3, 0xC0, 0x01, 0xF1,
  0xE0, 0x00, 0xF0, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x1F, 0x80, 0xFC,
  0x07, 0xF1, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x40, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0xFE, 0x1F, 0xF1, 0xFF,
  0x9F, 0xBF, 0xF1, 0xFF, 0x0F, 0x70, 0x7B, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x07, 0xF0, 0x1F, 0xC1, 0xE0, 0x03, 0xE0, 0x40, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F,
  0x01, 0xFC, 0x38, 0x00, 0x7C, 0x20, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF8, 0x03,
  0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0xE0,
  0x00, 0xFE, 0xFE, 0x0F, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x00, 0x30, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0x78, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x0F, 0x3C, 0x00,
  0x03, 0xC7, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x3E, 0x1E, 0x00, 0x07, 0x83,
  0xC0, 0x01, 0xE0, 0x78, 0x00, 0x7C, 0x0F, 0x00, 0x0F, 0x01, 0xE0, 0x03,
  0xC0, 0x3C, 0x00, 0xF8, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x1E,
  0x01, 0xE0, 0x03, 0xC0, 0x7C, 0x00, 0x78, 0x0F, 0x00, 0x0F, 0x03, 0xC0,
  0x01, 0xE0, 0xF8, 0x00, 0x3C, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x3F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F,
  0x7F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0xA0, 0x00, 0x1F, 0x70, 0x00, 0xFC, 0xFE, 0x0F, 0xF1, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0x01, 0xFF, 0xF8, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x07, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0xF8, 0xFF, 0xE0, 0xF3, 0xFF, 0xF0,
  0xF7, 0xFF, 0xF8, 0xFF, 0x80, 0xFC, 0xFE, 0x00, 0x7E, 0xFC, 0x00, 0x3E,
  0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x78, 0x00, 0x1E,
  0x7C, 0x00, 0x1E, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0xFC,
  0x1F, 0xC3, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80,
  0x00, 0x08, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x01,
  0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x81, 0xF8, 0x0F, 0xC1,
  0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x1E,
  0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x87, 0xC0, 0x07, 0xC3, 0xE0, 0x03,
  0xE0, 0xF8, 0x03, 0xE0, 0x3F, 0x03, 0xE0, 0x0F, 0xE7, 0xE0, 0x03, 0xFF,
  0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0xFC,
  0x3F, 0x80, 0xFC, 0x07, 0xE0, 0xF8, 0x01, 0xF8, 0xF8, 0x00, 0x7E, 0x7C,
  0x00, 0x1F, 0x3C, 0x00, 0x07, 0x9E, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xF7,
  0x80, 0x00, 0xFB, 0xC0, 0x00, 0x79, 0xF0, 0x00, 0x3C, 0xF8, 0x00, 0x3E,
  0x3E, 0x00, 0x3E, 0x1F, 0xC0, 0x7F, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xFF,
  0x80, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x3F, 0x03, 0xF0, 0x7C, 0x00,
  0xF8, 0x7C, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x3C, 0xF0, 0x00,
  0x3E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00,
  0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x7E, 0x7C, 0x00, 0xFE, 0x3F, 0x03, 0xDE, 0x3F, 0xFF, 0xDE, 0x0F, 0xFF,
  0x9E, 0x07, 0xFE, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x20, 0x3F,
  0xC0, 0x3F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x02, 0x00,
  0x00, 0x7B, 0xFF, 0xFF, 0xFF, 0xF7, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xBF, 0xFF, 0xFF, 0xFE, 0x30, 0x1E,
  0x3F, 0x3F, 0x3F, 0x3F, 0x3E, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x3E, 0x3E,
  0x3C, 0x7C, 0x7C, 0x78, 0x78, 0x78, 0xF0, 0xF0, 0xE0, 0xE0, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x03,
  0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xFC, 0x0F, 0xE6, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x18, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0x00, 0x78,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x0C, 0x00, 0x3C, 0x3C, 0x00,
  0xFF, 0xF0, 0x1E, 0x3C, 0x03, 0xFF, 0xF8, 0x1E, 0x38, 0x07, 0xFF, 0xF8,
  0x0E, 0x78, 0x0F, 0xC0, 0x78, 0x0E, 0x78, 0x0F, 0x00, 0x78, 0x0F, 0x70,
  0x1F, 0x00, 0x78, 0x0F, 0xF0, 0x1E, 0x00, 0x78, 0x0F, 0xF0, 0x1E, 0x00,
  0x70, 0x0F, 0xF0, 0x3C, 0x00, 0x70, 0x0F, 0xF0, 0x3C, 0x00, 0xF0, 0x0F,
  0xF0, 0x3C, 0x00, 0xF0, 0x0F, 0xF0, 0x3C, 0x00, 0xF0, 0x0F, 0xF0, 0x3C,
  0x00, 0xF0, 0x0E, 0xF0, 0x3C, 0x00, 0xF0, 0x1E, 0xF0, 0x1E, 0x01, 0xF0,
  0x1E, 0xF0, 0x1E, 0x01, 0xF8, 0x3C, 0xF0, 0x1F, 0x03, 0xB8, 0x3C, 0x70,
  0x0F, 0xFF, 0xBF, 0xF8, 0x78, 0x07, 0xFF, 0x1F, 0xF0, 0x78, 0x03, 0xFC,
  0x0F, 0xE0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x04, 0x00, 0x03, 0xFC, 0x00, 0x7C,
  0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3D,
  0xE0, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x0F,
  0x1E, 0x00, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x03,
  0xC1, 0xE0, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x01,
  0xF0, 0x1E, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0x78, 0x07, 0xC0, 0x00,
  0x7C, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x3C, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xE0, 0x00, 0x3C,
  0x01, 0xE0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x03,
  0xE0, 0x78, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00,
  0x3E, 0x3E, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x07, 0xCF, 0x00, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0x00, 0xF8, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xCF, 0x80, 0x07, 0xE7, 0xC0, 0x01,
  0xFB, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0x7C, 0x00,
  0x0F, 0xBE, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xEF, 0x80, 0x01, 0xE7, 0xC0,
  0x01, 0xF3, 0xE0, 0x03, 0xF1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x1F, 0x00, 0x1F, 0xCF, 0x80, 0x03, 0xF7,
  0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0xFD, 0xF0, 0x01, 0xFE, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFE, 0x07, 0xFC, 0x07, 0xE0, 0xFF, 0x00, 0x0C, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x40, 0x7F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1A, 0x00,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFE, 0x0F, 0x80, 0x07, 0xF8, 0x7C, 0x00, 0x0F, 0xE3, 0xE0, 0x00,
  0x3F, 0x1F, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x0F,
  0xBE, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3E, 0xF8, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x0F, 0xBE, 0x00,
  0x00, 0xF9, 0xF0, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0xFC, 0x7C, 0x00, 0x0F,
  0xE3, 0xE0, 0x00, 0xFE, 0x1F, 0x00, 0x3F, 0xE0, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFE, 0x03, 0xFE, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0xC0, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x03, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0x3D, 0xF0, 0x00, 0x00,
  0xF7, 0xC0, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x0F, 0x3E, 0x00, 0x00, 0x3C,
  0xFC, 0x00, 0x00, 0xF1, 0xF8, 0x00, 0x03, 0xC3, 0xF0, 0x00, 0x0F, 0x07,
  0xF0, 0x00, 0x3C, 0x0F, 0xFF, 0x7F, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFC, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x87, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x01, 0xF6, 0x3F, 0xBF,
  0xF9, 0xFF, 0x8F, 0xF8, 0x1E, 0x00, 0xF8, 0x00, 0x0F, 0xDF, 0x00, 0x03,
  0xE3, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0xC1, 0xF0,
  0x03, 0xF0, 0x3E, 0x00, 0xFC, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x1F, 0x01, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x87,
  0xC0, 0x01, 0xF1, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x07, 0xDF, 0x80, 0x00,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0x3F,
  0x00, 0x0F, 0xC3, 0xE0, 0x01, 0xF0, 0x7E, 0x00, 0x3E, 0x07, 0xE0, 0x07,
  0xC0, 0x7C, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x0F,
  0xC0, 0x7C, 0x00, 0xF8, 0x0F, 0x80, 0x0F, 0x81, 0xF0, 0x01, 0xF8, 0x3E,
  0x00, 0x1F, 0x87, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x03,
  0xF3, 0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0x78, 0x00, 0x01, 0xEF, 0xF7, 0x80, 0x00, 0x1E, 0xFF, 0x7C, 0x00,
  0x01, 0xEF, 0xF3, 0xC0, 0x00, 0x3C, 0xFF, 0x3C, 0x00, 0x03, 0xCF, 0xF3,
  0xE0, 0x00, 0x7C, 0xFF, 0x1E, 0x00, 0x07, 0x8F, 0xF1, 0xF0, 0x00, 0x78,
  0xFF, 0x0F, 0x00, 0x0F, 0x0F, 0xF0, 0xF0, 0x00, 0xF0, 0xFF, 0x0F, 0x80,
  0x1F, 0x0F, 0xF0, 0x78, 0x01, 0xE0, 0xFF, 0x07, 0x80, 0x1E, 0x0F, 0xF0,
  0x7C, 0x03, 0xC0, 0xFF, 0x03, 0xC0, 0x3C, 0x0F, 0xF0, 0x3E, 0x03, 0xC0,
  0xFF, 0x01, 0xE0, 0x78, 0x0F, 0xF0, 0x1E, 0x07, 0x80, 0xFF, 0x01, 0xF0,
  0xF8, 0x0F, 0xF0, 0x0F, 0x0F, 0x00, 0xFF, 0x00, 0xF0, 0xF0, 0x0F, 0xF0,
  0x0F, 0x9E, 0x00, 0xFF, 0x00, 0x79, 0xE0, 0x0F, 0xF0, 0x07, 0xDE, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x01, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0x80, 0x0F, 0xF0,
  0x01, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFE, 0xF8, 0x00,
  0x0F, 0xF3, 0xE0, 0x00, 0x7F, 0x9F, 0x80, 0x03, 0xFC, 0x7C, 0x00, 0x1F,
  0xE1, 0xF0, 0x00, 0xFF, 0x0F, 0xC0, 0x07, 0xF8, 0x3E, 0x00, 0x3F, 0xC0,
  0xF8, 0x01, 0xFE, 0x07, 0xE0, 0x0F, 0xF0, 0x1F, 0x00, 0x7F, 0x80, 0x7C,
  0x03, 0xFC, 0x03, 0xE0, 0x1F, 0xE0, 0x0F, 0x80, 0xFF, 0x00, 0x7E, 0x07,
  0xF8, 0x01, 0xF0, 0x3F, 0xC0, 0x07, 0xC1, 0xFE, 0x00, 0x3F, 0x0F, 0xF0,
  0x00, 0xF8, 0x7F, 0x80, 0x03, 0xE3, 0xFC, 0x00, 0x1F, 0x9F, 0xE0, 0x00,
  0x7C, 0xFF, 0x00, 0x01, 0xF7, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x07, 0xF8, 0x07, 0xF8, 0x03, 0xF8, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x07,
  0xC0, 0x7C, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x3F, 0x0F, 0x80, 0x00,
  0x07, 0xC7, 0xC0, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x00, 0x3E, 0x7C, 0x00,
  0x00, 0x0F, 0x9E, 0x00, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x00, 0x7B, 0xE0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x00,
  0x3E, 0x7C, 0x00, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x03, 0xE7, 0xC0, 0x00,
  0x00, 0xF9, 0xF8, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x1F, 0x0F, 0xC0,
  0x00, 0x0F, 0x81, 0xF8, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x03, 0xF0, 0x0F,
  0xF0, 0x03, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xCF, 0x80, 0x1F, 0xDF, 0x00, 0x0F, 0xBE, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3E, 0xF8,
  0x00, 0xFD, 0xF0, 0x0F, 0xF3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF8, 0x1F, 0xFF, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x07, 0xF8, 0x07, 0xF8, 0x03, 0xF8, 0x00, 0x7F, 0x01, 0xF8,
  0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x3F, 0x0F,
  0x80, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x00, 0x3E,
  0x7C, 0x00, 0x00, 0x0F, 0x9E, 0x00, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x00,
  0x7B, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7B, 0xE0,
  0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x03, 0xE7,
  0xC0, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x1F,
  0x0F, 0xC0, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x03,
  0xF0, 0x0F, 0xF0, 0x03, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00,
  0x5F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xE0, 0xF8, 0x01, 0xFC, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE3,
  0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x03,
  0xE3, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x8F, 0x80,
  0x07, 0xC3, 0xE0, 0x03, 0xF0, 0xF8, 0x03, 0xF8, 0x3F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x3E, 0x03, 0xE0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x3E, 0x00,
  0xFC, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x3E,
  0x00, 0x1F, 0x0F, 0x80, 0x07, 0xE3, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x1F,
  0x3E, 0x00, 0x07, 0xCF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x3F, 0x00, 0xFF,
  0x80, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xF8, 0x1F,
  0x8F, 0xC0, 0x03, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1F, 0x40, 0x00, 0x7E, 0xE0, 0x01, 0xF9, 0xFF, 0x7F, 0xE3,
  0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x00, 0x0C, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x01,
  0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x7C, 0x7E,
  0x00, 0x0F, 0xC3, 0xF8, 0x01, 0xF8, 0x1F, 0xFB, 0xFF, 0x00, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7E, 0xF0, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x01, 0xF3,
  0xE0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x1E, 0x0F,
  0x80, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x01, 0xE0, 0x1E,
  0x00, 0x07, 0xC0, 0x3E, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x1E, 0x00, 0x78,
  0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0,
  0x07, 0xC0, 0x03, 0xE0, 0x0F, 0x80, 0x07, 0xC0, 0x3E, 0x00, 0x07, 0x80,
  0x7C, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x1F, 0x07,
  0xC0, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x7C, 0x7C,
  0x00, 0x00, 0xF8, 0xF0, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x01, 0xE7, 0xC0,
  0x00, 0x03, 0xEF, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xEF, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0x9E, 0x00, 0x07, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0xC0, 0x00,
  0xF1, 0xF0, 0x00, 0xF7, 0x80, 0x07, 0xC7, 0xC0, 0x03, 0xDE, 0x00, 0x1F,
  0x0F, 0x00, 0x0F, 0x78, 0x00, 0x7C, 0x3E, 0x00, 0x3D, 0xF0, 0x01, 0xE0,
  0xF8, 0x01, 0xF3, 0xC0, 0x0F, 0x81, 0xE0, 0x07, 0x8F, 0x00, 0x3E, 0x07,
  0x80, 0x1E, 0x3E, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0xF8, 0x03, 0xC0, 0x7C,
  0x03, 0xC1, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x07, 0x80, 0x7C, 0x03, 0xC0,
  0x7C, 0x1F, 0x01, 0xF0, 0x0F, 0x81, 0xF0, 0x3C, 0x07, 0x80, 0x3E, 0x07,
  0x80, 0xF0, 0x3E, 0x00, 0x78, 0x1E, 0x03, 0xE0, 0xF8, 0x01, 0xE0, 0xF8,
  0x07, 0x83, 0xC0, 0x07, 0xC3, 0xC0, 0x1E, 0x0F, 0x00, 0x1F, 0x0F, 0x00,
  0x7C, 0x7C, 0x00, 0x3C, 0x7C, 0x01, 0xF1, 0xF0, 0x00, 0xF1, 0xF0, 0x03,
  0xC7, 0x80, 0x03, 0xE7, 0x80, 0x0F, 0x1E, 0x00, 0x0F, 0x9E, 0x00, 0x3E,
  0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x7B, 0xE0, 0x00, 0x7B, 0xC0, 0x01, 0xEF,
  0x00, 0x01, 0xEF, 0x00, 0x07, 0xBC, 0x00, 0x03, 0xFC, 0x00, 0x1E, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3E, 0x03, 0xE0,
  0x01, 0xF0, 0x0F, 0x80, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF0, 0x00, 0xF8, 0x07, 0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0xF0,
  0x00, 0x0F, 0x87, 0xC0, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x7C, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x07, 0x8F,
  0x80, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x07, 0xC0, 0xF8,
  0x00, 0x3E, 0x01, 0xF0, 0x00, 0xF0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80,
  0x3E, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0xF8, 0x3E,
  0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x0F, 0xBE, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x0F, 0x8F, 0x80, 0x00,
  0xF8, 0x7C, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x03, 0xE0,
  0x3E, 0x00, 0x3E, 0x01, 0xF0, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x3E,
  0x00, 0xF0, 0x00, 0xF8, 0x0F, 0x80, 0x07, 0xC0, 0x78, 0x00, 0x1F, 0x07,
  0xC0, 0x00, 0x78, 0x3C, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x0F, 0x3E, 0x00,
  0x00, 0x7D, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00,
  0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x18, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0x9E,
  0x00, 0x03, 0xCF, 0x00, 0x01, 0xE3, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xF0,
  0x78, 0x00, 0x70, 0x3C, 0x00, 0x78, 0x0F, 0x00, 0x38, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x1C, 0x00, 0xF0, 0x1E, 0x00, 0x3C, 0x0F, 0x00, 0x1E, 0x0F,
  0x00, 0x07, 0x87, 0x80, 0x03, 0xC7, 0x80, 0x00, 0xF3, 0xC0, 0x00, 0x7B,
  0xC0, 0x00, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFC, 0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x07, 0x00, 0x7F,
  0x00, 0x0F, 0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x0F, 0x00, 0xFC,
  0x10, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x01, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF1, 0xFF, 0xFF, 0xCF, 0xE0, 0x0F, 0x7E, 0x00, 0x3D, 0xF0, 0x00, 0xF7,
  0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xF7, 0x80,
  0x0F, 0xDF, 0x00, 0x7F, 0x7F, 0x07, 0xFC, 0xFF, 0xFE, 0x71, 0xFF, 0xF1,
  0xC3, 0xFF, 0x07, 0x00, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x07, 0xE0, 0x0F, 0x8F, 0xFE, 0x07, 0xDF,
  0xFF, 0x83, 0xFF, 0xFF, 0xE1, 0xFF, 0x01, 0xF8, 0xFE, 0x00, 0x7E, 0x7E,
  0x00, 0x1F, 0x3F, 0x00, 0x07, 0xDF, 0x80, 0x03, 0xEF, 0x80, 0x01, 0xF7,
  0xC0, 0x00, 0x7B, 0xE0, 0x00, 0x3D, 0xF0, 0x00, 0x1E, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xEF, 0x80, 0x00,
  0xF7, 0xC0, 0x00, 0x7B, 0xE0, 0x00, 0x7D, 0xF8, 0x00, 0x3E, 0xFC, 0x00,
  0x3E, 0x7F, 0x00, 0x1F, 0x3F, 0xC0, 0x1F, 0x1F, 0xF8, 0x3F, 0x8F, 0x3F,
  0xFF, 0x87, 0x8F, 0xFF, 0x83, 0xC3, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x7F, 0x00, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0xC0, 0xE3,
  0xF0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x02, 0x1F,
  0xE7, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0xFC, 0x0F,
  0x03, 0xFF, 0x8F, 0x0F, 0xFF, 0xCF, 0x1F, 0xFF, 0xEF, 0x3F, 0x81, 0xFF,
  0x3E, 0x00, 0x7F, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x78, 0x00, 0x1F,
  0x7C, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x7F, 0x3F, 0xC3, 0xEF,
  0x1F, 0xFF, 0xEF, 0x0F, 0xFF, 0x8F, 0x03, 0xFF, 0x0F, 0x00, 0x10, 0x00,
  0x00, 0x7E, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x81,
  0xF8, 0x1F, 0x87, 0xC0, 0x1F, 0x9F, 0x00, 0x1F, 0x3E, 0x00, 0x1E, 0x78,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x06, 0x1F, 0xE1, 0xFC,
  0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x00, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x7E, 0x00,
  0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x07, 0xFF, 0xF1, 0xFF, 0xFE, 0x3F, 0xFF, 0xC0,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xFF, 0x8F, 0x0F, 0xFF, 0xCF, 0x1F, 0xFF, 0xEF, 0x3F, 0x81, 0xFF,
  0x3E, 0x00, 0x7F, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x78, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x78, 0x00, 0x1F,
  0x7C, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x7F, 0x1F, 0x81, 0xEF,
  0x1F, 0xFF, 0xEF, 0x0F, 0xFF, 0xCF, 0x03, 0xFF, 0x0F, 0x00, 0x10, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x20, 0x00, 0x3E, 0x38, 0x00, 0xFC, 0x3F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0xFC, 0x0F, 0x8F, 0xFE, 0x1F, 0x3F,
  0xFF, 0x3E, 0xFF, 0xFF, 0x7F, 0xC0, 0x7E, 0xFF, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0x80, 0x27, 0xFF, 0xFF, 0xB8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x40, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x3E, 0xEF,
  0xEF, 0xFC, 0xFF, 0xCF, 0xF0, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x2F, 0x80, 0x0F, 0x9F, 0x00, 0x3E, 0x3E, 0x00, 0xF8,
  0x7C, 0x03, 0xE0, 0xF8, 0x0F, 0x81, 0xF0, 0x3E, 0x03, 0xE0, 0xFC, 0x07,
  0xC3, 0xF0, 0x0F, 0x8F, 0xC0, 0x1F, 0x1F, 0x00, 0x3E, 0x7C, 0x00, 0x7D,
  0xF0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xE3,
  0xE0, 0x0F, 0x83, 0xE0, 0x1F, 0x07, 0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x07,
  0xC0, 0xF8, 0x07, 0xC1, 0xF0, 0x0F, 0xC3, 0xE0, 0x0F, 0x87, 0xC0, 0x0F,
  0x8F, 0x80, 0x0F, 0x9F, 0x00, 0x1F, 0xBE, 0x00, 0x1F, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x1F, 0x00, 0x0F, 0xC0, 0xF0, 0xFF, 0xE0, 0x7F, 0xF0, 0xF3, 0xFF, 0xF1,
  0xFF, 0xF8, 0xF7, 0xFF, 0xFB, 0xFF, 0xFC, 0xFF, 0x81, 0xFB, 0xC0, 0xFE,
  0xFE, 0x00, 0xFF, 0x80, 0x3E, 0xFC, 0x00, 0x7F, 0x00, 0x3E, 0xFC, 0x00,
  0x7E, 0x00, 0x1E, 0xFC, 0x00, 0x3E, 0x00, 0x1E, 0xF8, 0x00, 0x3C, 0x00,
  0x1F, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0xF8,
  0x00, 0x3C, 0x00, 0x1F, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0xF8, 0x00, 0x3C,
  0x00, 0x1F, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0xF8, 0x00, 0x3C, 0x00, 0x1F,
  0xF8, 0x00, 0x3C, 0x00, 0x1F, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0xF8, 0x00,
  0x3C, 0x00, 0x1F, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0xF8, 0x00, 0x3C, 0x00,
  0x1F, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0xF8,
  0x00, 0x3C, 0x00, 0x1F, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0xF8, 0x00, 0x3C,
  0x00, 0x1F, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x1F, 0x81, 0xE1, 0xFF,
  0xE3, 0xCF, 0xFF, 0xE7, 0x9F, 0xFF, 0xEF, 0xF8, 0x0F, 0xDF, 0xC0, 0x0F,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0xE0, 0x01, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xF8, 0x0F, 0xC1, 0xF0, 0x03, 0xF1, 0xF0,
  0x00, 0xF8, 0xF8, 0x00, 0x3E, 0x78, 0x00, 0x1F, 0x7C, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xE7, 0xC0, 0x01, 0xF3, 0xE0, 0x00,
  0xF8, 0xF8, 0x00, 0xF8, 0x7E, 0x00, 0xFC, 0x1F, 0xC1, 0xFC, 0x07, 0xFF,
  0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x78, 0x7F, 0xF0, 0x3C, 0xFF, 0xFC, 0x1E, 0x7F, 0xFF, 0x0F,
  0xF8, 0x1F, 0xC7, 0xF0, 0x03, 0xF3, 0xF0, 0x00, 0xF9, 0xF8, 0x00, 0x3E,
  0xFC, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xBE, 0x00, 0x03, 0xDF, 0x00, 0x01,
  0xEF, 0x80, 0x00, 0xF7, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0x7C, 0x00, 0x07, 0xBE, 0x00, 0x07, 0xDF, 0x00,
  0x03, 0xEF, 0xC0, 0x01, 0xF7, 0xE0, 0x01, 0xF3, 0xF8, 0x00, 0xF9, 0xFE,
  0x00, 0xF8, 0xFF, 0xC3, 0xFC, 0x7D, 0xFF, 0xFC, 0x3E, 0x7F, 0xFC, 0x1F,
  0x1F, 0xF8, 0x0F, 0x80, 0xC0, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0x8F, 0x0F, 0xFF,
  0xCF, 0x1F, 0xFF, 0xEF, 0x3F, 0x81, 0xFF, 0x3E, 0x00, 0x7F, 0x7C, 0x00,
  0x3F, 0x7C, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0x7C, 0x00, 0x3F, 0x7E, 0x00,
  0x3F, 0x3F, 0x00, 0x7F, 0x3F, 0xC3, 0xEF, 0x1F, 0xFF, 0xEF, 0x0F, 0xFF,
  0x8F, 0x03, 0xFF, 0x0F, 0x00, 0x30, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x1F, 0xF0, 0x7F, 0xF1, 0xFF, 0xF3, 0xFF,
  0xF7, 0xE1, 0xFF, 0x80, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0x01, 0xF8, 0x03, 0xFF, 0xF0, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xC0, 0x3D,
  0xE0, 0x01, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03,
  0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0,
  0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xFE, 0x00, 0x1F, 0xF8, 0x0F, 0xDF,
  0xFF, 0xF3, 0xFF, 0xFC, 0x3F, 0xFE, 0x00, 0x08, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0xE1, 0x07,
  0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x18, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x0F, 0xDF, 0x00,
  0x3F, 0xBF, 0xC3, 0xFF, 0x3F, 0xFF, 0xDE, 0x3F, 0xFF, 0x3C, 0x1F, 0xF8,
  0x78, 0x03, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xDE, 0x00, 0x03, 0xE7, 0xC0,
  0x00, 0xF9, 0xF0, 0x00, 0x3C, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC1,
  0xE0, 0x01, 0xE0, 0x7C, 0x00, 0xF8, 0x1F, 0x00, 0x3E, 0x03, 0xC0, 0x0F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x07, 0x80, 0xF8, 0x01, 0xF0,
  0x3E, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xE1, 0xF0, 0x00,
  0x78, 0x78, 0x00, 0x1F, 0x3E, 0x00, 0x03, 0xCF, 0x00, 0x00, 0xF3, 0xC0,
  0x00, 0x3D, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0xF0, 0x01, 0xF8, 0x00, 0xFB, 0xE0, 0x03, 0xF0, 0x01, 0xF3, 0xC0,
  0x0F, 0xF0, 0x03, 0xC7, 0x80, 0x1F, 0xE0, 0x07, 0x8F, 0x80, 0x3F, 0xC0,
  0x1F, 0x1F, 0x00, 0xF3, 0xC0, 0x3E, 0x1E, 0x01, 0xE7, 0x80, 0x78, 0x3E,
  0x03, 0xCF, 0x00, 0xF0, 0x7C, 0x07, 0x9F, 0x03, 0xE0, 0x78, 0x1E, 0x1E,
  0x07, 0xC0, 0xF0, 0x3C, 0x3C, 0x0F, 0x01, 0xF0, 0x78, 0x78, 0x1E, 0x03,
  0xE1, 0xE0, 0x78, 0x7C, 0x03, 0xC3, 0xC0, 0xF0, 0xF0, 0x07, 0x87, 0x81,
  0xE1, 0xE0, 0x0F, 0x9F, 0x03, 0xE7, 0xC0, 0x1F, 0x3C, 0x03, 0xCF, 0x80,
  0x1E, 0x78, 0x07, 0x9E, 0x00, 0x3C, 0xF0, 0x0F, 0x3C, 0x00, 0x7B, 0xC0,
  0x0F, 0x78, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x1F, 0x9F,
  0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0x7C, 0x07, 0x80, 0x1F, 0x07, 0xC0, 0x07, 0xC7, 0xC0, 0x01, 0xF7, 0xC0,
  0x00, 0xFB, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xF7,
  0xC0, 0x00, 0xFB, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x78,
  0x0F, 0x00, 0x7C, 0x07, 0xC0, 0x7C, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x3E,
  0x00, 0x3E, 0x3E, 0x00, 0x0F, 0xBE, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07,
  0xDF, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0xF8, 0xF0, 0x00, 0x3E, 0x3E, 0x00,
  0x1F, 0x0F, 0x80, 0x07, 0xC1, 0xE0, 0x01, 0xE0, 0x7C, 0x00, 0xF8, 0x0F,
  0x00, 0x3E, 0x03, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x1E, 0x01, 0xF0,
  0x07, 0xC0, 0x78, 0x00, 0xF0, 0x3E, 0x00, 0x3E, 0x0F, 0x00, 0x0F, 0x87,
  0xC0, 0x01, 0xE1, 0xF0, 0x00, 0x7C, 0x78, 0x00, 0x0F, 0x3E, 0x00, 0x03,
  0xCF, 0x80, 0x00, 0xFB, 0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x01, 0x3F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF0,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x3F, 0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0x0F,
  0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x0F, 0xF8, 0x07, 0xE0, 0x03, 0xFC,
  0x01, 0xFF, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x03,
  0xF0, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xE0, 0x01, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xF8, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0x80, 0x07, 0x80,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xC0,
  0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x7F, 0x01, 0xFF,
  0x03, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0xFF, 0x00, 0xFF, 0x00,
  0xFC, 0x00, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0x1F, 0xF1, 0xFF, 0xFF, 0xC0, 0x3F, 0xFE, 0x80, 0x07, 0xF8,
};

const GFXglyph NotoSans_Regular51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 6, 37, 14, 4, -36 },
  { 29, 15, 13, 21, 3, -36 },
  { 54, 31, 36, 33, 1, -36 },
  { 194, 23, 42, 29, 3, -39 },
  { 315, 38, 38, 42, 2, -37 },
  { 496, 34, 38, 37, 3, -37 },
  { 658, 5, 13, 11, 3, -36 },
  { 667, 12, 44, 15, 2, -36 },
  { 733, 11, 44, 15, 2, -36 },
  { 794, 24, 23, 28, 2, -39 },
  { 863, 24, 24, 29, 3, -30 },
  { 935, 8, 13, 14, 2, -6 },
  { 948, 12, 4, 16, 2, -16 },
  { 954, 6, 7, 14, 4, -6 },
  { 960, 17, 36, 19, 1, -36 },
  { 1037, 25, 38, 29, 2, -37 },
  { 1156, 13, 36, 29, 5, -36 },
  { 1215, 25, 37, 29, 2, -37 },
  { 1331, 24, 38, 29, 2, -37 },
  { 1445, 27, 37, 29, 1, -37 },
  { 1570, 23, 37, 29, 3, -36 },
  { 1677, 24, 38, 29, 3, -37 },
  { 1791, 25, 36, 29, 2, -36 },
  { 1904, 25, 38, 29, 2, -37 },
  { 2023, 24, 38, 29, 3, -37 },
  { 2137, 6, 29, 14, 4, -28 },
  { 2159, 8, 35, 14, 2, -28 },
  { 2194, 24, 25, 29, 3, -31 },
  { 2269, 23, 14, 29, 3, -25 },
  { 2310, 24, 25, 29, 3, -31 },
  { 2385, 20, 38, 22, 1, -37 },
  { 2480, 40, 41, 46, 3, -36 },
  { 2685, 33, 37, 33, 0, -37 },
  { 2838, 25, 36, 33, 5, -36 },
  { 2951, 28, 38, 32, 3, -37 },
  { 3084, 29, 36, 37, 5, -36 },
  { 3215, 20, 36, 28, 5, -36 },
  { 3305, 20, 36, 26, 5, -36 },
  { 3395, 30, 38, 37, 3, -37 },
  { 3538, 28, 36, 38, 5, -36 },
  { 3664, 13, 36, 17, 2, -36 },
  { 3723, 13, 46, 14, -4, -36 },
  { 3798, 27, 36, 32, 5, -36 },
  { 3920, 20, 36, 27, 5, -36 },
  { 4010, 36, 36, 46, 5, -36 },
  { 4172, 29, 36, 39, 5, -36 },
  { 4303, 34, 38, 40, 3, -37 },
  { 4465, 23, 36, 31, 5, -36 },
  { 4569, 34, 46, 40, 3, -37 },
  { 4765, 26, 36, 32, 5, -36 },
  { 4882, 23, 38, 28, 3, -37 },
  { 4992, 27, 36, 28, 1, -36 },
  { 5114, 28, 37, 37, 5, -36 },
  { 5244, 31, 36, 31, 0, -36 },
  { 5384, 46, 36, 47, 1, -36 },
  { 5591, 30, 36, 30, 0, -36 },
  { 5726, 29, 36, 29, 0, -36 },
  { 5857, 25, 36, 29, 2, -36 },
  { 5970, 12, 44, 17, 4, -36 },
  { 6036, 18, 36, 19, 1, -36 },
  { 6117, 12, 44, 17, 1, -36 },
  { 6183, 25, 23, 29, 2, -37 },
  { 6255, 23, 3, 23, 0, 5 },
  { 6264, 10, 8, 14, 2, -39 },
  { 6274, 22, 29, 29, 2, -28 },
  { 6354, 25, 40, 31, 4, -39 },
  { 6479, 20, 29, 24, 3, -28 },
  { 6552, 24, 40, 31, 3, -39 },
  { 6672, 23, 29, 29, 3, -28 },
  { 6756, 19, 39, 18, 1, -39 },
  { 6849, 24, 40, 31, 3, -28 },
  { 6969, 23, 39, 32, 4, -39 },
  { 7082, 5, 38, 13, 4, -38 },
  { 7106, 12, 50, 13, -3, -38 },
  { 7181, 23, 39, 27, 4, -39 },
  { 7294, 5, 39, 13, 4, -39 },
  { 7319, 40, 28, 48, 4, -28 },
  { 7459, 23, 28, 32, 4, -28 },
  { 7540, 25, 29, 31, 3, -28 },
  { 7631, 25, 40, 31, 4, -28 },
  { 7756, 24, 40, 31, 3, -28 },
  { 7876, 16, 28, 21, 4, -28 },
  { 7932, 19, 29, 24, 3, -28 },
  { 8001, 16, 35, 18, 1, -34 },
  { 8071, 23, 28, 32, 4, -27 },
  { 8152, 26, 27, 26, 0, -27 },
  { 8240, 39, 27, 40, 1, -27 },
  { 8372, 25, 27, 27, 1, -27 },
  { 8457, 26, 39, 26, 0, -27 },
  { 8584, 20, 27, 24, 2, -27 },
  { 8652, 17, 44, 19, 1, -36 },
  { 8746, 4, 51, 28, 12, -39 },
  { 8772, 16, 44, 19, 2, -36 },
  { 8860, 24, 6, 29, 3, -21 },
};

const GFXfont NotoSans_Regular51pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Regular51pt7bBitmaps,
  (GFXglyph *)NotoSans_Regular51pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _NOTOSANS_REGULAR51PT7B_H_
