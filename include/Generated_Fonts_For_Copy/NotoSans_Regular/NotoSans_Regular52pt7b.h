#ifndef _NOTOSANS_REGULAR52PT7B_H_
#define _NOTOSANS_REGULAR52PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Regular.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Regular52pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE3, 0x00, 0x00, 0x00,
  0x1E, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0xF8, 0x3E, 0xF0, 0x7D, 0xE0, 0xFB,
  0xC1, 0xF7, 0x83, 0xEF, 0x07, 0x9E, 0x0F, 0x3C, 0x1E, 0x78, 0x1C, 0xF0,
  0x39, 0xE0, 0x73, 0x80, 0xE7, 0x01, 0xC0, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0x1C, 0x03, 0x80, 0x00, 0x78, 0x07, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x01,
  0xE0, 0x3C, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x1E,
  0x01, 0xC0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x78, 0x0F, 0x00, 0x00, 0xF0,
  0x1E, 0x01, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1E, 0x03, 0xC0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x70, 0x0F,
  0x00, 0x00, 0xE0, 0x1C, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x38, 0x07, 0x00,
  0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xF0,
  0x07, 0x00, 0xF0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x3C, 0x07, 0x80, 0x00,
  0x78, 0x0F, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x03,
  0x80, 0x70, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x3C,
  0x07, 0x80, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F, 0x38, 0x7C, 0x7C, 0x38,
  0x08, 0xF8, 0x38, 0x00, 0xF8, 0x38, 0x00, 0xF8, 0x38, 0x00, 0xF8, 0x38,
  0x00, 0xF8, 0x38, 0x00, 0x7C, 0x38, 0x00, 0x7F, 0x38, 0x00, 0x3F, 0xF8,
  0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x7F,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x39, 0xFE, 0x00, 0x38, 0x7E, 0x00, 0x38,
  0x1F, 0x00, 0x38, 0x1F, 0x00, 0x38, 0x1F, 0x00, 0x38, 0x1F, 0x00, 0x38,
  0x1F, 0x80, 0x38, 0x3E, 0xF0, 0x38, 0x7E, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x78, 0x03, 0xFF,
  0x00, 0x03, 0xC0, 0x1F, 0xFE, 0x00, 0x1E, 0x00, 0x78, 0x7C, 0x00, 0x78,
  0x03, 0xC0, 0xF0, 0x03, 0xC0, 0x0F, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x07,
  0x80, 0x78, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x03, 0x80, 0x78, 0x0F, 0x00,
  0x0E, 0x01, 0xE0, 0x3C, 0x00, 0x38, 0x07, 0x81, 0xE0, 0x00, 0xE0, 0x1E,
  0x0F, 0x00, 0x03, 0x80, 0x78, 0x3C, 0x00, 0x0E, 0x01, 0xE1, 0xE0, 0x00,
  0x3C, 0x07, 0x87, 0x83, 0xC0, 0xF0, 0x1E, 0x3C, 0x3F, 0xC3, 0xC0, 0xF0,
  0xF1, 0xFF, 0x8F, 0x03, 0xC7, 0x8F, 0xFF, 0x1E, 0x1F, 0x1E, 0x7C, 0x3C,
  0x7F, 0xF8, 0xF1, 0xE0, 0x78, 0xFF, 0xC7, 0x87, 0x81, 0xE1, 0xFE, 0x1E,
  0x1C, 0x07, 0x80, 0xC0, 0xF0, 0xF0, 0x0E, 0x00, 0x03, 0xC3, 0xC0, 0x3C,
  0x00, 0x1E, 0x0F, 0x00, 0xF0, 0x00, 0x78, 0x3C, 0x03, 0xC0, 0x03, 0xC0,
  0xF0, 0x0F, 0x00, 0x0F, 0x03, 0xC0, 0x3C, 0x00, 0x78, 0x0F, 0x00, 0xF0,
  0x03, 0xC0, 0x1C, 0x03, 0x80, 0x0F, 0x00, 0x70, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x78, 0x01, 0xE0, 0x07, 0x81, 0xE0, 0x0F, 0x00, 0x0F, 0x0F, 0x00,
  0x3C, 0x00, 0x3F, 0xFC, 0x01, 0xE0, 0x00, 0x7F, 0xE0, 0x0F, 0x80, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0xFC, 0x1F, 0x80, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x1F,
  0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x0F, 0x80, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00,
  0xF8, 0x1F, 0x80, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x01, 0xF9, 0xF8, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xC1, 0xFD,
  0xF8, 0x00, 0xF0, 0x7F, 0x1F, 0x80, 0x3E, 0x1F, 0x81, 0xF8, 0x07, 0xC3,
  0xE0, 0x1F, 0x80, 0xF0, 0xFC, 0x01, 0xF8, 0x3E, 0x1F, 0x00, 0x1F, 0x87,
  0xC3, 0xE0, 0x01, 0xF9, 0xF0, 0x7C, 0x00, 0x1F, 0xBE, 0x0F, 0x80, 0x01,
  0xFF, 0x81, 0xF0, 0x00, 0x1F, 0xE0, 0x3E, 0x00, 0x01, 0xF8, 0x07, 0xC0,
  0x00, 0x7F, 0x80, 0xFC, 0x00, 0x1F, 0xF8, 0x0F, 0xE0, 0x0F, 0xFF, 0x80,
  0xFF, 0xFF, 0xF9, 0xF8, 0x1F, 0xFF, 0xFE, 0x1F, 0x80, 0xFF, 0xFF, 0x01,
  0xF8, 0x07, 0xFF, 0x80, 0x1F, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0xFB, 0xDE,
  0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xE7, 0x00, 0x01, 0xF0, 0x3E, 0x03, 0xC0,
  0x7C, 0x07, 0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x3E, 0x03,
  0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x07, 0x80, 0x78, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x3E, 0x03,
  0xE0, 0x1E, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xC0,
  0x3E, 0x01, 0xF0, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xF0,
  0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x7C, 0x03, 0xC0, 0x3C,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x0F, 0x80, 0xF8,
  0x1F, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x7C, 0x07, 0x80, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x70,
  0x1C, 0x07, 0x7E, 0x1C, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x80, 0x01,
  0xE7, 0x80, 0x03, 0xE7, 0xC0, 0x03, 0xE3, 0xE0, 0x07, 0xC3, 0xF0, 0x0F,
  0xC1, 0xF0, 0x0F, 0x81, 0xF8, 0x03, 0x80, 0xE0, 0x01, 0x00, 0x80, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x1F, 0x3F, 0x3E, 0x3E, 0x3E, 0x3C, 0x3C, 0x7C, 0x78, 0x78,
  0x70, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7B, 0xFF,
  0xFF, 0xFF, 0xF3, 0x00, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E,
  0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80,
  0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xC3, 0xF8, 0x3F, 0x00, 0xF8, 0x3E, 0x00,
  0x7C, 0x7C, 0x00, 0x3C, 0x7C, 0x00, 0x3E, 0x78, 0x00, 0x3E, 0xF8, 0x00,
  0x1E, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x3E, 0x7C, 0x00,
  0x3E, 0x3C, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0xF8, 0x1F, 0xE7,
  0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x18,
  0x00, 0x00, 0x78, 0x07, 0xC0, 0xFE, 0x0F, 0xF0, 0xFF, 0x9F, 0xBD, 0xF9,
  0xFF, 0x8F, 0xF8, 0x7B, 0x83, 0xC8, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x07, 0xFC, 0x3F, 0xC1, 0xF0, 0x03, 0xE0, 0xE0, 0x00, 0xF8,
  0x20, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x3E, 0x00, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x07, 0xF8, 0x3F, 0xC3, 0xE0, 0x03, 0xF0, 0xC0, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x80, 0x00, 0x3F, 0x78, 0x00, 0x3F, 0x3F,
  0xC3, 0xFF, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xBC, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x1F, 0x3C, 0x00, 0x01,
  0xE3, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x78, 0x3C,
  0x00, 0x0F, 0x03, 0xC0, 0x01, 0xF0, 0x3C, 0x00, 0x3E, 0x03, 0xC0, 0x03,
  0xC0, 0x3C, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x1E, 0x00, 0x3C, 0x03, 0xE0, 0x03, 0xC0, 0x3C, 0x00, 0x3C, 0x07,
  0x80, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF8, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x7F, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x18, 0x03, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x80, 0x00,
  0x7C, 0xE0, 0x01, 0xFC, 0xFF, 0x0F, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x07, 0xF8, 0x08, 0x0F, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF8, 0x7F, 0xC0, 0xF9, 0xFF, 0xF0, 0xFB, 0xFF,
  0xF8, 0xF7, 0xE3, 0xFC, 0xFF, 0x00, 0x7E, 0xFE, 0x00, 0x3E, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00,
  0x1F, 0x7C, 0x00, 0x1F, 0x3C, 0x00, 0x1E, 0x3E, 0x00, 0x3E, 0x1F, 0x00,
  0x7C, 0x1F, 0xE3, 0xFC, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x01, 0xFF,
  0xC0, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8,
  0x3F, 0x81, 0xFC, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E,
  0x78, 0x00, 0x3E, 0x78, 0x00, 0x3E, 0x78, 0x00, 0x3E, 0x7C, 0x00, 0x3E,
  0x7C, 0x00, 0x3C, 0x3E, 0x00, 0x7C, 0x3F, 0x00, 0xF8, 0x1F, 0xC3, 0xF0,
  0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF0, 0x1F, 0x83, 0xF8, 0x3E, 0x00, 0xFC, 0x7C, 0x00, 0x7E,
  0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x7E, 0x7F, 0x81, 0xFC, 0x3F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x3F, 0x83, 0xF0,
  0x7E, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0xF8, 0x00, 0x3C, 0xF8, 0x00, 0x3E,
  0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0x7C, 0x00, 0x7F, 0x7E, 0x00, 0xFF, 0x3F, 0xEF, 0xFF,
  0x1F, 0xFF, 0xDF, 0x0F, 0xFF, 0x1F, 0x03, 0xFC, 0x1F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xE0, 0x30, 0x3F, 0xC0, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0x02, 0x00, 0x00, 0x33, 0xFF, 0xFF, 0xFF, 0xF7, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E,
  0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x08, 0x3E, 0x3F, 0x3F, 0x3F, 0x3F, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x3E, 0x3E, 0x3E, 0x7C, 0x7C, 0x7C, 0x78,
  0x78, 0xF0, 0xF0, 0xF0, 0xE0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0xF0, 0x01, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xFE, 0x1F, 0xE7,
  0x00, 0x3E, 0x40, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x1F, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x0F,
  0x80, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x0F, 0xF8, 0x07, 0x87, 0x80, 0x1F,
  0xFF, 0x01, 0xE3, 0xC0, 0x3F, 0xFF, 0x80, 0xF3, 0xC0, 0x3F, 0x87, 0xC0,
  0x79, 0xE0, 0x3E, 0x01, 0xE0, 0x1C, 0xF0, 0x1E, 0x00, 0xF0, 0x0F, 0x70,
  0x1F, 0x00, 0x78, 0x07, 0xF8, 0x0F, 0x00, 0x3C, 0x03, 0xFC, 0x07, 0x80,
  0x1E, 0x01, 0xFE, 0x03, 0xC0, 0x0F, 0x00, 0xFF, 0x03, 0xE0, 0x07, 0x80,
  0x7F, 0x81, 0xE0, 0x03, 0xC0, 0x3B, 0xC0, 0xF0, 0x01, 0xE0, 0x1D, 0xE0,
  0x3C, 0x00, 0xF0, 0x1E, 0xF0, 0x1E, 0x00, 0xF8, 0x0F, 0x78, 0x0F, 0x00,
  0x7C, 0x07, 0x3C, 0x07, 0xC0, 0x7E, 0x07, 0x9E, 0x01, 0xF0, 0x7F, 0x87,
  0x87, 0x80, 0xFF, 0xF9, 0xFF, 0xC3, 0xC0, 0x3F, 0xF8, 0x7F, 0xC1, 0xE0,
  0x07, 0xF8, 0x1F, 0x80, 0x78, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x60, 0x00, 0x1F,
  0xE0, 0x01, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7B,
  0xC0, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x1E,
  0x3C, 0x00, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x01,
  0xE0, 0x3C, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x00,
  0x78, 0x03, 0xE0, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC,
  0x03, 0xE0, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0xF8, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00,
  0x7C, 0x3C, 0x00, 0x00, 0x1E, 0x3E, 0x00, 0x00, 0x0F, 0x9F, 0x00, 0x00,
  0x07, 0xCF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xF8, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0xF8,
  0x00, 0xFF, 0x3E, 0x00, 0x0F, 0xCF, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0x3E,
  0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFB, 0xE0, 0x00,
  0x3C, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xE3, 0xE0,
  0x0F, 0xF0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xF8, 0xF8, 0x00, 0x7F, 0x3E, 0x00, 0x07, 0xEF, 0x80, 0x00,
  0xFB, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0xFB, 0xE0, 0x00, 0x7E, 0xF8, 0x00, 0x7F, 0x3F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0x03, 0xFF, 0x9F, 0xE0, 0x7F, 0x80, 0x0E, 0x0F, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x06, 0x07, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x60, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0xF8, 0x00, 0xFF, 0x83, 0xE0,
  0x00, 0x7F, 0x0F, 0x80, 0x00, 0xFE, 0x3E, 0x00, 0x01, 0xF8, 0xF8, 0x00,
  0x03, 0xF3, 0xE0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x1F, 0xBE, 0x00, 0x00,
  0x3E, 0xF8, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x3E, 0xF8, 0x00,
  0x00, 0xFB, 0xE0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x1F, 0x3E, 0x00, 0x00,
  0x7C, 0xF8, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0xFC,
  0x3E, 0x00, 0x0F, 0xE0, 0xF8, 0x01, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xEF, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFE, 0xFF, 0xC0, 0xFF,
  0x00, 0x07, 0x03, 0xF8, 0x00, 0x02, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0x7C, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0xFB,
  0xF0, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x07, 0xC7,
  0xE0, 0x00, 0x0F, 0x8F, 0xE0, 0x00, 0x1F, 0x0F, 0xE0, 0x00, 0x3E, 0x0F,
  0xF0, 0x00, 0x7C, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x14, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC3, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3F, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xE1, 0xFD,
  0xFF, 0xEF, 0xFE, 0x7F, 0xC1, 0xF8, 0x00, 0xF8, 0x00, 0x07, 0xFF, 0x00,
  0x01, 0xF3, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC1,
  0xF0, 0x01, 0xF8, 0x3E, 0x00, 0x7E, 0x07, 0xC0, 0x1F, 0x80, 0xF8, 0x07,
  0xE0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x3E, 0x00, 0x7C, 0x0F, 0x80, 0x0F,
  0x83, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x07, 0xCF, 0x80,
  0x00, 0xFB, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F,
  0xBE, 0x00, 0x0F, 0xE7, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x3E, 0x07, 0xE0,
  0x07, 0xC0, 0x7C, 0x00, 0xF8, 0x0F, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xE0,
  0x0F, 0xC0, 0x7C, 0x00, 0xF8, 0x0F, 0x80, 0x1F, 0x81, 0xF0, 0x01, 0xF8,
  0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x3F, 0x1F, 0x00,
  0x03, 0xF3, 0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7E,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFB, 0xC0, 0x00, 0x07, 0xBF, 0xDE, 0x00, 0x00, 0x3D, 0xFE, 0xF8,
  0x00, 0x03, 0xEF, 0xF3, 0xC0, 0x00, 0x1E, 0x7F, 0x9F, 0x00, 0x00, 0xF3,
  0xFC, 0xF8, 0x00, 0x0F, 0x1F, 0xE3, 0xC0, 0x00, 0x79, 0xFF, 0x1F, 0x00,
  0x07, 0xCF, 0xF8, 0x78, 0x00, 0x3C, 0x7F, 0xC3, 0xC0, 0x01, 0xE3, 0xFE,
  0x1F, 0x00, 0x1E, 0x1F, 0xF0, 0x78, 0x00, 0xF0, 0xFF, 0x83, 0xE0, 0x0F,
  0x87, 0xFC, 0x1F, 0x00, 0x78, 0x3F, 0xE0, 0x78, 0x03, 0xC1, 0xFF, 0x03,
  0xE0, 0x3E, 0x0F, 0xF8, 0x0F, 0x01, 0xE0, 0x7F, 0xC0, 0x78, 0x0F, 0x03,
  0xFE, 0x03, 0xE0, 0xF0, 0x1F, 0xF0, 0x0F, 0x07, 0x80, 0xFF, 0x80, 0x7C,
  0x7C, 0x07, 0xFC, 0x03, 0xE3, 0xC0, 0x3F, 0xE0, 0x0F, 0x1E, 0x01, 0xFF,
  0x00, 0x7D, 0xF0, 0x0F, 0xF8, 0x01, 0xEF, 0x00, 0x7F, 0xC0, 0x0F, 0xF8,
  0x03, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x80,
  0x0F, 0xE0, 0x07, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xE0, 0x01, 0xF0, 0x01,
  0xFF, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFE, 0xF8, 0x00, 0x0F, 0xF3,
  0xE0, 0x00, 0x7F, 0x9F, 0x80, 0x03, 0xFC, 0x7C, 0x00, 0x1F, 0xE1, 0xF0,
  0x00, 0xFF, 0x0F, 0xC0, 0x07, 0xF8, 0x3E, 0x00, 0x3F, 0xC0, 0xF8, 0x01,
  0xFE, 0x07, 0xE0, 0x0F, 0xF0, 0x1F, 0x00, 0x7F, 0x80, 0xFC, 0x03, 0xFC,
  0x03, 0xE0, 0x1F, 0xE0, 0x0F, 0x80, 0xFF, 0x00, 0x7E, 0x07, 0xF8, 0x01,
  0xF0, 0x3F, 0xC0, 0x07, 0xC1, 0xFE, 0x00, 0x3F, 0x0F, 0xF0, 0x00, 0xF8,
  0x7F, 0x80, 0x03, 0xE3, 0xFC, 0x00, 0x1F, 0x9F, 0xE0, 0x00, 0x7C, 0xFF,
  0x00, 0x01, 0xF7, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xBF, 0xF8, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x1F, 0x0F,
  0x80, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00, 0x3E,
  0x7C, 0x00, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x01, 0xF7,
  0xC0, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x0F,
  0x8F, 0x80, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00,
  0xF8, 0x0F, 0xC0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xF8, 0x03, 0xFC, 0xF8, 0x00,
  0xFE, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x7C, 0xF8, 0x01,
  0xFC, 0xF8, 0x7F, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0x00, 0xFF, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xBF, 0xF8, 0x03, 0xFC, 0x00, 0x7F, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x1F,
  0x0F, 0x80, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00,
  0x3E, 0x7C, 0x00, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x01, 0xF7, 0xC0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x01,
  0xF7, 0xC0, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00,
  0x0F, 0x8F, 0x80, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x03, 0xF0, 0x7E, 0x00,
  0x00, 0xF8, 0x0F, 0xC0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x05, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0x80, 0x1F, 0xC1, 0xF0,
  0x00, 0xFC, 0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF8, 0xF8, 0x00, 0x1F,
  0x1F, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x8F, 0x80,
  0x01, 0xF1, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xF0,
  0xF8, 0x00, 0xFC, 0x1F, 0x01, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x3E, 0x01, 0xF0, 0x07,
  0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x7E, 0x03, 0xE0, 0x07,
  0xC0, 0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x81, 0xF0, 0x00, 0xF8, 0x3E,
  0x00, 0x1F, 0x87, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x3F, 0x1F, 0x00, 0x03,
  0xE3, 0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x7E, 0x00,
  0x3E, 0x00, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE3, 0xFE,
  0x7F, 0x8F, 0xC0, 0x07, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x7D, 0xC0, 0x03,
  0xFB, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x07, 0xFF, 0xE0,
  0x00, 0x18, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xE3, 0xE0, 0x00,
  0x7C, 0x3F, 0x80, 0x1F, 0xC1, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0xF0, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x01, 0xF3, 0xE0, 0x00,
  0x03, 0xE3, 0xE0, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x1F, 0x0F, 0x80, 0x00,
  0x3E, 0x0F, 0x80, 0x00, 0x78, 0x1F, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x03,
  0xE0, 0x3E, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x3E,
  0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x0F, 0x80, 0x07, 0xC0, 0x1F, 0x00, 0x07, 0x80, 0x3E, 0x00,
  0x0F, 0x80, 0xF8, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x1F, 0x03, 0xC0, 0x00,
  0x3E, 0x0F, 0x80, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00,
  0xF8, 0xF8, 0x00, 0x00, 0xF1, 0xF0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x03,
  0xEF, 0x80, 0x00, 0x03, 0xDF, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFB, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xE7, 0xC0, 0x01,
  0xFE, 0x00, 0x07, 0x8F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0x1F, 0x00, 0x07,
  0xF8, 0x00, 0x3E, 0x1E, 0x00, 0x1F, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x3C,
  0xF0, 0x00, 0xF0, 0x7C, 0x00, 0x79, 0xE0, 0x03, 0xE0, 0xF8, 0x01, 0xF3,
  0xE0, 0x07, 0xC0, 0xF0, 0x03, 0xE3, 0xC0, 0x0F, 0x81, 0xF0, 0x07, 0x87,
  0x80, 0x1E, 0x03, 0xE0, 0x0F, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x1F,
  0x00, 0xF8, 0x07, 0x80, 0x78, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0xF0, 0x3C,
  0x03, 0xC0, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x80, 0x1E, 0x07, 0xC0, 0x78,
  0x1F, 0x00, 0x3E, 0x0F, 0x00, 0xF0, 0x3C, 0x00, 0x7C, 0x1E, 0x01, 0xF0,
  0x78, 0x00, 0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0x00, 0xF0, 0xF0, 0x03, 0xC3,
  0xE0, 0x01, 0xF1, 0xE0, 0x07, 0xC7, 0x80, 0x03, 0xE7, 0xC0, 0x0F, 0x8F,
  0x00, 0x07, 0xCF, 0x80, 0x0F, 0x3E, 0x00, 0x07, 0x9E, 0x00, 0x1E, 0x7C,
  0x00, 0x0F, 0x3C, 0x00, 0x3E, 0xF0, 0x00, 0x1F, 0x78, 0x00, 0x3D, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x7E, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x07,
  0xC0, 0x00, 0xF8, 0x0F, 0x80, 0x03, 0xC0, 0x1F, 0x00, 0x1F, 0x00, 0x7C,
  0x00, 0xF8, 0x00, 0xF8, 0x03, 0xC0, 0x01, 0xF0, 0x1F, 0x00, 0x07, 0xC0,
  0xF8, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x1E, 0x1F, 0x00, 0x00, 0x7C, 0xF8,
  0x00, 0x00, 0xFB, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xCF, 0x80, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x03, 0xC0,
  0xF8, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0xF8, 0x07, 0xC0, 0x03, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0xF8,
  0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1F, 0x9F,
  0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0xFB, 0xE0,
  0x00, 0x07, 0xDF, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x3E, 0x0F, 0x80, 0x03, 0xE0, 0x3E, 0x00, 0x1F, 0x01, 0xF0, 0x01, 0xF0,
  0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x00, 0xF8, 0x07, 0xC0, 0x07,
  0xC0, 0x7C, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xE1,
  0xE0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x01, 0xEF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF8,
  0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x0E,
  0x78, 0x00, 0x07, 0x8F, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0xF0, 0x78, 0x00,
  0x3C, 0x1E, 0x00, 0x1E, 0x03, 0xC0, 0x07, 0x80, 0xF0, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x38, 0x00, 0xF0, 0x1E, 0x00, 0x3C, 0x07, 0x80,
  0x07, 0x83, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x78, 0x00, 0x0F, 0x1E,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFC, 0x0F, 0x81, 0xF8, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xE0, 0x1F, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F,
  0x1F, 0xE0, 0xE0, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x7F,
  0xF0, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0xC7, 0xFF, 0x8F, 0x9F, 0xC0, 0x1F,
  0x7E, 0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x0F, 0xDF, 0x00, 0x3F, 0xBE, 0x00, 0xFF, 0x7F,
  0x0F, 0xDE, 0x7F, 0xFF, 0x3C, 0x7F, 0xFC, 0x78, 0x7F, 0xF0, 0x70, 0x04,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x87, 0xFC, 0x07, 0xCF, 0xFF, 0x83, 0xEF, 0xFF,
  0xE1, 0xFF, 0xEF, 0xF8, 0xFF, 0x00, 0x7E, 0x7F, 0x00, 0x1F, 0x3F, 0x00,
  0x07, 0xDF, 0x80, 0x03, 0xEF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0x7E, 0x00, 0x0F,
  0xBF, 0x80, 0x0F, 0x9F, 0xE0, 0x0F, 0xCF, 0xFE, 0x1F, 0xC7, 0x9F, 0xFF,
  0xC3, 0xC7, 0xFF, 0xC1, 0xE0, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x3F, 0xFF, 0x0F, 0xFF, 0xF1, 0xFF, 0xFE, 0x3F, 0x80, 0x23,
  0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x03, 0x1F,
  0xF7, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x1F, 0xF0, 0xF8, 0x3F, 0xFE, 0x7C, 0x3F, 0xFF, 0xBE, 0x3F,
  0xCF, 0xFF, 0x3F, 0x00, 0x7F, 0x9F, 0x00, 0x1F, 0xDF, 0x00, 0x0F, 0xEF,
  0x80, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x3F, 0x7C, 0x00, 0x1F, 0xBE, 0x00, 0x0F, 0xDF, 0x80,
  0x0F, 0xE7, 0xE0, 0x0F, 0xF1, 0xFC, 0x3F, 0xF8, 0x7F, 0xFF, 0x7C, 0x1F,
  0xFF, 0x1E, 0x07, 0xFE, 0x0F, 0x00, 0x10, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xE7, 0xF8, 0x3F, 0x00, 0xFC,
  0x3E, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x78, 0x00, 0x1E,
  0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x80, 0x0C, 0x1F, 0xF0, 0xFC,
  0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x06, 0x00,
  0x00, 0x1F, 0x80, 0x1F, 0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0x04,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x01, 0xFF, 0xF1, 0xFF, 0xFE, 0x3F, 0xFF, 0xC7,
  0xFF, 0xF8, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x01,
  0xFF, 0x07, 0x83, 0xFF, 0xE3, 0xC3, 0xFF, 0xFB, 0xE3, 0xFF, 0xFF, 0xF3,
  0xF0, 0x0F, 0xF9, 0xF0, 0x01, 0xFD, 0xF0, 0x00, 0xFE, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xF7, 0xC0, 0x01, 0xFB, 0xE0, 0x00, 0xFD, 0xF8, 0x00, 0xFE, 0x7E,
  0x00, 0xFF, 0x1F, 0xC1, 0xFF, 0x87, 0xFF, 0xF7, 0xC1, 0xFF, 0xF3, 0xE0,
  0x7F, 0xE1, 0xF0, 0x01, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x88, 0x00, 0x0F,
  0x86, 0x00, 0x0F, 0xC3, 0xF8, 0x3F, 0xC1, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0x80, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x7F, 0xE0, 0xF9, 0xFF, 0xF8, 0xFB, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0x00, 0x7E, 0xFE, 0x00, 0x3E, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0x7F, 0xFF, 0xF7, 0x90, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x00, 0xF0,
  0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0xC7, 0xEF, 0xFE, 0xFF, 0xCF, 0xF8, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x07, 0xFF, 0x00, 0x1F, 0x3E,
  0x00, 0x7C, 0x7C, 0x01, 0xF0, 0xF8, 0x07, 0xC1, 0xF0, 0x1F, 0x03, 0xE0,
  0x7C, 0x07, 0xC1, 0xF8, 0x0F, 0x87, 0xE0, 0x1F, 0x1F, 0x80, 0x3E, 0x7E,
  0x00, 0x7C, 0xF8, 0x00, 0xFB, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xE0,
  0x07, 0xFF, 0xE0, 0x0F, 0xC7, 0xE0, 0x1F, 0x07, 0xC0, 0x3E, 0x07, 0xC0,
  0x7C, 0x0F, 0xC0, 0xF8, 0x0F, 0xC1, 0xF0, 0x0F, 0x83, 0xE0, 0x0F, 0x87,
  0xC0, 0x1F, 0x8F, 0x80, 0x1F, 0x9F, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x7C,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xC0, 0x3F, 0xF0, 0xF1, 0xFF, 0xF0, 0x7F,
  0xF8, 0xFB, 0xFF, 0xF9, 0xFF, 0xFC, 0xFF, 0xF7, 0xF9, 0xFF, 0xFE, 0xFF,
  0x00, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xFC, 0x00, 0x3F,
  0x00, 0x1F, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xFC, 0x00, 0x3E, 0x00, 0x0F,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xF0,
  0x7F, 0xE0, 0xF1, 0xFF, 0xF8, 0xFB, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0xFF,
  0x00, 0x7E, 0xFE, 0x00, 0x3E, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xDF, 0xF0,
  0x3F, 0x00, 0x7E, 0x0F, 0x80, 0x0F, 0xC7, 0xC0, 0x01, 0xF1, 0xF0, 0x00,
  0x3E, 0x78, 0x00, 0x0F, 0xBE, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7B, 0xE0,
  0x00, 0x1E, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xEF, 0x80, 0x00,
  0xF9, 0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0xC3, 0xE0,
  0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x1F, 0xE1, 0xFC, 0x03, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x7F,
  0xC0, 0x78, 0xFF, 0xF8, 0x3E, 0xFF, 0xFE, 0x1F, 0xFE, 0xFF, 0x8F, 0xF0,
  0x07, 0xE7, 0xF0, 0x01, 0xF3, 0xF0, 0x00, 0x7D, 0xF8, 0x00, 0x3E, 0xFC,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x01,
  0xFF, 0xC0, 0x01, 0xF7, 0xE0, 0x00, 0xFB, 0xF8, 0x00, 0xF9, 0xFE, 0x00,
  0xFC, 0xFF, 0xE3, 0xFC, 0x7D, 0xFF, 0xFC, 0x3E, 0x7F, 0xFC, 0x1F, 0x0F,
  0xFC, 0x0F, 0x80, 0x60, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0x07, 0x83, 0xFF, 0xE3, 0xC3, 0xFF, 0xFB,
  0xE3, 0xFC, 0xFF, 0xF3, 0xF0, 0x07, 0xF9, 0xF0, 0x01, 0xFD, 0xF0, 0x00,
  0xFE, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x03, 0xF7, 0xC0, 0x01, 0xFB, 0xE0, 0x00, 0xFD,
  0xF8, 0x00, 0xFE, 0x7E, 0x00, 0xFF, 0x1F, 0xC3, 0xFF, 0x87, 0xFF, 0xF7,
  0xC1, 0xFF, 0xF3, 0xE0, 0x7F, 0xE1, 0xF0, 0x01, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xF0, 0x3F, 0xF8, 0x7F,
  0xFC, 0x7F, 0xDF, 0x7F, 0xEF, 0xFC, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xFF, 0x01, 0xFF,
  0xFE, 0x7F, 0xFF, 0xE7, 0xF0, 0xFC, 0xF8, 0x00, 0xCF, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x07,
  0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1E, 0x00, 0x01, 0xEC, 0x00, 0x3E, 0xF8, 0x0F, 0xCF, 0xFF,
  0xFC, 0xFF, 0xFF, 0x07, 0xFF, 0xE0, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0xFF, 0xFD,
  0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0x83, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x86, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x04, 0x00,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0x7C, 0x00, 0x7F, 0x7E, 0x00, 0xFF,
  0x7F, 0x87, 0xFF, 0x3F, 0xFF, 0xCF, 0x1F, 0xFF, 0x8F, 0x07, 0xFE, 0x0F,
  0x00, 0x20, 0x00, 0xF8, 0x00, 0x07, 0xDE, 0x00, 0x01, 0xF7, 0xC0, 0x00,
  0x7D, 0xF0, 0x00, 0x3E, 0x3C, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xC3, 0xE0,
  0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x03, 0xC0, 0x0F, 0x80,
  0xF8, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x07, 0x80, 0x7C, 0x01, 0xF0, 0x1E,
  0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x03, 0xE0, 0x03, 0xE0, 0xF0, 0x00, 0x78,
  0x7C, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0xC7, 0x80, 0x00, 0xF3, 0xE0, 0x00,
  0x3C, 0xF0, 0x00, 0x0F, 0xBC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0xF0, 0x00, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xF8, 0x00,
  0xFB, 0xC0, 0x07, 0xF0, 0x01, 0xE7, 0x80, 0x0F, 0xE0, 0x07, 0xCF, 0x80,
  0x3D, 0xE0, 0x0F, 0x9F, 0x00, 0x7B, 0xC0, 0x1F, 0x1E, 0x00, 0xF7, 0x80,
  0x3C, 0x3C, 0x03, 0xCF, 0x80, 0xF8, 0x7C, 0x07, 0x8F, 0x01, 0xF0, 0xF8,
  0x0F, 0x1E, 0x03, 0xC0, 0xF0, 0x3E, 0x3C, 0x07, 0x81, 0xF0, 0x78, 0x7C,
  0x1F, 0x03, 0xE0, 0xF0, 0x78, 0x3E, 0x03, 0xC3, 0xE0, 0xF0, 0x78, 0x07,
  0x87, 0x81, 0xF0, 0xF0, 0x0F, 0x8F, 0x01, 0xE3, 0xE0, 0x1F, 0x1E, 0x03,
  0xC7, 0x80, 0x1E, 0x78, 0x07, 0xCF, 0x00, 0x3C, 0xF0, 0x07, 0x9E, 0x00,
  0x79, 0xE0, 0x0F, 0x7C, 0x00, 0xFB, 0x80, 0x1E, 0xF0, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x03, 0xF0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x0F, 0x9F, 0x80, 0x07, 0xC3, 0xE0, 0x03,
  0xE0, 0x7C, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3E, 0x00, 0x7C,
  0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x03, 0xE3, 0xE0, 0x00, 0x7C, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7D,
  0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x07, 0xC1, 0xF0, 0x01,
  0xF0, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x7C, 0x01, 0xF0, 0x3F, 0x00, 0x3E,
  0x0F, 0x80, 0x07, 0xC7, 0xC0, 0x01, 0xFB, 0xE0, 0x00, 0x3F, 0xF8, 0x00,
  0x07, 0xEF, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xC3,
  0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x1E, 0x07, 0x80, 0x07, 0xC0, 0xF8, 0x00,
  0xF8, 0x1F, 0x00, 0x1E, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x03,
  0xC0, 0x3E, 0x00, 0x7C, 0x07, 0xC0, 0x0F, 0x80, 0xF0, 0x00, 0xF0, 0x3E,
  0x00, 0x1F, 0x07, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x07,
  0xC7, 0xC0, 0x00, 0x78, 0xF0, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0xF7, 0x80,
  0x00, 0x1E, 0xF0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x08,
  0x7F, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x07, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x1F, 0x80, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x03, 0xFC, 0x07, 0xF8, 0x03, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF8, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x07, 0xF0, 0x00, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xF0, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x1F, 0x80,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x03, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x1F,
  0x00, 0x7F, 0x01, 0xFE, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x1F, 0x80,
  0xFF, 0x80, 0xFF, 0x00, 0xFE, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0x7F,
  0xF0, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0,
  0x1F, 0xFE, 0x80, 0x03, 0xF8,
};

const GFXglyph NotoSans_Regular52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 6, 38, 14, 4, -37 },
  { 30, 15, 13, 21, 3, -37 },
  { 55, 31, 37, 34, 1, -37 },
  { 199, 24, 42, 30, 3, -39 },
  { 325, 38, 39, 43, 3, -38 },
  { 511, 35, 39, 38, 3, -38 },
  { 682, 5, 13, 12, 3, -37 },
  { 691, 12, 45, 16, 2, -37 },
  { 759, 12, 45, 16, 2, -37 },
  { 827, 24, 24, 29, 2, -40 },
  { 899, 24, 25, 30, 3, -31 },
  { 974, 8, 13, 14, 2, -6 },
  { 987, 13, 4, 17, 2, -16 },
  { 994, 6, 7, 14, 4, -6 },
  { 1000, 18, 37, 19, 1, -37 },
  { 1084, 24, 39, 30, 3, -38 },
  { 1201, 13, 37, 30, 5, -37 },
  { 1262, 25, 38, 30, 2, -38 },
  { 1381, 25, 39, 30, 2, -38 },
  { 1503, 28, 37, 30, 1, -37 },
  { 1633, 24, 38, 30, 3, -37 },
  { 1747, 24, 39, 30, 3, -38 },
  { 1864, 25, 37, 30, 2, -37 },
  { 1980, 24, 39, 30, 3, -38 },
  { 2097, 24, 39, 30, 3, -38 },
  { 2214, 6, 30, 14, 4, -29 },
  { 2237, 8, 36, 14, 2, -29 },
  { 2273, 24, 26, 30, 3, -32 },
  { 2351, 24, 14, 30, 3, -25 },
  { 2393, 24, 26, 30, 3, -32 },
  { 2471, 20, 39, 23, 1, -38 },
  { 2569, 41, 42, 47, 3, -37 },
  { 2785, 33, 37, 33, 0, -37 },
  { 2938, 26, 37, 34, 5, -37 },
  { 3059, 28, 39, 33, 3, -38 },
  { 3196, 30, 37, 38, 5, -37 },
  { 3335, 21, 37, 29, 5, -37 },
  { 3433, 21, 37, 27, 5, -37 },
  { 3531, 31, 39, 38, 3, -38 },
  { 3683, 28, 37, 39, 5, -37 },
  { 3813, 14, 37, 18, 2, -37 },
  { 3878, 13, 47, 14, -4, -37 },
  { 3955, 27, 37, 32, 5, -37 },
  { 4080, 21, 37, 27, 5, -37 },
  { 4178, 37, 37, 47, 5, -37 },
  { 4350, 29, 37, 40, 5, -37 },
  { 4485, 34, 39, 41, 3, -38 },
  { 4651, 24, 37, 31, 5, -37 },
  { 4762, 34, 47, 41, 3, -38 },
  { 4962, 27, 37, 32, 5, -37 },
  { 5087, 23, 39, 29, 3, -38 },
  { 5200, 27, 37, 29, 1, -37 },
  { 5325, 28, 38, 38, 5, -37 },
  { 5458, 31, 37, 31, 0, -37 },
  { 5602, 47, 37, 48, 1, -37 },
  { 5820, 30, 37, 30, 0, -37 },
  { 5959, 29, 37, 29, 0, -37 },
  { 6094, 26, 37, 30, 2, -37 },
  { 6215, 12, 45, 17, 4, -37 },
  { 6283, 18, 37, 19, 1, -37 },
  { 6367, 12, 45, 17, 1, -37 },
  { 6435, 26, 23, 30, 2, -37 },
  { 6510, 23, 3, 23, 0, 5 },
  { 6519, 11, 8, 15, 2, -40 },
  { 6530, 23, 29, 29, 2, -28 },
  { 6614, 25, 41, 32, 4, -40 },
  { 6743, 20, 29, 25, 3, -28 },
  { 6816, 25, 41, 32, 3, -40 },
  { 6945, 24, 29, 29, 3, -28 },
  { 7032, 19, 40, 18, 1, -40 },
  { 7127, 25, 40, 32, 3, -28 },
  { 7252, 24, 40, 32, 4, -40 },
  { 7372, 5, 38, 13, 4, -38 },
  { 7396, 12, 50, 13, -3, -38 },
  { 7471, 23, 40, 28, 4, -40 },
  { 7586, 5, 40, 13, 4, -40 },
  { 7611, 40, 28, 49, 4, -28 },
  { 7751, 24, 28, 32, 4, -28 },
  { 7835, 26, 29, 31, 3, -28 },
  { 7930, 25, 40, 32, 4, -28 },
  { 8055, 25, 40, 32, 3, -28 },
  { 8180, 17, 28, 21, 4, -28 },
  { 8240, 20, 29, 25, 3, -28 },
  { 8313, 17, 35, 19, 1, -34 },
  { 8388, 24, 29, 32, 4, -28 },
  { 8475, 26, 28, 26, 0, -28 },
  { 8566, 39, 28, 41, 1, -28 },
  { 8703, 26, 28, 28, 1, -28 },
  { 8794, 27, 40, 27, 0, -28 },
  { 8929, 20, 28, 24, 2, -28 },
  { 8999, 17, 45, 20, 1, -37 },
  { 9095, 4, 53, 29, 12, -40 },
  { 9122, 16, 45, 20, 2, -37 },
  { 9212, 24, 7, 30, 3, -22 },
};

const GFXfont NotoSans_Regular52pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Regular52pt7bBitmaps,
  (GFXglyph *)NotoSans_Regular52pt7bGlyphs,
  0x20, 0x7E, 71
};

#endif // _NOTOSANS_REGULAR52PT7B_H_
