#ifndef _NOTOSANS_REGULAR64PT7B_H_
#define _NOTOSANS_REGULAR64PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Regular.ttf
// Size: 64pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Regular64pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C,
  0x7C, 0x7C, 0x7C, 0x7C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x38, 0xFE, 0xFE, 0xFE, 0xFF, 0xFE, 0xFE, 0xFE, 0x38,
  0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xDF,
  0x03, 0xF7, 0xC0, 0xF9, 0xF0, 0x3E, 0x7C, 0x07, 0x9F, 0x01, 0xE7, 0x80,
  0x79, 0xE0, 0x1E, 0x78, 0x07, 0x9E, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x1E,
  0x78, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x00, 0x78, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0xF0, 0x00, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x3C, 0x00, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x07, 0xC0, 0x00,
  0x03, 0xC0, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x01,
  0xE0, 0x00, 0x01, 0xF0, 0x07, 0x80, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x00, 0x3C,
  0x01, 0xF0, 0x00, 0x00, 0xF0, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0xFF, 0x1E,
  0x1F, 0x87, 0xE0, 0xF0, 0x0C, 0x7E, 0x07, 0x80, 0x03, 0xF0, 0x3C, 0x00,
  0x1F, 0x81, 0xE0, 0x00, 0xF8, 0x0F, 0x00, 0x07, 0xE0, 0x78, 0x00, 0x3F,
  0x03, 0xC0, 0x01, 0xF8, 0x1E, 0x00, 0x07, 0xF0, 0xF0, 0x00, 0x3F, 0xE7,
  0x80, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x07, 0xBF, 0xF0, 0x00, 0x3C, 0x3F, 0xC0, 0x01,
  0xE0, 0x7E, 0x00, 0x0F, 0x01, 0xF8, 0x00, 0x78, 0x0F, 0xC0, 0x03, 0xC0,
  0x7E, 0x00, 0x1E, 0x03, 0xF0, 0x00, 0xF0, 0x1F, 0x80, 0x07, 0x80, 0xFE,
  0x00, 0x3C, 0x0F, 0xDC, 0x01, 0xE0, 0xFE, 0xFF, 0x0F, 0x7F, 0xE7, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xF0,
  0x01, 0xFF, 0xFC, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x3C, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0x78, 0x03, 0xE0, 0x07, 0xC0, 0x01,
  0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x7C, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x7C,
  0x01, 0xF0, 0x3E, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x7C, 0x00, 0x01, 0xF0,
  0x07, 0xC1, 0xF0, 0x00, 0x03, 0xE0, 0x0F, 0x83, 0xE0, 0xFE, 0x03, 0xC0,
  0x1F, 0x0F, 0x87, 0xFF, 0x07, 0xC0, 0x3C, 0x1F, 0x1F, 0xFF, 0x0F, 0x80,
  0xF8, 0x7C, 0x7F, 0xFE, 0x1F, 0x01, 0xF1, 0xF0, 0xFC, 0x7E, 0x1F, 0x07,
  0xC3, 0xE3, 0xE0, 0x7E, 0x1F, 0xFF, 0x8F, 0x87, 0xC0, 0x7C, 0x3F, 0xFE,
  0x1F, 0x0F, 0x80, 0x78, 0x3F, 0xF8, 0x7C, 0x1E, 0x00, 0xF0, 0x1F, 0xE0,
  0xF8, 0x7C, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0x00, 0x07,
  0xC1, 0xF0, 0x07, 0xC0, 0x00, 0x1F, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x7C,
  0x07, 0xC0, 0x1F, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x3E, 0x00, 0x03, 0xE0,
  0x1F, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0xF0, 0x07, 0xC0, 0x01, 0xF0, 0x01, 0xE0, 0x0F, 0x00, 0x07, 0xC0, 0x03,
  0xE0, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x3E, 0x00, 0x07,
  0xC1, 0xF0, 0x00, 0xF8, 0x00, 0x0F, 0xEF, 0xE0, 0x01, 0xF0, 0x00, 0x0F,
  0xFF, 0x80, 0x07, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xCF, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xF8, 0x07, 0xFB, 0xFC, 0x00,
  0x1F, 0x80, 0xFF, 0x1F, 0xE0, 0x01, 0xF0, 0x1F, 0xC0, 0xFF, 0x00, 0x3F,
  0x03, 0xF8, 0x07, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0xC0, 0x3E, 0x07,
  0xE0, 0x01, 0xFE, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xF0, 0x7C, 0x07, 0xE0,
  0x00, 0x7F, 0x8F, 0xC0, 0xFC, 0x00, 0x03, 0xFD, 0xFC, 0x0F, 0xC0, 0x00,
  0x1F, 0xFF, 0x80, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x0F, 0xC0, 0x00, 0x07,
  0xFF, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0xE0, 0x07, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0xF0, 0x07, 0xF8, 0x00, 0x0F, 0xFF, 0x80,
  0x3F, 0xC0, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0x87, 0xFF, 0x9F, 0xE0, 0x1F,
  0xFF, 0xFF, 0xF0, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xF8, 0x03, 0xFF,
  0xFF, 0x80, 0x1F, 0xC0, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFD, 0xF7, 0xDF, 0x7D, 0xF7, 0x9E,
  0x79, 0xE7, 0x9E, 0x78, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xC0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7C,
  0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x03,
  0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x01,
  0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F,
  0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0,
  0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x1F,
  0x80, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x03, 0x00, 0x3E, 0x00, 0x6F, 0x80, 0xF8, 0x0F, 0xBF, 0xE1, 0xC3, 0xFE,
  0xFF, 0xF7, 0x7F, 0xFB, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xC1, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xDF, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x07, 0xE3,
  0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xF0, 0x3F,
  0x00, 0x3F, 0x80, 0xFE, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0xF0, 0x07, 0x80,
  0x00, 0xC0, 0x08, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x8F, 0xCF, 0xE7, 0xE3, 0xF1, 0xF8, 0xF8, 0xFC, 0x7E, 0x3E,
  0x1F, 0x0F, 0x0F, 0x87, 0xC3, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x38, 0xFE, 0xFE, 0xFE, 0xFF, 0xFE, 0xFE, 0xFE,
  0x38, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFC, 0xFF, 0xC0, 0x3F, 0x80, 0x7F, 0x81, 0xFC, 0x00, 0x7E, 0x07, 0xE0,
  0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xC3, 0xE0, 0x00,
  0x1F, 0x9F, 0x80, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x03,
  0xF7, 0xC0, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03,
  0xF7, 0xC0, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0xFD,
  0xF8, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x7E, 0x3F,
  0x00, 0x01, 0xF8, 0xFC, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x07, 0xE0,
  0x01, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0xFF, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0,
  0x1F, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFE, 0x3F, 0xBF, 0x7F, 0x9F,
  0xFF, 0x8F, 0xFF, 0x87, 0xEF, 0x03, 0xF3, 0x01, 0xF9, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFD,
  0xFF, 0xC1, 0xFE, 0x00, 0x7F, 0x83, 0xE0, 0x00, 0xFE, 0x06, 0x00, 0x01,
  0xFC, 0x10, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFD, 0xFF, 0xE1, 0xFC, 0x00, 0x7F, 0x83, 0xC0,
  0x00, 0x7F, 0x0C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0xA0, 0x00, 0x01, 0xFC, 0xF0, 0x00, 0x0F, 0xF3, 0xFC, 0x01,
  0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x07, 0xDF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFB, 0xF0, 0x00,
  0x00, 0x7E, 0xFC, 0x00, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0x0F, 0x8F, 0xC0,
  0x00, 0x07, 0xE3, 0xF0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0xF8, 0x3F,
  0x00, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x0F, 0x80,
  0xFC, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0xF8,
  0x03, 0xF0, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xF0, 0x03, 0xE0, 0x00, 0xFC, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x03, 0xF0,
  0x1F, 0x80, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x3F, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xBF, 0xF8, 0x00, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0x01, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x90, 0x00,
  0x01, 0xFC, 0xF0, 0x00, 0x3F, 0xC7, 0xF8, 0x07, 0xFC, 0x3F, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0xC0, 0x1F,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x0E, 0x00, 0x0F,
  0xC3, 0xFF, 0xC0, 0x3E, 0x1F, 0xFF, 0xC0, 0xF9, 0xFF, 0xFF, 0x83, 0xEF,
  0xFF, 0xFF, 0x0F, 0xBE, 0x01, 0xFE, 0x3F, 0xE0, 0x01, 0xFC, 0xFF, 0x00,
  0x03, 0xF3, 0xF8, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x1F, 0xBF, 0x00, 0x00,
  0x3E, 0xF8, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xEF,
  0xC0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x01, 0xF9, 0xF8,
  0x00, 0x07, 0xE3, 0xF0, 0x00, 0x3F, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0,
  0x0F, 0xE0, 0x3F, 0xC0, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xF8, 0x7F,
  0xE0, 0x7F, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x7E,
  0x3E, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x1F, 0x8F,
  0x80, 0x00, 0x7E, 0x3E, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x07, 0xE3, 0xF0,
  0x00, 0x3F, 0x07, 0xE0, 0x00, 0xFC, 0x1F, 0xC0, 0x07, 0xE0, 0x3F, 0x80,
  0x3F, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0xFF, 0xBF, 0xC0, 0x01, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xC1, 0xFF, 0x01, 0xFC, 0x01, 0xFE, 0x0F,
  0xE0, 0x01, 0xFC, 0x3F, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x7E,
  0x3F, 0x80, 0x03, 0xF8, 0xFF, 0x80, 0x3F, 0xC1, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFC, 0xFF, 0xC0, 0x7F, 0x00,
  0x7F, 0x03, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0xFC, 0x7E, 0x00, 0x03,
  0xF1, 0xF8, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x3E,
  0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x0F, 0xDF, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x01, 0xFD, 0xFC, 0x00,
  0x0F, 0xF3, 0xF0, 0x00, 0x7F, 0xCF, 0xF0, 0x07, 0xFF, 0x1F, 0xFF, 0xFF,
  0x7C, 0x3F, 0xFF, 0xFB, 0xF0, 0x7F, 0xFF, 0x8F, 0xC0, 0x7F, 0xFC, 0x3F,
  0x00, 0x3F, 0x80, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x20, 0x0F, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x7C, 0xFE, 0xFE, 0xFF, 0xFF, 0xFE, 0xFE, 0x7C, 0x10, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x38, 0xFE, 0xFE, 0xFE, 0xFF, 0xFE, 0xFE, 0xFE, 0x38,
  0x0F, 0x87, 0xF1, 0xFC, 0xFF, 0x3F, 0xC7, 0xF1, 0xFC, 0x3E, 0x02, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xC7, 0xE1, 0xF8, 0x7E, 0x3F, 0x0F, 0xC3, 0xF0, 0xF8, 0x3E, 0x1F, 0x87,
  0xC1, 0xF0, 0x78, 0x3E, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE3,
  0xE0, 0x03, 0xF9, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xFF,
  0xE0, 0x07, 0xC1, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0xF0, 0xF8, 0x00, 0xFF,
  0xFF, 0xC0, 0x3E, 0x3E, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0x9F, 0x00, 0x3F,
  0x00, 0x7C, 0x01, 0xE7, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x79, 0xE0, 0x0F,
  0xC0, 0x07, 0xC0, 0x1F, 0x78, 0x03, 0xE0, 0x01, 0xF0, 0x07, 0xFE, 0x01,
  0xF8, 0x00, 0x7C, 0x01, 0xFF, 0x80, 0x7C, 0x00, 0x1E, 0x00, 0x7F, 0xE0,
  0x1F, 0x00, 0x07, 0x80, 0x1F, 0xF0, 0x07, 0xC0, 0x01, 0xE0, 0x07, 0xFC,
  0x01, 0xF0, 0x00, 0xF8, 0x01, 0xFF, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x7F,
  0xC0, 0x1F, 0x00, 0x0F, 0x80, 0x1E, 0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x07,
  0xBC, 0x01, 0xF0, 0x00, 0xF8, 0x03, 0xEF, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0xFB, 0xC0, 0x1F, 0x00, 0x1F, 0x80, 0x3C, 0xF8, 0x07, 0xE0, 0x07, 0xF0,
  0x1F, 0x3E, 0x00, 0xF8, 0x03, 0xFC, 0x0F, 0x8F, 0x80, 0x3F, 0x83, 0xEF,
  0x87, 0xE1, 0xE0, 0x07, 0xFF, 0xF1, 0xFF, 0xF0, 0x7C, 0x00, 0xFF, 0xF8,
  0x7F, 0xF8, 0x1F, 0x00, 0x1F, 0xFC, 0x0F, 0xFC, 0x07, 0xE0, 0x01, 0xFC,
  0x00, 0xFC, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x00, 0x01,
  0xF3, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x7C,
  0x00, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00,
  0x00, 0x3F, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x1F,
  0x00, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00,
  0x01, 0xF0, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0xF8,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0x01,
  0xF8, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x00, 0x07, 0xE7, 0xC0, 0x00,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x00, 0x7F, 0xF8, 0xFC, 0x00, 0x07, 0xFC,
  0xFC, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0xFC,
  0xFC, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E,
  0xFC, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0xFC,
  0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03, 0xF0,
  0xFC, 0x00, 0x7F, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFC, 0x00, 0x07, 0xFC, 0xFC, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x00, 0xFE,
  0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x01, 0xFE,
  0xFC, 0x00, 0x07, 0xFC, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xE0,
  0x07, 0xE0, 0x7F, 0xC0, 0x00, 0x38, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x03, 0x80, 0xFF, 0xFC, 0x3F, 0xE0, 0x1F,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x7E, 0x00, 0x7F, 0xFE, 0x03,
  0xF0, 0x00, 0x1F, 0xF8, 0x1F, 0x80, 0x00, 0x3F, 0xE0, 0xFC, 0x00, 0x00,
  0x7F, 0x87, 0xE0, 0x00, 0x01, 0xFE, 0x3F, 0x00, 0x00, 0x07, 0xF1, 0xF8,
  0x00, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0x03,
  0xF3, 0xF0, 0x00, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x00, 0x7E, 0xFC, 0x00,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x7E, 0x00,
  0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x00, 0xFE,
  0xFC, 0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0x7F, 0x3F, 0x00, 0x00,
  0x03, 0xF9, 0xF8, 0x00, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0x03, 0xF8, 0x7E,
  0x00, 0x00, 0x3F, 0xC3, 0xF0, 0x00, 0x07, 0xFC, 0x1F, 0x80, 0x00, 0xFF,
  0xC0, 0xFC, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xBF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFB, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x0F, 0xC0, 0x3F, 0xE0,
  0x00, 0x06, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x00,
  0x3F, 0x7F, 0x00, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x00, 0x03, 0xF3, 0xF8,
  0x00, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x00,
  0xFC, 0x7F, 0x80, 0x00, 0x03, 0xF0, 0xFF, 0x00, 0x00, 0x0F, 0xC1, 0xFF,
  0x00, 0x00, 0x3F, 0x03, 0xFF, 0x00, 0x00, 0xFC, 0x07, 0xFF, 0xC1, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xF0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE8, 0x0F, 0xE7,
  0xFF, 0xF3, 0xFF, 0xF1, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0xC0, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x0F, 0xE3,
  0xF0, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x00, 0xFC,
  0x0F, 0xC0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x3F, 0x00, 0x0F, 0xE0, 0x0F, 0xC0, 0x07, 0xF0, 0x03, 0xF0, 0x03,
  0xF8, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x0F, 0xC0,
  0x7F, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x3F,
  0x07, 0xE0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x00,
  0xFC, 0xFE, 0x00, 0x00, 0x3F, 0x7F, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xDF, 0xC0, 0x00, 0x3F, 0xE3, 0xF8,
  0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0xFC, 0x03,
  0xF8, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x1F, 0xC0, 0x03, 0xF0,
  0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x0F,
  0xC0, 0x03, 0xF8, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x0F, 0xE0,
  0x3F, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x0F,
  0xE0, 0xFC, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x00, 0x7F, 0x0F, 0xC0, 0x00,
  0x0F, 0xE3, 0xF0, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x00, 0x3F, 0xBF, 0x00,
  0x00, 0x0F, 0xF0, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xBE, 0x00, 0x00, 0x01,
  0xF7, 0xFE, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFB, 0xF0, 0x00, 0x00, 0x3E,
  0xFF, 0xE7, 0xC0, 0x00, 0x00, 0xFB, 0xFF, 0x9F, 0x80, 0x00, 0x07, 0xEF,
  0xFE, 0x7E, 0x00, 0x00, 0x1F, 0x3F, 0xF8, 0xF8, 0x00, 0x00, 0x7C, 0xFF,
  0xE3, 0xF0, 0x00, 0x03, 0xE3, 0xFF, 0x87, 0xC0, 0x00, 0x0F, 0x8F, 0xFE,
  0x1F, 0x00, 0x00, 0x3E, 0x3F, 0xFC, 0x7E, 0x00, 0x01, 0xF0, 0xFF, 0xF0,
  0xF8, 0x00, 0x07, 0xC3, 0xFF, 0xC3, 0xF0, 0x00, 0x3F, 0x0F, 0xFF, 0x0F,
  0xC0, 0x00, 0xF8, 0x3F, 0xFC, 0x1F, 0x00, 0x03, 0xE0, 0xFF, 0xF0, 0x7E,
  0x00, 0x1F, 0x03, 0xFF, 0xC0, 0xF8, 0x00, 0x7C, 0x0F, 0xFF, 0x03, 0xE0,
  0x03, 0xF0, 0x3F, 0xFC, 0x0F, 0xC0, 0x0F, 0x80, 0xFF, 0xF0, 0x1F, 0x00,
  0x3E, 0x03, 0xFF, 0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0xFF, 0x01, 0xF8, 0x07,
  0xC0, 0x3F, 0xFC, 0x03, 0xE0, 0x1F, 0x00, 0xFF, 0xF0, 0x0F, 0xC0, 0xF8,
  0x03, 0xFF, 0xC0, 0x1F, 0x03, 0xE0, 0x0F, 0xFF, 0x00, 0x7C, 0x1F, 0x80,
  0x3F, 0xFC, 0x01, 0xF8, 0x7C, 0x00, 0xFF, 0xF0, 0x03, 0xE1, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xCF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0x3E, 0x00, 0x3F,
  0xFC, 0x00, 0x7C, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x03, 0xFF,
  0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0xC0,
  0x01, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFB, 0xF0,
  0x00, 0x01, 0xFF, 0xBF, 0x80, 0x00, 0x1F, 0xF9, 0xF8, 0x00, 0x01, 0xFF,
  0x9F, 0xC0, 0x00, 0x1F, 0xF8, 0xFE, 0x00, 0x01, 0xFF, 0x87, 0xE0, 0x00,
  0x1F, 0xF8, 0x7F, 0x00, 0x01, 0xFF, 0x83, 0xF8, 0x00, 0x1F, 0xF8, 0x1F,
  0x80, 0x01, 0xFF, 0x81, 0xFC, 0x00, 0x1F, 0xF8, 0x0F, 0xE0, 0x01, 0xFF,
  0xC0, 0x7E, 0x00, 0x1F, 0xFC, 0x07, 0xF0, 0x01, 0xFF, 0xC0, 0x3F, 0x80,
  0x1F, 0xFC, 0x01, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xC0, 0x1F, 0xFC, 0x00,
  0xFC, 0x01, 0xFF, 0xC0, 0x07, 0xE0, 0x1F, 0xFC, 0x00, 0x7F, 0x01, 0xFF,
  0xC0, 0x03, 0xF0, 0x1F, 0xFC, 0x00, 0x3F, 0x81, 0xFF, 0xC0, 0x01, 0xFC,
  0x1F, 0xFC, 0x00, 0x0F, 0xC1, 0xFF, 0xC0, 0x00, 0xFE, 0x1F, 0xFC, 0x00,
  0x07, 0xF1, 0xFF, 0xC0, 0x00, 0x3F, 0x1F, 0xFC, 0x00, 0x03, 0xF9, 0xFF,
  0xC0, 0x00, 0x1F, 0xDF, 0xFC, 0x00, 0x00, 0xFD, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x00, 0xFE,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x00,
  0x7E, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xF7, 0xE0, 0x00, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x00,
  0x7E, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x1F, 0x80,
  0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x07, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0xF8, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFC, 0x7E, 0x00, 0xFF, 0xF3, 0xF0, 0x00, 0x7F, 0xDF, 0x80, 0x00,
  0xFE, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7F,
  0x7E, 0x00, 0x07, 0xF3, 0xF0, 0x01, 0xFF, 0x9F, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x80, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x83,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x7F, 0x00,
  0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x00,
  0x01, 0xF9, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xBF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x00,
  0x01, 0xF9, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x00, 0x1F,
  0x9F, 0xC0, 0x00, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x00, 0x1F,
  0xE0, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xF8, 0x3F, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFC, 0x07, 0xE0, 0x07, 0xFF, 0x03, 0xF0, 0x00, 0x3F, 0xC1,
  0xF8, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x00, 0xFC,
  0x3F, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x1F,
  0x87, 0xE0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x03,
  0xF0, 0xFC, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00,
  0xFE, 0x1F, 0x80, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0xFE, 0x07, 0xE0, 0x01,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0x80,
  0x3F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF0,
  0x01, 0xF8, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x7E,
  0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x0F,
  0xC0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0xFE,
  0x3F, 0x00, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x07,
  0xF7, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x1F,
  0xF0, 0x03, 0xF0, 0xFE, 0x00, 0x01, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xD8, 0x00, 0x00, 0xFE, 0xF8, 0x00, 0x1F, 0xE7, 0xFF, 0x0F,
  0xFF, 0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0x7E, 0x00, 0x00,
  0x07, 0xE7, 0xE0, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x00, 0x3F, 0x0F, 0xC0,
  0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0xFF, 0x01,
  0xFF, 0xE3, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xF7,
  0xE0, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0xFC, 0x00, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0xFC, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x7E, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x00, 0x0F,
  0x87, 0xE0, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0xFC, 0x00,
  0x00, 0x01, 0xF3, 0xF0, 0x00, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x00, 0x1F,
  0xBE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xF9, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x7E, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xC7, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xDF,
  0x00, 0x00, 0xFC, 0x3F, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3F, 0x0F, 0xC0,
  0x00, 0x7D, 0xF0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x1F, 0x7E, 0x00, 0x07,
  0xE0, 0x7E, 0x00, 0x0F, 0xCF, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xE3,
  0xE0, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0xF8, 0xFC, 0x00, 0x3F, 0x00, 0xF8,
  0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x1F, 0x87, 0xC0, 0x03,
  0xF0, 0x0F, 0xC0, 0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x03, 0xF0, 0x01, 0xF0,
  0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x0F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x3E, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0x80, 0xFC, 0x01,
  0xF0, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x00, 0x3E, 0x01, 0xF8,
  0x07, 0xC0, 0x3F, 0x00, 0x0F, 0xC0, 0x7C, 0x01, 0xF8, 0x0F, 0xC0, 0x03,
  0xF0, 0x3F, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0x81,
  0xF8, 0x00, 0x1F, 0x03, 0xE0, 0x03, 0xE0, 0x7E, 0x00, 0x07, 0xE0, 0xF8,
  0x00, 0xFC, 0x1F, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x07, 0xC0, 0x00,
  0x3E, 0x1F, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF8,
  0xFC, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x7E, 0x3E, 0x00, 0x00, 0xFC, 0xFC,
  0x00, 0x0F, 0x8F, 0x80, 0x00, 0x1F, 0x3E, 0x00, 0x03, 0xE7, 0xE0, 0x00,
  0x07, 0xCF, 0x80, 0x00, 0xFD, 0xF8, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x1F,
  0x7C, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xF7, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x00, 0x3F,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0x01, 0xF8, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x3F, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0xFC, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0xF8, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x00, 0x7E,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x00, 0x1F, 0xBF, 0x00,
  0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x00, 0xFC,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x7E, 0x03, 0xF8, 0x00,
  0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x01,
  0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x1F,
  0x80, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x1F,
  0xC0, 0xFC, 0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x7E, 0x00,
  0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x01, 0xFC,
  0xFC, 0x00, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00,
  0x07, 0xE3, 0xF0, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x03, 0xF0,
  0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x07, 0xF0, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x1F, 0x80, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x3F, 0x00,
  0x00, 0x7E, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x3F, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x01,
  0xF9, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x3E,
  0xF8, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3C, 0x7C, 0x00, 0x00, 0x7C,
  0x3E, 0x00, 0x00, 0x78, 0x3E, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xF0,
  0x1F, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x01, 0xE0, 0x0F, 0x80, 0x03, 0xE0,
  0x07, 0xC0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x07, 0xC0,
  0x03, 0xE0, 0x0F, 0x80, 0x01, 0xF0, 0x0F, 0x80, 0x01, 0xF0, 0x1F, 0x00,
  0x00, 0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x7C, 0x3E, 0x00,
  0x00, 0x7C, 0x3E, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x0F, 0xE0, 0x7F, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xC0, 0x7C, 0x01, 0xFE, 0x06, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F,
  0xF0, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0x03, 0xF3, 0xFC, 0x00, 0x3F, 0x7F, 0x00, 0x03, 0xF7, 0xE0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00,
  0x1F, 0xF7, 0xE0, 0x03, 0xFF, 0x7F, 0x80, 0xFD, 0xF3, 0xFF, 0xFF, 0x9F,
  0x3F, 0xFF, 0xF1, 0xF1, 0xFF, 0xFE, 0x1F, 0x07, 0xFF, 0x80, 0xF0, 0x0F,
  0x80, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x01, 0xFC, 0x00,
  0x7E, 0x1F, 0xFF, 0x00, 0xFC, 0x7F, 0xFF, 0x81, 0xF9, 0xFF, 0xFF, 0x83,
  0xF7, 0xFF, 0xFF, 0x87, 0xFF, 0x00, 0x7F, 0x8F, 0xFC, 0x00, 0x7F, 0x1F,
  0xE0, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x7E, 0xFE,
  0x00, 0x00, 0xFD, 0xFC, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x01, 0xF7, 0xE0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x3F, 0x7F, 0x00, 0x00,
  0x7E, 0xFF, 0x00, 0x01, 0xFD, 0xFE, 0x00, 0x03, 0xF3, 0xFE, 0x00, 0x0F,
  0xE7, 0xFE, 0x00, 0x3F, 0x8F, 0xFF, 0x01, 0xFF, 0x1F, 0x3F, 0xFF, 0xFC,
  0x3E, 0x3F, 0xFF, 0xF0, 0x7C, 0x3F, 0xFF, 0x80, 0xF8, 0x1F, 0xFE, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0x80, 0xF0, 0xFF,
  0x00, 0x08, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x18, 0x7F, 0xE0, 0x7C, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x01, 0x70, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x03, 0xFC, 0x0F, 0xC0, 0x7F, 0xFC, 0x3F, 0x03, 0xFF, 0xFC,
  0xFC, 0x3F, 0xFF, 0xF9, 0xF1, 0xFF, 0xFF, 0xF7, 0xC7, 0xF8, 0x07, 0xFF,
  0x3F, 0x80, 0x07, 0xFD, 0xFC, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x3F, 0xDF,
  0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x7F, 0x7E, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x0F, 0xF3, 0xF0,
  0x00, 0x3F, 0xCF, 0xE0, 0x01, 0xFF, 0x1F, 0xE0, 0x3F, 0x7C, 0x3F, 0xFF,
  0xF9, 0xF0, 0x7F, 0xFF, 0xC7, 0xC0, 0xFF, 0xFE, 0x1F, 0x00, 0xFF, 0xE0,
  0x7C, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x0F,
  0xF0, 0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0xFC, 0x7E, 0x00,
  0x03, 0xF3, 0xF0, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x03,
  0xEF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0x0F, 0xF0, 0x00, 0x30, 0x7F, 0xE0, 0x1F, 0x81, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x7F,
  0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x01, 0xFC, 0x02, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF0, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xFF, 0xC1, 0xF0, 0x3F, 0xFF, 0xC7, 0xC3, 0xFF, 0xFF, 0x9F, 0x0F, 0xFF,
  0xFF, 0x7C, 0x7F, 0x80, 0x7F, 0xF3, 0xF8, 0x00, 0x7F, 0xCF, 0xC0, 0x00,
  0xFF, 0x7E, 0x00, 0x03, 0xFD, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x1F,
  0xDF, 0xC0, 0x00, 0x7F, 0x3F, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x1F, 0xF1,
  0xFE, 0x01, 0xF7, 0xC3, 0xFF, 0xFF, 0xBF, 0x07, 0xFF, 0xFE, 0xFC, 0x0F,
  0xFF, 0xE3, 0xF0, 0x0F, 0xFF, 0x0F, 0xC0, 0x03, 0x80, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x88, 0x00, 0x01, 0xFC, 0x3C, 0x00, 0x0F, 0xF0, 0xFF, 0x81, 0xFF, 0x83,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0x83, 0xFF,
  0xE0, 0xFC, 0x7F, 0xFF, 0x87, 0xE7, 0xFF, 0xFF, 0x3F, 0x7F, 0xFF, 0xF9,
  0xFF, 0xE0, 0x1F, 0xEF, 0xFC, 0x00, 0x3F, 0x7F, 0xC0, 0x01, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0xF8, 0x79, 0xFB, 0xFF, 0xFF, 0xDF, 0x9E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB,
  0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E,
  0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x00, 0x00, 0x3C, 0x00, 0x7E, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0xFC, 0xE3, 0xFC, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xC0, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x5F, 0x80, 0x01, 0xFC, 0xFC, 0x00, 0x1F,
  0xC7, 0xE0, 0x01, 0xFC, 0x3F, 0x00, 0x1F, 0xC1, 0xF8, 0x01, 0xFC, 0x0F,
  0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80,
  0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0,
  0x01, 0xF8, 0xFE, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x7E, 0xFE, 0x00, 0x03,
  0xF7, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFD,
  0xFC, 0x00, 0x3F, 0xC7, 0xF0, 0x01, 0xFC, 0x1F, 0x80, 0x0F, 0xC0, 0x7E,
  0x00, 0x7E, 0x03, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00,
  0xFC, 0x01, 0xFC, 0x07, 0xE0, 0x07, 0xF0, 0x3F, 0x00, 0x1F, 0xC1, 0xF8,
  0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF8, 0x7E, 0x00, 0x0F, 0xE3, 0xF0, 0x00,
  0x3F, 0x9F, 0x80, 0x00, 0xFC, 0xFC, 0x00, 0x07, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x3E, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x0F, 0x87,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC3, 0xE3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0xFD,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xCF,
  0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFB, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7E,
  0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xEF, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0xF8, 0x07, 0xC1, 0xFF, 0xF8, 0x3E, 0x1F, 0xFF, 0xF1,
  0xF1, 0xFF, 0xFF, 0xCF, 0xDF, 0xFF, 0xFE, 0x7F, 0xF8, 0x07, 0xFB, 0xFF,
  0x00, 0x0F, 0xDF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFE, 0x03, 0xFC, 0x03, 0xFE, 0x0F, 0xE0, 0x01, 0xFC, 0x1F,
  0x80, 0x01, 0xFC, 0x7F, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x01, 0xFB, 0xF8,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x01,
  0xF9, 0xF8, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x3F,
  0x83, 0xF8, 0x00, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x01, 0xF0, 0x7F, 0xFC, 0x03,
  0xE1, 0xFF, 0xFE, 0x07, 0xC7, 0xFF, 0xFE, 0x0F, 0xDF, 0xFF, 0xFE, 0x1F,
  0xFC, 0x03, 0xFE, 0x3F, 0xF0, 0x01, 0xFC, 0x7F, 0xC0, 0x01, 0xFC, 0xFF,
  0x00, 0x01, 0xF9, 0xFC, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x03, 0xF7, 0xF0,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0x7F, 0x00, 0x00,
  0x7E, 0xFE, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x01, 0xFB, 0xFC, 0x00, 0x07,
  0xF7, 0xF8, 0x00, 0x0F, 0xCF, 0xF8, 0x00, 0x3F, 0x9F, 0xF8, 0x00, 0xFE,
  0x3F, 0xFC, 0x07, 0xF8, 0x7E, 0xFF, 0xFF, 0xF0, 0xFC, 0xFF, 0xFF, 0xC1,
  0xF8, 0xFF, 0xFE, 0x03, 0xF0, 0x7F, 0xF0, 0x07, 0xE0, 0x0F, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFF,
  0xC1, 0xF0, 0x3F, 0xFF, 0xC7, 0xC3, 0xFF, 0xFF, 0x9F, 0x0F, 0xFF, 0xFF,
  0x7C, 0x7F, 0x80, 0x7F, 0xF3, 0xF8, 0x00, 0x7F, 0xCF, 0xC0, 0x00, 0xFF,
  0x7E, 0x00, 0x03, 0xFD, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x1F, 0xDF,
  0xC0, 0x00, 0xFF, 0x3F, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x3F, 0xF1, 0xFE,
  0x03, 0xF7, 0xC3, 0xFF, 0xFF, 0xBF, 0x07, 0xFF, 0xFC, 0xFC, 0x0F, 0xFF,
  0xE3, 0xF0, 0x0F, 0xFE, 0x0F, 0xC0, 0x03, 0x80, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xFF, 0x81, 0xFF, 0xF8, 0x3F, 0xFF, 0x87, 0xFF,
  0xF8, 0xFF, 0xFF, 0xDF, 0xC1, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x80,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xE3, 0xF8, 0x01,
  0xF1, 0xF8, 0x00, 0x11, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x01,
  0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xF7, 0x00, 0x01, 0xFB, 0xF0, 0x03, 0xFD, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x3F, 0xFF, 0xF7, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xE0, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x04, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0x03,
  0xFF, 0xC0, 0x01, 0xE0, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFE, 0xFC, 0x00, 0x0F, 0xF7, 0xF0, 0x01,
  0xFF, 0x9F, 0xE0, 0x3F, 0x7C, 0xFF, 0xFF, 0xFB, 0xE3, 0xFF, 0xFF, 0x9F,
  0x0F, 0xFF, 0xF0, 0xF8, 0x1F, 0xFF, 0x07, 0xC0, 0x07, 0x80, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x1F, 0x8F,
  0xC0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x07, 0xE0,
  0x7C, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8,
  0x07, 0xE0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x1F,
  0x80, 0x07, 0xE0, 0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0xF8, 0x07,
  0xE0, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x00, 0xFC,
  0x7C, 0x00, 0x00, 0x7E, 0x3E, 0x00, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0x0F,
  0x9F, 0x00, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0xFF,
  0x80, 0x03, 0xE3, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xF0, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x3E, 0xF8, 0x00, 0xF8, 0x3F, 0x00, 0x3E,
  0x7C, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x3E, 0x00, 0x7E, 0x07, 0xC0, 0x0F,
  0x9F, 0x80, 0x3F, 0x03, 0xF0, 0x0F, 0xC7, 0xC0, 0x1F, 0x01, 0xF8, 0x07,
  0xC3, 0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xE1, 0xF8, 0x0F, 0xC0, 0x3E, 0x03,
  0xF0, 0x7C, 0x07, 0xC0, 0x1F, 0x81, 0xF0, 0x3E, 0x03, 0xE0, 0x0F, 0xC0,
  0xF8, 0x1F, 0x03, 0xF0, 0x03, 0xE0, 0x7C, 0x0F, 0xC1, 0xF8, 0x01, 0xF0,
  0x7C, 0x03, 0xE0, 0xF8, 0x00, 0xFC, 0x3E, 0x01, 0xF0, 0x7C, 0x00, 0x7E,
  0x1F, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x1F, 0x00, 0x3E, 0x3F, 0x00, 0x0F,
  0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x07, 0xE7, 0xC0, 0x0F, 0x8F, 0x80, 0x01,
  0xF3, 0xE0, 0x03, 0xEF, 0xC0, 0x00, 0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x00,
  0x7D, 0xF0, 0x00, 0xFB, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x3F, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x01,
  0xF8, 0x1F, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x07, 0xF0, 0x07, 0xE0, 0x07,
  0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0xC0, 0x01, 0xF8, 0x1F,
  0x80, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0x7E, 0x7E,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00, 0xFC, 0x3F,
  0x00, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x1F, 0xC0, 0x07, 0xF0, 0x0F,
  0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0xC0, 0x03,
  0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00,
  0xFE, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xBF, 0x00, 0x00,
  0x1F, 0x9F, 0x80, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x0F, 0xC3, 0xF0, 0x00,
  0x07, 0xE1, 0xF8, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x03, 0xF0, 0x3F, 0x00,
  0x01, 0xF8, 0x0F, 0x80, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0xFC, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x07, 0xE0, 0x0F, 0xC0, 0x01,
  0xF0, 0x07, 0xC0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x3E, 0x03, 0xF0, 0x00,
  0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xE0, 0xF8, 0x00,
  0x01, 0xF8, 0xFC, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0x3E, 0x3E, 0x00,
  0x00, 0x1F, 0xBF, 0x00, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x03, 0xEF, 0x80,
  0x00, 0x00, 0xF7, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x04, 0x1F, 0xE0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x7F,
  0x00, 0x0F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xF8, 0x00, 0xFE,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x01, 0xFE, 0x00,
  0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0x80,
  0x0F, 0xFC, 0x01, 0xFF, 0xE0, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x03, 0xFC, 0x01, 0xFF, 0xC0, 0x0F,
  0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x04, 0x7F, 0xF0, 0x00, 0x17, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xA0, 0x00, 0x3F, 0xF8, 0x80, 0x00, 0x0B, 0x00,
};

const GFXglyph NotoSans_Regular64pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 8, 47, 17, 5, -46 },
  { 48, 18, 17, 26, 4, -46 },
  { 87, 38, 46, 41, 2, -46 },
  { 306, 29, 53, 37, 4, -49 },
  { 499, 47, 47, 53, 3, -46 },
  { 776, 44, 47, 47, 3, -46 },
  { 1035, 6, 17, 14, 4, -46 },
  { 1048, 14, 56, 19, 3, -46 },
  { 1146, 15, 56, 19, 2, -46 },
  { 1251, 30, 29, 35, 3, -49 },
  { 1360, 30, 31, 37, 3, -38 },
  { 1477, 9, 15, 17, 3, -7 },
  { 1494, 15, 5, 21, 3, -20 },
  { 1504, 8, 9, 17, 5, -8 },
  { 1513, 22, 46, 24, 1, -46 },
  { 1640, 30, 47, 37, 3, -46 },
  { 1817, 17, 46, 37, 6, -46 },
  { 1915, 30, 46, 37, 3, -46 },
  { 2088, 30, 47, 37, 3, -46 },
  { 2265, 34, 46, 37, 1, -46 },
  { 2461, 29, 47, 37, 4, -46 },
  { 2632, 30, 47, 37, 4, -46 },
  { 2809, 30, 46, 37, 3, -46 },
  { 2982, 30, 47, 37, 3, -46 },
  { 3159, 30, 47, 37, 3, -46 },
  { 3336, 8, 36, 17, 5, -35 },
  { 3372, 10, 43, 17, 2, -35 },
  { 3426, 30, 32, 37, 3, -39 },
  { 3546, 29, 17, 37, 4, -31 },
  { 3608, 30, 32, 37, 3, -39 },
  { 3728, 25, 47, 28, 1, -46 },
  { 3875, 50, 52, 58, 4, -46 },
  { 4200, 41, 46, 41, 0, -46 },
  { 4436, 32, 46, 42, 6, -46 },
  { 4620, 34, 47, 40, 4, -46 },
  { 4820, 37, 46, 47, 6, -46 },
  { 5033, 26, 46, 36, 6, -46 },
  { 5183, 26, 46, 33, 6, -46 },
  { 5333, 38, 47, 47, 4, -46 },
  { 5557, 35, 46, 47, 6, -46 },
  { 5759, 16, 46, 22, 3, -46 },
  { 5851, 17, 58, 17, -5, -46 },
  { 5975, 34, 46, 40, 6, -46 },
  { 6171, 26, 46, 34, 6, -46 },
  { 6321, 46, 46, 58, 6, -46 },
  { 6586, 36, 46, 49, 6, -46 },
  { 6793, 42, 47, 50, 4, -46 },
  { 7040, 29, 46, 39, 6, -46 },
  { 7207, 42, 57, 50, 4, -46 },
  { 7507, 33, 46, 40, 6, -46 },
  { 7697, 29, 47, 35, 3, -46 },
  { 7868, 34, 46, 36, 1, -46 },
  { 8064, 35, 47, 47, 6, -46 },
  { 8270, 38, 46, 38, 0, -46 },
  { 8489, 58, 46, 60, 1, -46 },
  { 8823, 37, 46, 38, 0, -46 },
  { 9036, 36, 46, 36, 0, -46 },
  { 9243, 32, 46, 37, 2, -46 },
  { 9427, 14, 56, 21, 5, -46 },
  { 9525, 22, 46, 24, 1, -46 },
  { 9652, 14, 56, 21, 2, -46 },
  { 9750, 32, 29, 37, 2, -46 },
  { 9866, 29, 4, 28, 0, 6 },
  { 9881, 12, 10, 18, 3, -49 },
  { 9896, 28, 36, 36, 3, -35 },
  { 10022, 31, 50, 39, 5, -49 },
  { 10216, 25, 36, 31, 4, -35 },
  { 10329, 30, 50, 39, 4, -49 },
  { 10517, 29, 36, 36, 4, -35 },
  { 10648, 24, 49, 22, 1, -49 },
  { 10795, 30, 50, 39, 4, -35 },
  { 10983, 29, 49, 40, 5, -49 },
  { 11161, 7, 47, 17, 5, -47 },
  { 11203, 16, 62, 17, -4, -47 },
  { 11327, 29, 49, 34, 5, -49 },
  { 11505, 6, 49, 17, 5, -49 },
  { 11542, 50, 35, 60, 5, -35 },
  { 11761, 29, 35, 40, 5, -35 },
  { 11888, 31, 36, 39, 4, -35 },
  { 12028, 31, 50, 39, 5, -35 },
  { 12222, 30, 50, 39, 4, -35 },
  { 12410, 20, 35, 26, 5, -35 },
  { 12498, 25, 36, 31, 3, -35 },
  { 12611, 21, 43, 23, 1, -42 },
  { 12724, 29, 35, 40, 5, -34 },
  { 12851, 33, 34, 33, 0, -34 },
  { 12992, 49, 34, 50, 1, -34 },
  { 13201, 32, 34, 34, 1, -34 },
  { 13337, 33, 49, 33, 0, -34 },
  { 13540, 26, 34, 30, 2, -34 },
  { 13651, 20, 56, 24, 2, -46 },
  { 13791, 5, 64, 35, 15, -49 },
  { 13831, 21, 56, 24, 2, -46 },
  { 13978, 30, 9, 37, 3, -27 },
};

const GFXfont NotoSans_Regular64pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Regular64pt7bBitmaps,
  (GFXglyph *)NotoSans_Regular64pt7bGlyphs,
  0x20, 0x7E, 87
};

#endif // _NOTOSANS_REGULAR64PT7B_H_
