#ifndef _NOTOSANS_REGULAR42PT7B_H_
#define _NOTOSANS_REGULAR42PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Regular.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Regular42pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xDE, 0xF7, 0xBD, 0xEF, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x38, 0x00, 0x03, 0xBF, 0xFF, 0xFC, 0x80, 0xF1, 0xFE, 0x1F,
  0xC3, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1D, 0x83,
  0x80, 0x00, 0x70, 0x38, 0x00, 0x38, 0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x0E,
  0x07, 0x00, 0x07, 0x03, 0x80, 0x07, 0x03, 0x80, 0x03, 0x81, 0xC0, 0x01,
  0xC0, 0xE0, 0x00, 0xE0, 0x70, 0x1F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xF0, 0x1C, 0x0E, 0x00, 0x0E, 0x07, 0x00, 0x07, 0x03, 0x80,
  0x07, 0x03, 0x80, 0x03, 0x81, 0xC0, 0x01, 0xC0, 0xE0, 0x3F, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF0, 0x38, 0x1C, 0x00, 0x1C, 0x0E,
  0x00, 0x0E, 0x07, 0x00, 0x07, 0x03, 0x80, 0x03, 0x83, 0x80, 0x03, 0x81,
  0xC0, 0x01, 0xC0, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0x70, 0x38, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0xFF, 0xE0, 0x7F,
  0xFF, 0x9F, 0xFF, 0xE7, 0xC6, 0x1C, 0xF0, 0xC0, 0x1C, 0x18, 0x03, 0x83,
  0x00, 0x70, 0x60, 0x0F, 0x0C, 0x01, 0xF1, 0x80, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x67, 0xE0, 0x0C,
  0x3C, 0x01, 0x83, 0xC0, 0x30, 0x78, 0x06, 0x0F, 0x00, 0xC1, 0xD0, 0x18,
  0x7B, 0xE3, 0xFE, 0x7F, 0xFF, 0xCF, 0xFF, 0xE0, 0x3F, 0xE0, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x1F, 0x80, 0x03, 0x80,
  0x7F, 0x80, 0x0F, 0x01, 0xE7, 0x80, 0x1C, 0x03, 0x87, 0x80, 0x70, 0x07,
  0x07, 0x00, 0xE0, 0x1C, 0x0E, 0x03, 0x80, 0x38, 0x1C, 0x07, 0x00, 0x70,
  0x38, 0x1C, 0x00, 0xE0, 0x70, 0x78, 0x01, 0xC0, 0xE0, 0xE0, 0x03, 0x81,
  0xC3, 0xC0, 0x07, 0x03, 0x87, 0x00, 0x0E, 0x07, 0x1C, 0x7F, 0x0E, 0x0E,
  0x39, 0xFF, 0x1C, 0x3C, 0xE3, 0xDE, 0x3C, 0xF1, 0xCE, 0x0E, 0x3F, 0xE7,
  0x1C, 0x1C, 0x3F, 0x1E, 0x38, 0x3C, 0x00, 0x38, 0x70, 0x38, 0x00, 0xF1,
  0xE0, 0x70, 0x01, 0xC3, 0x80, 0xE0, 0x07, 0x07, 0x01, 0xC0, 0x0E, 0x0F,
  0x03, 0x80, 0x38, 0x0E, 0x07, 0x00, 0x70, 0x1C, 0x1E, 0x01, 0xC0, 0x38,
  0x38, 0x07, 0x80, 0x70, 0x70, 0x0E, 0x00, 0x7B, 0xE0, 0x3C, 0x00, 0xFF,
  0x80, 0x70, 0x00, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x01, 0xE0, 0x3C, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0x78, 0x0F, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x1E, 0x03,
  0xC0, 0x00, 0x78, 0x3C, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x3C, 0x3F, 0x3E, 0x01, 0xC1, 0xE0, 0xF8, 0x1E, 0x1E, 0x03,
  0xE0, 0xF0, 0xF0, 0x0F, 0x87, 0x0F, 0x00, 0x3E, 0x78, 0x78, 0x00, 0xFF,
  0x83, 0xC0, 0x03, 0xFC, 0x1E, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x7E, 0x03,
  0xC0, 0x07, 0xF8, 0x1F, 0x80, 0xFF, 0xE0, 0x7F, 0xFF, 0xCF, 0x81, 0xFF,
  0xF8, 0x3E, 0x03, 0xFF, 0x00, 0xFC, 0xFF, 0xFE, 0xEE, 0xEE, 0xEE, 0x60,
  0x07, 0x83, 0x83, 0xC3, 0xC1, 0xE1, 0xE0, 0xF0, 0x70, 0x78, 0x3C, 0x1C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x1C, 0x0F, 0x07, 0x81, 0xC0, 0xF0, 0x78,
  0x1E, 0x07, 0x03, 0xC0, 0xF0, 0x38, 0xF0, 0x1E, 0x03, 0xC0, 0xF0, 0x1E,
  0x07, 0x80, 0xF0, 0x3C, 0x07, 0x01, 0xE0, 0x78, 0x1E, 0x03, 0x80, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0x81, 0xE0, 0x78, 0x1E, 0x0F, 0x03, 0xC0, 0xF0, 0x78, 0x1E, 0x0F,
  0x03, 0x81, 0xE0, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x38, 0x38, 0x1F, 0xE7, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3B, 0x80,
  0x0F, 0x78, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x3E, 0x0F, 0x83, 0xC1, 0xE0,
  0x10, 0x10, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x3C, 0xF7, 0xDE, 0x79, 0xC7, 0x3C, 0xE3,
  0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x77, 0xFF, 0xFF, 0x90, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x38,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00,
  0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x1E, 0x00, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x1F,
  0xFF, 0x83, 0xE0, 0x78, 0x3C, 0x03, 0xC7, 0x80, 0x1C, 0x78, 0x01, 0xE7,
  0x80, 0x1E, 0x70, 0x00, 0xEF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xF7, 0x00,
  0x0E, 0x78, 0x01, 0xE7, 0x80, 0x1E, 0x38, 0x01, 0xE3, 0xC0, 0x3C, 0x1E,
  0x07, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x3F, 0xC0, 0x01, 0xE0, 0x7C,
  0x1F, 0x8F, 0xF3, 0xFE, 0xFB, 0xFC, 0x7B, 0x0F, 0x41, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x07, 0xFC, 0x01, 0xFF, 0xF0, 0x7F, 0xFF, 0x8F, 0xC0,
  0x7C, 0x70, 0x03, 0xC2, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFE, 0x03, 0xFF, 0xF0, 0xFF,
  0xFF, 0x87, 0x80, 0x7C, 0x60, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x1F, 0x00, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE8, 0x00, 0x3E, 0xE0,
  0x07, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0xEF, 0x00, 0x07, 0xBC, 0x00, 0x1C, 0xF0, 0x00, 0xE3, 0xC0, 0x07, 0x8F,
  0x00, 0x1C, 0x3C, 0x00, 0xE0, 0xF0, 0x07, 0x83, 0xC0, 0x3C, 0x0F, 0x00,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x3C, 0x03, 0xC0, 0xE0, 0x0F, 0x07, 0x00,
  0x3C, 0x3C, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x7F, 0xFF, 0x8F, 0xFF,
  0xF1, 0xFF, 0xFE, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x0F, 0xFF, 0xC1, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xD0, 0x00, 0xF3, 0x00, 0x7E,
  0x7F, 0xFF, 0x8F, 0xFF, 0xE0, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x3F,
  0xFC, 0x07, 0xFF, 0xC0, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x07, 0xC0, 0x73, 0xFF, 0x0F, 0x7F, 0xFC, 0xFF, 0x07, 0xCF, 0xC0, 0x1E,
  0xF8, 0x01, 0xEF, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0x70, 0x00,
  0xF7, 0x00, 0x0F, 0x70, 0x00, 0xF7, 0x80, 0x0F, 0x38, 0x00, 0xE3, 0xC0,
  0x1E, 0x1E, 0x03, 0xC0, 0xFF, 0xFC, 0x07, 0xFF, 0x80, 0x3F, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3, 0xC0, 0x3C,
  0x78, 0x01, 0xE7, 0x80, 0x1E, 0x78, 0x01, 0xE7, 0x80, 0x1E, 0x78, 0x01,
  0xE7, 0x80, 0x1C, 0x3C, 0x03, 0xC1, 0xF0, 0xF8, 0x0F, 0xDF, 0x00, 0x7F,
  0xC0, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0x1F, 0x83, 0xC0, 0x7C, 0x78,
  0x03, 0xE7, 0x00, 0x1E, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xF7, 0x80, 0x1E, 0x7C, 0x03, 0xE3, 0xFF, 0xFC,
  0x1F, 0xFF, 0x80, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0xE0, 0x1F, 0xFF,
  0x83, 0xE0, 0x78, 0x78, 0x03, 0xC7, 0x80, 0x1E, 0xF0, 0x01, 0xEF, 0x00,
  0x0E, 0xF0, 0x00, 0xEF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xF7, 0x80, 0x1F, 0x78, 0x03, 0xF3, 0xE0, 0xFF, 0x1F, 0xFE, 0xF0,
  0xFF, 0xCF, 0x03, 0xE0, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x1F,
  0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0x00, 0x77, 0xFF, 0xFF, 0x90,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1D, 0xFF, 0xFF, 0xE4, 0x1C,
  0x7C, 0xF9, 0xF3, 0xE1, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF9, 0xE3, 0xC7, 0x8E, 0x3C, 0x78, 0xE1, 0xC7, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0xF0, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x00, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x1F, 0xF8, 0x7F, 0xFF, 0x1F, 0xFF, 0xCE, 0x01, 0xE4, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x04, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00,
  0x78, 0x3C, 0x00, 0x00, 0x1E, 0x1C, 0x01, 0xFC, 0x07, 0x1E, 0x03, 0xFF,
  0x83, 0x8E, 0x03, 0xFF, 0xC0, 0xEF, 0x03, 0xC0, 0xE0, 0x77, 0x03, 0xC0,
  0x70, 0x3B, 0x81, 0xC0, 0x38, 0x1D, 0xC1, 0xE0, 0x1C, 0x0E, 0xE0, 0xE0,
  0x0E, 0x07, 0xF0, 0x70, 0x07, 0x03, 0xF8, 0x38, 0x03, 0x81, 0xF8, 0x1C,
  0x03, 0xC0, 0xFC, 0x0E, 0x01, 0xE0, 0x77, 0x07, 0x80, 0xF0, 0x73, 0x83,
  0xC0, 0xF8, 0x39, 0xC0, 0xF1, 0xEE, 0x38, 0xE0, 0x3F, 0xE7, 0xF8, 0x78,
  0x0F, 0xE1, 0xF8, 0x1C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x04, 0x00,
  0x0F, 0xC0, 0x1E, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x1E, 0xF0, 0x00, 0x03, 0x9E, 0x00, 0x00, 0xF1, 0xC0, 0x00,
  0x1E, 0x3C, 0x00, 0x03, 0x83, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x1C, 0x0F,
  0x00, 0x07, 0x80, 0xE0, 0x00, 0xF0, 0x1E, 0x00, 0x1C, 0x03, 0xC0, 0x07,
  0x80, 0x3C, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xE0, 0x3C, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xC0, 0xE0,
  0x00, 0x78, 0x3C, 0x00, 0x07, 0x87, 0x80, 0x00, 0xF1, 0xE0, 0x00, 0x0E,
  0x3C, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x03, 0xC0, 0xFF,
  0xFC, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xE0, 0x1F, 0xCF, 0x00, 0x1F,
  0x78, 0x00, 0x7B, 0xC0, 0x03, 0xDE, 0x00, 0x1E, 0xF0, 0x00, 0xF7, 0x80,
  0x07, 0xBC, 0x00, 0x39, 0xE0, 0x03, 0xCF, 0x00, 0xFC, 0x7F, 0xFF, 0x83,
  0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0xF0, 0x03, 0xE7, 0x80, 0x0F, 0xBC, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xBC, 0x01, 0xFD, 0xFF, 0xFF,
  0xCF, 0xFF, 0xF8, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xC3, 0xF0, 0x0E, 0x1F, 0x00, 0x08, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x01, 0x83, 0xFF, 0xFE, 0x03,
  0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xE0, 0xF0, 0x1F, 0xF0, 0xF0, 0x01, 0xF8, 0xF0, 0x00, 0xFC, 0xF0,
  0x00, 0x3C, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0,
  0x00, 0x3E, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0xF8, 0xF0, 0x01, 0xF8, 0xF0,
  0x1F, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0xFE, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xFF, 0xFD, 0xFF,
  0xFE, 0xFF, 0xFF, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x01, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xE0, 0x1E, 0x1F, 0x80, 0x02, 0x3E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x03,
  0xFF, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0x78, 0x00,
  0x07, 0x78, 0x00, 0x07, 0x7C, 0x00, 0x07, 0x3E, 0x00, 0x07, 0x1F, 0x00,
  0x07, 0x1F, 0xC0, 0x0F, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00, 0xFF,
  0xFC, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xC0, 0xFF, 0xFF, 0xFD, 0xFE, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x3F, 0xCF, 0xFF, 0xFF, 0xC0, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0xC0, 0x7A, 0x7F, 0x7F, 0xCF,
  0xF1, 0xF8, 0x00, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xCF, 0x00, 0x1E, 0x3C,
  0x00, 0xF0, 0xF0, 0x07, 0x83, 0xC0, 0x3E, 0x0F, 0x01, 0xF0, 0x3C, 0x0F,
  0x80, 0xF0, 0x3C, 0x03, 0xC1, 0xE0, 0x0F, 0x0F, 0x00, 0x3C, 0x78, 0x00,
  0xF3, 0xC0, 0x03, 0xDF, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFC,
  0xF0, 0x03, 0xE3, 0xE0, 0x0F, 0x07, 0xC0, 0x3C, 0x0F, 0x00, 0xF0, 0x3E,
  0x03, 0xC0, 0x7C, 0x0F, 0x00, 0xF8, 0x3C, 0x01, 0xE0, 0xF0, 0x07, 0xC3,
  0xC0, 0x0F, 0x8F, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0xF0, 0x00, 0xFB, 0xC0,
  0x01, 0xF0, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xEE, 0x00, 0x01,
  0xDF, 0xBC, 0x00, 0x0F, 0xFE, 0xF0, 0x00, 0x3B, 0xF9, 0xC0, 0x00, 0xEF,
  0xF7, 0x80, 0x07, 0xBF, 0xCE, 0x00, 0x1C, 0xFF, 0x3C, 0x00, 0xF3, 0xFC,
  0xF0, 0x03, 0x8F, 0xF1, 0xC0, 0x0E, 0x3F, 0xC7, 0x80, 0x78, 0xFF, 0x1E,
  0x01, 0xC3, 0xFC, 0x38, 0x07, 0x0F, 0xF0, 0xF0, 0x3C, 0x3F, 0xC1, 0xC0,
  0xE0, 0xFF, 0x07, 0x87, 0x83, 0xFC, 0x1E, 0x1C, 0x0F, 0xF0, 0x38, 0x70,
  0x3F, 0xC0, 0xF3, 0xC0, 0xFF, 0x03, 0xCE, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F, 0x00, 0xFF, 0x00, 0xFC, 0x03, 0xFC,
  0x03, 0xE0, 0x0F, 0xF0, 0x07, 0x80, 0x3F, 0xC0, 0x1E, 0x00, 0xF0, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE,
  0x00, 0x0F, 0xEF, 0x00, 0x0F, 0xEF, 0x80, 0x0F, 0xE7, 0x80, 0x0F, 0xE3,
  0xC0, 0x0F, 0xE3, 0xE0, 0x0F, 0xF1, 0xE0, 0x0F, 0xF0, 0xF0, 0x0F, 0xF0,
  0xF0, 0x0F, 0xF0, 0x78, 0x0F, 0xF0, 0x7C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0,
  0x1E, 0x0F, 0xF0, 0x1F, 0x0F, 0xF0, 0x0F, 0x0F, 0xF0, 0x07, 0x8F, 0xF0,
  0x07, 0xCF, 0xF0, 0x03, 0xCF, 0xF0, 0x01, 0xEF, 0xF0, 0x01, 0xF7, 0xF0,
  0x00, 0xF7, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00,
  0x3F, 0xFF, 0xF0, 0x0F, 0xE0, 0x3F, 0x03, 0xF0, 0x01, 0xF0, 0x78, 0x00,
  0x1F, 0x1F, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x1E, 0xF8, 0x00, 0x03, 0xDE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0xF3, 0xE0,
  0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x87, 0xE0, 0x03, 0xE0, 0x7F, 0x01, 0xF8,
  0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF,
  0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0xFE, 0x78, 0x1F, 0xEF, 0x00, 0x7D, 0xE0,
  0x07, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xBC, 0x03, 0xF7, 0xFF,
  0xFC, 0xFF, 0xFE, 0x1F, 0xFF, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xE0, 0x3F,
  0x03, 0xF0, 0x01, 0xF0, 0x78, 0x00, 0x1F, 0x1F, 0x00, 0x01, 0xE3, 0xC0,
  0x00, 0x1E, 0xF8, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0x9E, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x87,
  0xE0, 0x03, 0xE0, 0x7F, 0x01, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0x80, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xFC, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8,
  0x3C, 0x07, 0xF0, 0xF0, 0x03, 0xC3, 0xC0, 0x07, 0x8F, 0x00, 0x1E, 0x3C,
  0x00, 0x78, 0xF0, 0x01, 0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x1E, 0x3C, 0x00,
  0x78, 0xF0, 0x03, 0xC3, 0xC0, 0x1F, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0,
  0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x0F, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0xF0,
  0x1F, 0x03, 0xC0, 0x3C, 0x0F, 0x00, 0x78, 0x3C, 0x01, 0xF0, 0xF0, 0x03,
  0xC3, 0xC0, 0x0F, 0x8F, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0xF0, 0x00, 0xFB,
  0xC0, 0x01, 0xF0, 0x07, 0xFF, 0x03, 0xFF, 0xF8, 0xFF, 0xFF, 0x3F, 0x01,
  0xE7, 0x80, 0x04, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xF0, 0x00, 0x7B, 0xC0, 0x3F, 0x7F, 0xFF, 0xCF, 0xFF, 0xF0,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x1E, 0x78, 0x00, 0x3C, 0xF8, 0x00, 0xF0, 0xFC, 0x07, 0xE0,
  0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0xF0, 0x00, 0x07,
  0xB8, 0x00, 0x03, 0xDE, 0x00, 0x03, 0xCF, 0x00, 0x01, 0xE3, 0xC0, 0x00,
  0xF1, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x1E, 0x00,
  0x3C, 0x0F, 0x00, 0x1E, 0x03, 0xC0, 0x0E, 0x01, 0xE0, 0x0F, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x07, 0x80, 0x1E, 0x03, 0xC0, 0x07, 0x01, 0xE0, 0x03,
  0xC1, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0x70, 0x78, 0x00, 0x3C, 0x78, 0x00,
  0x1E, 0x3C, 0x00, 0x07, 0x1E, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3E,
  0xF0, 0x00, 0xF8, 0x00, 0x79, 0xE0, 0x01, 0xF0, 0x00, 0xF3, 0xC0, 0x07,
  0xE0, 0x01, 0xE3, 0xC0, 0x0F, 0xE0, 0x07, 0x87, 0x80, 0x1D, 0xC0, 0x0F,
  0x0F, 0x00, 0x3B, 0x80, 0x1E, 0x1E, 0x00, 0xF7, 0x80, 0x3C, 0x1E, 0x01,
  0xCF, 0x00, 0xF0, 0x3C, 0x03, 0x8E, 0x01, 0xE0, 0x78, 0x0F, 0x1E, 0x03,
  0xC0, 0x70, 0x1E, 0x3C, 0x07, 0x00, 0xF0, 0x38, 0x38, 0x1E, 0x01, 0xE0,
  0xF0, 0x70, 0x3C, 0x03, 0xC1, 0xE0, 0xF0, 0x78, 0x03, 0x83, 0x81, 0xE0,
  0xE0, 0x07, 0x87, 0x01, 0xC3, 0xC0, 0x0F, 0x1E, 0x03, 0xC7, 0x80, 0x1E,
  0x3C, 0x07, 0x8F, 0x00, 0x1C, 0x70, 0x07, 0x1C, 0x00, 0x3D, 0xE0, 0x0E,
  0x78, 0x00, 0x7B, 0xC0, 0x1E, 0xF0, 0x00, 0xF7, 0x00, 0x3D, 0xE0, 0x00,
  0xEE, 0x00, 0x3B, 0x80, 0x01, 0xDC, 0x00, 0x77, 0x00, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x1F, 0x3C, 0x00, 0x1E, 0x3E, 0x00, 0x3C, 0x1E, 0x00, 0x38, 0x0F, 0x00,
  0x78, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0xF0, 0x03, 0xC1, 0xE0, 0x03, 0xC3,
  0xC0, 0x01, 0xE3, 0xC0, 0x00, 0xF7, 0x80, 0x00, 0xF7, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0xF7, 0x00, 0x01, 0xE7, 0x80, 0x01, 0xE3, 0xC0, 0x03, 0xC3,
  0xC0, 0x03, 0x81, 0xE0, 0x07, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0x78, 0x1E, 0x00, 0x7C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x78, 0x00,
  0x1E, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0x78, 0x00, 0x1E, 0x78, 0x00,
  0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x1E, 0x00, 0x78, 0x1F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x81, 0xE0, 0x07, 0x81, 0xE0, 0x03, 0xC3,
  0xC0, 0x03, 0xC3, 0xC0, 0x01, 0xE7, 0x80, 0x01, 0xE7, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0,
  0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07,
  0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78,
  0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0x80,
  0x07, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00,
  0x78, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x80, 0x03, 0xB8, 0x00, 0x3B, 0xC0, 0x07, 0x1C, 0x00, 0x71, 0xE0, 0x0E,
  0x0E, 0x00, 0xE0, 0xF0, 0x1E, 0x07, 0x01, 0xC0, 0x78, 0x1C, 0x03, 0x83,
  0x80, 0x1C, 0x38, 0x01, 0xC7, 0x00, 0x0E, 0x70, 0x00, 0xEE, 0x00, 0x07,
  0xE0, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0x78, 0x7C, 0x3C,
  0x1E, 0x0F, 0x03, 0x01, 0xF8, 0x03, 0xFF, 0xC3, 0xFF, 0xF8, 0x78, 0x3E,
  0x10, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x03, 0xF0, 0x7F, 0xFC, 0x7F, 0xFF, 0x7F, 0x03, 0xDE, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xE0, 0x3F,
  0x7F, 0xFD, 0xCF, 0xFE, 0x71, 0xFF, 0x1C, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x1F, 0x80, 0xE7, 0xFE, 0x0E, 0xFF,
  0xF0, 0xFE, 0x0F, 0x8F, 0x80, 0x7C, 0xF0, 0x03, 0xCF, 0x00, 0x1E, 0xF0,
  0x01, 0xEE, 0x00, 0x1E, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xEE, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x1E,
  0xF0, 0x01, 0xEF, 0x80, 0x3C, 0xFC, 0x07, 0xCE, 0xFF, 0xF8, 0xE7, 0xFF,
  0x0C, 0x3F, 0xC0, 0x00, 0xFC, 0x03, 0xFF, 0xC3, 0xFF, 0xC3, 0xF1, 0xE3,
  0xE0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x21, 0xFF, 0xF0,
  0x7F, 0xF8, 0x0F, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x1F, 0x87, 0x07, 0xFE, 0x71, 0xFF, 0xF7, 0x3F, 0x07,
  0xF3, 0xC0, 0x3F, 0x7C, 0x01, 0xF7, 0x80, 0x0F, 0x78, 0x00, 0xF7, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x0F, 0x70, 0x00, 0xF7, 0x80, 0x0F, 0x78, 0x00, 0xF3,
  0xC0, 0x1F, 0x3E, 0x03, 0xF1, 0xFF, 0xF7, 0x0F, 0xFE, 0x70, 0x7F, 0xC7,
  0x01, 0xF8, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x81, 0xF0, 0xFC, 0x3C, 0x03,
  0xC3, 0xC0, 0x1E, 0x78, 0x01, 0xE7, 0x80, 0x1E, 0x70, 0x00, 0xEF, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03,
  0xF0, 0x0E, 0x1F, 0xFF, 0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0x80, 0x01, 0xFE,
  0x07, 0xFC, 0x1F, 0xF8, 0x7C, 0x10, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x3F, 0xF3, 0xFF, 0xE7, 0xFF, 0xC0, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x01, 0xF8,
  0x70, 0x7F, 0xE7, 0x1F, 0xFF, 0x71, 0xF0, 0xFF, 0x3C, 0x03, 0xF7, 0xC0,
  0x1F, 0x78, 0x00, 0xF7, 0x80, 0x0F, 0x70, 0x00, 0xFF, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x77,
  0x80, 0x0F, 0x78, 0x00, 0xF7, 0x80, 0x0F, 0x3C, 0x01, 0xF3, 0xE0, 0x3F,
  0x1F, 0xFF, 0x70, 0xFF, 0xE7, 0x07, 0xFC, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x20, 0x01, 0xE3, 0xC0,
  0x7E, 0x3F, 0xFF, 0xC3, 0xFF, 0xF8, 0x07, 0xFC, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x1F, 0x83, 0x9F, 0xFC, 0x77,
  0xFF, 0xCF, 0xE0, 0xFD, 0xF0, 0x07, 0xBE, 0x00, 0xF7, 0x80, 0x0E, 0xF0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0x77, 0xBF, 0xE6, 0x00, 0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xC0, 0x03, 0x81, 0xE0,
  0x7C, 0x1E, 0x03, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x1E, 0x07, 0x83, 0xEF, 0xF3, 0xFC, 0xFC,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x01, 0xEE,
  0x00, 0xF3, 0x80, 0x7C, 0xE0, 0x3E, 0x38, 0x1F, 0x0E, 0x0F, 0x83, 0x87,
  0xC0, 0xE3, 0xE0, 0x38, 0xF0, 0x0E, 0x78, 0x03, 0xBE, 0x00, 0xFF, 0x80,
  0x3F, 0xF0, 0x0F, 0x9E, 0x03, 0x87, 0xC0, 0xE0, 0xF0, 0x38, 0x1E, 0x0E,
  0x07, 0xC3, 0x80, 0xF8, 0xE0, 0x1E, 0x38, 0x03, 0xCE, 0x00, 0xFB, 0x80,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE1, 0xF8, 0x07, 0xE0, 0xE7, 0xFE, 0x1F, 0xF8, 0xEF, 0xFF, 0x3F,
  0xFC, 0xFE, 0x1F, 0xFC, 0x3E, 0xF8, 0x07, 0xE0, 0x1E, 0xF0, 0x07, 0xE0,
  0x0F, 0xF0, 0x03, 0xC0, 0x0F, 0xF0, 0x03, 0xC0, 0x0F, 0xE0, 0x03, 0xC0,
  0x0F, 0xE0, 0x03, 0xC0, 0x0F, 0xE0, 0x03, 0xC0, 0x0F, 0xE0, 0x03, 0xC0,
  0x0F, 0xE0, 0x03, 0xC0, 0x0F, 0xE0, 0x03, 0xC0, 0x0F, 0xE0, 0x03, 0xC0,
  0x0F, 0xE0, 0x03, 0xC0, 0x0F, 0xE0, 0x03, 0xC0, 0x0F, 0xE0, 0x03, 0xC0,
  0x0F, 0xE0, 0x03, 0xC0, 0x0F, 0xE0, 0x03, 0xC0, 0x0F, 0xE0, 0x03, 0xC0,
  0x0F, 0xE0, 0x03, 0xC0, 0x0F, 0xE0, 0x03, 0xC0, 0x0F, 0xE1, 0xFC, 0x1C,
  0xFF, 0xE3, 0xBF, 0xFE, 0x7F, 0x07, 0xEF, 0x80, 0x3D, 0xF0, 0x07, 0xBC,
  0x00, 0x77, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x78, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xF0,
  0x3E, 0x0F, 0xC3, 0xE0, 0x1E, 0x3E, 0x00, 0x79, 0xE0, 0x03, 0xCF, 0x00,
  0x0F, 0x70, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3D, 0xC0, 0x01, 0xEF, 0x00, 0x0F, 0x78, 0x00,
  0x73, 0xC0, 0x07, 0x8F, 0x00, 0x7C, 0x3C, 0x07, 0xC1, 0xFF, 0xFC, 0x07,
  0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xE1, 0xF8, 0x0E, 0x7F, 0xE0, 0xEF, 0xFF,
  0x8F, 0xE0, 0xF8, 0xF8, 0x07, 0xCF, 0x00, 0x3C, 0xF0, 0x01, 0xEF, 0x00,
  0x1E, 0xE0, 0x01, 0xEE, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0E, 0xE0, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xEF,
  0x00, 0x3E, 0xF8, 0x03, 0xCF, 0xC0, 0x7C, 0xEF, 0xFF, 0x8E, 0x7F, 0xF0,
  0xE3, 0xFC, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x70, 0x7F, 0xE7, 0x1F, 0xFF, 0x71,
  0xF0, 0x7F, 0x3C, 0x03, 0xF7, 0xC0, 0x1F, 0x78, 0x00, 0xF7, 0x80, 0x0F,
  0x70, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0xF7, 0x80, 0x0F, 0x78, 0x00, 0xF7, 0x80,
  0x0F, 0x3C, 0x01, 0xF3, 0xE0, 0x3F, 0x1F, 0xFF, 0x70, 0xFF, 0xE7, 0x07,
  0xFC, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0xE0, 0xFF, 0x1F, 0xF9, 0xFD, 0xDF, 0x2F, 0xC0, 0x7C,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x00, 0x07, 0xF8, 0x1F, 0xFF, 0x7F, 0xFE, 0x7C,
  0x1E, 0xF0, 0x02, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x7F,
  0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x00,
  0x0F, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0xC0, 0x1F, 0xFF, 0xFE, 0xFF,
  0xFC, 0x7F, 0xF0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0x00, 0x7F, 0xC3, 0xFE, 0x07,
  0xF0, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3D, 0xE0, 0x0F, 0xBE, 0x03,
  0xF3, 0xFF, 0xEE, 0x7F, 0xF9, 0xC3, 0xFE, 0x38, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xDE, 0x00, 0x1E, 0xF0, 0x01, 0xE3, 0x80, 0x0F, 0x1E, 0x00, 0x70,
  0xF0, 0x07, 0x83, 0x80, 0x3C, 0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x03, 0xC0,
  0xF0, 0x1E, 0x0F, 0x00, 0x70, 0x78, 0x03, 0xC3, 0x80, 0x1E, 0x3C, 0x00,
  0x71, 0xE0, 0x03, 0xCE, 0x00, 0x1E, 0xF0, 0x00, 0x77, 0x80, 0x03, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0xF0, 0x01, 0xE0,
  0x07, 0xBC, 0x01, 0xF0, 0x07, 0x9E, 0x00, 0xF8, 0x03, 0xCF, 0x00, 0x7C,
  0x01, 0xE3, 0x80, 0x77, 0x00, 0xE1, 0xE0, 0x3B, 0x80, 0xF0, 0xF0, 0x1D,
  0xC0, 0x78, 0x78, 0x1E, 0xF0, 0x3C, 0x1C, 0x0E, 0x38, 0x1C, 0x0F, 0x07,
  0x1C, 0x1E, 0x07, 0x87, 0x8F, 0x0F, 0x03, 0xC3, 0xC7, 0x87, 0x00, 0xE1,
  0xC1, 0xC3, 0x80, 0x79, 0xE0, 0xF3, 0xC0, 0x3C, 0xF0, 0x79, 0xE0, 0x0E,
  0x70, 0x1C, 0xE0, 0x07, 0x38, 0x0E, 0x70, 0x03, 0xFC, 0x07, 0xF8, 0x01,
  0xFC, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x7E, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x0F, 0x00, 0xF0, 0x00, 0xF7, 0x80,
  0x1E, 0x3C, 0x03, 0xE3, 0xC0, 0x3C, 0x1E, 0x07, 0x80, 0xF0, 0xF8, 0x0F,
  0x0F, 0x00, 0x79, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x00,
  0x0F, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x79, 0xE0,
  0x0F, 0x0F, 0x00, 0xF0, 0xF8, 0x1E, 0x07, 0x83, 0xC0, 0x3C, 0x3C, 0x01,
  0xE7, 0x80, 0x1E, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xDE,
  0x00, 0x1E, 0xF0, 0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x07,
  0x83, 0xC0, 0x3C, 0x1E, 0x01, 0xC0, 0x70, 0x1E, 0x03, 0xC0, 0xF0, 0x1E,
  0x0F, 0x00, 0x78, 0x78, 0x03, 0xC3, 0xC0, 0x0E, 0x3C, 0x00, 0x79, 0xE0,
  0x03, 0xCE, 0x00, 0x0E, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x03, 0xE0,
  0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x03, 0xF0, 0x1F,
  0xC0, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x3F,
  0x03, 0xF0, 0x0F, 0x80, 0x3F, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x0C,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0x03, 0xF0, 0x0F, 0xE0, 0x07, 0xC0, 0x0F,
  0x00, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xF0, 0x07, 0xF0,
  0x07, 0xC0, 0x7F, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x0F, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x17,
  0xFC, 0x01, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xE8, 0x00, 0xF8,
};

const GFXglyph NotoSans_Regular42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 5, 31, 11, 3, -30 },
  { 21, 11, 11, 17, 3, -30 },
  { 37, 25, 30, 27, 1, -30 },
  { 131, 19, 34, 24, 3, -32 },
  { 212, 31, 30, 35, 2, -30 },
  { 329, 29, 30, 31, 2, -30 },
  { 438, 4, 11, 9, 3, -30 },
  { 444, 9, 37, 13, 2, -30 },
  { 486, 10, 37, 13, 1, -30 },
  { 533, 19, 19, 23, 2, -32 },
  { 579, 20, 20, 24, 2, -25 },
  { 629, 6, 10, 11, 2, -5 },
  { 637, 10, 3, 14, 2, -13 },
  { 641, 5, 6, 11, 3, -5 },
  { 645, 15, 30, 16, 0, -30 },
  { 702, 20, 30, 24, 2, -30 },
  { 777, 11, 30, 24, 4, -30 },
  { 819, 20, 30, 24, 2, -30 },
  { 894, 20, 30, 24, 2, -30 },
  { 969, 22, 30, 24, 1, -30 },
  { 1052, 19, 30, 24, 3, -30 },
  { 1124, 20, 30, 24, 2, -30 },
  { 1199, 20, 30, 24, 2, -30 },
  { 1274, 20, 30, 24, 2, -30 },
  { 1349, 20, 30, 24, 2, -30 },
  { 1424, 5, 24, 11, 3, -23 },
  { 1439, 7, 28, 11, 1, -23 },
  { 1464, 20, 21, 24, 2, -26 },
  { 1517, 20, 11, 24, 2, -20 },
  { 1545, 20, 21, 24, 2, -26 },
  { 1598, 17, 31, 18, 0, -30 },
  { 1664, 33, 34, 38, 2, -30 },
  { 1805, 27, 30, 27, 0, -30 },
  { 1907, 21, 30, 27, 4, -30 },
  { 1986, 22, 30, 27, 3, -30 },
  { 2069, 24, 30, 31, 4, -30 },
  { 2159, 17, 30, 23, 4, -30 },
  { 2223, 17, 30, 22, 4, -30 },
  { 2287, 24, 30, 31, 3, -30 },
  { 2377, 23, 30, 31, 4, -30 },
  { 2464, 11, 30, 14, 2, -30 },
  { 2506, 11, 38, 11, -3, -30 },
  { 2559, 22, 30, 26, 4, -30 },
  { 2642, 17, 30, 22, 4, -30 },
  { 2706, 30, 30, 38, 4, -30 },
  { 2819, 24, 30, 32, 4, -30 },
  { 2909, 27, 30, 33, 3, -30 },
  { 3011, 19, 30, 25, 4, -30 },
  { 3083, 27, 37, 33, 3, -30 },
  { 3208, 22, 30, 26, 4, -30 },
  { 3291, 19, 30, 23, 2, -30 },
  { 3363, 23, 30, 23, 0, -30 },
  { 3450, 23, 30, 31, 4, -30 },
  { 3537, 25, 30, 25, 0, -30 },
  { 3631, 39, 30, 39, 0, -30 },
  { 3778, 24, 30, 25, 0, -30 },
  { 3868, 24, 30, 24, 0, -30 },
  { 3958, 20, 30, 24, 2, -30 },
  { 4033, 10, 37, 14, 3, -30 },
  { 4080, 15, 30, 16, 0, -30 },
  { 4137, 9, 37, 14, 1, -30 },
  { 4179, 20, 19, 24, 2, -30 },
  { 4227, 19, 2, 19, 0, 4 },
  { 4232, 8, 7, 12, 2, -32 },
  { 4239, 18, 23, 24, 2, -23 },
  { 4291, 20, 32, 26, 4, -32 },
  { 4371, 17, 23, 20, 2, -23 },
  { 4420, 20, 32, 26, 2, -32 },
  { 4500, 20, 23, 24, 2, -23 },
  { 4558, 15, 32, 14, 1, -32 },
  { 4618, 20, 33, 26, 2, -23 },
  { 4701, 19, 32, 26, 4, -32 },
  { 4777, 5, 31, 11, 3, -31 },
  { 4797, 10, 41, 11, -2, -31 },
  { 4849, 18, 32, 22, 4, -32 },
  { 4921, 3, 32, 11, 4, -32 },
  { 4933, 32, 23, 39, 4, -23 },
  { 5025, 19, 23, 26, 4, -23 },
  { 5080, 21, 23, 25, 2, -23 },
  { 5141, 20, 33, 26, 4, -23 },
  { 5224, 20, 33, 26, 2, -23 },
  { 5307, 13, 23, 17, 4, -23 },
  { 5345, 16, 23, 20, 2, -23 },
  { 5391, 13, 28, 15, 1, -28 },
  { 5437, 19, 23, 26, 3, -23 },
  { 5492, 21, 23, 21, 0, -23 },
  { 5553, 33, 23, 33, 0, -23 },
  { 5648, 20, 23, 22, 1, -23 },
  { 5706, 21, 33, 21, 0, -23 },
  { 5793, 16, 23, 20, 2, -23 },
  { 5839, 14, 37, 16, 1, -30 },
  { 5904, 3, 42, 23, 10, -32 },
  { 5920, 14, 37, 16, 1, -30 },
  { 5985, 20, 6, 24, 2, -18 },
};

const GFXfont NotoSans_Regular42pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Regular42pt7bBitmaps,
  (GFXglyph *)NotoSans_Regular42pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _NOTOSANS_REGULAR42PT7B_H_
