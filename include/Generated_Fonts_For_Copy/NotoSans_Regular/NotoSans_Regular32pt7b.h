#ifndef _NOTOSANS_REGULAR32PT7B_H_
#define _NOTOSANS_REGULAR32PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Regular.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Regular32pt7bBitmaps[] PROGMEM = {
  0x00, 0x77, 0x77, 0x77, 0x77, 0x77, 0x76, 0x66, 0x66, 0x60, 0x06, 0xFF,
  0x70, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1D, 0x8C, 0xC6, 0x01, 0x83,
  0x00, 0x30, 0x60, 0x0E, 0x1C, 0x01, 0xC3, 0x00, 0x30, 0x60, 0x06, 0x0C,
  0x00, 0xC1, 0x83, 0xFF, 0xFF, 0x7F, 0xFF, 0xE0, 0xC1, 0x80, 0x18, 0x30,
  0x03, 0x06, 0x00, 0x61, 0xC0, 0x1C, 0x38, 0x3F, 0xFF, 0xF7, 0xFF, 0xFE,
  0x0C, 0x18, 0x01, 0x87, 0x00, 0x70, 0xE0, 0x0E, 0x18, 0x01, 0x83, 0x00,
  0x30, 0x60, 0x06, 0x1C, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x01, 0xFF,
  0xC7, 0xFF, 0xDE, 0x63, 0x38, 0xC0, 0x71, 0x80, 0xE3, 0x01, 0xC6, 0x01,
  0xFC, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0xDF, 0x01, 0x8E, 0x03,
  0x0E, 0x06, 0x18, 0x0C, 0x77, 0x19, 0xEF, 0xFF, 0x9F, 0xFC, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x3E, 0x00, 0xE0, 0xFE, 0x01, 0x83,
  0x8C, 0x07, 0x06, 0x1C, 0x0C, 0x0C, 0x38, 0x30, 0x18, 0x30, 0xE0, 0x30,
  0x61, 0x80, 0x60, 0xC7, 0x00, 0xC1, 0x8C, 0x01, 0x87, 0x39, 0xE3, 0x0E,
  0x67, 0xF7, 0x19, 0xDC, 0xE7, 0xF3, 0x30, 0xE7, 0xCC, 0x61, 0xC0, 0x38,
  0xC1, 0x80, 0x61, 0x83, 0x01, 0xC3, 0x06, 0x03, 0x06, 0x0C, 0x0E, 0x0C,
  0x18, 0x18, 0x18, 0x70, 0x70, 0x38, 0xC0, 0xC0, 0x3F, 0x83, 0x00, 0x3E,
  0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x80, 0x0F, 0x1E, 0x00, 0x70, 0x70, 0x03,
  0x83, 0x80, 0x1C, 0x1C, 0x00, 0xE0, 0xE0, 0x03, 0x8E, 0x00, 0x1C, 0xF0,
  0x00, 0x7F, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x80, 0x03, 0xDE, 0x07, 0x38,
  0x78, 0x33, 0x81, 0xE3, 0x9C, 0x07, 0x9C, 0xE0, 0x1F, 0xC7, 0x00, 0x7C,
  0x38, 0x01, 0xE1, 0xE0, 0x1F, 0x87, 0x83, 0xFE, 0x3F, 0xFC, 0x78, 0x7F,
  0x81, 0xE0, 0xFF, 0xFF, 0xDB, 0x07, 0x0E, 0x1C, 0x1C, 0x38, 0x38, 0x70,
  0x70, 0x70, 0x70, 0x60, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x70,
  0x70, 0x70, 0x70, 0x38, 0x38, 0x18, 0x1C, 0x0E, 0x07, 0xE0, 0xE1, 0xC1,
  0xC3, 0x83, 0x87, 0x06, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0x70, 0xE3, 0x87, 0x0E, 0x38, 0x61, 0xC7, 0x00, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x0C, 0x04, 0x18, 0x6F, 0xB7, 0xFF, 0xFF, 0x81,
  0xE0, 0x07, 0xC0, 0x0D, 0xC0, 0x39, 0xC0, 0xE3, 0x83, 0xC3, 0x81, 0x84,
  0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x7F, 0xFF, 0xFF, 0xFE, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x39, 0xCE, 0xE7, 0x39, 0x9C, 0xFF,
  0xFF, 0xFF, 0x6F, 0xF7, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x0C, 0x01, 0xC0,
  0x1C, 0x03, 0x80, 0x38, 0x03, 0x00, 0x70, 0x07, 0x00, 0x60, 0x0E, 0x00,
  0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x03, 0x00, 0x70, 0x07,
  0x00, 0xE0, 0x00, 0x0F, 0xC0, 0x7F, 0xE0, 0xE1, 0xE3, 0x81, 0xC6, 0x01,
  0xDC, 0x03, 0xB8, 0x07, 0x70, 0x06, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x06, 0xE0, 0x1D, 0xC0,
  0x39, 0x80, 0x73, 0x81, 0xC3, 0x87, 0x87, 0xFE, 0x03, 0xF8, 0x00, 0x03,
  0x0F, 0x1F, 0x3B, 0xF3, 0xE3, 0x43, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x1F, 0xC0,
  0xFF, 0xE3, 0xE3, 0xE3, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xF0, 0x7F, 0xF1, 0xE0, 0xF1,
  0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00,
  0xF0, 0x3F, 0xC0, 0x7F, 0x80, 0x1F, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x06, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0xFE, 0x03, 0xDF, 0xFF, 0x1F,
  0xFC, 0x00, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1B, 0x00, 0x1D,
  0x80, 0x0C, 0xC0, 0x0E, 0x60, 0x0E, 0x30, 0x0E, 0x18, 0x06, 0x0C, 0x07,
  0x06, 0x07, 0x03, 0x03, 0x01, 0x83, 0x80, 0xC3, 0x80, 0x61, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x7F, 0xF9, 0xFF, 0xE7, 0xFF, 0x9C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x01, 0xFF, 0x07, 0xFF, 0x1C, 0x7E,
  0x00, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01,
  0xE0, 0x0F, 0xE0, 0x7B, 0xFF, 0xC7, 0xFC, 0x00, 0x03, 0xF8, 0x1F, 0xF0,
  0x7C, 0x11, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xCF, 0xE3, 0xFF, 0xE7, 0xC1, 0xEF, 0x01, 0xDC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1D, 0x80, 0x73, 0x80, 0xE3, 0xC3, 0x83,
  0xFF, 0x03, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0,
  0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00,
  0x1E, 0x00, 0x0F, 0xE0, 0x7F, 0xE1, 0xE1, 0xE3, 0x80, 0xEE, 0x01, 0xDC,
  0x03, 0xB8, 0x07, 0x38, 0x0C, 0x78, 0x38, 0x7D, 0xE0, 0x7F, 0x00, 0xFF,
  0x03, 0xDF, 0x0E, 0x0F, 0x38, 0x07, 0x70, 0x06, 0xC0, 0x0F, 0x80, 0x1F,
  0x80, 0x3F, 0x00, 0xEF, 0x03, 0xCF, 0xFF, 0x07, 0xF8, 0x00, 0x0F, 0xC0,
  0x7F, 0xE1, 0xE3, 0xE7, 0x81, 0xCE, 0x01, 0xDC, 0x03, 0xB0, 0x03, 0x60,
  0x06, 0xC0, 0x0F, 0xC0, 0x3F, 0x80, 0x7B, 0x81, 0xF7, 0xFE, 0xE7, 0xF9,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x03, 0x80,
  0x1F, 0x0F, 0xF8, 0x1F, 0xE0, 0x00, 0x2F, 0xFF, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x6F, 0xF7, 0x13, 0xDE, 0xF3, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xEF, 0x73, 0x9C, 0xCE, 0x60, 0x00, 0x06, 0x00, 0x3C, 0x01, 0xF0, 0x0F,
  0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xFC, 0x00,
  0x3E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xC0, 0x01, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFC, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x3E, 0x03, 0xF0, 0x1F, 0x00, 0xF8,
  0x0F, 0xC0, 0x1E, 0x00, 0x20, 0x00, 0x00, 0x1F, 0xC7, 0xFF, 0x9E, 0x3C,
  0x80, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x07, 0x80,
  0x70, 0x07, 0x00, 0x70, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0xFF, 0xF0, 0x01, 0xF8, 0x3E, 0x01, 0xE0, 0x07, 0x81, 0xC0, 0x00,
  0xE1, 0xC0, 0x00, 0x30, 0xC0, 0x38, 0x1C, 0xE0, 0xFF, 0x86, 0x60, 0xF3,
  0xC3, 0xF0, 0xE0, 0xE1, 0xF8, 0x60, 0x70, 0x78, 0x70, 0x38, 0x3C, 0x38,
  0x1C, 0x1E, 0x1C, 0x0E, 0x1F, 0x0E, 0x07, 0x0F, 0x87, 0x03, 0x86, 0xC1,
  0x83, 0xC7, 0x70, 0xFF, 0x77, 0x38, 0x3F, 0x1F, 0x0C, 0x02, 0x02, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x80, 0x1F, 0x07, 0xC0,
  0x07, 0xFF, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x80, 0x01, 0xD8, 0x00, 0x1D, 0xC0, 0x03, 0x9C,
  0x00, 0x38, 0xC0, 0x03, 0x0E, 0x00, 0x70, 0xE0, 0x07, 0x07, 0x00, 0xE0,
  0x70, 0x0E, 0x07, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0x81, 0xFF, 0xFC, 0x18,
  0x01, 0xC3, 0x80, 0x1C, 0x38, 0x00, 0xE7, 0x00, 0x0E, 0x70, 0x00, 0xE7,
  0x00, 0x07, 0xE0, 0x00, 0x70, 0xFF, 0xE0, 0xFF, 0xF8, 0xFF, 0xFC, 0xE0,
  0x1E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0,
  0x3C, 0xFF, 0xF0, 0xFF, 0xF8, 0xE0, 0x3C, 0xE0, 0x0E, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0E, 0xE0, 0xFE, 0xFF,
  0xFC, 0xFF, 0xF0, 0x01, 0xFF, 0x03, 0xFF, 0xC7, 0xE3, 0xE7, 0xC0, 0x23,
  0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x30,
  0x7F, 0xF8, 0x0F, 0xFC, 0xFF, 0xC0, 0x3F, 0xFE, 0x0F, 0xFF, 0xE3, 0x80,
  0x7C, 0xE0, 0x07, 0xB8, 0x00, 0xEE, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xEE, 0x00, 0x7B, 0x80,
  0x7C, 0xE1, 0xFE, 0x3F, 0xFE, 0x0F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x3F, 0xFD, 0xFF, 0xEE, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xFF, 0xEF, 0xFF, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x00,
  0x01, 0xFF, 0x80, 0xFF, 0xFC, 0x3F, 0x1F, 0x0F, 0x00, 0x23, 0xC0, 0x00,
  0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0x70, 0x00, 0xEE, 0x00, 0x1C, 0xE0, 0x03, 0x9E, 0x00, 0x71,
  0xF8, 0x1E, 0x1F, 0xFF, 0xC0, 0xFF, 0xF0, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1C, 0xFF,
  0xFF, 0xC7, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC7, 0xFF,
  0xFE, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x83, 0xB7, 0xDF, 0xCF, 0xC0, 0xE0, 0x07,
  0x70, 0x07, 0x38, 0x07, 0x1C, 0x07, 0x0E, 0x07, 0x87, 0x07, 0x83, 0x87,
  0x81, 0xC3, 0x80, 0xE3, 0x80, 0x73, 0x80, 0x3B, 0xC0, 0x1F, 0xE0, 0x0F,
  0xB8, 0x07, 0x9E, 0x03, 0x87, 0x81, 0xC1, 0xC0, 0xE0, 0x70, 0x70, 0x3C,
  0x38, 0x0F, 0x1C, 0x03, 0x8E, 0x00, 0xE7, 0x00, 0x7B, 0x80, 0x1E, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x07, 0xFD, 0x80, 0x0D, 0xFB, 0x80, 0x3B, 0xF7, 0x00, 0x67,
  0xE7, 0x01, 0xCF, 0xCE, 0x03, 0x9F, 0x9C, 0x06, 0x3F, 0x1C, 0x1C, 0x7E,
  0x38, 0x38, 0xFC, 0x30, 0x61, 0xF8, 0x71, 0xC3, 0xF0, 0xE3, 0x07, 0xE0,
  0xEE, 0x0F, 0xC1, 0xDC, 0x1F, 0x83, 0xB0, 0x3F, 0x03, 0xE0, 0x7E, 0x07,
  0xC0, 0xFC, 0x07, 0x01, 0xF8, 0x0E, 0x03, 0x80, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x80, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFB, 0x80, 0x3E, 0xF0, 0x0F,
  0x9C, 0x03, 0xE3, 0x80, 0xF8, 0xE0, 0x3E, 0x1C, 0x0F, 0x87, 0x83, 0xE0,
  0xE0, 0xF8, 0x1C, 0x3E, 0x07, 0x8F, 0x80, 0xE3, 0xE0, 0x1C, 0xF8, 0x07,
  0xBE, 0x00, 0xEF, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1C,
  0x03, 0xFE, 0x00, 0x7F, 0xFC, 0x07, 0xE3, 0xF0, 0x78, 0x03, 0xC3, 0x80,
  0x0E, 0x38, 0x00, 0x39, 0xC0, 0x01, 0xDC, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0x70, 0x00, 0x73, 0x80, 0x03, 0x9E,
  0x00, 0x38, 0x78, 0x03, 0xC1, 0xF0, 0x7C, 0x07, 0xFF, 0xC0, 0x0F, 0xF8,
  0x00, 0xFF, 0x81, 0xFF, 0xE3, 0xFF, 0xE7, 0x01, 0xEE, 0x01, 0xDC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3B, 0x80, 0xF7, 0x1F, 0xCF,
  0xFF, 0x1F, 0xF8, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x7F, 0xFC, 0x07, 0xE3, 0xF0, 0x78, 0x03, 0xC3, 0x80, 0x0E, 0x38, 0x00,
  0x39, 0xC0, 0x01, 0xDC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0x70, 0x00, 0x73, 0x80, 0x03, 0x9E, 0x00, 0x38, 0x78,
  0x03, 0xC1, 0xF0, 0x7C, 0x07, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x01, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0xFF,
  0xC0, 0xFF, 0xF0, 0xFF, 0xF8, 0xE0, 0x3C, 0xE0, 0x1C, 0xE0, 0x0E, 0xE0,
  0x0E, 0xE0, 0x0E, 0xE0, 0x1E, 0xE0, 0x1C, 0xE0, 0x3C, 0xFF, 0xF8, 0xFF,
  0xE0, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0x70, 0xE0, 0x70, 0xE0, 0x38, 0xE0,
  0x3C, 0xE0, 0x1C, 0xE0, 0x0E, 0xE0, 0x0F, 0xE0, 0x07, 0x1F, 0xF0, 0xFF,
  0xF7, 0xCF, 0xBC, 0x02, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xF0,
  0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xE0, 0x0F, 0xE0, 0xFB, 0xFF, 0xCF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0xEE, 0x00, 0xE3, 0xE1, 0xF0,
  0xFF, 0xF0, 0x3F, 0xE0, 0xE0, 0x00, 0xFC, 0x00, 0x1D, 0xC0, 0x07, 0x38,
  0x00, 0xE3, 0x80, 0x1C, 0x70, 0x07, 0x0E, 0x00, 0xE0, 0xE0, 0x1C, 0x1C,
  0x07, 0x03, 0x80, 0xE0, 0x38, 0x1C, 0x07, 0x07, 0x00, 0xE0, 0xE0, 0x0E,
  0x38, 0x01, 0xC7, 0x00, 0x38, 0xE0, 0x03, 0xB8, 0x00, 0x77, 0x00, 0x06,
  0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0xE0,
  0x07, 0x00, 0x3B, 0x80, 0x3C, 0x01, 0xDC, 0x01, 0xE0, 0x0E, 0xE0, 0x1F,
  0x00, 0xE3, 0x80, 0xFC, 0x07, 0x1C, 0x06, 0xE0, 0x38, 0xE0, 0x77, 0x01,
  0xC7, 0x03, 0x98, 0x1C, 0x1C, 0x1C, 0xE0, 0xE0, 0xE0, 0xC7, 0x07, 0x07,
  0x0E, 0x18, 0x38, 0x38, 0x70, 0xE3, 0x80, 0xE3, 0x07, 0x1C, 0x07, 0x38,
  0x18, 0xE0, 0x39, 0xC0, 0xE7, 0x01, 0xCE, 0x07, 0x70, 0x06, 0x60, 0x3B,
  0x80, 0x3F, 0x00, 0xDC, 0x01, 0xF8, 0x07, 0xC0, 0x07, 0x80, 0x3E, 0x00,
  0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x38, 0x00, 0x70,
  0x01, 0xCF, 0x00, 0x70, 0xE0, 0x0E, 0x0E, 0x03, 0x81, 0xE0, 0xE0, 0x1C,
  0x1C, 0x01, 0xC7, 0x00, 0x39, 0xC0, 0x03, 0xB8, 0x00, 0x3E, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x07, 0x70, 0x00, 0xCE, 0x00, 0x38,
  0xE0, 0x0E, 0x1E, 0x01, 0xC1, 0xC0, 0x70, 0x1C, 0x1C, 0x03, 0x83, 0x80,
  0x38, 0xE0, 0x07, 0xB8, 0x00, 0x78, 0xE0, 0x01, 0xDC, 0x00, 0xE7, 0x00,
  0x38, 0xE0, 0x1C, 0x38, 0x07, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x38, 0x70,
  0x0F, 0x1C, 0x01, 0xCE, 0x00, 0x3B, 0x00, 0x0F, 0xC0, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x7F, 0xFF,
  0x7F, 0xFF, 0x7F, 0xFF, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0xFF, 0xF0, 0xE0, 0x07, 0x00,
  0x70, 0x03, 0x00, 0x38, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x1C, 0x00, 0xE0,
  0x0E, 0x00, 0x60, 0x07, 0x00, 0x70, 0x03, 0x00, 0x38, 0x03, 0x80, 0x1C,
  0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0xFF, 0xFC, 0x38, 0x70,
  0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1F, 0xFF, 0xF0, 0x01, 0x80, 0x03,
  0x80, 0x03, 0xC0, 0x07, 0xC0, 0x06, 0x60, 0x0E, 0x60, 0x0C, 0x30, 0x1C,
  0x30, 0x18, 0x18, 0x18, 0x1C, 0x30, 0x0C, 0x30, 0x0E, 0x70, 0x06, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0xE0, 0xE0, 0xC0, 0xC0, 0xC0, 0x1F,
  0xF0, 0xFF, 0xE1, 0x83, 0xC0, 0x07, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC3,
  0xFF, 0x3F, 0xFD, 0xE0, 0x37, 0x00, 0xF8, 0x07, 0xE0, 0x1D, 0xC0, 0xF7,
  0x07, 0xDF, 0xFB, 0x1F, 0xCC, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x67, 0xF0, 0xDF, 0xF9, 0xF0, 0x7B,
  0xC0, 0x77, 0x00, 0xEE, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xEF, 0x01, 0xDF, 0x07, 0x37, 0xFE,
  0x67, 0xF0, 0x0F, 0xF3, 0xFF, 0x78, 0x37, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x7C,
  0x33, 0xFF, 0x0F, 0xF0, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x8F, 0xF7, 0x3F, 0xFE, 0xF0, 0x7D, 0xC0,
  0x7F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x77, 0x01, 0xEF, 0x07, 0xCF, 0xFB, 0x8F,
  0xE3, 0x0F, 0xE0, 0xFF, 0xC7, 0x83, 0x9C, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0xC1, 0xCF, 0xFF, 0x0F, 0xF8, 0x07, 0xF0, 0x7F, 0x0E, 0x00,
  0xE0, 0x0C, 0x01, 0xC0, 0x1C, 0x07, 0xFE, 0xFF, 0xE1, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1F, 0xC6, 0x7F, 0xFD, 0xE0,
  0xFB, 0x80, 0xFE, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xEE, 0x03, 0xDE, 0x0F, 0x9F,
  0xFF, 0x1F, 0xCE, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE8, 0x07,
  0x9F, 0xFE, 0x3F, 0xF8, 0x07, 0x80, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3B, 0xFC, 0xDF, 0xFB, 0xE0, 0xFF,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0x27, 0xF6, 0x00, 0x07, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77,
  0x02, 0x07, 0x0F, 0x06, 0x00, 0x00, 0x00, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x06, 0x0E, 0xFE, 0xFC, 0x70, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x1E, 0xE0, 0xF3,
  0x83, 0x8E, 0x1C, 0x38, 0xE0, 0xE7, 0x03, 0x38, 0x0D, 0xE0, 0x3F, 0x80,
  0xF7, 0x03, 0x8E, 0x0E, 0x3C, 0x38, 0x70, 0xE0, 0xE3, 0x81, 0xCE, 0x07,
  0xB8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF,
  0xE1, 0xFC, 0xDF, 0xF3, 0xFE, 0xF8, 0x7E, 0x0F, 0xF0, 0x3C, 0x07, 0xE0,
  0x3C, 0x07, 0xE0, 0x1C, 0x03, 0xE0, 0x18, 0x03, 0xE0, 0x18, 0x03, 0xE0,
  0x18, 0x03, 0xE0, 0x18, 0x03, 0xE0, 0x18, 0x03, 0xE0, 0x18, 0x03, 0xE0,
  0x18, 0x03, 0xE0, 0x18, 0x03, 0xE0, 0x18, 0x03, 0xE0, 0x18, 0x03, 0xE0,
  0x18, 0x03, 0xCF, 0xF3, 0x7F, 0xEF, 0x83, 0xFC, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1C, 0x0F, 0xF0, 0x3F, 0xF8,
  0x78, 0x3C, 0x70, 0x1E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x06, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x06, 0xE0, 0x0E, 0xE0, 0x0E, 0x70, 0x1E,
  0x38, 0x3C, 0x1F, 0xF8, 0x0F, 0xE0, 0xCF, 0xF1, 0xBF, 0xF3, 0xE0, 0xF7,
  0x80, 0xEE, 0x01, 0xDC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x01, 0xDE, 0x03, 0xBE, 0x1E, 0x6F, 0xFC,
  0xCF, 0xE1, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x00, 0x1F, 0xC6, 0x7F, 0xFD, 0xE0, 0xFB, 0x80,
  0xFE, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xEE, 0x03, 0xDE, 0x0F, 0x9F, 0xF7, 0x1F,
  0xCE, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0xC7, 0xF3, 0xFD, 0xC3, 0xC0, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x00, 0x3F, 0xF7, 0xFE, 0xE0, 0x6C, 0x00, 0xC0, 0x0E, 0x00, 0xF8,
  0x07, 0xF0, 0x1F, 0xC0, 0x3E, 0x00, 0xF0, 0x07, 0x00, 0x70, 0x07, 0xC0,
  0xEF, 0xFE, 0xFF, 0x80, 0x18, 0x06, 0x03, 0x80, 0xE0, 0xFF, 0xFF, 0xF3,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0xC0, 0x7F, 0x0F, 0xC0, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0xFF, 0x07, 0xDF, 0xFF, 0x3F,
  0x8C, 0xE0, 0x07, 0x70, 0x07, 0x70, 0x0E, 0x70, 0x0E, 0x38, 0x0C, 0x38,
  0x1C, 0x18, 0x1C, 0x1C, 0x38, 0x1C, 0x38, 0x0C, 0x38, 0x0E, 0x70, 0x0E,
  0x70, 0x06, 0x60, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0xE0,
  0x1C, 0x03, 0xB8, 0x0F, 0x03, 0x9C, 0x0F, 0x81, 0xCE, 0x06, 0xC0, 0xE3,
  0x03, 0x70, 0x71, 0xC3, 0xB8, 0x70, 0xE1, 0xCC, 0x38, 0x70, 0xC6, 0x1C,
  0x18, 0xE3, 0x8C, 0x0E, 0x71, 0xCE, 0x07, 0x30, 0x67, 0x01, 0xB8, 0x3B,
  0x80, 0xDC, 0x1D, 0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x0F, 0x01,
  0xE0, 0x07, 0x00, 0x70, 0x00, 0xF0, 0x1E, 0xE0, 0x38, 0xE0, 0xE1, 0xE3,
  0x81, 0xC7, 0x01, 0xDC, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0x80, 0x0F, 0x80,
  0x3B, 0x80, 0xF7, 0x01, 0xC7, 0x07, 0x07, 0x1C, 0x0F, 0x38, 0x0E, 0xE0,
  0x0E, 0xE0, 0x07, 0x70, 0x07, 0x70, 0x0E, 0x30, 0x0E, 0x38, 0x0E, 0x38,
  0x1C, 0x1C, 0x1C, 0x1C, 0x18, 0x1C, 0x38, 0x0E, 0x38, 0x0E, 0x70, 0x06,
  0x70, 0x07, 0x70, 0x03, 0x60, 0x03, 0xE0, 0x03, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0xFE, 0x00, 0xFC,
  0x00, 0x70, 0x00, 0x7F, 0xFB, 0xFF, 0xC0, 0x1C, 0x01, 0xC0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x70, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x38, 0x01, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xC1, 0xF0, 0x7C, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x70, 0x3C, 0x3E,
  0x0F, 0x00, 0xF0, 0x1C, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0xE0, 0x7C, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3E, 0x0F, 0xC0, 0x70, 0x1C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x38, 0x0F, 0x01, 0xF0, 0x3C, 0x3E, 0x0E, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x70, 0x1C, 0x1F, 0x0F, 0x83,
  0x80, 0x7E, 0x03, 0xFF, 0xFE, 0x0F, 0xF4, 0x03, 0x80,
};

const GFXglyph NotoSans_Regular32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 4, 23, 9, 2, -23 },
  { 13, 9, 8, 13, 2, -23 },
  { 22, 19, 23, 21, 1, -23 },
  { 77, 15, 26, 18, 2, -24 },
  { 126, 23, 23, 27, 2, -23 },
  { 193, 21, 23, 23, 2, -23 },
  { 254, 3, 8, 7, 2, -23 },
  { 257, 8, 28, 10, 1, -23 },
  { 285, 7, 28, 10, 1, -23 },
  { 310, 15, 14, 18, 1, -24 },
  { 337, 15, 15, 18, 2, -19 },
  { 366, 5, 8, 9, 1, -4 },
  { 371, 8, 3, 10, 1, -10 },
  { 374, 4, 4, 9, 2, -4 },
  { 376, 12, 23, 12, 0, -23 },
  { 411, 15, 23, 18, 2, -23 },
  { 455, 8, 23, 18, 3, -23 },
  { 478, 15, 23, 18, 2, -23 },
  { 522, 15, 23, 18, 1, -23 },
  { 566, 17, 23, 18, 1, -23 },
  { 615, 14, 23, 18, 2, -23 },
  { 656, 15, 23, 18, 2, -23 },
  { 700, 16, 23, 18, 1, -23 },
  { 746, 15, 23, 18, 2, -23 },
  { 790, 15, 23, 18, 2, -23 },
  { 834, 4, 18, 9, 2, -18 },
  { 843, 5, 22, 9, 1, -18 },
  { 857, 15, 15, 18, 2, -19 },
  { 886, 14, 9, 18, 2, -16 },
  { 902, 15, 15, 18, 2, -19 },
  { 931, 13, 23, 14, 0, -23 },
  { 969, 25, 26, 29, 2, -23 },
  { 1051, 20, 23, 20, 0, -23 },
  { 1109, 16, 23, 21, 3, -23 },
  { 1155, 17, 23, 20, 2, -23 },
  { 1204, 18, 23, 23, 3, -23 },
  { 1256, 13, 23, 18, 3, -23 },
  { 1294, 13, 23, 17, 3, -23 },
  { 1332, 19, 23, 23, 2, -23 },
  { 1387, 18, 23, 24, 3, -23 },
  { 1439, 9, 23, 11, 1, -23 },
  { 1465, 9, 29, 9, -3, -23 },
  { 1498, 17, 23, 20, 3, -23 },
  { 1547, 13, 23, 17, 3, -23 },
  { 1585, 23, 23, 29, 3, -23 },
  { 1652, 18, 23, 24, 3, -23 },
  { 1704, 21, 23, 25, 2, -23 },
  { 1765, 15, 23, 19, 3, -23 },
  { 1809, 21, 28, 25, 2, -23 },
  { 1883, 16, 23, 20, 3, -23 },
  { 1929, 14, 23, 18, 2, -23 },
  { 1970, 17, 23, 18, 0, -23 },
  { 2019, 17, 23, 23, 3, -23 },
  { 2068, 19, 23, 19, 0, -23 },
  { 2123, 29, 23, 30, 0, -23 },
  { 2207, 19, 23, 19, 0, -23 },
  { 2262, 18, 23, 18, 0, -23 },
  { 2314, 16, 23, 18, 1, -23 },
  { 2360, 7, 28, 11, 3, -23 },
  { 2385, 12, 23, 12, 0, -23 },
  { 2420, 7, 28, 11, 1, -23 },
  { 2445, 16, 14, 18, 1, -23 },
  { 2473, 14, 2, 14, 0, 3 },
  { 2477, 7, 6, 9, 1, -25 },
  { 2483, 14, 17, 18, 1, -17 },
  { 2513, 15, 24, 20, 3, -24 },
  { 2558, 12, 17, 15, 2, -17 },
  { 2584, 15, 24, 20, 2, -24 },
  { 2629, 14, 17, 18, 2, -17 },
  { 2659, 12, 24, 11, 0, -24 },
  { 2695, 15, 25, 20, 2, -17 },
  { 2742, 14, 24, 20, 3, -24 },
  { 2784, 4, 24, 8, 2, -24 },
  { 2796, 8, 32, 8, -2, -24 },
  { 2828, 14, 24, 17, 3, -24 },
  { 2870, 3, 24, 8, 3, -24 },
  { 2879, 24, 17, 30, 3, -17 },
  { 2930, 14, 17, 20, 3, -17 },
  { 2960, 16, 17, 19, 2, -17 },
  { 2994, 15, 25, 20, 3, -17 },
  { 3041, 15, 25, 20, 2, -17 },
  { 3088, 10, 17, 13, 3, -17 },
  { 3110, 12, 17, 15, 2, -17 },
  { 3136, 10, 21, 12, 1, -21 },
  { 3163, 14, 17, 20, 3, -17 },
  { 3193, 16, 17, 16, 0, -17 },
  { 3227, 25, 17, 25, 0, -17 },
  { 3281, 15, 17, 17, 1, -17 },
  { 3313, 16, 25, 16, 0, -17 },
  { 3363, 13, 17, 15, 1, -17 },
  { 3391, 10, 28, 12, 1, -23 },
  { 3426, 2, 32, 18, 8, -24 },
  { 3434, 10, 28, 12, 1, -23 },
  { 3469, 15, 4, 18, 2, -13 },
};

const GFXfont NotoSans_Regular32pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Regular32pt7bBitmaps,
  (GFXglyph *)NotoSans_Regular32pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _NOTOSANS_REGULAR32PT7B_H_
