#ifndef _NOTOSANS_REGULAR62PT7B_H_
#define _NOTOSANS_REGULAR62PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Regular.ttf
// Size: 62pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Regular62pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0x7F, 0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x3E,
  0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E,
  0x3E, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x1C, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x08, 0x3E, 0x7F, 0x7F, 0xFF, 0x7F, 0x7F, 0x7E, 0x3C, 0xFC, 0x1F,
  0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xC0, 0x7D, 0xE0,
  0x3E, 0xF0, 0x1F, 0x78, 0x0F, 0xBC, 0x07, 0xDE, 0x03, 0xCF, 0x01, 0xE7,
  0x80, 0xF3, 0xC0, 0x79, 0xE0, 0x1C, 0xF0, 0x0E, 0x00, 0x07, 0xC0, 0x1E,
  0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x3E, 0x00, 0x00, 0x78,
  0x03, 0xC0, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x00, 0xF8, 0x03, 0xC0, 0x00,
  0x0F, 0x80, 0x7C, 0x00, 0x00, 0xF0, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x01, 0xF0,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x1E, 0x00, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00,
  0x78, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x3E, 0x00, 0x00, 0x78, 0x03, 0xC0,
  0x00, 0x0F, 0x80, 0x3C, 0x00, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x0F, 0x80,
  0x00, 0x1E, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0xF0, 0x00, 0x03, 0xE0, 0x0F, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x03,
  0xC0, 0x1F, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x1E, 0x00,
  0x00, 0x7C, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x78, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFC, 0x7F, 0x8F, 0x1F, 0xC7, 0xE0, 0xF0, 0x18, 0xFC, 0x0F, 0x00, 0x0F,
  0x80, 0xF0, 0x00, 0xF8, 0x0F, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0xF8, 0x0F,
  0x00, 0x0F, 0xC0, 0xF0, 0x00, 0xFC, 0x0F, 0x00, 0x07, 0xE0, 0xF0, 0x00,
  0x7F, 0xCF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0x7F, 0xE0, 0x00, 0xF0, 0xFE, 0x00,
  0x0F, 0x07, 0xF0, 0x00, 0xF0, 0x3F, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0xF0,
  0x1F, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0xF0, 0x3F, 0x00, 0x0F, 0x03, 0xEC,
  0x00, 0xF0, 0x7E, 0xFC, 0x0F, 0x3F, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xC0,
  0x07, 0xFF, 0x80, 0x00, 0x3C, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xE0, 0x03,
  0xE1, 0xF0, 0x00, 0x1E, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF0, 0x01, 0xF0,
  0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x07,
  0xC0, 0x0F, 0x80, 0x07, 0xC0, 0x1E, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0xF0,
  0x07, 0xC0, 0x01, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0x0F, 0x80, 0x3C, 0x03,
  0xE0, 0x00, 0x7C, 0x01, 0xE0, 0x1E, 0x00, 0x03, 0xE0, 0x0F, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x78, 0x1F, 0x00, 0x00, 0xF8, 0x03, 0xC0, 0xF8, 0x00,
  0x07, 0xC0, 0x1E, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0xF0, 0x7C, 0x1F, 0xC0,
  0xF0, 0x0F, 0x87, 0xC3, 0xFF, 0x07, 0x80, 0x7C, 0x3C, 0x3F, 0xFC, 0x3E,
  0x03, 0xC3, 0xE3, 0xFF, 0xF1, 0xF0, 0x3E, 0x1E, 0x1F, 0x0F, 0xC7, 0xC3,
  0xF1, 0xF1, 0xF0, 0x3E, 0x1F, 0xFF, 0x1F, 0x0F, 0x80, 0xF0, 0xFF, 0xF0,
  0xF8, 0x78, 0x07, 0xC3, 0xFF, 0x0F, 0x83, 0xC0, 0x3E, 0x07, 0xE0, 0x7C,
  0x3E, 0x00, 0xF0, 0x00, 0x07, 0xC1, 0xF0, 0x07, 0x80, 0x00, 0x3C, 0x0F,
  0x80, 0x3C, 0x00, 0x03, 0xE0, 0x7C, 0x01, 0xE0, 0x00, 0x1E, 0x03, 0xE0,
  0x0F, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x78, 0x00, 0x1F, 0x00, 0xF8, 0x03,
  0xC0, 0x00, 0xF8, 0x07, 0xC0, 0x1E, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0xF0,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x07, 0xC0, 0x07, 0x80, 0x7C, 0x00,
  0x3C, 0x00, 0x3C, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x1E, 0x00, 0x1E,
  0x00, 0x07, 0xC1, 0xF0, 0x01, 0xF0, 0x00, 0x3F, 0x3F, 0x80, 0x1F, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFC,
  0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x10, 0x1F, 0xFF, 0xC0,
  0x00, 0xF8, 0x0F, 0xF3, 0xF8, 0x00, 0x3E, 0x07, 0xF8, 0x7F, 0x00, 0x1F,
  0x83, 0xF8, 0x0F, 0xE0, 0x07, 0xC0, 0xFC, 0x01, 0xFC, 0x01, 0xF0, 0x7E,
  0x00, 0x3F, 0x80, 0xFC, 0x1F, 0x80, 0x07, 0xF0, 0x3E, 0x07, 0xC0, 0x00,
  0xFE, 0x1F, 0x83, 0xF0, 0x00, 0x1F, 0xC7, 0xC0, 0xFC, 0x00, 0x03, 0xFB,
  0xF0, 0x3F, 0x00, 0x00, 0x7F, 0xF8, 0x0F, 0xC0, 0x00, 0x0F, 0xFE, 0x03,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0xC0, 0x1F, 0x80,
  0x00, 0x1F, 0xF8, 0x07, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0xFE, 0x00, 0x1F,
  0xFF, 0xE0, 0x3F, 0xF0, 0x3F, 0xFB, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x7F,
  0x80, 0xFF, 0xFF, 0xFC, 0x0F, 0xF0, 0x1F, 0xFF, 0xFC, 0x01, 0xFE, 0x01,
  0xFF, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x00, 0x7E,
  0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x03,
  0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x80, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8,
  0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x0F, 0xC0, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F,
  0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00,
  0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x1F,
  0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x1F, 0x80, 0x7C,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x80, 0x0F, 0x00, 0x17,
  0x80, 0x78, 0x07, 0xBF, 0xC3, 0xC3, 0xFD, 0xFF, 0xDE, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x20, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3E, 0x7C, 0x00,
  0x01, 0xF3, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF8, 0x7E, 0x00, 0x1F,
  0x81, 0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xE0, 0x3F, 0x00, 0x3E, 0x01,
  0xF0, 0x00, 0x70, 0x06, 0x00, 0x01, 0x00, 0x20, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x9F,
  0xCF, 0xC7, 0xE3, 0xF1, 0xF1, 0xF8, 0xFC, 0x7C, 0x3E, 0x1E, 0x1F, 0x0F,
  0x87, 0x83, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x08, 0x3E, 0x7F, 0x7F, 0xFF, 0x7F, 0x7F, 0x7E, 0x3C, 0x00, 0x00,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8,
  0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0xFC, 0x3F,
  0x00, 0x07, 0xE1, 0xF0, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0xFC, 0xFC, 0x00,
  0x03, 0xE7, 0xC0, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x07, 0xEF, 0x80,
  0x00, 0x3F, 0x7C, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x0F, 0x9F, 0x80, 0x00,
  0x7C, 0x7C, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x3F, 0x0F, 0x80, 0x03, 0xF0,
  0x7E, 0x00, 0x3F, 0x81, 0xF8, 0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0x80, 0x3F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0xFF, 0x01,
  0xFF, 0x07, 0xFF, 0x0F, 0xFF, 0x1F, 0xDF, 0x7F, 0x9F, 0xFE, 0x1F, 0xFC,
  0x1F, 0x78, 0x1F, 0x70, 0x1F, 0x20, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xF8, 0x7F, 0xC0, 0x1F, 0xE1, 0xF8, 0x00, 0x7F, 0x07, 0x00,
  0x01, 0xFC, 0x10, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F,
  0xC0, 0x1F, 0xE1, 0xF0, 0x00, 0x3F, 0x86, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFA, 0x00,
  0x00, 0x1F, 0xDC, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x7F, 0xC7, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x01, 0xF7,
  0xC0, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00, 0xF8,
  0xF8, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x7C,
  0x1F, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x3E,
  0x07, 0xE0, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x1F,
  0x00, 0xFC, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x0F,
  0x80, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x07,
  0xC0, 0x03, 0xF0, 0x07, 0xC0, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0xFC, 0x03,
  0xE0, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x3F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0x83, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x03,
  0xFC, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE8, 0x00, 0x00, 0xFC, 0xE0,
  0x00, 0x3F, 0xCF, 0xE0, 0x1F, 0xF8, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x07, 0xC1, 0xFF, 0xE0, 0x1F,
  0x1F, 0xFF, 0xC0, 0x7C, 0xFF, 0xFF, 0xC1, 0xF7, 0xFF, 0xFF, 0x87, 0xFE,
  0x00, 0xFE, 0x3F, 0xE0, 0x01, 0xFC, 0xFF, 0x00, 0x03, 0xF3, 0xF8, 0x00,
  0x07, 0xEF, 0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00,
  0xF9, 0xF0, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x3F,
  0x7C, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x0F, 0x8F,
  0x80, 0x00, 0x7E, 0x3F, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x07, 0xC1, 0xF8,
  0x00, 0x3F, 0x03, 0xF0, 0x01, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFC, 0x0F, 0xE0, 0x0F, 0xF0, 0xFE, 0x00, 0x1F, 0x87, 0xE0,
  0x00, 0x7C, 0x3E, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x1F, 0x9F, 0x80, 0x00,
  0x7C, 0xFC, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x3F, 0x1F, 0x00, 0x01, 0xF8,
  0xFC, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0xFC, 0x1F, 0xC0, 0x0F, 0xC0, 0x7F,
  0x00, 0xFC, 0x01, 0xFE, 0x1F, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0,
  0x07, 0xF9, 0xFF, 0x00, 0x7F, 0x03, 0xFE, 0x07, 0xE0, 0x07, 0xF8, 0x7E,
  0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xBE,
  0x00, 0x00, 0xFD, 0xF8, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0xFE, 0x3F, 0xC0,
  0x1F, 0xE0, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xA0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0xFE, 0x00, 0x3F, 0x07, 0xE0, 0x00,
  0xFC, 0x7E, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0x7D,
  0xF8, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F,
  0xBF, 0x00, 0x03, 0xFC, 0xFC, 0x00, 0x3F, 0xE7, 0xF8, 0x07, 0xDF, 0x1F,
  0xFF, 0xFC, 0xF8, 0x7F, 0xFF, 0xC7, 0xC1, 0xFF, 0xFC, 0x7E, 0x03, 0xFF,
  0x83, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x10, 0x03, 0xFE,
  0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3E, 0x7F, 0x7F, 0xFF, 0xFF,
  0x7F, 0x7F, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x3E, 0x7F,
  0x7F, 0xFF, 0x7F, 0x7F, 0x7E, 0x3C, 0x0F, 0x07, 0xE3, 0xFC, 0xFF, 0x3F,
  0xCF, 0xF1, 0xFC, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x1F, 0x87, 0xE3, 0xF0, 0xFC, 0x3F, 0x0F,
  0x83, 0xE1, 0xF8, 0x7C, 0x1F, 0x07, 0xC1, 0xE0, 0xF8, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFC, 0x7E, 0x01, 0xFE, 0x70, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0xFF, 0x00, 0x3C, 0x3E,
  0x00, 0x3F, 0xFF, 0xE0, 0x3E, 0x3E, 0x00, 0x7F, 0xFF, 0xE0, 0x1E, 0x3C,
  0x00, 0xFF, 0xFF, 0xE0, 0x1E, 0x7C, 0x01, 0xF8, 0x03, 0xC0, 0x1F, 0x78,
  0x03, 0xF0, 0x03, 0xC0, 0x1F, 0x78, 0x03, 0xE0, 0x03, 0xC0, 0x0F, 0xF8,
  0x07, 0xC0, 0x03, 0xC0, 0x0F, 0xF8, 0x07, 0xC0, 0x03, 0xC0, 0x0F, 0xF0,
  0x0F, 0x80, 0x03, 0xC0, 0x0F, 0xF0, 0x0F, 0x80, 0x07, 0xC0, 0x0F, 0xF0,
  0x0F, 0x80, 0x07, 0xC0, 0x0F, 0xF0, 0x0F, 0x80, 0x07, 0xC0, 0x0F, 0xF0,
  0x0F, 0x80, 0x07, 0xC0, 0x1F, 0xF0, 0x0F, 0x80, 0x07, 0xC0, 0x1F, 0xF0,
  0x0F, 0x80, 0x07, 0xC0, 0x1E, 0xF0, 0x0F, 0x80, 0x07, 0xC0, 0x1E, 0xF0,
  0x0F, 0x80, 0x0F, 0xC0, 0x3E, 0xF0, 0x07, 0xC0, 0x0F, 0xC0, 0x3C, 0xF0,
  0x07, 0xC0, 0x1F, 0xC0, 0x7C, 0xF8, 0x07, 0xE0, 0x3D, 0xE0, 0xF8, 0xF8,
  0x03, 0xFF, 0xFD, 0xFF, 0xF8, 0x78, 0x01, 0xFF, 0xF8, 0xFF, 0xF0, 0x7C,
  0x00, 0xFF, 0xF0, 0x7F, 0xE0, 0x7C, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x30, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x01, 0xEF, 0x80, 0x00, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x00, 0x03, 0xE7,
  0xC0, 0x00, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x00, 0x07, 0xC7, 0xE0, 0x00,
  0x00, 0x07, 0xC3, 0xE0, 0x00, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x00, 0x0F,
  0x83, 0xF0, 0x00, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x00, 0x1F, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x07,
  0xE0, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x03, 0xF0,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x1F, 0x00,
  0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x00,
  0xFC, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x7C,
  0x00, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFF, 0x1F, 0x80, 0x01, 0xFE, 0x3F, 0x00, 0x00, 0xFE,
  0x7E, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x03, 0xF3,
  0xF0, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x0F, 0x9F,
  0x80, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0xF8, 0xFC,
  0x00, 0x03, 0xF1, 0xF8, 0x00, 0x1F, 0xC3, 0xF0, 0x07, 0xFF, 0x07, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xF0, 0x7E, 0x00, 0x1F, 0xF8, 0xFC, 0x00, 0x07, 0xF9, 0xF8, 0x00,
  0x03, 0xF3, 0xF0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x7F,
  0xBF, 0x00, 0x03, 0xFE, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFC, 0x03,
  0xF8, 0x1F, 0xF0, 0x00, 0x18, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x06, 0x03, 0xFF, 0xC1,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xE0, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x81, 0xF8, 0x00, 0x1F, 0xF8,
  0x3F, 0x00, 0x00, 0xFF, 0x87, 0xE0, 0x00, 0x07, 0xF8, 0xFC, 0x00, 0x00,
  0x7F, 0x1F, 0x80, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x00, 0x7E, 0x7E, 0x00,
  0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x1F, 0xBF,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00,
  0x03, 0xF7, 0xE0, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0x1F, 0x9F, 0x80,
  0x00, 0x07, 0xF3, 0xF0, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x00, 0x7F, 0x8F,
  0xC0, 0x00, 0x1F, 0xE1, 0xF8, 0x00, 0x0F, 0xF8, 0x3F, 0x00, 0x0F, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFD, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xE0, 0x0F, 0xF0, 0x0F, 0xF8, 0x00, 0x07, 0x00, 0xFF, 0x00, 0x00, 0x08,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x0F,
  0xCF, 0xE0, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x03, 0xF1, 0xFC, 0x00,
  0x00, 0x1F, 0x87, 0xF0, 0x00, 0x00, 0xFC, 0x3F, 0xE0, 0x00, 0x07, 0xE0,
  0xFF, 0xC0, 0x00, 0x3F, 0x03, 0xFF, 0xE0, 0x1F, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFC, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x3F,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x81,
  0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0x3E, 0x00, 0xFC,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x01, 0xF8, 0xFC,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xC0, 0xFC,
  0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x7F, 0x00, 0xFC,
  0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0xFC,
  0x03, 0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0xFC,
  0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00, 0xFC,
  0xFE, 0x00, 0x00, 0xFD, 0xFE, 0x00, 0x00, 0xFD, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0x9F, 0x80, 0x00, 0xFF,
  0x1F, 0xC0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0xFC,
  0x03, 0xF0, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0xFC,
  0x00, 0xFE, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0xFC,
  0x00, 0x3F, 0x80, 0xFC, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x1F, 0xC0, 0xFC,
  0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x03, 0xF8, 0xFC, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x00, 0xFE, 0xFC,
  0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x7D, 0xFF, 0xBE, 0x00, 0x00, 0x07, 0xDF, 0xFB, 0xF0, 0x00,
  0x00, 0x7D, 0xFF, 0x9F, 0x00, 0x00, 0x0F, 0x9F, 0xF9, 0xF0, 0x00, 0x00,
  0xF9, 0xFF, 0x9F, 0x80, 0x00, 0x0F, 0x9F, 0xF8, 0xF8, 0x00, 0x01, 0xF1,
  0xFF, 0x8F, 0x80, 0x00, 0x1F, 0x1F, 0xF8, 0xFC, 0x00, 0x03, 0xE1, 0xFF,
  0x87, 0xC0, 0x00, 0x3E, 0x1F, 0xF8, 0x7E, 0x00, 0x03, 0xE1, 0xFF, 0x83,
  0xE0, 0x00, 0x7C, 0x1F, 0xF8, 0x3E, 0x00, 0x07, 0xC1, 0xFF, 0x83, 0xF0,
  0x00, 0xF8, 0x1F, 0xF8, 0x1F, 0x00, 0x0F, 0x81, 0xFF, 0x81, 0xF0, 0x00,
  0xF8, 0x1F, 0xF8, 0x1F, 0x80, 0x1F, 0x01, 0xFF, 0x80, 0xF8, 0x01, 0xF0,
  0x1F, 0xF8, 0x0F, 0xC0, 0x1F, 0x01, 0xFF, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xFF, 0x80, 0x7E, 0x07, 0xC0, 0x1F, 0xF8,
  0x03, 0xE0, 0x7C, 0x01, 0xFF, 0x80, 0x3E, 0x07, 0xC0, 0x1F, 0xF8, 0x03,
  0xF0, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0xF8, 0x01, 0xF9,
  0xF8, 0x01, 0xFF, 0x80, 0x0F, 0x9F, 0x00, 0x1F, 0xF8, 0x00, 0xF9, 0xF0,
  0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0x80, 0x01,
  0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x1F, 0xFB, 0xF0, 0x00, 0x03, 0xFF, 0x7F, 0x00, 0x00, 0x7F, 0xE7,
  0xE0, 0x00, 0x0F, 0xFC, 0x7E, 0x00, 0x01, 0xFF, 0x8F, 0xE0, 0x00, 0x3F,
  0xF0, 0xFC, 0x00, 0x07, 0xFE, 0x0F, 0xC0, 0x00, 0xFF, 0xC1, 0xFC, 0x00,
  0x1F, 0xF8, 0x1F, 0x80, 0x03, 0xFF, 0x01, 0xF8, 0x00, 0x7F, 0xE0, 0x3F,
  0x80, 0x0F, 0xFC, 0x03, 0xF0, 0x01, 0xFF, 0x80, 0x7F, 0x00, 0x3F, 0xF0,
  0x07, 0xF0, 0x07, 0xFE, 0x00, 0x7E, 0x00, 0xFF, 0xC0, 0x0F, 0xE0, 0x1F,
  0xF8, 0x00, 0xFC, 0x03, 0xFF, 0x00, 0x0F, 0xC0, 0x7F, 0xE0, 0x01, 0xFC,
  0x0F, 0xFC, 0x00, 0x1F, 0x81, 0xFF, 0x80, 0x01, 0xF8, 0x3F, 0xF0, 0x00,
  0x3F, 0x87, 0xFE, 0x00, 0x03, 0xF0, 0xFF, 0xC0, 0x00, 0x3F, 0x1F, 0xF8,
  0x00, 0x07, 0xF3, 0xFF, 0x00, 0x00, 0x7E, 0x7F, 0xE0, 0x00, 0x0F, 0xEF,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x00, 0x07, 0xE3, 0xF0,
  0x00, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00,
  0x00, 0x7E, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x00, 0x1F,
  0xBF, 0x00, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x00, 0x03, 0xEF, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xDF, 0x80,
  0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00,
  0x01, 0xF9, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x7E, 0x00, 0x00, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x00, 0x1F, 0xC0,
  0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xCF, 0xC0, 0x03, 0xFC, 0xFC, 0x00, 0x0F,
  0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFE, 0xFC, 0x00,
  0x3F, 0xCF, 0xC0, 0x0F, 0xF8, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00,
  0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x00,
  0xFE, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC7,
  0xF0, 0x00, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00, 0x03, 0xF1, 0xF8, 0x00,
  0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x00, 0x0F, 0xDF,
  0x80, 0x00, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0x81, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0xFF, 0x00, 0x00, 0x1F,
  0xC0, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x03,
  0xFF, 0x81, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x00, 0x3F, 0xE0, 0xFC, 0x00, 0x0F,
  0xE0, 0xFC, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03,
  0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x01,
  0xF0, 0xFC, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03,
  0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F,
  0xE0, 0xFC, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x7F, 0x80, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0xFC, 0x01, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x1F,
  0x80, 0xFC, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03,
  0xF8, 0xFC, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00,
  0xFE, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC3, 0xFE,
  0x01, 0xFC, 0x3F, 0x80, 0x01, 0xC7, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x80, 0x00, 0x0F, 0xEF, 0x00, 0x01,
  0xFC, 0xFF, 0x80, 0xFF, 0xCF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00,
  0x3F, 0x0F, 0xE0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0xF0,
  0x3F, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00,
  0x00, 0xFC, 0xFC, 0x00, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00, 0x3F, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x00,
  0xF8, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x7E, 0x03, 0xF0,
  0x00, 0x03, 0xE0, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x01, 0xF8,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x7C, 0x00,
  0x07, 0xE0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x3F, 0x00, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x1F, 0x80,
  0x00, 0x0F, 0x80, 0xFC, 0x00, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x03, 0xF0,
  0x7E, 0x00, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x00, 0x7E, 0x1F, 0x00, 0x00,
  0x03, 0xF1, 0xF8, 0x00, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x00, 0x7E, 0x7C,
  0x00, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x00,
  0x7D, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3E, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7E, 0x7E,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xFC, 0x3F, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xF8, 0x1F, 0x00,
  0x03, 0xE7, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x07, 0xC7, 0xC0, 0x01, 0xF8,
  0x1F, 0x80, 0x07, 0xC7, 0xC0, 0x01, 0xF0, 0x1F, 0x80, 0x07, 0xC7, 0xE0,
  0x01, 0xF0, 0x0F, 0x80, 0x0F, 0xC3, 0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x0F,
  0x83, 0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x0F, 0x83, 0xF0, 0x03, 0xE0, 0x0F,
  0xC0, 0x0F, 0x81, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x81, 0xF0, 0x07,
  0xE0, 0x07, 0xE0, 0x1F, 0x01, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x1F, 0x01,
  0xF8, 0x07, 0xC0, 0x03, 0xE0, 0x3F, 0x00, 0xF8, 0x07, 0xC0, 0x03, 0xE0,
  0x3E, 0x00, 0xF8, 0x0F, 0xC0, 0x03, 0xF0, 0x3E, 0x00, 0xFC, 0x0F, 0xC0,
  0x03, 0xF0, 0x7E, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x7C,
  0x1F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x7E, 0x1F, 0x80, 0x01, 0xF8, 0x7C,
  0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x3E, 0x1F, 0x00, 0x00,
  0xF8, 0xF8, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x3F, 0x3F,
  0x00, 0x00, 0xFC, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0xFD, 0xF0, 0x00,
  0x1F, 0x3E, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x7D,
  0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x7D, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xE3, 0xF0, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x1F, 0x80, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x3E, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00,
  0x1F, 0x8F, 0x80, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x0F, 0xDF, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x01, 0xF0,
  0xFC, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00,
  0x7E, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0xF8, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00,
  0x07, 0xE0, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x0F,
  0xC0, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x01, 0xF9, 0xFC,
  0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x01, 0xF8,
  0x3F, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x03,
  0xF0, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x03,
  0xF0, 0x07, 0xE0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x3F, 0x00,
  0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x00, 0xFC, 0x7E,
  0x00, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x3C, 0xF8, 0x00, 0x00, 0xF8, 0xF0,
  0x00, 0x01, 0xE1, 0xF0, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x0F, 0x03, 0xE0,
  0x00, 0x3E, 0x03, 0xC0, 0x00, 0x78, 0x07, 0xC0, 0x01, 0xF0, 0x07, 0x80,
  0x03, 0xE0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x3E, 0x07,
  0xC0, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0xF8, 0x7C,
  0x00, 0x00, 0xF9, 0xF0, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x01, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x1F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x0F, 0x00, 0x3F,
  0x81, 0x80, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0xFF, 0xC0, 0x1F, 0xBF, 0xC0, 0x03, 0xF7,
  0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE,
  0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFE, 0xFE, 0x01, 0xF7, 0xDF, 0xFF, 0xFC,
  0xF9, 0xFF, 0xFF, 0x9F, 0x1F, 0xFF, 0xC3, 0xE0, 0xFF, 0xF0, 0x3C, 0x01,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x0F, 0xC3, 0xFF, 0xC0, 0x3F,
  0x3F, 0xFF, 0xC0, 0xFD, 0xFF, 0xFF, 0x83, 0xEF, 0xFF, 0xFF, 0x0F, 0xFE,
  0x01, 0xFE, 0x3F, 0xE0, 0x01, 0xF8, 0xFF, 0x00, 0x03, 0xF3, 0xF8, 0x00,
  0x0F, 0xCF, 0xE0, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x7E, 0xFC, 0x00, 0x01,
  0xFB, 0xF0, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x0F, 0xBF, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x01, 0xFB, 0xF8, 0x00,
  0x07, 0xEF, 0xE0, 0x00, 0x1F, 0xBF, 0xC0, 0x00, 0xFC, 0xFF, 0x00, 0x07,
  0xF3, 0xFE, 0x00, 0x3F, 0x8F, 0xFE, 0x01, 0xFE, 0x3E, 0xFF, 0xFF, 0xF0,
  0xF9, 0xFF, 0xFF, 0x83, 0xE1, 0xFF, 0xF8, 0x0F, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x7F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0x80, 0x70, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x10, 0x7F, 0x80,
  0x78, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0x03, 0xF0, 0x0F, 0xFF,
  0x0F, 0xC0, 0xFF, 0xFF, 0x1F, 0x07, 0xFF, 0xFE, 0x7C, 0x3F, 0xFF, 0xFD,
  0xF1, 0xFE, 0x01, 0xFF, 0xC7, 0xF0, 0x01, 0xFF, 0x3F, 0x80, 0x03, 0xFC,
  0xFC, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x3F, 0x7E,
  0x00, 0x00, 0xFD, 0xF8, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x0F, 0xDF, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x03,
  0xF7, 0xC0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0xFD,
  0xF8, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x7F, 0x3F,
  0x80, 0x03, 0xFC, 0x7F, 0x00, 0x1F, 0xF1, 0xFF, 0x01, 0xFF, 0xC3, 0xFF,
  0xFF, 0xDF, 0x07, 0xFF, 0xFE, 0x7C, 0x07, 0xFF, 0xE1, 0xF0, 0x0F, 0xFF,
  0x07, 0xC0, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x7E, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0xFC, 0x3F, 0x00,
  0x03, 0xF1, 0xF0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x7C, 0xFC, 0x00, 0x03,
  0xE7, 0xC0, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x06, 0x07, 0xFC, 0x01, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0,
  0x1F, 0xC0, 0xC0, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xE0, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xFF, 0xC1, 0xF0,
  0x3F, 0xFF, 0xC7, 0xC1, 0xFF, 0xFF, 0x9F, 0x0F, 0xFF, 0xFF, 0x7C, 0x3F,
  0x80, 0x7F, 0xF1, 0xFC, 0x00, 0x7F, 0xCF, 0xE0, 0x00, 0xFF, 0x3F, 0x00,
  0x01, 0xFC, 0xF8, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x0F, 0xDF, 0x80, 0x00,
  0x3F, 0x7E, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0xFD, 0xF0,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x3F, 0x7E, 0x00,
  0x00, 0xFC, 0xFC, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x1F, 0xCF, 0xE0, 0x00,
  0xFF, 0x1F, 0xC0, 0x07, 0xFC, 0x3F, 0x80, 0x7F, 0xF0, 0xFF, 0xFF, 0xF7,
  0xC1, 0xFF, 0xFF, 0x9F, 0x01, 0xFF, 0xFC, 0xFC, 0x03, 0xFF, 0xC3, 0xF0,
  0x00, 0x60, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE1, 0x80, 0x00, 0x7F, 0x07, 0xC0, 0x03,
  0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0xFC, 0x3F, 0xFE,
  0x0F, 0xCF, 0xFF, 0xF8, 0xFD, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xE0, 0x1F, 0xEF, 0xF8, 0x00, 0x7E, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F,
  0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x1F, 0xFC, 0x00, 0x01, 0xF0, 0x33, 0xFF, 0xFF, 0xFF, 0xF7, 0x80, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x30, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x7E, 0xFF, 0xFB, 0xFF, 0xCF, 0xFE, 0x3F,
  0xF0, 0x7F, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x02, 0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xF8, 0xFC,
  0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x1F,
  0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x0F,
  0xC1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0xFC, 0xFE,
  0x00, 0x0F, 0xCF, 0xC0, 0x00, 0xFD, 0xFC, 0x00, 0x0F, 0xBF, 0xC0, 0x00,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0x3F, 0x80, 0x0F, 0xE1,
  0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xC0, 0xFE, 0x00, 0xFC, 0x07, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x0F, 0xC0, 0x1F, 0xC0, 0xFC,
  0x00, 0xFE, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03,
  0xF8, 0xFC, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x07, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0xF8, 0x3F, 0xFC, 0x01, 0xFF, 0xE0,
  0xF8, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0xF9, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC,
  0xFB, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFE,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7E, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7E,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x00, 0x07, 0xF0, 0x0F, 0x83, 0xFF, 0xE0, 0xF8, 0xFF, 0xFF, 0x8F, 0x9F,
  0xFF, 0xFC, 0xFB, 0xFF, 0xFF, 0xCF, 0xFE, 0x01, 0xFE, 0xFF, 0x80, 0x07,
  0xEF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFE,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F,
  0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x07, 0xF0,
  0x00, 0xFC, 0x1F, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x01, 0xF8, 0x7E, 0x00,
  0x01, 0xF9, 0xF8, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x03, 0xE7, 0xE0, 0x00,
  0x07, 0xEF, 0x80, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x0F,
  0xDF, 0x80, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0xFC,
  0x7E, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0xC1,
  0xFC, 0x00, 0x7F, 0x01, 0xFE, 0x03, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x03, 0xE0, 0xFF, 0xF0, 0x0F, 0x8F,
  0xFF, 0xF0, 0x3E, 0x7F, 0xFF, 0xE0, 0xFB, 0xFF, 0xFF, 0xC3, 0xFF, 0x80,
  0x7F, 0x8F, 0xF8, 0x00, 0xFE, 0x3F, 0xC0, 0x01, 0xFC, 0xFE, 0x00, 0x03,
  0xF3, 0xF8, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7E,
  0xFC, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xEF, 0xC0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x01,
  0xFB, 0xF8, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x3F, 0x3F, 0xC0, 0x01, 0xFC,
  0xFF, 0x80, 0x0F, 0xE3, 0xFF, 0x80, 0xFF, 0x8F, 0xBF, 0xFF, 0xFC, 0x3F,
  0x7F, 0xFF, 0xE0, 0xFC, 0x7F, 0xFF, 0x03, 0xF0, 0xFF, 0xF0, 0x0F, 0xC0,
  0x3C, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xFF, 0xC1, 0xF0, 0x3F, 0xFF, 0xC7, 0xC1, 0xFF, 0xFF, 0x9F, 0x0F, 0xFF,
  0xFF, 0x7C, 0x7F, 0x80, 0x7F, 0xF1, 0xFC, 0x00, 0x7F, 0xCF, 0xE0, 0x00,
  0xFF, 0x3F, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x0F,
  0xDF, 0x80, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0x7C, 0x00,
  0x00, 0xFD, 0xF0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x0F, 0xDF, 0x80, 0x00,
  0x3F, 0x7E, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x1F,
  0xCF, 0xE0, 0x00, 0xFF, 0x1F, 0xC0, 0x07, 0xFC, 0x7F, 0xC0, 0x7F, 0xF0,
  0xFF, 0xFF, 0xF7, 0xC1, 0xFF, 0xFF, 0xBF, 0x01, 0xFF, 0xF8, 0xFC, 0x03,
  0xFF, 0xC3, 0xF0, 0x00, 0x60, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x07, 0xFF, 0x81, 0xFF, 0xF8, 0x7F, 0xEF, 0x8F, 0xFE, 0xF9, 0xFF, 0xEF,
  0xBF, 0x82, 0xFB, 0xE0, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFC, 0x7F, 0x00, 0x3C, 0xFC, 0x00, 0x04, 0xFC, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFE, 0x00,
  0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x7E, 0xF8, 0x00, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x01, 0xF0, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xF8, 0x10, 0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x0F,
  0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x78, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x7F, 0xFE, 0x00, 0x0F, 0xF7, 0xF0, 0x01, 0xFF, 0x7F, 0x80, 0x7F, 0xF3,
  0xFF, 0xFF, 0xDF, 0x1F, 0xFF, 0xF9, 0xF0, 0xFF, 0xFF, 0x1F, 0x03, 0xFF,
  0xC1, 0xF0, 0x05, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x7C, 0x00, 0x00,
  0x7E, 0x7E, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00,
  0xFC, 0x3F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x01,
  0xF8, 0x1F, 0x80, 0x01, 0xF0, 0x0F, 0x80, 0x03, 0xF0, 0x0F, 0xC0, 0x03,
  0xE0, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xC0, 0x03, 0xE0, 0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x0F,
  0x80, 0x01, 0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x00, 0x01, 0xF8, 0x1F,
  0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x00, 0x7C, 0x3E,
  0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00, 0x3E, 0x7C,
  0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF3, 0xE0,
  0x00, 0xFF, 0x80, 0x07, 0xE7, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xCF, 0xC0,
  0x03, 0xFE, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0xBC, 0x00, 0x3E, 0x1F, 0x00,
  0x1F, 0x7C, 0x00, 0xFC, 0x3F, 0x00, 0x3E, 0xF8, 0x01, 0xF8, 0x7E, 0x00,
  0xF9, 0xF0, 0x03, 0xE0, 0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xC0, 0xF8, 0x03,
  0xE3, 0xE0, 0x1F, 0x81, 0xF8, 0x0F, 0x87, 0xC0, 0x3F, 0x03, 0xF0, 0x1F,
  0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x3E, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0xFC,
  0x1F, 0x03, 0xF0, 0x0F, 0xC1, 0xF0, 0x3F, 0x07, 0xC0, 0x0F, 0x83, 0xE0,
  0x3E, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x7C, 0x1F, 0x00, 0x3E, 0x1F, 0x00,
  0xF8, 0x7E, 0x00, 0x7E, 0x3E, 0x00, 0xF8, 0xF8, 0x00, 0x7C, 0x7C, 0x01,
  0xF1, 0xF0, 0x00, 0xF9, 0xF0, 0x03, 0xE3, 0xE0, 0x01, 0xF3, 0xE0, 0x03,
  0xEF, 0x80, 0x03, 0xF7, 0xC0, 0x07, 0xDF, 0x00, 0x03, 0xEF, 0x00, 0x0F,
  0xBE, 0x00, 0x07, 0xDE, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x7E,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x3F, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x07, 0xE0, 0x01, 0xF8,
  0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03, 0xF1,
  0xF8, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0x3F, 0x1F, 0x80,
  0x00, 0xFC, 0x1F, 0x80, 0x03, 0xF0, 0x1F, 0x80, 0x0F, 0xC0, 0x3F, 0x00,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x7E, 0x03,
  0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0xFE, 0xFE,
  0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x7E, 0x7E,
  0x00, 0x00, 0x7E, 0x3E, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x3F,
  0x00, 0x00, 0xF8, 0x1F, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x0F,
  0x80, 0x01, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x07,
  0xC0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x03,
  0xE0, 0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x01, 0xF0, 0x0F, 0x80, 0x01,
  0xF8, 0x1F, 0x80, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x00,
  0xFC, 0x3F, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00,
  0x3E, 0x7E, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0x80,
  0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0xFF,
  0xE0, 0x0F, 0xF8, 0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xC0, 0x01,
  0xFE, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xF0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x0F,
  0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xFE, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x09, 0xFF, 0xE0, 0x00, 0x5F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0x90, 0x00, 0x0F, 0xF8,
};

const GFXglyph NotoSans_Regular62pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 8, 45, 17, 4, -44 },
  { 46, 17, 16, 25, 4, -44 },
  { 80, 36, 44, 40, 2, -44 },
  { 278, 28, 51, 35, 4, -47 },
  { 457, 45, 46, 52, 3, -45 },
  { 716, 42, 46, 45, 3, -45 },
  { 958, 6, 16, 14, 4, -44 },
  { 970, 15, 54, 19, 2, -44 },
  { 1072, 14, 54, 19, 2, -44 },
  { 1167, 29, 28, 34, 3, -47 },
  { 1269, 29, 30, 35, 3, -37 },
  { 1378, 9, 15, 17, 3, -7 },
  { 1395, 15, 5, 20, 2, -19 },
  { 1405, 8, 9, 17, 4, -8 },
  { 1414, 21, 44, 23, 1, -44 },
  { 1530, 29, 46, 35, 3, -45 },
  { 1697, 16, 44, 35, 6, -44 },
  { 1785, 29, 45, 35, 3, -45 },
  { 1949, 29, 46, 35, 3, -45 },
  { 2116, 33, 45, 35, 1, -45 },
  { 2302, 28, 45, 35, 4, -44 },
  { 2460, 30, 46, 35, 3, -45 },
  { 2633, 29, 44, 35, 3, -44 },
  { 2793, 29, 46, 35, 3, -45 },
  { 2960, 29, 46, 35, 3, -45 },
  { 3127, 8, 35, 17, 4, -34 },
  { 3162, 10, 42, 17, 2, -34 },
  { 3215, 29, 31, 35, 3, -38 },
  { 3328, 29, 17, 35, 3, -30 },
  { 3390, 29, 31, 35, 3, -38 },
  { 3503, 24, 46, 27, 1, -45 },
  { 3641, 48, 50, 56, 4, -44 },
  { 3941, 40, 44, 40, 0, -44 },
  { 4161, 31, 44, 40, 6, -44 },
  { 4332, 33, 46, 39, 4, -45 },
  { 4522, 35, 44, 45, 6, -44 },
  { 4715, 25, 44, 34, 6, -44 },
  { 4853, 25, 44, 32, 6, -44 },
  { 4991, 37, 46, 45, 4, -45 },
  { 5204, 34, 44, 46, 6, -44 },
  { 5391, 16, 44, 21, 2, -44 },
  { 5479, 16, 56, 17, -5, -44 },
  { 5591, 32, 44, 38, 6, -44 },
  { 5767, 25, 44, 32, 6, -44 },
  { 5905, 44, 44, 56, 6, -44 },
  { 6147, 35, 44, 47, 6, -44 },
  { 6340, 41, 46, 48, 4, -45 },
  { 6576, 28, 44, 38, 6, -44 },
  { 6730, 41, 56, 48, 4, -45 },
  { 7017, 32, 44, 39, 6, -44 },
  { 7193, 28, 46, 34, 3, -45 },
  { 7354, 33, 44, 34, 1, -44 },
  { 7536, 34, 45, 45, 6, -44 },
  { 7728, 37, 44, 37, 0, -44 },
  { 7932, 56, 44, 58, 1, -44 },
  { 8240, 36, 44, 36, 0, -44 },
  { 8438, 35, 44, 35, 0, -44 },
  { 8631, 31, 44, 35, 2, -44 },
  { 8802, 14, 54, 20, 5, -44 },
  { 8897, 22, 44, 23, 1, -44 },
  { 9018, 13, 54, 20, 2, -44 },
  { 9106, 31, 28, 35, 2, -45 },
  { 9215, 28, 4, 28, 0, 6 },
  { 9229, 13, 9, 17, 2, -47 },
  { 9244, 27, 35, 35, 3, -34 },
  { 9363, 30, 48, 38, 5, -47 },
  { 9543, 25, 35, 30, 3, -34 },
  { 9653, 30, 48, 38, 3, -47 },
  { 9833, 29, 35, 35, 3, -34 },
  { 9960, 23, 47, 21, 1, -47 },
  { 10096, 30, 49, 38, 3, -34 },
  { 10280, 28, 47, 38, 5, -47 },
  { 10445, 6, 46, 16, 5, -46 },
  { 10480, 14, 61, 16, -3, -46 },
  { 10587, 28, 47, 33, 5, -47 },
  { 10752, 6, 47, 16, 5, -47 },
  { 10788, 48, 34, 58, 5, -34 },
  { 10992, 28, 34, 38, 5, -34 },
  { 11111, 31, 35, 38, 3, -34 },
  { 11247, 30, 49, 38, 5, -34 },
  { 11431, 30, 49, 38, 3, -34 },
  { 11615, 20, 34, 26, 5, -34 },
  { 11700, 24, 35, 30, 3, -34 },
  { 11805, 20, 42, 22, 1, -41 },
  { 11910, 28, 34, 38, 5, -33 },
  { 12029, 32, 33, 32, 0, -33 },
  { 12161, 47, 33, 49, 1, -33 },
  { 12355, 31, 33, 33, 1, -33 },
  { 12483, 32, 48, 32, 0, -33 },
  { 12675, 25, 33, 29, 2, -33 },
  { 12779, 20, 54, 24, 2, -44 },
  { 12914, 4, 62, 34, 15, -47 },
  { 12945, 20, 54, 24, 2, -44 },
  { 13080, 29, 8, 35, 3, -26 },
};

const GFXfont NotoSans_Regular62pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Regular62pt7bBitmaps,
  (GFXglyph *)NotoSans_Regular62pt7bGlyphs,
  0x20, 0x7E, 84
};

#endif // _NOTOSANS_REGULAR62PT7B_H_
