#ifndef _NOTOSANS_REGULAR55PT7B_H_
#define _NOTOSANS_REGULAR55PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Regular.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Regular55pt7bBitmaps[] PROGMEM = {
  0x00, 0xFC, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF1, 0xE3, 0xC7, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xC0, 0x00, 0x00, 0x00, 0x30, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0x1C,
  0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x03, 0xFE, 0x07, 0xBC,
  0x0F, 0x78, 0x1E, 0xF0, 0x3D, 0xE0, 0x7B, 0xC0, 0xF7, 0x80, 0xE7, 0x01,
  0xCE, 0x03, 0x80, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x07, 0x80, 0x78, 0x00,
  0x03, 0xC0, 0x3C, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0xF0, 0x0E, 0x00,
  0x00, 0x78, 0x0F, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x3C, 0x03, 0xC0,
  0x00, 0x1E, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x07, 0x80, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x78, 0x07,
  0x80, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x03, 0xC0,
  0x3C, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1E,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x03,
  0x80, 0x78, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00,
  0xF0, 0x0F, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00,
  0x3C, 0x03, 0xC0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0x1F, 0xEE, 0x3F, 0x1F, 0x87, 0x01, 0x8F, 0x83, 0x80, 0x0F, 0x81, 0xC0,
  0x07, 0xC0, 0xE0, 0x03, 0xE0, 0x70, 0x01, 0xF0, 0x38, 0x00, 0x7C, 0x1C,
  0x00, 0x3F, 0x0E, 0x00, 0x0F, 0xE7, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF,
  0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00,
  0x1F, 0xFE, 0x00, 0x0E, 0x7F, 0x80, 0x07, 0x0F, 0xE0, 0x03, 0x81, 0xF0,
  0x01, 0xC0, 0xF8, 0x00, 0xE0, 0x3C, 0x00, 0x70, 0x1E, 0x00, 0x38, 0x1F,
  0x00, 0x1C, 0x0F, 0xE0, 0x0E, 0x0F, 0xFF, 0x07, 0x3F, 0xDF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0x80, 0x3F, 0xF8, 0x00, 0x0F, 0x00, 0x3F, 0xFC, 0x00, 0x1E,
  0x00, 0x7C, 0x3C, 0x00, 0x1E, 0x00, 0x78, 0x1E, 0x00, 0x3C, 0x00, 0xF0,
  0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x0F, 0x00,
  0xF8, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x00, 0xF0, 0x0F, 0x01, 0xE0, 0x00,
  0xF0, 0x0F, 0x01, 0xE0, 0x00, 0xF0, 0x0F, 0x03, 0xC0, 0x00, 0xF0, 0x0F,
  0x03, 0xC0, 0x00, 0xF0, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0x0F, 0x0F, 0x80,
  0x00, 0xF0, 0x0F, 0x0F, 0x07, 0xE0, 0xF0, 0x1E, 0x1F, 0x1F, 0xF0, 0xF0,
  0x1E, 0x1E, 0x3F, 0xF8, 0x78, 0x1E, 0x3C, 0x7E, 0x7C, 0x7C, 0x3E, 0x3C,
  0x78, 0x3E, 0x3F, 0xFC, 0x78, 0x78, 0x1E, 0x3F, 0xF8, 0x78, 0xF0, 0x1E,
  0x1F, 0xF0, 0xF0, 0xF0, 0x0F, 0x03, 0xC1, 0xF0, 0xF0, 0x0F, 0x00, 0x01,
  0xE0, 0xF0, 0x0F, 0x00, 0x03, 0xE0, 0xF0, 0x0F, 0x00, 0x03, 0xC0, 0xF0,
  0x0F, 0x00, 0x07, 0x80, 0xF0, 0x0F, 0x00, 0x07, 0x80, 0xF0, 0x0F, 0x00,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x1E, 0x00,
  0xF0, 0x0F, 0x00, 0x3E, 0x00, 0xF0, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x1E,
  0x00, 0x7C, 0x00, 0x78, 0x1E, 0x00, 0x78, 0x00, 0x7C, 0x3C, 0x00, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0xF0, 0x00, 0x1F, 0xF8, 0x01, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x3E, 0x00,
  0xF8, 0x00, 0x01, 0xE0, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0x00,
  0x78, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x00, 0x1F,
  0x87, 0xE0, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x3E, 0x07, 0xF7, 0xE0, 0x01, 0xE0,
  0x7E, 0x1F, 0x80, 0x1F, 0x07, 0xE0, 0x7E, 0x00, 0xF8, 0x7E, 0x01, 0xF8,
  0x07, 0x83, 0xE0, 0x07, 0xE0, 0x7C, 0x3F, 0x00, 0x1F, 0x83, 0xE1, 0xF0,
  0x00, 0x7E, 0x3E, 0x0F, 0x80, 0x01, 0xFB, 0xF0, 0x7C, 0x00, 0x07, 0xFF,
  0x03, 0xE0, 0x00, 0x1F, 0xF0, 0x1F, 0x00, 0x00, 0x7F, 0x80, 0xFC, 0x00,
  0x01, 0xF8, 0x07, 0xE0, 0x00, 0x3F, 0xE0, 0x1F, 0x80, 0x03, 0xFF, 0xC0,
  0xFF, 0x00, 0x7F, 0xFF, 0x03, 0xFF, 0xFF, 0xF9, 0xFC, 0x0F, 0xFF, 0xFF,
  0x07, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F, 0xC0, 0x7F, 0xFC, 0x00, 0x7F, 0x00,
  0x28, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x7B, 0xDE, 0xF7, 0xBD, 0xE7,
  0x38, 0x00, 0xF8, 0x0F, 0x80, 0xF8, 0x07, 0x80, 0x7C, 0x07, 0xC0, 0x3E,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x3C, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x0F,
  0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0xF8, 0x07, 0xC0, 0x3C, 0x03,
  0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xC0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0x03,
  0xE0, 0x3E, 0x07, 0xC0, 0x78, 0x0F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x70, 0x1E, 0x01,
  0x9F, 0x87, 0x87, 0xE7, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xF3, 0xC0, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0x87, 0xC0,
  0x07, 0xE1, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x0E, 0x01,
  0xC0, 0x00, 0x80, 0x40, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x8F, 0x87,
  0xC7, 0xE3, 0xE1, 0xF0, 0xF8, 0x78, 0x7C, 0x3C, 0x1E, 0x0F, 0x0F, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x30, 0xFB, 0xFF, 0xFF, 0xFF,
  0xDF, 0x1C, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xE0,
  0x1F, 0xE3, 0xFC, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x03, 0xE0, 0xF8, 0x00,
  0x7C, 0x7C, 0x00, 0x1F, 0x1F, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xFB, 0xE0,
  0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7B,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFB, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0x9E, 0x00, 0x03,
  0xE7, 0xC0, 0x00, 0xF9, 0xF0, 0x00, 0x7C, 0x3C, 0x00, 0x1F, 0x0F, 0x80,
  0x0F, 0xC3, 0xF0, 0x03, 0xE0, 0x7E, 0x03, 0xF8, 0x0F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x3E, 0x01, 0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0xFF, 0xE3, 0xF7,
  0xCF, 0xCF, 0xBF, 0x1F, 0xFC, 0x3E, 0xF0, 0x7C, 0x80, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xE0, 0xFF, 0xC7, 0xFC, 0x1F, 0x80, 0x3F, 0x87, 0x80,
  0x03, 0xE0, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF8, 0x7F, 0xE1, 0xFE, 0x0F, 0x80, 0x0F, 0xC3, 0x80, 0x01, 0xF8,
  0x40, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x3F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xEC, 0x00, 0x01, 0xFB, 0xE0, 0x01, 0xFC, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x0F, 0x9F, 0x00,
  0x00, 0x78, 0xF8, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x03,
  0xC1, 0xF0, 0x00, 0x3C, 0x0F, 0x80, 0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x03,
  0xE0, 0x01, 0xE0, 0x1F, 0x00, 0x1F, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0,
  0x0F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x0F, 0x80, 0x0F, 0x80, 0x78,
  0x00, 0x7C, 0x07, 0x80, 0x03, 0xE0, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x00,
  0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xC3, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x03, 0x80, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x60, 0x00, 0x1F, 0xBC,
  0x00, 0x3F, 0x9F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x00,
  0x7F, 0xFE, 0x00, 0x01, 0x40, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xFF,
  0x80, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x03, 0xFE, 0x06, 0x01, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x18, 0x00, 0xF8, 0x7F,
  0xF0, 0x3E, 0x7F, 0xFF, 0x0F, 0xBF, 0xFF, 0xE3, 0xEF, 0x83, 0xFC, 0xFF,
  0x80, 0x3F, 0x3F, 0x80, 0x07, 0xEF, 0xC0, 0x00, 0xFB, 0xF0, 0x00, 0x3E,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xDE, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x7D, 0xF0,
  0x00, 0x1E, 0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xE1, 0xF0, 0x01, 0xF0,
  0x7F, 0x01, 0xFC, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0x80, 0x03, 0xFF, 0x80, 0x00, 0x04, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x3F, 0xC0, 0xFE,
  0x0F, 0xC0, 0x0F, 0xC7, 0xE0, 0x01, 0xF1, 0xF0, 0x00, 0x7C, 0x7C, 0x00,
  0x0F, 0x1F, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0xF1, 0xF0, 0x00, 0x7C, 0x7C,
  0x00, 0x1F, 0x0F, 0x80, 0x0F, 0xC3, 0xF0, 0x03, 0xE0, 0x7E, 0x03, 0xF0,
  0x0F, 0xE1, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x01, 0xFC, 0x3F, 0xC0, 0xFC,
  0x03, 0xF8, 0x7E, 0x00, 0x3F, 0x1F, 0x00, 0x07, 0xEF, 0x80, 0x00, 0xFB,
  0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x03, 0xE7, 0xC0,
  0x01, 0xF9, 0xF8, 0x00, 0xFC, 0x3F, 0xE3, 0xFE, 0x07, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x00, 0x08, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x1F,
  0xC3, 0xFC, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x03, 0xE1, 0xF0, 0x00, 0x7C,
  0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x03, 0xCF, 0x80, 0x00, 0xFB, 0xE0, 0x00,
  0x3E, 0xF8, 0x00, 0x07, 0xBE, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x7B, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xF7, 0xC0, 0x01, 0xFD,
  0xF8, 0x00, 0xFF, 0x7F, 0x00, 0x7F, 0x8F, 0xFF, 0xFD, 0xE1, 0xFF, 0xFE,
  0x78, 0x3F, 0xFF, 0x3E, 0x03, 0xFF, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x1C, 0xFF, 0xF0, 0x07, 0xFF,
  0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x7D, 0xFB, 0xFF, 0xFF, 0xFF, 0x9F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x7D, 0xFF, 0xFF,
  0xFF, 0xEF, 0x8E, 0x00, 0x1F, 0x1F, 0x8F, 0xE7, 0xF3, 0xF9, 0xF8, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x1F, 0x8F, 0x87, 0xC3,
  0xE3, 0xE1, 0xF0, 0xF8, 0x78, 0x3C, 0x3C, 0x1E, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF1, 0xFF, 0xFF, 0xCF, 0xF9, 0xFF, 0x38, 0x00, 0xFD, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFE,
  0x3F, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x7C,
  0x00, 0x1C, 0x00, 0x1F, 0x0F, 0x00, 0x1F, 0xFF, 0x01, 0xE3, 0xE0, 0x0F,
  0xFF, 0xE0, 0x3C, 0x78, 0x03, 0xFF, 0xFC, 0x03, 0xCF, 0x00, 0xFC, 0x07,
  0x80, 0x7B, 0xC0, 0x3E, 0x00, 0xF0, 0x0F, 0x78, 0x07, 0x80, 0x1E, 0x01,
  0xEF, 0x01, 0xF0, 0x03, 0xC0, 0x3D, 0xE0, 0x3C, 0x00, 0x78, 0x07, 0xF8,
  0x0F, 0x80, 0x0F, 0x00, 0xFF, 0x01, 0xF0, 0x01, 0xE0, 0x1F, 0xE0, 0x3E,
  0x00, 0x3C, 0x03, 0xFC, 0x07, 0x80, 0x07, 0x80, 0x7F, 0x80, 0xF0, 0x01,
  0xF0, 0x0F, 0xF0, 0x1F, 0x00, 0x3E, 0x01, 0xFE, 0x03, 0xE0, 0x07, 0xC0,
  0x7B, 0xC0, 0x3C, 0x01, 0xF8, 0x0F, 0x78, 0x07, 0x80, 0x3F, 0x03, 0xE7,
  0x80, 0xF8, 0x0F, 0xF0, 0x78, 0xF0, 0x0F, 0xE7, 0xDF, 0xFE, 0x1E, 0x00,
  0xFF, 0xF1, 0xFF, 0xC3, 0xE0, 0x0F, 0xFC, 0x1F, 0xE0, 0x3C, 0x00, 0x7E,
  0x01, 0xF8, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x60, 0x00, 0x0F,
  0xF0, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x0F, 0x78, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0x7D, 0xF0,
  0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x00, 0x7C,
  0x7C, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x00,
  0x7C, 0x1F, 0x00, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x3E, 0x00,
  0x00, 0x7C, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x0F,
  0x80, 0x00, 0x78, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x03, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0,
  0x07, 0xC0, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00,
  0x7C, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x00, 0xF8, 0x1F, 0x00,
  0x00, 0x1F, 0x87, 0xC0, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x00, 0x3E, 0x3E,
  0x00, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0xF8, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0xF8, 0x00, 0x7F, 0x8F, 0x80,
  0x01, 0xFC, 0xF8, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x7C, 0xF8, 0x00, 0x07,
  0xCF, 0x80, 0x00, 0x7C, 0xF8, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x7C, 0xF8,
  0x00, 0x07, 0xCF, 0x80, 0x00, 0x7C, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x03,
  0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x0F, 0x80, 0x01, 0xFC, 0xF8, 0x00,
  0x0F, 0xCF, 0x80, 0x00, 0x7E, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7E, 0xF8, 0x00, 0x07,
  0xEF, 0x80, 0x00, 0xFC, 0xF8, 0x00, 0x7F, 0xCF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xF0, 0x01, 0xE0, 0x7F, 0x00, 0x01,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x1E, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xE8, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0xF8, 0x00, 0x7F, 0xC0, 0xF8, 0x00, 0x0F, 0xE0, 0xF8, 0x00, 0x07, 0xF0,
  0xF8, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x00, 0xFC,
  0xF8, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0x3E,
  0xF8, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x3E,
  0xF8, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0x7C,
  0xF8, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x01, 0xF8,
  0xF8, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x0F, 0xF0, 0xF8, 0x00, 0x3F, 0xE0,
  0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xE0, 0x00, 0xF0, 0x1F, 0xC0, 0x00,
  0x08, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x7C,
  0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x03, 0xEF,
  0xC0, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00, 0x7C,
  0xFC, 0x00, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0x1F, 0x1F, 0xC0, 0x00, 0x0F,
  0x87, 0xF0, 0x00, 0x07, 0xC1, 0xFC, 0x00, 0x03, 0xE0, 0x7F, 0xC0, 0x03,
  0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xF8, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x07, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x0F, 0xC0, 0x3E, 0x03, 0xFB, 0xFF, 0xCF, 0xFE, 0x3F, 0xF0, 0xFF, 0x80,
  0xF8, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x3F, 0x3E, 0x00, 0x03, 0xF1, 0xF0,
  0x00, 0x3F, 0x0F, 0x80, 0x03, 0xF0, 0x7C, 0x00, 0x3F, 0x03, 0xE0, 0x01,
  0xF0, 0x1F, 0x00, 0x1F, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x80,
  0x3E, 0x01, 0xF8, 0x01, 0xF0, 0x1F, 0x80, 0x0F, 0x81, 0xF8, 0x00, 0x7C,
  0x1F, 0x80, 0x03, 0xE1, 0xF8, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0xF8, 0xF8,
  0x00, 0x07, 0xCF, 0xC0, 0x00, 0x3E, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0x9F, 0x80, 0x03, 0xF8, 0x7E, 0x00, 0x1F,
  0x81, 0xF8, 0x00, 0xF8, 0x0F, 0xC0, 0x07, 0xC0, 0x3F, 0x00, 0x3E, 0x00,
  0xFC, 0x01, 0xF0, 0x03, 0xF0, 0x0F, 0x80, 0x1F, 0x80, 0x7C, 0x00, 0x7E,
  0x03, 0xE0, 0x01, 0xF8, 0x1F, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x3F, 0x07,
  0xC0, 0x00, 0xFC, 0x3E, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x0F, 0xCF, 0x80,
  0x00, 0x7E, 0x7C, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x07, 0xE0, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x03, 0xDF, 0xFF, 0xC0, 0x00, 0x03, 0xDF, 0xFB, 0xE0, 0x00,
  0x07, 0xDF, 0xFB, 0xE0, 0x00, 0x07, 0x9F, 0xF9, 0xE0, 0x00, 0x07, 0x9F,
  0xF9, 0xF0, 0x00, 0x0F, 0x9F, 0xF9, 0xF0, 0x00, 0x0F, 0x1F, 0xF8, 0xF0,
  0x00, 0x1F, 0x1F, 0xF8, 0xF8, 0x00, 0x1E, 0x1F, 0xF8, 0xF8, 0x00, 0x1E,
  0x1F, 0xF8, 0x7C, 0x00, 0x3E, 0x1F, 0xF8, 0x7C, 0x00, 0x3C, 0x1F, 0xF8,
  0x3C, 0x00, 0x7C, 0x1F, 0xF8, 0x3E, 0x00, 0x7C, 0x1F, 0xF8, 0x3E, 0x00,
  0x78, 0x1F, 0xF8, 0x1E, 0x00, 0xF8, 0x1F, 0xF8, 0x1F, 0x00, 0xF0, 0x1F,
  0xF8, 0x1F, 0x00, 0xF0, 0x1F, 0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0xF8, 0x0F,
  0x81, 0xE0, 0x1F, 0xF8, 0x07, 0x83, 0xE0, 0x1F, 0xF8, 0x07, 0xC3, 0xE0,
  0x1F, 0xF8, 0x07, 0xC3, 0xC0, 0x1F, 0xF8, 0x03, 0xC7, 0xC0, 0x1F, 0xF8,
  0x03, 0xE7, 0x80, 0x1F, 0xF8, 0x03, 0xEF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0xF8, 0x00, 0x7C, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03,
  0xFD, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFB, 0xF0, 0x00, 0x1F,
  0xF3, 0xE0, 0x00, 0x3F, 0xE7, 0xE0, 0x00, 0x7F, 0xC7, 0xE0, 0x00, 0xFF,
  0x87, 0xC0, 0x01, 0xFF, 0x0F, 0xC0, 0x03, 0xFE, 0x0F, 0xC0, 0x07, 0xFC,
  0x0F, 0x80, 0x0F, 0xF8, 0x1F, 0x80, 0x1F, 0xF0, 0x1F, 0x80, 0x3F, 0xE0,
  0x3F, 0x00, 0x7F, 0xC0, 0x3F, 0x00, 0xFF, 0x80, 0x3E, 0x01, 0xFF, 0x00,
  0x7E, 0x03, 0xFE, 0x00, 0x7E, 0x07, 0xFC, 0x00, 0x7C, 0x0F, 0xF8, 0x00,
  0xFC, 0x1F, 0xF0, 0x00, 0xFC, 0x3F, 0xE0, 0x00, 0xF8, 0x7F, 0xC0, 0x01,
  0xF8, 0xFF, 0x80, 0x01, 0xF9, 0xFF, 0x00, 0x01, 0xF3, 0xFE, 0x00, 0x03,
  0xF7, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFD, 0xFF, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x3F, 0x80, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x1F, 0x80,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x7C, 0x00, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x00, 0x3F, 0x3E, 0x00, 0x00,
  0x00, 0xF9, 0xF0, 0x00, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x00, 0x3E, 0x7C,
  0x00, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3E,
  0x7C, 0x00, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x00, 0x0F, 0x9F, 0x00, 0x00,
  0x00, 0x7C, 0xFC, 0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0x3E, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x00,
  0xF8, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0xFC, 0x03, 0xF8,
  0x00, 0x0F, 0xC0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0xA0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xCF, 0x80, 0x1F, 0xF7, 0xC0,
  0x03, 0xFB, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F,
  0x7C, 0x00, 0x1F, 0xBE, 0x00, 0x3F, 0x9F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x01, 0xFF, 0xF8, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFD, 0xFF, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x3F, 0x80, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x1F, 0x80,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x7C, 0x00, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x00, 0x3F, 0x3E, 0x00, 0x00,
  0x00, 0xF9, 0xF0, 0x00, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x00, 0x3E, 0x7C,
  0x00, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3E,
  0x7C, 0x00, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x00, 0x0F, 0x9F, 0x00, 0x00,
  0x00, 0x7C, 0xFC, 0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0x3E, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x00,
  0xF8, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0xFC, 0x03, 0xF8,
  0x00, 0x0F, 0xC0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0xBF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0xF8, 0x01,
  0xFF, 0x0F, 0x80, 0x03, 0xF0, 0xF8, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0xF8,
  0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x8F, 0x80,
  0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x0F,
  0x8F, 0x80, 0x01, 0xF8, 0xF8, 0x00, 0x3F, 0x0F, 0x80, 0x07, 0xE0, 0xF8,
  0x0F, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xF0, 0x0F,
  0x80, 0x1F, 0x00, 0xF8, 0x01, 0xF8, 0x0F, 0x80, 0x0F, 0x80, 0xF8, 0x00,
  0xFC, 0x0F, 0x80, 0x07, 0xE0, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xF0,
  0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF8, 0xF8, 0x00, 0x0F, 0xCF, 0x80,
  0x00, 0x7C, 0xF8, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xE3, 0xF8, 0x00, 0xF1, 0xF8, 0x00, 0x08, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xA0,
  0x00, 0x0F, 0x9F, 0x00, 0x1F, 0xCF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x00, 0x20, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01,
  0xF7, 0xC0, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x3E, 0x3E, 0x00, 0x01, 0xF8,
  0xFC, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00,
  0x80, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0x0F, 0x9F, 0x00,
  0x00, 0x07, 0xCF, 0xC0, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x03, 0xE1, 0xF0,
  0x00, 0x01, 0xF0, 0xFC, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00, 0xF8, 0x1F,
  0x00, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x3E, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x1F, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0,
  0x01, 0xF0, 0x01, 0xF0, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x03, 0xE0, 0x3E,
  0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x3E, 0x0F,
  0x80, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x03, 0xE3,
  0xE0, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0x3E,
  0xF8, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0xFF, 0x00,
  0x01, 0xF3, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xF9, 0xF8, 0x00, 0x3D, 0xE0,
  0x00, 0x7C, 0x7C, 0x00, 0x1E, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x7C,
  0x00, 0x3E, 0x1F, 0x00, 0x0F, 0xBE, 0x00, 0x1F, 0x07, 0xC0, 0x07, 0x8F,
  0x00, 0x0F, 0x83, 0xE0, 0x07, 0xC7, 0x80, 0x0F, 0x81, 0xF0, 0x03, 0xE3,
  0xE0, 0x07, 0xC0, 0xF8, 0x01, 0xE1, 0xF0, 0x03, 0xE0, 0x3E, 0x01, 0xF0,
  0x78, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x07, 0x80, 0x7C, 0x01, 0xF0, 0x3E,
  0x03, 0xE0, 0x3C, 0x00, 0xF8, 0x1F, 0x01, 0xF0, 0x3E, 0x00, 0x7C, 0x0F,
  0x00, 0xF8, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x0F, 0x87,
  0xC0, 0x1F, 0x07, 0x80, 0x07, 0xC3, 0xE0, 0x0F, 0x87, 0xC0, 0x03, 0xE1,
  0xE0, 0x03, 0xC3, 0xE0, 0x01, 0xF1, 0xF0, 0x01, 0xF1, 0xF0, 0x00, 0x7C,
  0xF8, 0x00, 0xF9, 0xF0, 0x00, 0x3E, 0x78, 0x00, 0x3C, 0xF8, 0x00, 0x1F,
  0x3C, 0x00, 0x1E, 0x7C, 0x00, 0x07, 0xBE, 0x00, 0x0F, 0xBE, 0x00, 0x03,
  0xDF, 0x00, 0x07, 0xDE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x3F, 0x00,
  0x00, 0x7C, 0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x0F, 0xC0,
  0x01, 0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x07, 0xC0, 0x01, 0xF0, 0x0F, 0x80, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0xF8,
  0x1F, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x7E, 0x3E, 0x00, 0x00, 0x3E,
  0x7C, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x7C,
  0x3E, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x01, 0xF0,
  0x0F, 0x80, 0x03, 0xE0, 0x07, 0xC0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0,
  0x03, 0xE0, 0x0F, 0x80, 0x03, 0xF0, 0x0F, 0x80, 0x01, 0xF8, 0x1F, 0x00,
  0x00, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x00, 0x7C, 0x7C, 0x00,
  0x00, 0x7E, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7E, 0xF8, 0x00,
  0x00, 0xF9, 0xF8, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x1F, 0x83, 0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0xF8, 0x07, 0xC0, 0x01,
  0xF0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x3E,
  0x00, 0x1F, 0x80, 0x7C, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0x7C, 0x7C, 0x00,
  0x00, 0x7D, 0xF0, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0x00,
  0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xE0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF0,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x07, 0x80, 0x00, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x07,
  0x9E, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0xF0, 0x78, 0x00, 0x3C, 0x07, 0x80, 0x07, 0x80, 0xF0, 0x01, 0xE0,
  0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x1E, 0x01, 0xE0, 0x03, 0xC0,
  0x78, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x78, 0x78, 0x00,
  0x0F, 0x1F, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x1E, 0xF8, 0x00, 0x01, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFC, 0x0F,
  0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x00,
  0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xF8,
  0x0F, 0xC1, 0x80, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0xFF,
  0xE0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x7F, 0x80, 0x1E,
  0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF8,
  0x03, 0xFD, 0xFE, 0x3F, 0x7B, 0xFF, 0xFC, 0xF3, 0xFF, 0xF0, 0xE1, 0xFF,
  0xC1, 0xC0, 0x68, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x3F, 0x80, 0x3C,
  0x3F, 0xFC, 0x0F, 0x3F, 0xFF, 0x83, 0xDF, 0xFF, 0xF0, 0xFF, 0xC0, 0xFE,
  0x3F, 0x80, 0x0F, 0xCF, 0xC0, 0x01, 0xF3, 0xF0, 0x00, 0x7E, 0xF8, 0x00,
  0x0F, 0xBE, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x3E, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x03, 0xEF, 0xC0, 0x01, 0xFB, 0xF0,
  0x00, 0x7C, 0xFE, 0x00, 0x3F, 0x3F, 0xC0, 0x1F, 0x8F, 0x7F, 0xFF, 0xE3,
  0xCF, 0xFF, 0xF0, 0xF1, 0xFF, 0xF8, 0x38, 0x3F, 0xF8, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x3F, 0xC0, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFE,
  0x1F, 0xE0, 0xF8, 0xFE, 0x00, 0x23, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x61, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xC0,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0xFF, 0x07, 0xC0, 0xFF, 0xF1,
  0xF0, 0x7F, 0xFF, 0x7C, 0x3F, 0xFF, 0xEF, 0x1F, 0xC0, 0xFF, 0xCF, 0xC0,
  0x0F, 0xF3, 0xE0, 0x01, 0xFD, 0xF8, 0x00, 0x3F, 0x7C, 0x00, 0x0F, 0xDF,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC,
  0x00, 0x07, 0xDF, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x3F,
  0x3F, 0x00, 0x1F, 0xCF, 0xE0, 0x0F, 0xF1, 0xFF, 0xFF, 0xBC, 0x3F, 0xFF,
  0xCF, 0x07, 0xFF, 0xE3, 0xC0, 0x7F, 0xE0, 0xF0, 0x00, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x81,
  0xFC, 0x0F, 0xE0, 0xF8, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0xFC, 0x00, 0x3E,
  0x7C, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3F, 0x00, 0x01, 0x0F, 0xE0, 0x03, 0x83, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x00, 0x28, 0x00,
  0x00, 0x1F, 0xE0, 0x07, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xF0,
  0x20, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x07, 0xFF, 0xF8, 0xFF,
  0xFF, 0x8F, 0xFF, 0xF8, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0xF0, 0xF0, 0x7F, 0xFF, 0x3C, 0x3F, 0xFF, 0xEF, 0x1F, 0xC0,
  0xFF, 0xCF, 0xC0, 0x0F, 0xF3, 0xE0, 0x01, 0xFD, 0xF8, 0x00, 0x3F, 0x7C,
  0x00, 0x0F, 0xDF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0x7C, 0x00, 0x07, 0xDF, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0xFD,
  0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0xCF, 0xE0, 0x0F, 0xF1, 0xFF, 0x3F,
  0xFC, 0x3F, 0xFF, 0xDF, 0x07, 0xFF, 0xE7, 0xC0, 0x7F, 0xE1, 0xF0, 0x00,
  0x80, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x8C, 0x00, 0x07,
  0xE3, 0xE0, 0x07, 0xF0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x83, 0xFC, 0x07, 0x87, 0xFF,
  0x83, 0xCF, 0xFF, 0xF1, 0xEF, 0xFF, 0xFC, 0xF7, 0xC0, 0xFE, 0x7F, 0x80,
  0x1F, 0xBF, 0x80, 0x07, 0xDF, 0x80, 0x03, 0xEF, 0x80, 0x01, 0xF7, 0xC0,
  0x00, 0x7B, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xC0, 0x11, 0xEF, 0xFF, 0xFD, 0xE3, 0x00, 0x00,
  0x00, 0x00, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D,
  0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7C,
  0x00, 0x20, 0x07, 0x80, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0x78, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0xBF, 0xF9, 0xFF,
  0xCF, 0xFC, 0x7F, 0x80, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x02, 0xF0, 0x00, 0xFC, 0xF0, 0x00,
  0xF8, 0xF0, 0x01, 0xF0, 0xF0, 0x03, 0xE0, 0xF0, 0x07, 0xC0, 0xF0, 0x0F,
  0x80, 0xF0, 0x1F, 0x00, 0xF0, 0x3E, 0x00, 0xF0, 0x7E, 0x00, 0xF0, 0xFC,
  0x00, 0xF1, 0xF8, 0x00, 0xF3, 0xF0, 0x00, 0xF7, 0xE0, 0x00, 0xF7, 0xF0,
  0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0xFC, 0x7C, 0x00, 0xF8, 0x7E,
  0x00, 0xF0, 0x3F, 0x00, 0xF0, 0x1F, 0x80, 0xF0, 0x0F, 0x80, 0xF0, 0x0F,
  0xC0, 0xF0, 0x07, 0xE0, 0xF0, 0x03, 0xF0, 0xF0, 0x01, 0xF0, 0xF0, 0x01,
  0xF8, 0xF0, 0x00, 0xFC, 0xF0, 0x00, 0x7E, 0xF0, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x3C, 0x3F, 0xFC, 0x0F, 0xFF, 0x0F,
  0x3F, 0xFF, 0x87, 0xFF, 0xE3, 0xDF, 0xFF, 0xF3, 0xFF, 0xFC, 0xF7, 0x81,
  0xFD, 0xF0, 0x3F, 0xBF, 0x80, 0x1F, 0xF0, 0x07, 0xEF, 0xC0, 0x07, 0xF8,
  0x00, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xE0, 0x00, 0x7F, 0xE0,
  0x00, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xFE, 0x00, 0x0F,
  0x80, 0x01, 0xFF, 0x80, 0x03, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0x80, 0x01, 0xFF,
  0x80, 0x03, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x3E, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xE0,
  0x00, 0x7F, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3E, 0x00, 0x07,
  0xFE, 0x00, 0x0F, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xE0, 0x00, 0x7F, 0xE0,
  0x00, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xFE, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3F, 0xC0, 0x78, 0x7F, 0xF8, 0x3C, 0xFF, 0xFF,
  0x1E, 0xFF, 0xFF, 0xCF, 0x7C, 0x0F, 0xE7, 0xF8, 0x01, 0xFB, 0xF8, 0x00,
  0x7D, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x07, 0xBE, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0x7C, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0x01, 0xFE, 0x07, 0xF0, 0x7E, 0x00, 0x3F, 0x0F, 0x80, 0x03,
  0xE3, 0xF0, 0x00, 0x7E, 0x7C, 0x00, 0x07, 0xCF, 0x80, 0x00, 0xFF, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3E,
  0xF8, 0x00, 0x0F, 0x9F, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x7E, 0x3F, 0x00,
  0x1F, 0x83, 0xF0, 0x07, 0xE0, 0x3F, 0xEF, 0xFC, 0x03, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x3C, 0x3F, 0xFC, 0x0F, 0x3F, 0xFF, 0x83, 0xDF, 0xFF, 0xF0, 0xF7,
  0xC0, 0xFE, 0x3F, 0xC0, 0x1F, 0xCF, 0xE0, 0x03, 0xF3, 0xF0, 0x00, 0x7E,
  0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFB, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x03, 0xEF, 0xC0, 0x01,
  0xFB, 0xF0, 0x00, 0x7C, 0xFE, 0x00, 0x3F, 0x3F, 0xC0, 0x1F, 0x8F, 0x7F,
  0xFF, 0xE3, 0xCF, 0xFF, 0xF0, 0xF1, 0xFF, 0xF0, 0x3C, 0x3F, 0xF8, 0x0F,
  0x00, 0x40, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xF0,
  0xF0, 0x7F, 0xFF, 0x3C, 0x3F, 0xFF, 0xEF, 0x1F, 0xC0, 0xFB, 0xCF, 0xC0,
  0x0F, 0xF3, 0xE0, 0x01, 0xFD, 0xF8, 0x00, 0x3F, 0x7C, 0x00, 0x0F, 0xDF,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC,
  0x00, 0x07, 0xDF, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x3F,
  0x3F, 0x00, 0x1F, 0xCF, 0xE0, 0x0F, 0xF1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xDF, 0x07, 0xFF, 0xE7, 0xC0, 0x7F, 0xE1, 0xF0, 0x01, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x3F, 0xF8, 0x7F, 0xFC, 0x7F, 0xFE, 0x7F, 0xEF, 0x7F,
  0x17, 0xBC, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xFF, 0x0F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xE0, 0x1E, 0x7C, 0x00, 0x13, 0xE0, 0x00,
  0x1E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFF,
  0x00, 0x1F, 0xBF, 0x87, 0xFD, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x1F, 0xFF,
  0x80, 0x01, 0x00, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x01, 0xFF, 0xFE, 0xFF, 0xFF,
  0xBF, 0xFF, 0xE0, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x00, 0x07, 0xF9, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x03,
  0xFF, 0x00, 0x18, 0x00, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFB, 0xE0, 0x00,
  0xFD, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x9F, 0xFF,
  0xFB, 0xC7, 0xFF, 0xF9, 0xE1, 0xFF, 0xF8, 0xF0, 0x7F, 0xF0, 0x78, 0x03,
  0x40, 0x00, 0xFC, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x03,
  0xE3, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x1F,
  0x00, 0x0F, 0x81, 0xF0, 0x00, 0xF8, 0x1F, 0x00, 0x0F, 0x80, 0xF8, 0x01,
  0xF0, 0x0F, 0x80, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x07, 0xC0, 0x3E, 0x00,
  0x7C, 0x03, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0,
  0x78, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x0F, 0x00,
  0x00, 0xF9, 0xF0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x07, 0xFE, 0x00, 0x0F, 0xC0, 0x03, 0xEF, 0x80, 0x07, 0xF0, 0x00, 0xFB,
  0xE0, 0x01, 0xFC, 0x00, 0x3E, 0x7C, 0x00, 0x7F, 0x80, 0x0F, 0x9F, 0x00,
  0x3F, 0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x78, 0x01, 0xF0, 0xF0, 0x03, 0xDE,
  0x00, 0x7C, 0x3E, 0x01, 0xF7, 0xC0, 0x1E, 0x0F, 0x80, 0x7C, 0xF0, 0x0F,
  0x83, 0xE0, 0x1E, 0x3C, 0x03, 0xE0, 0x78, 0x07, 0x8F, 0x80, 0xF8, 0x1F,
  0x03, 0xE3, 0xE0, 0x3C, 0x07, 0xC0, 0xF0, 0x78, 0x1F, 0x01, 0xF0, 0x3C,
  0x1F, 0x07, 0xC0, 0x3E, 0x1F, 0x07, 0xC1, 0xE0, 0x0F, 0x87, 0x80, 0xF0,
  0xF8, 0x03, 0xE1, 0xE0, 0x3E, 0x3E, 0x00, 0x78, 0xF8, 0x0F, 0x8F, 0x80,
  0x1F, 0x3E, 0x01, 0xE3, 0xC0, 0x07, 0xCF, 0x00, 0x79, 0xF0, 0x01, 0xF3,
  0xC0, 0x1F, 0x7C, 0x00, 0x3D, 0xF0, 0x07, 0xDF, 0x00, 0x0F, 0x78, 0x00,
  0xF7, 0x80, 0x03, 0xFE, 0x00, 0x3D, 0xE0, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0xFE, 0x00,
  0x0F, 0xE7, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x0F, 0xC0, 0x1F, 0x80,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0x07,
  0xC0, 0x01, 0xF1, 0xF0, 0x00, 0x1F, 0x7E, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0xC1, 0xF8,
  0x01, 0xF0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x1F, 0x80, 0x1F, 0x07, 0xE0,
  0x03, 0xF0, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x7E,
  0xFC, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xE3, 0xE0,
  0x00, 0x7E, 0x3E, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x0F,
  0x81, 0xF0, 0x00, 0xF8, 0x0F, 0x80, 0x0F, 0x80, 0xF8, 0x01, 0xF0, 0x0F,
  0x80, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0x3E, 0x03,
  0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00,
  0x1F, 0x0F, 0x80, 0x00, 0xF0, 0xF8, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0xF9,
  0xF0, 0x00, 0x07, 0x9F, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x80,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x0F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x1F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xFC, 0x03, 0xFC, 0x01,
  0xF0, 0x00, 0xFE, 0x00, 0x7F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x03,
  0xFC, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x00, 0x7F,
  0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x1F,
  0x00, 0x3F, 0x80, 0x7F, 0xC0, 0x7E, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xF0, 0x07, 0xF8, 0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xF0,
  0x01, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x5F, 0xFE, 0x00, 0x3F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xB0, 0x03, 0xFF, 0xC8, 0x00,
  0x1F, 0xE0,
};

const GFXglyph NotoSans_Regular55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 7, 40, 15, 4, -39 },
  { 36, 15, 14, 22, 4, -39 },
  { 63, 33, 39, 36, 1, -39 },
  { 224, 25, 45, 31, 3, -42 },
  { 365, 40, 41, 46, 3, -40 },
  { 570, 37, 41, 40, 3, -40 },
  { 760, 5, 14, 12, 4, -39 },
  { 769, 13, 48, 17, 2, -39 },
  { 847, 12, 48, 17, 2, -39 },
  { 919, 26, 25, 30, 2, -42 },
  { 1001, 26, 27, 31, 3, -33 },
  { 1089, 9, 13, 15, 2, -6 },
  { 1104, 14, 4, 18, 2, -17 },
  { 1111, 7, 8, 15, 4, -7 },
  { 1118, 19, 39, 20, 1, -39 },
  { 1211, 26, 41, 31, 3, -40 },
  { 1345, 15, 39, 31, 5, -39 },
  { 1419, 26, 40, 31, 3, -40 },
  { 1549, 26, 41, 31, 2, -40 },
  { 1683, 29, 39, 31, 1, -39 },
  { 1825, 25, 40, 31, 3, -39 },
  { 1950, 26, 41, 31, 3, -40 },
  { 2084, 27, 39, 31, 2, -39 },
  { 2216, 26, 41, 31, 3, -40 },
  { 2350, 26, 41, 31, 3, -40 },
  { 2484, 7, 31, 15, 4, -30 },
  { 2512, 9, 37, 15, 2, -30 },
  { 2554, 26, 27, 31, 3, -33 },
  { 2642, 25, 15, 31, 3, -27 },
  { 2689, 26, 27, 31, 3, -33 },
  { 2777, 21, 41, 24, 1, -40 },
  { 2885, 43, 44, 49, 3, -39 },
  { 3122, 35, 39, 35, 0, -39 },
  { 3293, 28, 39, 36, 5, -39 },
  { 3430, 30, 41, 35, 3, -40 },
  { 3584, 32, 39, 40, 5, -39 },
  { 3740, 22, 39, 31, 5, -39 },
  { 3848, 22, 39, 29, 5, -39 },
  { 3956, 33, 41, 40, 3, -40 },
  { 4126, 30, 39, 41, 5, -39 },
  { 4273, 14, 39, 19, 2, -39 },
  { 4342, 14, 49, 15, -4, -39 },
  { 4428, 29, 39, 34, 5, -39 },
  { 4570, 22, 39, 29, 5, -39 },
  { 4678, 40, 39, 50, 5, -39 },
  { 4873, 31, 39, 42, 5, -39 },
  { 5025, 37, 41, 43, 3, -40 },
  { 5215, 25, 39, 33, 5, -39 },
  { 5337, 37, 49, 43, 3, -40 },
  { 5564, 28, 39, 34, 5, -39 },
  { 5701, 25, 41, 30, 3, -40 },
  { 5830, 29, 39, 31, 1, -39 },
  { 5972, 30, 40, 40, 5, -39 },
  { 6122, 33, 39, 33, 0, -39 },
  { 6283, 49, 39, 51, 1, -39 },
  { 6522, 32, 39, 32, 0, -39 },
  { 6678, 31, 39, 31, 0, -39 },
  { 6830, 27, 39, 31, 2, -39 },
  { 6962, 13, 48, 18, 4, -39 },
  { 7040, 19, 39, 20, 1, -39 },
  { 7133, 13, 48, 18, 1, -39 },
  { 7211, 27, 25, 31, 2, -40 },
  { 7296, 25, 3, 24, 0, 5 },
  { 7306, 11, 9, 15, 2, -42 },
  { 7319, 23, 31, 31, 3, -30 },
  { 7409, 26, 43, 34, 5, -42 },
  { 7549, 22, 31, 26, 3, -30 },
  { 7635, 26, 43, 34, 3, -42 },
  { 7775, 25, 31, 31, 3, -30 },
  { 7872, 20, 42, 19, 1, -42 },
  { 7977, 26, 43, 34, 3, -30 },
  { 8117, 25, 42, 34, 5, -42 },
  { 8249, 6, 41, 14, 4, -41 },
  { 8280, 13, 54, 14, -3, -41 },
  { 8368, 24, 42, 29, 5, -42 },
  { 8494, 5, 42, 14, 5, -42 },
  { 8521, 42, 30, 51, 5, -30 },
  { 8679, 25, 30, 34, 5, -30 },
  { 8773, 27, 31, 33, 3, -30 },
  { 8878, 26, 43, 34, 5, -30 },
  { 9018, 26, 43, 34, 3, -30 },
  { 9158, 17, 30, 23, 5, -30 },
  { 9222, 21, 31, 26, 3, -30 },
  { 9304, 18, 37, 20, 1, -36 },
  { 9388, 25, 30, 34, 4, -29 },
  { 9482, 28, 29, 28, 0, -29 },
  { 9584, 42, 30, 43, 1, -30 },
  { 9742, 27, 29, 29, 1, -29 },
  { 9840, 28, 42, 28, 0, -29 },
  { 9987, 22, 29, 26, 2, -29 },
  { 10067, 17, 48, 21, 2, -39 },
  { 10169, 4, 55, 30, 13, -42 },
  { 10197, 17, 48, 21, 2, -39 },
  { 10299, 26, 7, 31, 3, -23 },
};

const GFXfont NotoSans_Regular55pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Regular55pt7bBitmaps,
  (GFXglyph *)NotoSans_Regular55pt7bGlyphs,
  0x20, 0x7E, 75
};

#endif // _NOTOSANS_REGULAR55PT7B_H_
