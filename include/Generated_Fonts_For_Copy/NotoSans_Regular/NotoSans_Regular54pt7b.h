#ifndef _NOTOSANS_REGULAR54PT7B_H_
#define _NOTOSANS_REGULAR54PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Regular.ttf
// Size: 54pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Regular54pt7bBitmaps[] PROGMEM = {
  0x00, 0xFD, 0xFB, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x38, 0x70,
  0xE1, 0xC0, 0x00, 0x00, 0x00, 0x10, 0xFB, 0xF7, 0xFF, 0xFF, 0x9F, 0x1C,
  0xF8, 0x7F, 0xF0, 0xFB, 0xE0, 0xF7, 0x81, 0xEF, 0x03, 0xDE, 0x07, 0xBC,
  0x0F, 0x78, 0x1E, 0xF0, 0x3D, 0xE0, 0x7B, 0xC0, 0xF7, 0x81, 0xEF, 0x03,
  0xCE, 0x07, 0x80, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0x1E, 0x01, 0xE0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x1E, 0x01, 0xC0, 0x00,
  0x1E, 0x01, 0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x3C, 0x03, 0xC0, 0x00,
  0x3C, 0x03, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFF, 0x00, 0x38, 0x07, 0x80, 0x00, 0x78, 0x07, 0x80, 0x00,
  0x78, 0x07, 0x80, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00,
  0x70, 0x0F, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00,
  0xF0, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xE0, 0x1C, 0x00, 0x01,
  0xE0, 0x3C, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x03,
  0xC0, 0x3C, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x03,
  0xC0, 0x78, 0x00, 0x03, 0x80, 0x78, 0x00, 0x07, 0x80, 0x78, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x3F, 0x8E, 0x1F, 0x1F, 0x07,
  0x01, 0x0F, 0x03, 0x80, 0x0F, 0x81, 0xC0, 0x07, 0xC0, 0xE0, 0x03, 0xE0,
  0x70, 0x00, 0xF0, 0x38, 0x00, 0x7C, 0x1C, 0x00, 0x3F, 0x8E, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0E, 0x3F,
  0x80, 0x07, 0x07, 0xC0, 0x03, 0x81, 0xF0, 0x01, 0xC0, 0xF8, 0x00, 0xE0,
  0x7C, 0x00, 0x70, 0x3E, 0x00, 0x38, 0x1F, 0xC0, 0x1C, 0x1F, 0x7C, 0x0E,
  0x7F, 0xBF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0x00, 0x3F, 0xE0, 0x00, 0x3E, 0x00, 0xFF, 0xE0, 0x00, 0x78, 0x03,
  0xE3, 0xE0, 0x01, 0xF0, 0x07, 0x83, 0xC0, 0x03, 0xC0, 0x1F, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x0F, 0x00, 0x78, 0x00,
  0xF0, 0x1E, 0x00, 0xF0, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x03, 0xC0, 0x3C,
  0x0F, 0x80, 0x07, 0x80, 0x78, 0x1E, 0x00, 0x0F, 0x00, 0xF0, 0x7C, 0x00,
  0x1E, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x03, 0xC3, 0xC0, 0x00, 0x78, 0x0F,
  0x07, 0x83, 0xC0, 0xF0, 0x1E, 0x1E, 0x1F, 0xE1, 0xE0, 0x3C, 0x3C, 0x7F,
  0xE1, 0xE0, 0x78, 0xF1, 0xFF, 0xE3, 0xC1, 0xE3, 0xE3, 0xC3, 0xE7, 0xC7,
  0xC7, 0x8F, 0x03, 0xC7, 0xFF, 0x1F, 0x1E, 0x07, 0x87, 0xFC, 0x3C, 0x3C,
  0x07, 0x83, 0xF0, 0xF0, 0xF0, 0x0F, 0x00, 0x01, 0xE1, 0xE0, 0x1E, 0x00,
  0x07, 0x83, 0xC0, 0x3C, 0x00, 0x0F, 0x07, 0x80, 0x78, 0x00, 0x3C, 0x0F,
  0x00, 0xF0, 0x00, 0xF8, 0x1E, 0x01, 0xE0, 0x01, 0xE0, 0x3C, 0x03, 0xC0,
  0x07, 0xC0, 0x78, 0x07, 0x80, 0x0F, 0x00, 0x70, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0xF0,
  0x03, 0xC0, 0x03, 0xC3, 0xE0, 0x0F, 0x00, 0x07, 0xFF, 0x80, 0x3E, 0x00,
  0x07, 0xFE, 0x00, 0x78, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0xF8,
  0x07, 0xC0, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x3C,
  0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x7C,
  0x1F, 0x80, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xC1, 0xFC,
  0xFC, 0x00, 0x7C, 0x3F, 0x07, 0xE0, 0x0F, 0x87, 0xE0, 0x3F, 0x00, 0xF8,
  0x7C, 0x01, 0xFC, 0x0F, 0x8F, 0xC0, 0x0F, 0xE1, 0xF0, 0xF8, 0x00, 0x7F,
  0x1F, 0x0F, 0x80, 0x03, 0xFB, 0xE0, 0xF8, 0x00, 0x1F, 0xFE, 0x0F, 0x80,
  0x00, 0xFF, 0xC0, 0xF8, 0x00, 0x07, 0xF8, 0x0F, 0x80, 0x00, 0x3F, 0x80,
  0xFC, 0x00, 0x07, 0xFC, 0x07, 0xE0, 0x00, 0xFF, 0xE0, 0x7F, 0x00, 0x7F,
  0xFF, 0x03, 0xFF, 0xFF, 0xF3, 0xF8, 0x1F, 0xFF, 0xFE, 0x1F, 0xC0, 0xFF,
  0xFF, 0x80, 0xFE, 0x03, 0xFF, 0xE0, 0x07, 0xF0, 0x01, 0x80, 0x00, 0x00,
  0xFF, 0xFF, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x38, 0x00, 0xF8, 0x0F,
  0x80, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x1F, 0x00,
  0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x01, 0xE0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0x7C,
  0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x01, 0xF0,
  0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x7C, 0x03, 0xC0, 0x3E,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x7C,
  0x07, 0x80, 0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0x03, 0xE0, 0x3C, 0x07, 0xC0,
  0xF8, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x80, 0x3C, 0x01, 0x78, 0x1E, 0x07, 0xBF, 0x8E, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF0, 0x01, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xEF, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0xF9, 0xF0, 0x00,
  0xF8, 0xFC, 0x00, 0xFC, 0x3E, 0x00, 0x7C, 0x1F, 0x80, 0x7E, 0x07, 0xE0,
  0x1E, 0x03, 0xE0, 0x03, 0x00, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1F, 0x1F, 0x3F, 0x3E, 0x3E, 0x3E, 0x3C, 0x7C,
  0x7C, 0x78, 0x78, 0x70, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x10, 0xFB, 0xF7, 0xFF, 0xFF, 0x9F, 0x1C, 0x00, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00,
  0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xF0,
  0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xF8, 0x1F, 0xC1, 0xF8, 0x03,
  0xE0, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x3E, 0x00,
  0x0F, 0xBE, 0x00, 0x03, 0xDF, 0x00, 0x01, 0xEF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xF7, 0x80, 0x00,
  0xF3, 0xC0, 0x00, 0xF9, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x3E, 0x3E, 0x00,
  0x3E, 0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x3F, 0x01, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x3C, 0x01, 0xF0, 0x0F, 0xC0, 0xFF, 0x07, 0xFC, 0x3F, 0xF3, 0xFB, 0xDF,
  0x8F, 0xFC, 0x3D, 0xE0, 0xF7, 0x03, 0xC8, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x01, 0xFF, 0x00, 0x03,
  0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x0F, 0xF0, 0x1F, 0xC3,
  0xE0, 0x03, 0xF0, 0xC0, 0x00, 0xF8, 0x40, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x7F,
  0x00, 0xFE, 0x0F, 0x00, 0x0F, 0xC1, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xB0, 0x00, 0x07,
  0xEF, 0x00, 0x07, 0xF3, 0xFF, 0x3F, 0xF8, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0xFB,
  0xC0, 0x00, 0x0F, 0x9E, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x07, 0xC7, 0x80,
  0x00, 0x7C, 0x3C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x3E, 0x0F, 0x00, 0x03,
  0xE0, 0x78, 0x00, 0x1E, 0x03, 0xC0, 0x01, 0xE0, 0x1E, 0x00, 0x1F, 0x00,
  0xF0, 0x01, 0xF0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0,
  0x0F, 0x80, 0x0F, 0x00, 0x78, 0x00, 0x78, 0x07, 0xC0, 0x03, 0xC0, 0x7C,
  0x00, 0x1E, 0x03, 0xC0, 0x00, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x03, 0xE0, 0xFF, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3F, 0x40, 0x00, 0x3F, 0x3C, 0x00, 0x3F, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0x80,
  0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x7F,
  0x80, 0xF8, 0xFF, 0xF0, 0x7C, 0xFF, 0xFE, 0x3E, 0xFF, 0xFF, 0x9F, 0xF0,
  0x0F, 0xEF, 0xE0, 0x01, 0xF7, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0x7B, 0xC0, 0x00, 0x7D, 0xF0, 0x00, 0x3E,
  0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x1F,
  0x81, 0xFF, 0x7F, 0xC0, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x03, 0xFF,
  0x80, 0x00, 0x08, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x83,
  0xF8, 0x0F, 0xE1, 0xF0, 0x01, 0xF1, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x3E,
  0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0xCF, 0x80, 0x03,
  0xE7, 0xC0, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0xFC, 0x01, 0xF0, 0x3F, 0x83,
  0xF0, 0x0F, 0xF7, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F,
  0xF8, 0x00, 0x7F, 0xFF, 0x00, 0xFE, 0x3F, 0xC0, 0xFC, 0x07, 0xF0, 0xFC,
  0x00, 0xFC, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0x9F, 0x80, 0x0F,
  0xC7, 0xF8, 0x7F, 0xC1, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF,
  0x80, 0x00, 0x10, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x03, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x03, 0xF8, 0x1F, 0xC3, 0xF0, 0x03, 0xE1, 0xF0,
  0x00, 0xF8, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xBE,
  0x00, 0x03, 0xDE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F,
  0xDF, 0x00, 0x0F, 0xEF, 0xC0, 0x0F, 0xF3, 0xF8, 0x1F, 0xF8, 0xFF, 0xFF,
  0x7C, 0x3F, 0xFF, 0x3E, 0x07, 0xFE, 0x1F, 0x00, 0x38, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xFC, 0x03, 0x0F, 0xFC, 0x01, 0xFF, 0xFC, 0x00,
  0xFF, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x02, 0x00, 0x00, 0x39, 0xFB, 0xF7,
  0xFF, 0xFF, 0x9F, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x7D, 0xFB, 0xFF, 0xFF, 0xCF, 0x8E,
  0x00, 0x0C, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x3F, 0x3E, 0x3E, 0x3E, 0x7C, 0x7C, 0x7C, 0x78, 0xF8, 0xF0,
  0xF0, 0xE0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x01, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xC0,
  0x7F, 0x30, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x1F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x0F, 0x80,
  0x00, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x78, 0x00, 0xFF, 0xC0, 0x1E,
  0x1E, 0x00, 0xFF, 0xFE, 0x07, 0x8F, 0x00, 0x7F, 0xFF, 0x80, 0xF3, 0xC0,
  0x3F, 0x87, 0xE0, 0x3D, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x78, 0x0F, 0x80,
  0x3C, 0x03, 0xDE, 0x03, 0xE0, 0x0F, 0x00, 0x77, 0x80, 0xF0, 0x03, 0xC0,
  0x1F, 0xC0, 0x7C, 0x00, 0xF0, 0x07, 0xF0, 0x1E, 0x00, 0x3C, 0x01, 0xFC,
  0x07, 0x80, 0x0F, 0x00, 0x7F, 0x01, 0xE0, 0x03, 0xC0, 0x3F, 0xC0, 0x78,
  0x00, 0xF0, 0x0F, 0xF0, 0x1E, 0x00, 0x3C, 0x03, 0xFC, 0x07, 0x80, 0x1F,
  0x00, 0xFF, 0x01, 0xF0, 0x07, 0xC0, 0x7B, 0xC0, 0x3C, 0x01, 0xF0, 0x1E,
  0xF0, 0x0F, 0x80, 0xFE, 0x0F, 0x1E, 0x01, 0xF8, 0xF3, 0xC7, 0xC7, 0x80,
  0x7F, 0xFC, 0xFF, 0xE1, 0xE0, 0x0F, 0xFE, 0x1F, 0xF0, 0x3C, 0x00, 0xFE,
  0x03, 0xF0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x30, 0x00, 0x07, 0xF0,
  0x00, 0x7C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0x0F,
  0x3E, 0x00, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x00,
  0x78, 0x7C, 0x00, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0x0F, 0x83, 0xE0, 0x00,
  0x03, 0xC0, 0xF8, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x00, 0x78, 0x07, 0xC0,
  0x00, 0x3E, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x03, 0xC0, 0x0F,
  0x80, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x3E, 0x00, 0x01, 0xF0, 0x0F,
  0x80, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x03, 0xE0,
  0x7C, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x07,
  0xC3, 0xE0, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00,
  0x0F, 0x9E, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7C, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xF1, 0xF0, 0x00, 0x7F, 0x3E, 0x00, 0x07, 0xE7, 0xC0, 0x00,
  0x7E, 0xF8, 0x00, 0x07, 0xDF, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0x7C,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0x7D, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x03,
  0xE7, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0xFE, 0x1F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE1, 0xF0, 0x00, 0xFF,
  0x3E, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00,
  0x0F, 0xDF, 0x00, 0x03, 0xFB, 0xE0, 0x03, 0xFE, 0x7F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xF0, 0x3F, 0xF0, 0x3F, 0x03, 0xFC, 0x00, 0x18, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x1C, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0C, 0x00, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0x00, 0x07, 0xF8, 0x3E, 0x00,
  0x03, 0xF8, 0x7C, 0x00, 0x03, 0xF8, 0xF8, 0x00, 0x03, 0xF9, 0xF0, 0x00,
  0x03, 0xF3, 0xE0, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x07, 0xEF, 0x80, 0x00,
  0x07, 0xDF, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x07, 0xEF,
  0x80, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0x7E, 0x7C,
  0x00, 0x01, 0xF8, 0xF8, 0x00, 0x0F, 0xE1, 0xF0, 0x00, 0x7F, 0x83, 0xE0,
  0x07, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBE, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0x80, 0xFE, 0x07, 0xF8, 0x00, 0x0C, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x1F, 0x7C,
  0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x1F, 0x3E,
  0x00, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x1F, 0x1F,
  0x80, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x1F, 0x0F, 0xF0, 0x00, 0x1F, 0x07,
  0xFC, 0x00, 0x1F, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x24, 0x00, 0xF8,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFE, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x07, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x0F, 0x80, 0x3E, 0x83, 0xFB, 0xFF, 0xCF, 0xFE, 0x3F, 0xF0, 0xFF,
  0x00, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7E, 0xF8, 0x00, 0x0F, 0xCF,
  0x80, 0x01, 0xF8, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00,
  0x7C, 0x0F, 0x80, 0x0F, 0x80, 0xF8, 0x01, 0xF8, 0x0F, 0x80, 0x3F, 0x00,
  0xF8, 0x07, 0xE0, 0x0F, 0x80, 0xFC, 0x00, 0xF8, 0x1F, 0x80, 0x0F, 0x83,
  0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0xF8, 0xF8, 0x00,
  0x0F, 0x9F, 0x80, 0x00, 0xFB, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFE, 0x00, 0x0F, 0xF3, 0xF0, 0x00, 0xFE, 0x3F, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0xF8, 0x0F, 0xC0, 0x0F, 0x80, 0x7E, 0x00, 0xF8, 0x07, 0xE0, 0x0F,
  0x80, 0x3F, 0x00, 0xF8, 0x01, 0xF8, 0x0F, 0x80, 0x0F, 0xC0, 0xF8, 0x00,
  0xFC, 0x0F, 0x80, 0x07, 0xE0, 0xF8, 0x00, 0x3F, 0x0F, 0x80, 0x01, 0xF0,
  0xF8, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0xFC, 0xF8, 0x00, 0x07, 0xEF, 0x80,
  0x00, 0x3E, 0xF8, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0xF0, 0x00, 0x00, 0x7F, 0xFD,
  0xF0, 0x00, 0x01, 0xFF, 0xFB, 0xE0, 0x00, 0x03, 0xDF, 0xFB, 0xC0, 0x00,
  0x07, 0xBF, 0xF7, 0xC0, 0x00, 0x1E, 0x7F, 0xE7, 0x80, 0x00, 0x3C, 0xFF,
  0xCF, 0x80, 0x00, 0xF9, 0xFF, 0x9F, 0x00, 0x01, 0xE3, 0xFF, 0x1E, 0x00,
  0x03, 0xC7, 0xFE, 0x3E, 0x00, 0x0F, 0x8F, 0xFC, 0x7C, 0x00, 0x1E, 0x1F,
  0xF8, 0x78, 0x00, 0x7C, 0x3F, 0xF0, 0xF8, 0x00, 0xF0, 0x7F, 0xE0, 0xF0,
  0x01, 0xE0, 0xFF, 0xC1, 0xF0, 0x07, 0xC1, 0xFF, 0x83, 0xE0, 0x0F, 0x03,
  0xFF, 0x03, 0xC0, 0x1E, 0x07, 0xFE, 0x07, 0xC0, 0x7C, 0x0F, 0xFC, 0x0F,
  0x80, 0xF0, 0x1F, 0xF8, 0x0F, 0x03, 0xE0, 0x3F, 0xF0, 0x1F, 0x07, 0x80,
  0x7F, 0xE0, 0x1E, 0x0F, 0x00, 0xFF, 0xC0, 0x3E, 0x3E, 0x01, 0xFF, 0x80,
  0x7C, 0x78, 0x03, 0xFF, 0x00, 0x79, 0xF0, 0x07, 0xFE, 0x00, 0xFB, 0xE0,
  0x0F, 0xFC, 0x01, 0xF7, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xF0,
  0x03, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xF0,
  0x01, 0xFF, 0x80, 0x0F, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0x80, 0x07, 0xFE,
  0x00, 0x1E, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFB, 0xE0, 0x00, 0x1F,
  0xF7, 0xE0, 0x00, 0x3F, 0xE7, 0xE0, 0x00, 0x7F, 0xC7, 0xC0, 0x00, 0xFF,
  0xCF, 0xC0, 0x01, 0xFF, 0x8F, 0xC0, 0x03, 0xFF, 0x0F, 0x80, 0x07, 0xFE,
  0x1F, 0x80, 0x0F, 0xFC, 0x1F, 0x80, 0x1F, 0xF8, 0x1F, 0x00, 0x3F, 0xF0,
  0x3F, 0x00, 0x7F, 0xE0, 0x3F, 0x00, 0xFF, 0xC0, 0x3E, 0x01, 0xFF, 0x80,
  0x7E, 0x03, 0xFF, 0x00, 0x7C, 0x07, 0xFE, 0x00, 0xFC, 0x0F, 0xFC, 0x00,
  0xFC, 0x1F, 0xF8, 0x00, 0xF8, 0x3F, 0xF0, 0x01, 0xF8, 0x7F, 0xE0, 0x01,
  0xF8, 0xFF, 0xC0, 0x01, 0xF1, 0xFF, 0x80, 0x03, 0xF3, 0xFF, 0x00, 0x03,
  0xF7, 0xFE, 0x00, 0x03, 0xE7, 0xFC, 0x00, 0x07, 0xEF, 0xF8, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFE, 0x03, 0xFE, 0x00,
  0x7F, 0x00, 0x0F, 0xF0, 0x0F, 0xC0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x1F, 0x00, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x00, 0x7C, 0x3E, 0x00,
  0x00, 0x07, 0xC7, 0xE0, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00, 0x03, 0xE7,
  0xC0, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0x7C, 0x00, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x00, 0x3E, 0x7C, 0x00,
  0x00, 0x03, 0xE7, 0xE0, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x07, 0xE3,
  0xE0, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x01,
  0xF8, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x07, 0xF0, 0x07, 0xF8,
  0x01, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x02, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xE7, 0xC0, 0x07, 0xF3, 0xE0, 0x00, 0xFD, 0xF0,
  0x00, 0x3E, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0xBE, 0x00, 0x3F,
  0x9F, 0x00, 0xFF, 0x8F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0x01, 0xFF, 0xFC, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFE, 0x03,
  0xFE, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x0F, 0xC0, 0x00, 0x3F, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x00, 0x7C,
  0x3E, 0x00, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00,
  0x03, 0xE7, 0xC0, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x03, 0xE7, 0xC0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x00, 0x3E,
  0x7C, 0x00, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00,
  0x07, 0xE3, 0xE0, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x07, 0xF0,
  0x07, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x0F, 0x80, 0x0F, 0xF0,
  0xF8, 0x00, 0x3F, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x8F, 0x80,
  0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x0F,
  0x8F, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x1F, 0x8F, 0x80, 0x01, 0xF0, 0xF8,
  0x00, 0x3F, 0x0F, 0x80, 0x07, 0xE0, 0xF8, 0x01, 0xFC, 0x0F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x0F,
  0x80, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0xF8, 0x01,
  0xF0, 0x0F, 0x80, 0x1F, 0x80, 0xF8, 0x00, 0xF8, 0x0F, 0x80, 0x07, 0xC0,
  0xF8, 0x00, 0x7E, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x3F, 0x0F, 0x80,
  0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0xFC, 0xF8, 0x00, 0x07,
  0xCF, 0x80, 0x00, 0x7E, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0xC0, 0x07,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x3F, 0xC0, 0xFC, 0x7E,
  0x00, 0x0C, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x80,
  0x00, 0x7E, 0xF0, 0x00, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x00, 0x60, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1E, 0xF8, 0x00,
  0x00, 0xFB, 0xE0, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x0F, 0x9F, 0x00, 0x00,
  0x7C, 0x7E, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0xFE,
  0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x3E, 0x7C,
  0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x7E, 0x3E, 0x00, 0x00, 0x7C, 0x1F,
  0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0xF8, 0x0F,
  0x80, 0x00, 0xF8, 0x0F, 0x80, 0x01, 0xF0, 0x0F, 0x80, 0x01, 0xF0, 0x07,
  0xC0, 0x01, 0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x07, 0xC0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x03, 0xE0, 0x07, 0xC0, 0x01,
  0xF0, 0x07, 0xC0, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0xF0, 0x0F, 0x80, 0x00,
  0xF8, 0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00,
  0x7C, 0x3E, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00,
  0x3E, 0x7C, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00,
  0x1F, 0x78, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xBE, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xDF, 0x80, 0x01, 0xFC, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xE3, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xF1, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xF8, 0x7C, 0x00, 0x3F, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x1E, 0xF8,
  0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x3C, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x9E,
  0x00, 0x1F, 0x03, 0xE0, 0x07, 0xCF, 0x80, 0x0F, 0x81, 0xF0, 0x03, 0xC7,
  0xC0, 0x0F, 0x80, 0xF8, 0x01, 0xE1, 0xE0, 0x07, 0xC0, 0x7C, 0x01, 0xF0,
  0xF8, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x78,
  0x1E, 0x01, 0xF0, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x03, 0xE0, 0x3E,
  0x07, 0xC0, 0x7C, 0x00, 0xF8, 0x1E, 0x01, 0xE0, 0x3C, 0x00, 0x7C, 0x0F,
  0x00, 0xF0, 0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x7C, 0x1F, 0x00, 0x1F, 0x07,
  0xC0, 0x3E, 0x0F, 0x80, 0x07, 0xC3, 0xC0, 0x0F, 0x07, 0x80, 0x03, 0xE3,
  0xE0, 0x07, 0xC7, 0xC0, 0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x00, 0x78,
  0xF0, 0x00, 0xF1, 0xF0, 0x00, 0x3E, 0x78, 0x00, 0x78, 0xF0, 0x00, 0x1F,
  0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x0F, 0x7C, 0x00, 0x03,
  0xDE, 0x00, 0x07, 0xBE, 0x00, 0x01, 0xEF, 0x00, 0x03, 0xDE, 0x00, 0x00,
  0xF7, 0x80, 0x01, 0xEF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x7C, 0x00,
  0x00, 0xF8, 0xFC, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0xC0, 0xF8, 0x00,
  0x1F, 0x01, 0xF8, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x03, 0xE0, 0x0F, 0x80, 0x03, 0xE0, 0x1F, 0x00, 0x03, 0xE0, 0x7C,
  0x00, 0x07, 0xC1, 0xF0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x0F, 0xCF, 0x80,
  0x00, 0x0F, 0x9E, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x1F, 0x7E, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x03,
  0xE0, 0xF8, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x7C,
  0x01, 0xF0, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xF0, 0x0F, 0x80,
  0x03, 0xE0, 0x1F, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xE1, 0xF8, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x0F, 0xBF, 0x00, 0x00,
  0x0F, 0x80, 0xF8, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0xF9, 0xF0, 0x00,
  0x03, 0xE1, 0xF0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1F, 0x03, 0xE0, 0x00,
  0x3E, 0x07, 0xC0, 0x00, 0xF8, 0x07, 0xC0, 0x01, 0xF0, 0x0F, 0xC0, 0x07,
  0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x3E, 0x00, 0x1F, 0x00, 0xFC,
  0x00, 0x1F, 0x01, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E, 0x0F, 0x80,
  0x00, 0x7C, 0x3E, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0xF9, 0xF0, 0x00,
  0x00, 0xFB, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x07, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0x80,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xC0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0xE1,
  0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xE0, 0x78, 0x00,
  0x3C, 0x07, 0x80, 0x0F, 0x00, 0xF0, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x01,
  0xE0, 0x0F, 0x00, 0x1E, 0x03, 0xC0, 0x03, 0xC0, 0x78, 0x00, 0x3C, 0x1F,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0x78, 0xF8, 0x00, 0x0F, 0x1E, 0x00, 0x00,
  0xF3, 0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFC, 0x0F, 0xF3, 0xFE, 0x07, 0x00, 0x7E, 0x04, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0x3F, 0xE0, 0x1F, 0x3F, 0x00, 0x1F, 0x7E, 0x00, 0x1F, 0x7C, 0x00,
  0x1F, 0x7C, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0x7C, 0x00,
  0x3F, 0x7C, 0x00, 0x7F, 0x7E, 0x00, 0xFF, 0x7F, 0x87, 0xEF, 0x3F, 0xFF,
  0xCF, 0x1F, 0xFF, 0x8F, 0x07, 0xFE, 0x0F, 0x00, 0x40, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x0F, 0xFC, 0x07, 0x8F, 0xFF, 0x83, 0xDF, 0xFF, 0xE1, 0xEF, 0xFF, 0xF8,
  0xFF, 0x00, 0x7E, 0x7F, 0x00, 0x1F, 0x3F, 0x00, 0x07, 0xDF, 0x00, 0x03,
  0xEF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xBF, 0x00, 0x07, 0xDF,
  0xC0, 0x07, 0xCF, 0xF0, 0x07, 0xE7, 0xFF, 0x9F, 0xE3, 0xDF, 0xFF, 0xE1,
  0xC7, 0xFF, 0xE0, 0xE0, 0xFF, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x1F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE1, 0xF8, 0x03, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x80, 0x18, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x07, 0xFF, 0xF0,
  0x1F, 0xFE, 0x00, 0x02, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x01, 0xFF, 0x87, 0xC1,
  0xFF, 0xF9, 0xF0, 0xFF, 0xFF, 0x7C, 0x7F, 0xDF, 0xFF, 0x3F, 0x80, 0x7F,
  0xCF, 0xC0, 0x0F, 0xF7, 0xE0, 0x01, 0xFD, 0xF0, 0x00, 0x3F, 0x7C, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0x7C, 0x00, 0x0F, 0xDF, 0x00, 0x03, 0xF7, 0xE0, 0x01, 0xFC, 0xF8,
  0x00, 0x7F, 0x3F, 0x80, 0x7F, 0xC7, 0xFC, 0xFF, 0xF0, 0xFF, 0xFF, 0x7C,
  0x1F, 0xFF, 0x8F, 0x01, 0xFF, 0x83, 0xC0, 0x0C, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x01, 0xFE, 0xFF, 0x81, 0xF8,
  0x07, 0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x3E, 0x7C,
  0x00, 0x1F, 0x3C, 0x00, 0x07, 0xBE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x02, 0x1F, 0xC0, 0x06, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x00, 0x20, 0x00, 0x00, 0x3F, 0xE0, 0x0F,
  0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x1F, 0xFF, 0x8F, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xFF, 0x83, 0xC1, 0xFF, 0xF8, 0xF0, 0xFF, 0xFF,
  0x7C, 0x7F, 0xFF, 0xFF, 0x3F, 0x80, 0x7F, 0xCF, 0xC0, 0x0F, 0xF7, 0xE0,
  0x01, 0xFD, 0xF0, 0x00, 0x3F, 0x7C, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xDF,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0xFC, 0xF8, 0x00, 0x7F, 0x3F, 0x80, 0x3F,
  0xC7, 0xF8, 0x7F, 0xF0, 0xFF, 0xFF, 0x7C, 0x1F, 0xFF, 0x9F, 0x01, 0xFF,
  0x87, 0xC0, 0x0C, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E,
  0x30, 0x00, 0x3F, 0x0F, 0xC0, 0x3F, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x7F, 0xE0, 0xF1,
  0xFF, 0xF8, 0xF3, 0xFF, 0xFC, 0xF7, 0xFF, 0xFC, 0xFF, 0x00, 0x7E, 0xFE,
  0x00, 0x3E, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0x31,
  0xEF, 0xFF, 0xFD, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x79, 0xE7, 0x9E, 0x79,
  0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79,
  0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x00, 0x60, 0x07, 0x80, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x83,
  0xF7, 0xFF, 0x3F, 0xF9, 0xFF, 0x87, 0xE0, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x07, 0xFE, 0x00, 0x1F,
  0x3C, 0x00, 0x7C, 0x78, 0x01, 0xF0, 0xF0, 0x07, 0xC1, 0xE0, 0x1F, 0x03,
  0xC0, 0x7C, 0x07, 0x81, 0xF8, 0x0F, 0x07, 0xE0, 0x1E, 0x1F, 0x80, 0x3C,
  0x7E, 0x00, 0x79, 0xF8, 0x00, 0xF3, 0xE0, 0x01, 0xEF, 0xE0, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0xC0, 0x0F, 0xCF, 0xC0, 0x1F, 0x0F, 0xC0, 0x3C, 0x0F,
  0x80, 0x78, 0x0F, 0x80, 0xF0, 0x1F, 0x81, 0xE0, 0x1F, 0x83, 0xC0, 0x1F,
  0x07, 0x80, 0x1F, 0x0F, 0x00, 0x3F, 0x1E, 0x00, 0x3F, 0x3C, 0x00, 0x3E,
  0x78, 0x00, 0x7E, 0xF0, 0x00, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xF0, 0xFF, 0xC0, 0x3F, 0xF8, 0x78, 0xFF, 0xF8, 0x3F,
  0xFE, 0x3C, 0xFF, 0xFE, 0x7F, 0xFF, 0x9E, 0xFF, 0xFF, 0x3F, 0xFF, 0xEF,
  0xF0, 0x0F, 0xFC, 0x03, 0xF7, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x01,
  0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0x80, 0x03, 0xFE,
  0x00, 0x07, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0x80, 0x01,
  0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7C, 0x00,
  0x1F, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xC0, 0x01, 0xFF, 0x00, 0x03,
  0xE0, 0x00, 0xFF, 0x80, 0x01, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0x80, 0x03, 0xFE, 0x00, 0x07,
  0xC0, 0x01, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0xF0, 0x7F, 0xE0, 0xF1,
  0xFF, 0xF8, 0xF3, 0xFF, 0xFC, 0xF7, 0xFF, 0xFE, 0xFF, 0x00, 0x7E, 0xFE,
  0x00, 0x3E, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0x00,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x01, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x03, 0xE3, 0xE0,
  0x00, 0x7E, 0x7C, 0x00, 0x07, 0xDF, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x1F,
  0x7C, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0x3C, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x7C, 0xF8, 0x00,
  0x1F, 0x8F, 0x80, 0x03, 0xE1, 0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x01,
  0xFF, 0x7F, 0xC0, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0xF0, 0xFF, 0xC0, 0x78, 0xFF, 0xF8, 0x3C,
  0xFF, 0xFE, 0x1E, 0xFF, 0xFF, 0x8F, 0xF0, 0x0F, 0xE7, 0xF0, 0x01, 0xF3,
  0xF0, 0x00, 0xFD, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x00, 0xFB, 0xF0, 0x00, 0xFD, 0xFC, 0x00, 0x7C, 0xFF, 0x00, 0xFE, 0x7F,
  0xFB, 0xFE, 0x3D, 0xFF, 0xFE, 0x1E, 0x3F, 0xFE, 0x0F, 0x0F, 0xFC, 0x07,
  0x80, 0x30, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x83, 0xC1, 0xFF, 0xF8, 0xF0,
  0xFF, 0xFF, 0x7C, 0x7F, 0xDF, 0xFF, 0x3F, 0x80, 0x7F, 0xCF, 0xC0, 0x0F,
  0xF7, 0xE0, 0x01, 0xFD, 0xF0, 0x00, 0x3F, 0x7C, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0x7C, 0x00,
  0x0F, 0xDF, 0x00, 0x03, 0xF7, 0xE0, 0x01, 0xFC, 0xF8, 0x00, 0x7F, 0x3F,
  0x80, 0x7F, 0xC7, 0xFC, 0xFF, 0xF0, 0xFF, 0xFF, 0x7C, 0x1F, 0xFF, 0x9F,
  0x01, 0xFF, 0x87, 0xC0, 0x04, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0xF0, 0x7F,
  0xF1, 0xFF, 0xF3, 0xFF, 0xF7, 0xFF, 0xF7, 0xC0, 0xFF, 0x00, 0xFE, 0x00,
  0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x07, 0xFF, 0x81, 0xFF,
  0xFF, 0x3F, 0xFF, 0xE7, 0xF8, 0xFE, 0xFC, 0x00, 0xEF, 0x80, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0xC1,
  0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0x3F, 0xFE, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xF1, 0x83, 0xFF, 0xC0,
  0xFF, 0xE0, 0x1F, 0xF0, 0x00, 0xC0, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0xC0, 0x00, 0xFD, 0xF0, 0x00, 0xFE, 0xF8, 0x00, 0x7F, 0x7E, 0x00, 0xFF,
  0x9F, 0xF7, 0xFF, 0xCF, 0xFF, 0xFB, 0xE3, 0xFF, 0xF8, 0xF0, 0x7F, 0xF0,
  0x78, 0x01, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7D, 0xF0,
  0x00, 0x1F, 0xBE, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x1F,
  0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x01, 0xE0,
  0x03, 0xE0, 0x3E, 0x00, 0x78, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xE0,
  0x0F, 0x80, 0xF8, 0x01, 0xF0, 0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x03, 0xE0,
  0xF8, 0x00, 0x3C, 0x1F, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0xF8, 0xF8, 0x00,
  0x0F, 0x1F, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xDF,
  0x00, 0x00, 0x7B, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xFC,
  0x00, 0x3F, 0x00, 0x07, 0xBE, 0x00, 0x1F, 0xC0, 0x07, 0xCF, 0x00, 0x0F,
  0xE0, 0x03, 0xE7, 0xC0, 0x0F, 0xF0, 0x01, 0xF3, 0xE0, 0x07, 0xFC, 0x00,
  0xF1, 0xF0, 0x03, 0xDE, 0x00, 0xF8, 0x78, 0x03, 0xEF, 0x00, 0x7C, 0x3E,
  0x01, 0xE7, 0x80, 0x3C, 0x1F, 0x00, 0xF3, 0xE0, 0x3E, 0x0F, 0x80, 0xF8,
  0xF0, 0x1F, 0x03, 0xC0, 0x7C, 0x78, 0x0F, 0x81, 0xF0, 0x3C, 0x3E, 0x07,
  0x80, 0xF8, 0x3E, 0x0F, 0x07, 0xC0, 0x3C, 0x1F, 0x07, 0x83, 0xE0, 0x1F,
  0x0F, 0x03, 0xE1, 0xF0, 0x0F, 0x8F, 0x81, 0xF0, 0xF0, 0x07, 0xC7, 0xC0,
  0x78, 0xF8, 0x01, 0xE3, 0xC0, 0x3C, 0x7C, 0x00, 0xF9, 0xE0, 0x1F, 0x3C,
  0x00, 0x7D, 0xF0, 0x07, 0x9E, 0x00, 0x3E, 0xF0, 0x03, 0xDF, 0x00, 0x0F,
  0x78, 0x01, 0xFF, 0x80, 0x07, 0xBC, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xF0, 0xFC, 0x00, 0x7C, 0x0F, 0x80, 0x1F,
  0x80, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0xF8, 0x01, 0xF0, 0x3F, 0x00, 0x1F,
  0x07, 0xC0, 0x03, 0xF1, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xEF, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xEF, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x3E, 0x1F, 0x80, 0x0F, 0xC1,
  0xF0, 0x01, 0xF0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x1F, 0x00, 0x3E, 0x07,
  0xE0, 0x03, 0xE0, 0xF8, 0x00, 0x7E, 0x3E, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x7E, 0xF8, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xE7,
  0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0xF8, 0x1F, 0x00,
  0x0F, 0x81, 0xF0, 0x00, 0xF8, 0x1F, 0x00, 0x1F, 0x00, 0xF8, 0x01, 0xF0,
  0x0F, 0x80, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x07, 0xC0, 0x3E, 0x00, 0x7C,
  0x03, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xE0, 0x78,
  0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x1F, 0x00, 0x00,
  0xF9, 0xF0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0x80,
  0x0F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x1F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0xFC, 0x03, 0xFC, 0x01, 0xF8, 0x00,
  0xFE, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x03, 0xFC, 0x00,
  0x7E, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7E, 0x00, 0x3F, 0x80,
  0x1F, 0xF0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x7F, 0xC0, 0x7E, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x9F, 0xF8, 0x00, 0x5F, 0xFF, 0x00, 0xFF, 0xFF, 0xF9,
  0xFF, 0x9F, 0xFF, 0xFE, 0x00, 0xFF, 0xFA, 0x00, 0x1F, 0xF9, 0x00, 0x00,
  0x40,
};

const GFXglyph NotoSans_Regular54pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 7, 40, 15, 4, -39 },
  { 36, 15, 14, 22, 4, -39 },
  { 63, 32, 39, 35, 1, -39 },
  { 219, 25, 44, 31, 3, -41 },
  { 357, 39, 40, 45, 3, -39 },
  { 552, 36, 40, 40, 3, -39 },
  { 732, 5, 14, 12, 4, -39 },
  { 741, 13, 48, 16, 2, -39 },
  { 819, 12, 48, 16, 2, -39 },
  { 891, 25, 24, 30, 2, -41 },
  { 966, 25, 26, 31, 3, -32 },
  { 1048, 8, 13, 14, 2, -6 },
  { 1061, 13, 5, 17, 2, -17 },
  { 1070, 7, 8, 14, 4, -7 },
  { 1077, 19, 39, 20, 1, -39 },
  { 1170, 25, 40, 31, 3, -39 },
  { 1295, 14, 39, 31, 5, -39 },
  { 1364, 25, 39, 31, 3, -39 },
  { 1486, 26, 40, 31, 2, -39 },
  { 1616, 29, 39, 31, 1, -39 },
  { 1758, 25, 40, 31, 3, -39 },
  { 1883, 25, 40, 31, 3, -39 },
  { 2008, 26, 39, 31, 2, -39 },
  { 2135, 25, 40, 31, 3, -39 },
  { 2260, 25, 40, 31, 3, -39 },
  { 2385, 7, 31, 14, 4, -30 },
  { 2413, 8, 37, 14, 2, -30 },
  { 2450, 25, 27, 31, 3, -33 },
  { 2535, 25, 14, 31, 3, -26 },
  { 2579, 25, 27, 31, 3, -33 },
  { 2664, 21, 40, 23, 1, -39 },
  { 2769, 42, 44, 49, 3, -39 },
  { 3000, 34, 39, 35, 0, -39 },
  { 3166, 27, 39, 35, 5, -39 },
  { 3298, 29, 40, 34, 3, -39 },
  { 3443, 31, 39, 39, 5, -39 },
  { 3595, 22, 39, 30, 5, -39 },
  { 3703, 22, 39, 28, 5, -39 },
  { 3811, 32, 40, 39, 3, -39 },
  { 3971, 30, 39, 40, 5, -39 },
  { 4118, 14, 39, 18, 2, -39 },
  { 4187, 14, 49, 15, -4, -39 },
  { 4273, 28, 39, 33, 5, -39 },
  { 4410, 22, 39, 28, 5, -39 },
  { 4518, 39, 39, 49, 5, -39 },
  { 4709, 31, 39, 41, 5, -39 },
  { 4861, 36, 40, 42, 3, -39 },
  { 5041, 25, 39, 33, 5, -39 },
  { 5163, 36, 48, 42, 3, -39 },
  { 5379, 28, 39, 34, 5, -39 },
  { 5516, 24, 40, 30, 3, -39 },
  { 5636, 28, 39, 30, 1, -39 },
  { 5773, 30, 40, 39, 5, -39 },
  { 5923, 32, 39, 32, 0, -39 },
  { 6079, 49, 39, 50, 1, -39 },
  { 6318, 31, 39, 32, 0, -39 },
  { 6470, 31, 39, 31, 0, -39 },
  { 6622, 27, 39, 31, 2, -39 },
  { 6754, 12, 48, 18, 4, -39 },
  { 6826, 19, 39, 20, 1, -39 },
  { 6919, 12, 48, 18, 1, -39 },
  { 6991, 27, 25, 31, 2, -39 },
  { 7076, 24, 3, 24, 0, 5 },
  { 7085, 11, 8, 15, 2, -41 },
  { 7096, 24, 30, 30, 2, -29 },
  { 7186, 25, 42, 33, 5, -41 },
  { 7318, 21, 30, 26, 3, -29 },
  { 7397, 26, 42, 33, 3, -41 },
  { 7534, 25, 30, 30, 3, -29 },
  { 7628, 20, 41, 19, 1, -41 },
  { 7731, 26, 42, 33, 3, -29 },
  { 7868, 24, 41, 33, 5, -41 },
  { 7991, 6, 40, 14, 4, -40 },
  { 8021, 13, 53, 14, -3, -40 },
  { 8108, 23, 41, 29, 5, -41 },
  { 8226, 4, 41, 14, 5, -41 },
  { 8247, 41, 29, 50, 5, -29 },
  { 8396, 24, 29, 33, 5, -29 },
  { 8483, 27, 30, 33, 3, -29 },
  { 8585, 25, 42, 33, 5, -29 },
  { 8717, 26, 42, 33, 3, -29 },
  { 8854, 16, 29, 22, 5, -29 },
  { 8912, 20, 30, 26, 3, -29 },
  { 8987, 17, 37, 20, 1, -36 },
  { 9066, 25, 30, 33, 4, -29 },
  { 9160, 27, 29, 27, 0, -29 },
  { 9258, 41, 29, 42, 1, -29 },
  { 9407, 27, 29, 29, 1, -29 },
  { 9505, 28, 42, 28, 0, -29 },
  { 9652, 21, 29, 25, 2, -29 },
  { 9729, 17, 48, 21, 2, -39 },
  { 9831, 4, 54, 30, 13, -41 },
  { 9858, 17, 48, 21, 2, -39 },
  { 9960, 25, 8, 31, 3, -23 },
};

const GFXfont NotoSans_Regular54pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Regular54pt7bBitmaps,
  (GFXglyph *)NotoSans_Regular54pt7bGlyphs,
  0x20, 0x7E, 74
};

#endif // _NOTOSANS_REGULAR54PT7B_H_
