#ifndef _NOTOSANS_REGULAR15PT7B_H_
#define _NOTOSANS_REGULAR15PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Regular.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Regular15pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xF5, 0x3C, 0x99, 0x99, 0x09, 0x0C, 0x84, 0x4F, 0xF1, 0x20,
  0x90, 0x49, 0xFF, 0x24, 0x12, 0x09, 0x00, 0x10, 0xFB, 0x54, 0x8D, 0x0F,
  0x07, 0x0B, 0x97, 0xF8, 0x40, 0x80, 0x60, 0x92, 0x22, 0x4C, 0x49, 0x09,
  0x49, 0x2A, 0x9A, 0x88, 0x51, 0x12, 0x22, 0x2C, 0x87, 0x00, 0x38, 0x1B,
  0x04, 0x41, 0x30, 0x38, 0x1C, 0x0C, 0x8A, 0x16, 0x83, 0x31, 0xC7, 0xCC,
  0xF0, 0x2B, 0x49, 0x24, 0x93, 0x26, 0xC6, 0x22, 0x33, 0x11, 0x33, 0x22,
  0xC0, 0x30, 0x23, 0xF9, 0x87, 0x89, 0x80, 0x10, 0x20, 0x47, 0xF1, 0x02,
  0x04, 0x00, 0xFA, 0xFC, 0xF0, 0x08, 0x46, 0x21, 0x10, 0x8C, 0x42, 0x30,
  0x38, 0x9A, 0x14, 0x38, 0x70, 0x61, 0xC3, 0x87, 0x89, 0xE0, 0x13, 0xD1,
  0x11, 0x11, 0x11, 0x10, 0x79, 0x98, 0x10, 0x20, 0x41, 0x06, 0x18, 0x61,
  0x83, 0xF8, 0x79, 0x98, 0x10, 0x20, 0xCF, 0x01, 0x03, 0x07, 0x0B, 0xE0,
  0x06, 0x0E, 0x0E, 0x16, 0x36, 0x26, 0x46, 0xFF, 0xFF, 0x06, 0x06, 0x7C,
  0x83, 0x06, 0x0B, 0x1F, 0x81, 0x83, 0x07, 0x0B, 0xE0, 0x1C, 0xC1, 0x04,
  0x09, 0x9D, 0xA1, 0xC1, 0x86, 0x89, 0xF0, 0xFE, 0x0C, 0x10, 0x20, 0x81,
  0x06, 0x08, 0x30, 0x41, 0x80, 0x79, 0x8A, 0x16, 0x26, 0xC7, 0x33, 0x43,
  0x83, 0x8D, 0xF0, 0x39, 0x9A, 0x14, 0x38, 0x78, 0xDF, 0x83, 0x04, 0x19,
  0xE0, 0xF0, 0x0F, 0x6C, 0x00, 0x1A, 0x58, 0x02, 0x18, 0xC6, 0x06, 0x03,
  0x01, 0x80, 0xFE, 0x00, 0x07, 0xF0, 0x80, 0xC0, 0x60, 0x30, 0xCE, 0x20,
  0x00, 0x7B, 0x30, 0x41, 0x0C, 0x42, 0x08, 0x00, 0x83, 0x00, 0x0F, 0x03,
  0x8C, 0x60, 0x64, 0x72, 0x99, 0x39, 0x11, 0x91, 0x19, 0x12, 0x9E, 0xEC,
  0x00, 0x60, 0x03, 0xF8, 0x0C, 0x03, 0x01, 0xC0, 0x58, 0x12, 0x08, 0x83,
  0xF1, 0xFC, 0x41, 0x90, 0x2C, 0x0C, 0xFC, 0xC6, 0xC3, 0xC3, 0xC2, 0xFC,
  0xC3, 0xC3, 0xC3, 0xC3, 0xFE, 0x1E, 0x73, 0x40, 0xC0, 0x80, 0x80, 0x80,
  0xC0, 0xC0, 0x60, 0x3F, 0xFC, 0x67, 0x30, 0x58, 0x3C, 0x0E, 0x07, 0x03,
  0x83, 0xC1, 0x63, 0xBF, 0x00, 0xFF, 0x0C, 0x30, 0xC3, 0xFC, 0x30, 0xC3,
  0x0F, 0xC0, 0xFF, 0x0C, 0x30, 0xC3, 0xFC, 0x30, 0xC3, 0x0C, 0x00, 0x1F,
  0x98, 0x90, 0x18, 0x08, 0x04, 0x3E, 0x1F, 0x83, 0xC1, 0xB0, 0xCF, 0xE0,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1F, 0xFF, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x60, 0xE9, 0x24, 0x92, 0x4B, 0x80, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33,
  0x2C, 0xC3, 0xC6, 0xC4, 0xC8, 0xD0, 0xF0, 0xD8, 0xCC, 0xC4, 0xC2, 0xC3,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0F, 0xC0, 0xE0, 0x7C, 0x0F,
  0x83, 0xF8, 0x5D, 0x0B, 0xA2, 0x76, 0x4E, 0x59, 0xCE, 0x38, 0xC7, 0x10,
  0x80, 0xC0, 0xF0, 0x78, 0x3A, 0x1D, 0x8E, 0x47, 0x33, 0x8D, 0xC2, 0xE1,
  0xF0, 0x60, 0x1E, 0x1C, 0xC4, 0x0B, 0x03, 0x80, 0xE0, 0x38, 0x0F, 0x03,
  0xC0, 0x98, 0x63, 0xF0, 0xF9, 0x9F, 0x0E, 0x1C, 0x39, 0xFE, 0x60, 0xC1,
  0x83, 0x00, 0x1E, 0x1C, 0xC4, 0x0B, 0x03, 0x80, 0xE0, 0x38, 0x0F, 0x03,
  0xC0, 0x98, 0x63, 0xF0, 0x08, 0x03, 0x00, 0x60, 0xF8, 0xCE, 0xC2, 0xC2,
  0xC2, 0xFC, 0xF8, 0xCC, 0xC6, 0xC2, 0xC3, 0x7D, 0x8A, 0x04, 0x0C, 0x0F,
  0x03, 0x02, 0x07, 0x0B, 0xE0, 0xFF, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0x41, 0x31, 0x8F, 0x80, 0x80, 0xE0, 0xD0, 0x4C, 0x62, 0x21, 0x10,
  0xD8, 0x28, 0x14, 0x0E, 0x02, 0x00, 0xC3, 0x0D, 0x0C, 0x24, 0x30, 0x91,
  0xE2, 0x64, 0x98, 0x92, 0x42, 0xC9, 0x0A, 0x14, 0x38, 0x70, 0x61, 0x81,
  0x86, 0x00, 0xC1, 0x31, 0x88, 0x86, 0x81, 0xC0, 0x40, 0x70, 0x6C, 0x22,
  0x21, 0xB0, 0x60, 0xC1, 0x43, 0x62, 0x26, 0x34, 0x1C, 0x18, 0x08, 0x08,
  0x08, 0x08, 0xFE, 0x0C, 0x10, 0x41, 0x82, 0x08, 0x30, 0x41, 0x03, 0xF8,
  0xF8, 0x88, 0x88, 0x88, 0x88, 0x88, 0xF0, 0xC2, 0x10, 0xC2, 0x10, 0xC2,
  0x18, 0x42, 0xF3, 0x33, 0x33, 0x33, 0x33, 0x33, 0xF0, 0x10, 0x60, 0xA2,
  0x44, 0x50, 0xA0, 0x80, 0xFE, 0xCC, 0x7E, 0x10, 0x4F, 0xC6, 0x18, 0xFD,
  0xC1, 0x83, 0x07, 0xEC, 0x78, 0x70, 0xE1, 0xC3, 0x8E, 0xF0, 0x7F, 0x08,
  0x20, 0x82, 0x0C, 0x1F, 0x02, 0x04, 0x0B, 0xDC, 0x70, 0xE0, 0xC1, 0x83,
  0x8D, 0xE8, 0x7D, 0x8A, 0x1F, 0xF8, 0x10, 0x30, 0xBE, 0x3C, 0x82, 0x3E,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x00, 0x7B, 0x8E, 0x1C, 0x18, 0x30, 0x71,
  0xBD, 0x02, 0x0F, 0xF1, 0x80, 0xC1, 0x83, 0x07, 0xEC, 0x78, 0x70, 0xE1,
  0xC3, 0x87, 0x08, 0xE3, 0xFF, 0xFC, 0x32, 0x03, 0x33, 0x33, 0x33, 0x33,
  0x3E, 0xC0, 0xC1, 0x83, 0x06, 0x3C, 0x9A, 0x38, 0x68, 0xD9, 0x9B, 0x18,
  0xFF, 0xFF, 0xFC, 0xBD, 0xEC, 0x63, 0xC6, 0x3C, 0x63, 0xC6, 0x3C, 0x63,
  0xC6, 0x3C, 0x63, 0xBD, 0x8F, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0x7D, 0x8E,
  0x0C, 0x18, 0x30, 0x71, 0xBE, 0xBD, 0x8F, 0x0E, 0x1C, 0x38, 0x71, 0xFE,
  0xC1, 0x83, 0x06, 0x00, 0x7B, 0x8E, 0x1C, 0x18, 0x30, 0x71, 0xBD, 0x02,
  0x04, 0x08, 0x10, 0xBF, 0x31, 0x8C, 0x63, 0x18, 0xFA, 0x08, 0x18, 0x18,
  0x38, 0xBE, 0x23, 0x3E, 0xC6, 0x31, 0x8C, 0x61, 0xC0, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0x71, 0xBD, 0xC3, 0x42, 0x46, 0x64, 0x24, 0x2C, 0x38, 0x18,
  0xC6, 0x34, 0x62, 0x4E, 0x24, 0xB6, 0x69, 0x43, 0x94, 0x31, 0xC3, 0x0C,
  0xC3, 0x64, 0x3C, 0x18, 0x18, 0x2C, 0x66, 0xC3, 0xC3, 0x42, 0x46, 0x64,
  0x24, 0x2C, 0x18, 0x18, 0x10, 0x10, 0xE0, 0xC0, 0xF8, 0x44, 0x66, 0x22,
  0x1F, 0x08, 0x8C, 0x63, 0x13, 0x8C, 0x31, 0x8C, 0x61, 0x80, 0xFF, 0xFE,
  0xC3, 0x08, 0x42, 0x18, 0x62, 0x21, 0x08, 0x4E, 0x00, 0xF3, 0x18,
};

const GFXglyph NotoSans_Regular15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 2, 11, 4, 1, -11 },
  { 4, 4, 4, 6, 1, -11 },
  { 6, 9, 11, 10, 0, -11 },
  { 19, 7, 12, 9, 1, -11 },
  { 30, 11, 11, 12, 1, -11 },
  { 46, 10, 11, 11, 1, -11 },
  { 60, 1, 4, 3, 1, -11 },
  { 61, 3, 13, 5, 1, -11 },
  { 66, 4, 13, 5, 0, -11 },
  { 73, 7, 6, 8, 1, -11 },
  { 79, 7, 7, 9, 1, -9 },
  { 86, 2, 4, 4, 1, -2 },
  { 87, 3, 2, 5, 1, -5 },
  { 88, 2, 2, 4, 1, -2 },
  { 89, 5, 11, 6, 0, -11 },
  { 96, 7, 11, 9, 1, -11 },
  { 106, 4, 11, 9, 1, -11 },
  { 112, 7, 11, 9, 1, -11 },
  { 122, 7, 11, 9, 1, -11 },
  { 132, 8, 11, 9, 0, -11 },
  { 143, 7, 11, 9, 1, -11 },
  { 153, 7, 11, 9, 1, -11 },
  { 163, 7, 11, 9, 1, -11 },
  { 173, 7, 11, 9, 1, -11 },
  { 183, 7, 11, 9, 1, -11 },
  { 193, 2, 8, 4, 1, -8 },
  { 195, 3, 10, 4, 0, -8 },
  { 199, 7, 7, 9, 1, -9 },
  { 206, 7, 4, 9, 1, -7 },
  { 210, 7, 7, 9, 1, -9 },
  { 217, 6, 11, 7, 0, -11 },
  { 226, 12, 12, 13, 1, -11 },
  { 244, 10, 11, 10, 0, -11 },
  { 258, 8, 11, 10, 1, -11 },
  { 269, 8, 11, 9, 1, -11 },
  { 280, 9, 11, 11, 1, -11 },
  { 293, 6, 11, 8, 1, -11 },
  { 302, 6, 11, 8, 1, -11 },
  { 311, 9, 11, 11, 1, -11 },
  { 324, 9, 11, 11, 1, -11 },
  { 337, 3, 11, 5, 1, -11 },
  { 342, 4, 14, 4, -1, -11 },
  { 349, 8, 11, 9, 1, -11 },
  { 360, 6, 11, 8, 1, -11 },
  { 369, 11, 11, 14, 1, -11 },
  { 385, 9, 11, 11, 1, -11 },
  { 398, 10, 11, 12, 1, -11 },
  { 412, 7, 11, 9, 1, -11 },
  { 422, 10, 14, 12, 1, -11 },
  { 440, 8, 11, 9, 1, -11 },
  { 451, 7, 11, 8, 1, -11 },
  { 461, 8, 11, 8, 0, -11 },
  { 472, 9, 11, 11, 1, -11 },
  { 485, 9, 11, 9, 0, -11 },
  { 498, 14, 11, 14, 0, -11 },
  { 518, 9, 11, 9, 0, -11 },
  { 531, 8, 11, 8, 0, -11 },
  { 542, 7, 11, 9, 1, -11 },
  { 552, 4, 13, 5, 1, -11 },
  { 559, 5, 11, 6, 0, -11 },
  { 566, 4, 13, 5, 0, -11 },
  { 573, 7, 7, 9, 1, -11 },
  { 580, 7, 1, 7, 0, 1 },
  { 581, 3, 2, 4, 1, -11 },
  { 582, 6, 8, 8, 1, -8 },
  { 588, 7, 11, 9, 1, -11 },
  { 598, 6, 8, 7, 1, -8 },
  { 604, 7, 11, 9, 1, -11 },
  { 614, 7, 8, 8, 1, -8 },
  { 621, 6, 11, 5, 0, -11 },
  { 630, 7, 12, 9, 1, -8 },
  { 641, 7, 11, 9, 1, -11 },
  { 651, 2, 11, 4, 1, -11 },
  { 654, 4, 15, 4, -1, -11 },
  { 662, 7, 11, 8, 1, -11 },
  { 672, 2, 11, 4, 1, -11 },
  { 675, 12, 8, 14, 1, -8 },
  { 687, 7, 8, 9, 1, -8 },
  { 694, 7, 8, 9, 1, -8 },
  { 701, 7, 12, 9, 1, -8 },
  { 712, 7, 12, 9, 1, -8 },
  { 723, 5, 8, 6, 1, -8 },
  { 728, 6, 8, 7, 1, -8 },
  { 734, 5, 10, 5, 0, -10 },
  { 741, 7, 8, 9, 1, -8 },
  { 748, 8, 8, 8, 0, -8 },
  { 756, 12, 8, 12, 0, -8 },
  { 768, 8, 8, 8, 0, -8 },
  { 776, 8, 12, 8, 0, -8 },
  { 788, 5, 8, 7, 1, -8 },
  { 793, 5, 13, 6, 0, -11 },
  { 802, 1, 15, 8, 4, -11 },
  { 804, 5, 13, 6, 0, -11 },
  { 813, 7, 2, 9, 1, -6 },
};

const GFXfont NotoSans_Regular15pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Regular15pt7bBitmaps,
  (GFXglyph *)NotoSans_Regular15pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _NOTOSANS_REGULAR15PT7B_H_
