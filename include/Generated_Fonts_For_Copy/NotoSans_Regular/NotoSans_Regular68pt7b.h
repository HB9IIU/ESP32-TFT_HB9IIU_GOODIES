#ifndef _NOTOSANS_REGULAR68PT7B_H_
#define _NOTOSANS_REGULAR68PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Regular.ttf
// Size: 68pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Regular68pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x3E, 0x3E,
  0x3E, 0x3E, 0x3E, 0x3E, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7E, 0x3C, 0xFE, 0x07, 0xEF, 0xC0, 0xFD, 0xF8, 0x1F, 0xBF, 0x03,
  0xF7, 0xE0, 0x7E, 0xFC, 0x0F, 0xDF, 0x01, 0xFB, 0xE0, 0x3F, 0x7C, 0x07,
  0xEF, 0x80, 0x7D, 0xF0, 0x0F, 0xBE, 0x01, 0xE7, 0xC0, 0x3C, 0xF8, 0x07,
  0x8F, 0x00, 0xF1, 0xE0, 0x1E, 0x3C, 0x03, 0xC7, 0x80, 0x78, 0x00, 0x01,
  0xF0, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x07, 0x80, 0x00,
  0x03, 0xE0, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x03, 0xC0,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x1F,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x7C, 0x00,
  0x00, 0x1E, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFF, 0xC7, 0xF8, 0x7C, 0x1F, 0x0F, 0xE0, 0xF8, 0x02, 0x1F, 0x81, 0xF0,
  0x00, 0x7E, 0x03, 0xE0, 0x00, 0xFC, 0x07, 0xC0, 0x01, 0xF8, 0x0F, 0x80,
  0x03, 0xF0, 0x1F, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x07, 0xE0, 0x7C, 0x00,
  0x0F, 0xE0, 0xF8, 0x00, 0x1F, 0xF1, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x03, 0xEF, 0xFE, 0x00, 0x07, 0xC3, 0xFC, 0x00,
  0x0F, 0x83, 0xFC, 0x00, 0x1F, 0x03, 0xF8, 0x00, 0x3E, 0x03, 0xF0, 0x00,
  0x7C, 0x07, 0xE0, 0x00, 0xF8, 0x0F, 0xC0, 0x01, 0xF0, 0x1F, 0x80, 0x03,
  0xE0, 0x3F, 0x00, 0x07, 0xC0, 0xFF, 0x80, 0x0F, 0x83, 0xFB, 0xF0, 0x1F,
  0x1F, 0xF7, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x01, 0xFF,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x0F,
  0x81, 0xF8, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x3E, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0,
  0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0xFC,
  0x00, 0x03, 0xE0, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0xF8, 0x01, 0xF0, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x1F, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0xF8, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x7C, 0x1F, 0xF8, 0x1F, 0x00, 0x7C, 0x3F, 0x0F, 0xFF, 0x07, 0xC0, 0x3F,
  0x0F, 0x87, 0xFF, 0xE0, 0xF8, 0x0F, 0x87, 0xE3, 0xFF, 0xFC, 0x3E, 0x07,
  0xE1, 0xF0, 0xF8, 0x1F, 0x0F, 0xC3, 0xF0, 0xF8, 0x7E, 0x07, 0xE1, 0xFF,
  0xFC, 0x3E, 0x1F, 0x00, 0xF8, 0x3F, 0xFE, 0x1F, 0x07, 0xC0, 0x3E, 0x07,
  0xFF, 0x07, 0xC1, 0xF0, 0x07, 0xC0, 0x7F, 0x03, 0xE0, 0xF8, 0x01, 0xF0,
  0x00, 0x01, 0xF8, 0x3E, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x1F,
  0x00, 0x00, 0x3F, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0xF8, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x0F, 0x80,
  0x1F, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0xF8,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x03, 0xE0, 0x01, 0xF0, 0x07, 0xC0, 0x01, 0xF8, 0x00,
  0x7C, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x07, 0xE0, 0x7E, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x1F, 0x00, 0x07, 0xC0,
  0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xF8,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x3F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xCF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0x80, 0xFF,
  0xBF, 0xC0, 0x00, 0xFC, 0x07, 0xF8, 0x7F, 0x80, 0x03, 0xF0, 0x3F, 0xC0,
  0xFF, 0x80, 0x0F, 0xC1, 0xFE, 0x01, 0xFF, 0x00, 0x7E, 0x07, 0xF0, 0x03,
  0xFE, 0x01, 0xF8, 0x3F, 0x80, 0x03, 0xFC, 0x0F, 0xC0, 0xFE, 0x00, 0x07,
  0xF8, 0x3F, 0x03, 0xF0, 0x00, 0x0F, 0xF1, 0xFC, 0x0F, 0xC0, 0x00, 0x1F,
  0xE7, 0xE0, 0x3F, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0xFC, 0x00, 0x00, 0x7F,
  0xFC, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x0F, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xF8,
  0x03, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x07, 0xF8, 0x00, 0x0F, 0xFF, 0xE0,
  0x1F, 0xF8, 0x01, 0xFF, 0xBF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0x80,
  0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFE, 0x01,
  0xFF, 0xFF, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0xFE, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0x3E,
  0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x8F, 0x1E, 0x3C, 0x78, 0x00, 0x3E, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x0F,
  0xC0, 0x1F, 0x80, 0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0,
  0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0,
  0x03, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xF8,
  0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x70, 0x07, 0xC0, 0x0E, 0xFE, 0x07,
  0xC0, 0xFE, 0xFF, 0xE3, 0xC7, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x3E,
  0xFC, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x01, 0xFC,
  0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x1F, 0x80, 0x07, 0xF0,
  0x1F, 0xC0, 0x0F, 0xF0, 0x0F, 0xE0, 0x03, 0xE0, 0x0F, 0xC0, 0x00, 0xE0,
  0x07, 0x00, 0x00, 0x40, 0x04, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0xC7, 0xF1, 0xFC, 0x7E, 0x3F, 0x8F, 0xE3, 0xF0, 0xFC,
  0x3F, 0x1F, 0x87, 0xE1, 0xF0, 0x7C, 0x1F, 0x0F, 0x83, 0xE0, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3E, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x3C, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x3F,
  0x80, 0x0F, 0xE0, 0x3F, 0x80, 0x03, 0xF0, 0x1F, 0x80, 0x01, 0xFC, 0x1F,
  0xC0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x00, 0xFC,
  0xFC, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x1F,
  0x9F, 0x80, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x03,
  0xF7, 0xE0, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xF7, 0xE0, 0x00,
  0x01, 0xF9, 0xF8, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x7E, 0x7E, 0x00,
  0x00, 0x3F, 0x3F, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x0F, 0xCF, 0xC0,
  0x00, 0x07, 0xE3, 0xE0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x0F,
  0xE0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0xE7, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x01, 0xFF, 0x00, 0xFF,
  0xC0, 0x7F, 0xF0, 0x7F, 0xFC, 0x3F, 0xFF, 0x1F, 0xEF, 0xCF, 0xE3, 0xFF,
  0xF0, 0xFD, 0xF8, 0x3F, 0x7C, 0x0F, 0xCE, 0x03, 0xF1, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0,
  0x7F, 0xE0, 0x1F, 0xF0, 0x3F, 0x80, 0x07, 0xF8, 0x3E, 0x00, 0x03, 0xF8,
  0x18, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFC, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xC0, 0x0F, 0xF8, 0x3E, 0x00, 0x03, 0xF8,
  0x3C, 0x00, 0x01, 0xFC, 0x10, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFE, 0x80, 0x00, 0x01, 0xFE, 0xC0, 0x00, 0x03, 0xFC,
  0xFC, 0x00, 0x07, 0xFC, 0xFF, 0xE0, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0x03,
  0xE7, 0xC0, 0x00, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0x03, 0xF1, 0xF0, 0x00,
  0x00, 0x1F, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x00, 0x1F, 0x83,
  0xE0, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x00,
  0xFC, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x00, 0x7C, 0x01, 0xF0,
  0x00, 0x07, 0xE0, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x03, 0xE0, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x01,
  0xF0, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0xFC,
  0x00, 0x03, 0xE0, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFE, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF1, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xC0, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xFD, 0x00, 0x00, 0x07, 0xF3, 0x00, 0x00,
  0x1F, 0xE7, 0xC0, 0x00, 0xFF, 0x8F, 0xFF, 0x3F, 0xFE, 0x1F, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x0F, 0xFE,
  0x00, 0xFC, 0x3F, 0xFF, 0x80, 0xFC, 0x7F, 0xFF, 0xE0, 0xFC, 0xFF, 0xFF,
  0xF0, 0xFD, 0xFE, 0x1F, 0xF8, 0xFF, 0xE0, 0x03, 0xF8, 0xFF, 0xC0, 0x01,
  0xFC, 0xFF, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00,
  0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00,
  0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00,
  0xFE, 0x1F, 0x80, 0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xFC, 0x0F, 0xF0, 0x07,
  0xF8, 0x07, 0xFE, 0x3F, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0x80, 0x3F,
  0xC0, 0x7F, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00,
  0xFE, 0x1F, 0x80, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x1F, 0x87, 0xE0, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x03, 0xF0, 0xFC, 0x00,
  0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xFC, 0x07, 0xE0,
  0x01, 0xFC, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFF, 0x81, 0xFC, 0x00, 0x3F,
  0xF3, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0x3F, 0xF8, 0x01, 0xFF, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0xFE, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00, 0xFC,
  0x7E, 0x00, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x0F,
  0xDF, 0x80, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0xFB, 0xF0, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00,
  0x3F, 0x3F, 0x80, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x3F, 0x87, 0xF8, 0x00,
  0x3F, 0xC1, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x1F, 0xC0, 0x07, 0xF8, 0x3F, 0x80, 0x01, 0xF8, 0x3F,
  0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x7E, 0x7E,
  0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0x7E,
  0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0xFF, 0x3F,
  0x80, 0x01, 0xFF, 0x3F, 0xC0, 0x03, 0xFF, 0x1F, 0xF0, 0x0F, 0xFF, 0x0F,
  0xFF, 0xFF, 0xBF, 0x07, 0xFF, 0xFF, 0x3F, 0x03, 0xFF, 0xFE, 0x3F, 0x00,
  0xFF, 0xF8, 0x3F, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x0E,
  0x07, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E,
  0x3C, 0x0F, 0xC3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0x7E,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF0,
  0x7E, 0x1F, 0xC3, 0xF0, 0x7E, 0x0F, 0xC1, 0xF0, 0x7E, 0x0F, 0x81, 0xF0,
  0x3E, 0x0F, 0x81, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0xFE, 0x01, 0xFF, 0x1E,
  0x00, 0x07, 0xF1, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x3E, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0x83, 0xE0, 0x01, 0xFF, 0xFF,
  0x80, 0x3E, 0x1F, 0x00, 0x1F, 0xFF, 0xFC, 0x01, 0xF1, 0xF0, 0x01, 0xFF,
  0xFF, 0xE0, 0x0F, 0x8F, 0x80, 0x1F, 0xE0, 0x1F, 0x00, 0x3E, 0xFC, 0x01,
  0xFC, 0x00, 0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x0F, 0xBE,
  0x00, 0xFC, 0x00, 0x3E, 0x00, 0x7D, 0xF0, 0x07, 0xC0, 0x01, 0xF0, 0x03,
  0xFF, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x1F, 0xF8, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0xFF, 0xC0, 0x1F, 0x00, 0x03, 0xE0, 0x07, 0xFE, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x3F, 0xF0, 0x07, 0xC0, 0x00, 0xF8, 0x01, 0xFF, 0x80, 0x3E,
  0x00, 0x07, 0xC0, 0x0F, 0xFC, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x7F, 0xE0,
  0x0F, 0x80, 0x03, 0xF0, 0x03, 0xFF, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x3E,
  0xF8, 0x03, 0xE0, 0x00, 0xFC, 0x01, 0xF7, 0xC0, 0x1F, 0x00, 0x0F, 0xE0,
  0x0F, 0xBE, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0xF9, 0xF0, 0x03, 0xF0, 0x07,
  0xF8, 0x0F, 0xC7, 0xC0, 0x1F, 0xC0, 0x7F, 0xE0, 0xFC, 0x3E, 0x00, 0x7F,
  0xFF, 0xCF, 0xFF, 0xC1, 0xF0, 0x01, 0xFF, 0xFC, 0x7F, 0xFE, 0x0F, 0x80,
  0x07, 0xFF, 0xC1, 0xFF, 0xC0, 0x3E, 0x00, 0x1F, 0xF8, 0x07, 0xFC, 0x01,
  0xF0, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0xC7, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xDF, 0x00, 0x00, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x7E, 0x00, 0x00, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE1, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x00, 0x7E,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x00, 0x03, 0xF3, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0x0F, 0xC0,
  0x00, 0x7F, 0xE3, 0xF0, 0x00, 0x07, 0xF8, 0xFC, 0x00, 0x00, 0xFE, 0x3F,
  0x00, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x01, 0xFC,
  0xFC, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x07,
  0xF3, 0xF0, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00,
  0x1F, 0x8F, 0xC0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x07, 0xF0, 0xFC, 0x00,
  0x0F, 0xF8, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F,
  0xC0, 0x01, 0xFF, 0xC3, 0xF0, 0x00, 0x07, 0xF8, 0xFC, 0x00, 0x00, 0xFF,
  0x3F, 0x00, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x00,
  0xFE, 0xFC, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xBF, 0x00,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x00, 0xFE, 0xFC,
  0x00, 0x00, 0x7F, 0xBF, 0x00, 0x00, 0x3F, 0xCF, 0xC0, 0x00, 0x1F, 0xF3,
  0xF0, 0x00, 0x7F, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xF8, 0x0F, 0xF8, 0x0F, 0xFC, 0x00, 0x07, 0x80, 0xFF,
  0x80, 0x00, 0x04, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x08, 0x07, 0xFF, 0x00,
  0x03, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xC0,
  0x00, 0xFF, 0xF0, 0x3F, 0x00, 0x00, 0x7F, 0xE0, 0xFC, 0x00, 0x00, 0x7F,
  0xC3, 0xF0, 0x00, 0x00, 0xFF, 0x8F, 0xC0, 0x00, 0x01, 0xFE, 0x3F, 0x00,
  0x00, 0x03, 0xFC, 0xFC, 0x00, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x00, 0x0F,
  0xEF, 0xC0, 0x00, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0x00, 0x7E, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00,
  0x07, 0xF3, 0xF0, 0x00, 0x00, 0x3F, 0xCF, 0xC0, 0x00, 0x01, 0xFE, 0x3F,
  0x00, 0x00, 0x0F, 0xF0, 0xFC, 0x00, 0x00, 0x7F, 0xC3, 0xF0, 0x00, 0x07,
  0xFE, 0x0F, 0xC0, 0x00, 0x7F, 0xF0, 0x3F, 0x00, 0x3F, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFB, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xCF, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x00, 0x3C, 0x03, 0xFE, 0x00, 0x00, 0x0C, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xE0, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x01, 0xFE,
  0xF7, 0xFF, 0x7F, 0xFF, 0x3F, 0xFF, 0x1F, 0xFF, 0x0F, 0xFE, 0x03, 0xF8,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x07, 0xF3, 0xF0, 0x00,
  0x01, 0xFC, 0x7E, 0x00, 0x00, 0x7F, 0x8F, 0xC0, 0x00, 0x0F, 0xE1, 0xF8,
  0x00, 0x03, 0xF8, 0x3F, 0x00, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x3F, 0x80,
  0xFC, 0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x03, 0xF8, 0x03, 0xF0, 0x00, 0xFE,
  0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x01, 0xF8, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x1F, 0xC0, 0x00, 0xFC,
  0x07, 0xF0, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x00,
  0x7E, 0x1F, 0xC0, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x01, 0xF9, 0xFC, 0x00,
  0x00, 0x3F, 0x7F, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0x7F, 0x80, 0x00, 0x7F,
  0xC7, 0xF0, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x01, 0xF8, 0x0F, 0xF0, 0x00,
  0x3F, 0x00, 0xFF, 0x00, 0x07, 0xE0, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0xFE,
  0x00, 0x1F, 0x80, 0x1F, 0xE0, 0x03, 0xF0, 0x01, 0xFE, 0x00, 0x7E, 0x00,
  0x1F, 0xC0, 0x0F, 0xC0, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x3F,
  0x00, 0x03, 0xF8, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x03, 0xF8,
  0x1F, 0x80, 0x00, 0x7F, 0x83, 0xF0, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x00,
  0x7F, 0x0F, 0xC0, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x00, 0xFF, 0x3F, 0x00,
  0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0x80,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFB, 0xF0,
  0x00, 0x00, 0x0F, 0xBF, 0xFB, 0xF0, 0x00, 0x00, 0x0F, 0xBF, 0xF9, 0xF0,
  0x00, 0x00, 0x1F, 0xBF, 0xF9, 0xF8, 0x00, 0x00, 0x1F, 0x3F, 0xF9, 0xF8,
  0x00, 0x00, 0x3F, 0x3F, 0xF8, 0xFC, 0x00, 0x00, 0x3F, 0x3F, 0xF8, 0xFC,
  0x00, 0x00, 0x3E, 0x3F, 0xF8, 0xFC, 0x00, 0x00, 0x7E, 0x3F, 0xF8, 0x7E,
  0x00, 0x00, 0x7C, 0x3F, 0xF8, 0x7E, 0x00, 0x00, 0x7C, 0x3F, 0xF8, 0x3E,
  0x00, 0x00, 0xFC, 0x3F, 0xF8, 0x3F, 0x00, 0x00, 0xF8, 0x3F, 0xF8, 0x3F,
  0x00, 0x01, 0xF8, 0x3F, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x3F, 0xF8, 0x1F,
  0x80, 0x01, 0xF0, 0x3F, 0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x3F, 0xF8, 0x0F,
  0xC0, 0x03, 0xE0, 0x3F, 0xF8, 0x0F, 0xC0, 0x03, 0xE0, 0x3F, 0xF8, 0x07,
  0xC0, 0x07, 0xE0, 0x3F, 0xF8, 0x07, 0xE0, 0x07, 0xC0, 0x3F, 0xF8, 0x07,
  0xE0, 0x0F, 0xC0, 0x3F, 0xF8, 0x03, 0xF0, 0x0F, 0x80, 0x3F, 0xF8, 0x03,
  0xF0, 0x0F, 0x80, 0x3F, 0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x3F, 0xF8, 0x01,
  0xF8, 0x1F, 0x00, 0x3F, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0xF8, 0x00,
  0xF8, 0x3F, 0x00, 0x3F, 0xF8, 0x00, 0xFC, 0x3E, 0x00, 0x3F, 0xF8, 0x00,
  0xFC, 0x7E, 0x00, 0x3F, 0xF8, 0x00, 0x7E, 0x7C, 0x00, 0x3F, 0xF8, 0x00,
  0x7E, 0x7C, 0x00, 0x3F, 0xF8, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xBF, 0x80, 0x00, 0x0F, 0xFE, 0x7F, 0x00, 0x00,
  0x3F, 0xF9, 0xFC, 0x00, 0x00, 0xFF, 0xE3, 0xF8, 0x00, 0x03, 0xFF, 0x87,
  0xF0, 0x00, 0x0F, 0xFE, 0x1F, 0xC0, 0x00, 0x3F, 0xF8, 0x3F, 0x80, 0x00,
  0xFF, 0xE0, 0x7F, 0x00, 0x03, 0xFF, 0x81, 0xFC, 0x00, 0x0F, 0xFE, 0x03,
  0xF8, 0x00, 0x3F, 0xF8, 0x07, 0xF0, 0x00, 0xFF, 0xE0, 0x1F, 0xC0, 0x03,
  0xFF, 0x80, 0x3F, 0x80, 0x0F, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xF8, 0x01,
  0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xF8, 0x03, 0xFF, 0x80, 0x0F, 0xE0, 0x0F,
  0xFE, 0x00, 0x1F, 0xC0, 0x3F, 0xF8, 0x00, 0x3F, 0x80, 0xFF, 0xE0, 0x00,
  0xFE, 0x03, 0xFF, 0x80, 0x01, 0xFC, 0x0F, 0xFE, 0x00, 0x03, 0xF8, 0x3F,
  0xF8, 0x00, 0x0F, 0xE0, 0xFF, 0xE0, 0x00, 0x1F, 0xC3, 0xFF, 0x80, 0x00,
  0x3F, 0x87, 0xFE, 0x00, 0x00, 0xFE, 0x1F, 0xF8, 0x00, 0x01, 0xFC, 0x7F,
  0xE0, 0x00, 0x03, 0xF9, 0xFF, 0x80, 0x00, 0x0F, 0xE7, 0xFE, 0x00, 0x00,
  0x1F, 0xDF, 0xF8, 0x00, 0x00, 0x7F, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x7F, 0x00, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x1F, 0xC0,
  0x00, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xCF, 0xE0, 0x00,
  0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0x9F, 0x80, 0x00, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFD, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00,
  0x00, 0x03, 0xF3, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x00,
  0x01, 0xFC, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x07,
  0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0xFE, 0x3F, 0x00, 0x0F, 0xFC, 0x7E, 0x00, 0x03, 0xFC, 0xFC, 0x00,
  0x03, 0xF9, 0xF8, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x07, 0xF7, 0xE0, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01,
  0xFB, 0xF0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x1F,
  0xDF, 0x80, 0x00, 0x7F, 0x3F, 0x00, 0x01, 0xFE, 0x7E, 0x00, 0x0F, 0xF8,
  0xFC, 0x00, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x00,
  0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xCF, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x00, 0x03,
  0xF3, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x00, 0x00, 0xFD,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00,
  0x01, 0xFD, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x00, 0x00,
  0x7E, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x9F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC3,
  0xF8, 0x00, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xC0,
  0x01, 0xFF, 0x83, 0xF0, 0x00, 0x1F, 0xE0, 0xFC, 0x00, 0x03, 0xFC, 0x3F,
  0x00, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x03, 0xF0,
  0xFC, 0x00, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0x0F,
  0xE3, 0xF0, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x00, 0xFE, 0x3F, 0x00, 0x00,
  0x3F, 0x0F, 0xC0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x07, 0xF0, 0xFC, 0x00,
  0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0xFF, 0x03, 0xF0,
  0x03, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xFC,
  0x00, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x0F, 0xC0, 0x01,
  0xF8, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x00,
  0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0xFC,
  0x00, 0x03, 0xF8, 0x3F, 0x00, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x1F, 0xC3,
  0xF0, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x00, 0xFF, 0x3F, 0x00, 0x00, 0x1F,
  0xCF, 0xC0, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0x00,
  0xFF, 0x0F, 0xF0, 0x00, 0x1E, 0x1F, 0xC0, 0x00, 0x08, 0x3F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xFB, 0x80, 0x00, 0x0F,
  0xF7, 0xF0, 0x00, 0x7F, 0xCF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x00, 0x7E,
  0x7E, 0x00, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x07, 0xE7, 0xF0, 0x00,
  0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0xFF, 0x00, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x01, 0xFE, 0x03, 0xFE, 0x00,
  0x1F, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x00, 0x0F, 0xCF, 0xC0,
  0x00, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x1F, 0x80, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0x1F, 0xC0,
  0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x1F,
  0xC0, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00,
  0x00, 0x7E, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0xDF, 0x80, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0x03, 0xF7, 0xE0,
  0x00, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xF7, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xC7, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x7D,
  0xF0, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3F, 0x0F,
  0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x01, 0xFB, 0xF0,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0xFC, 0x0F, 0xE0,
  0x00, 0xFC, 0x7C, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x07, 0xE3, 0xF0, 0x00,
  0x7F, 0x01, 0xF8, 0x00, 0x3F, 0x1F, 0x80, 0x03, 0xF0, 0x0F, 0xC0, 0x01,
  0xF0, 0x7C, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFC,
  0x01, 0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0xE0, 0x0F, 0xC0, 0x07, 0xC0,
  0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x1F, 0x80, 0xFC,
  0x01, 0xFC, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xF0,
  0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0xFC, 0x03,
  0xF0, 0x00, 0x7E, 0x03, 0xE0, 0x03, 0xE0, 0x3F, 0x00, 0x03, 0xF0, 0x3F,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0xFC, 0x0F, 0xC0,
  0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0x7E, 0x00, 0x03, 0xF0, 0xFC, 0x00,
  0x1F, 0x87, 0xE0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x00,
  0xFC, 0x3F, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x1F,
  0x0F, 0xC0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0xFC,
  0xFC, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x1F, 0x3F,
  0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x00, 0xFD, 0xF0,
  0x00, 0x07, 0xEF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFC, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x81, 0xF8, 0x00,
  0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x00, 0x0F,
  0xE7, 0xE0, 0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x00, 0x07,
  0xE7, 0xE0, 0x00, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x00, 0x1F, 0xC3, 0xF0,
  0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00,
  0x7F, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x07, 0xE0,
  0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x07,
  0xF0, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x3F,
  0x00, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x07, 0xF7,
  0xF0, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x00, 0x7E, 0x03,
  0xF0, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0xFC,
  0x00, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x00, 0x7F, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0xFC, 0x00, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3D, 0xF0, 0x00, 0x00,
  0x3E, 0x7C, 0x00, 0x00, 0x1E, 0x3E, 0x00, 0x00, 0x1F, 0x0F, 0x80, 0x00,
  0x0F, 0x87, 0xC0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x07, 0xC0, 0xF8, 0x00,
  0x07, 0xC0, 0x3E, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x03, 0xE0, 0x07, 0xC0,
  0x01, 0xF0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0xFC, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x03,
  0xE0, 0x3E, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00,
  0x3F, 0x0F, 0x80, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x07, 0xE7, 0xC0, 0x00,
  0x01, 0xF7, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3E, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x1F, 0xFC, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xF0, 0x1F, 0x80, 0x3F, 0xC0, 0x30, 0x00, 0x3F, 0x80, 0x80, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xE0, 0x3F, 0x3F, 0xE0,
  0x00, 0xFD, 0xFE, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x0F, 0xDF, 0x80, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xF7,
  0xE0, 0x00, 0xFF, 0xDF, 0xC0, 0x07, 0xFF, 0x7F, 0xC0, 0xFE, 0xFC, 0xFF,
  0xFF, 0xF3, 0xF1, 0xFF, 0xFF, 0x87, 0xC3, 0xFF, 0xFC, 0x1F, 0x03, 0xFF,
  0xC0, 0x7C, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x07, 0xF8, 0x00, 0xFC, 0x3F,
  0xFF, 0x00, 0xFC, 0x7F, 0xFF, 0xC0, 0xFD, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xF0, 0x0F, 0xF8, 0xFF, 0xC0, 0x03, 0xF8, 0xFF, 0x80,
  0x01, 0xFC, 0xFF, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00,
  0x00, 0x7E, 0xFE, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x7E, 0xFE, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0xFE, 0xFF, 0x00,
  0x00, 0xFE, 0xFF, 0x00, 0x01, 0xFC, 0xFF, 0x80, 0x03, 0xFC, 0xFF, 0xC0,
  0x07, 0xF8, 0xFB, 0xFC, 0x3F, 0xF0, 0xF9, 0xFF, 0xFF, 0xF0, 0xF8, 0xFF,
  0xFF, 0xC0, 0xF0, 0x7F, 0xFF, 0x80, 0xF0, 0x1F, 0xFE, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x83, 0xFE, 0x03, 0xE1, 0xFE, 0x00,
  0x08, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x04, 0x7F, 0xC0, 0x07, 0x0F, 0xFF,
  0x7F, 0xC1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0xE0, 0x3F, 0x00, 0xFF,
  0xFC, 0x3F, 0x03, 0xFF, 0xFE, 0x3F, 0x07, 0xFF, 0xFF, 0xBF, 0x0F, 0xFF,
  0xFF, 0xBF, 0x1F, 0xF0, 0x0F, 0xFF, 0x1F, 0xC0, 0x03, 0xFF, 0x3F, 0x80,
  0x01, 0xFF, 0x7F, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0xFF, 0x7E, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x7F, 0x7F, 0x00,
  0x00, 0xFF, 0x3F, 0x80, 0x00, 0xFF, 0x3F, 0x80, 0x01, 0xFF, 0x1F, 0xE0,
  0x03, 0xFF, 0x1F, 0xF8, 0x3F, 0xFF, 0x0F, 0xFF, 0xFF, 0x9F, 0x07, 0xFF,
  0xFF, 0x1F, 0x01, 0xFF, 0xFE, 0x1F, 0x00, 0x7F, 0xF8, 0x1F, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFE, 0x01,
  0xFE, 0x07, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x00, 0x01,
  0xF8, 0xFE, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x02, 0x0F, 0xF8, 0x00, 0x3C, 0x0F, 0xFF, 0x9F, 0xF8, 0x0F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFF,
  0xC0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x07, 0xF0,
  0x18, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x1F, 0x03, 0xFF, 0xFE,
  0x1F, 0x07, 0xFF, 0xFF, 0x1F, 0x0F, 0xFF, 0xFF, 0x9F, 0x1F, 0xF0, 0x0F,
  0xFF, 0x1F, 0xC0, 0x03, 0xFF, 0x3F, 0x80, 0x01, 0xFF, 0x3F, 0x00, 0x00,
  0xFF, 0x7F, 0x00, 0x00, 0xFF, 0x7E, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00,
  0x7F, 0x7E, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00,
  0xFF, 0x3F, 0x80, 0x01, 0xFF, 0x1F, 0xE0, 0x03, 0xFF, 0x0F, 0xF8, 0x1F,
  0xFF, 0x0F, 0xFF, 0xFF, 0xBF, 0x07, 0xFF, 0xFF, 0x3F, 0x01, 0xFF, 0xFE,
  0x3F, 0x00, 0x7F, 0xF8, 0x3F, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFE, 0x20, 0x00, 0x00, 0xFE, 0x18, 0x00, 0x03, 0xFC, 0x1F, 0x00, 0x07,
  0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x03, 0xFE, 0x00, 0xFC,
  0x3F, 0xFF, 0x81, 0xF8, 0xFF, 0xFF, 0x83, 0xF7, 0xFF, 0xFF, 0xC7, 0xEF,
  0xFF, 0xFF, 0x8F, 0xBF, 0x00, 0xFF, 0x9F, 0xF8, 0x00, 0x7F, 0x3F, 0xE0,
  0x00, 0x7F, 0x7F, 0x80, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0xFD, 0xFC, 0x00,
  0x01, 0xFB, 0xF8, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x03, 0xEF, 0xC0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xF0, 0x3C, 0xFF, 0xFF, 0xFF, 0xEF,
  0xDF, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xBF, 0x7E, 0xFD, 0xFB,
  0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E,
  0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF,
  0xBF, 0x7E, 0xFC, 0x00, 0x1E, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x7F, 0x00, 0x7E, 0x00, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF,
  0xF0, 0xFF, 0xC0, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x02, 0xFC, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x3F, 0x8F, 0xC0,
  0x01, 0xFC, 0x3F, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x7F, 0x03, 0xF0, 0x03,
  0xF8, 0x0F, 0xC0, 0x1F, 0xC0, 0x3F, 0x00, 0xFE, 0x00, 0xFC, 0x07, 0xF0,
  0x03, 0xF0, 0x3F, 0x80, 0x0F, 0xC1, 0xFC, 0x00, 0x3F, 0x0F, 0xE0, 0x00,
  0xFC, 0x7F, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x3F,
  0x7F, 0x00, 0x00, 0xFB, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x3F, 0xEF, 0xE0, 0x00, 0xFF, 0x1F, 0xC0, 0x03, 0xF8, 0x3F,
  0x80, 0x0F, 0xC0, 0xFF, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0xFC, 0x03, 0xF8,
  0x03, 0xF0, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0xE0, 0x3F, 0x00, 0x3F, 0x80,
  0xFC, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0xFE, 0x0F, 0xC0, 0x03, 0xFC, 0x3F,
  0x00, 0x07, 0xF0, 0xFC, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x1F, 0xCF, 0xC0,
  0x00, 0x7F, 0xBF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF8, 0x0F, 0x83, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0xF8, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x0F, 0x9F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xF9,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xCF, 0xBF, 0x01, 0xFF, 0xFE, 0x03, 0xFE,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xEF, 0xF8, 0x00, 0x7F, 0xF0, 0x00,
  0x7E, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xFC, 0x01, 0xF0, 0x7F, 0xFF, 0x03, 0xE1, 0xFF, 0xFF, 0x87, 0xCF, 0xFF,
  0xFF, 0x8F, 0x9F, 0xFF, 0xFF, 0x1F, 0x7E, 0x01, 0xFF, 0x3F, 0xF0, 0x00,
  0xFE, 0x7F, 0xC0, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x01,
  0xFB, 0xF8, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F,
  0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x7E, 0x3F,
  0x80, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x1F, 0xDF, 0x80, 0x00,
  0x0F, 0xCF, 0xE0, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x07, 0xF1, 0xFC, 0x00,
  0x07, 0xF0, 0x7F, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x07, 0xF8, 0x0F, 0xFE,
  0x3F, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0xF8, 0x3F, 0xFF, 0x00, 0xF8, 0x7F, 0xFF, 0xC0, 0xF9,
  0xFF, 0xFF, 0xE0, 0xF9, 0xFF, 0xFF, 0xF0, 0xFB, 0xF0, 0x0F, 0xF8, 0xFF,
  0xC0, 0x07, 0xF8, 0xFF, 0x80, 0x01, 0xFC, 0xFF, 0x00, 0x01, 0xFC, 0xFE,
  0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x7E, 0xFC,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x7E, 0xFE,
  0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0xFC, 0xFF, 0x00, 0x01, 0xFC, 0xFF,
  0x80, 0x03, 0xFC, 0xFF, 0xE0, 0x07, 0xF8, 0xFB, 0xFC, 0x3F, 0xF0, 0xF9,
  0xFF, 0xFF, 0xE0, 0xFC, 0xFF, 0xFF, 0xC0, 0xFC, 0x7F, 0xFF, 0x80, 0xFC,
  0x1F, 0xFE, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0xFC, 0x1F, 0x03, 0xFF, 0xFE, 0x1F, 0x07, 0xFF, 0xFF, 0x1F, 0x0F,
  0xFF, 0xFF, 0x9F, 0x1F, 0xF0, 0x0F, 0xFF, 0x1F, 0xC0, 0x03, 0xFF, 0x3F,
  0x80, 0x01, 0xFF, 0x3F, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0xFF, 0x7E,
  0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x7F, 0x7F,
  0x00, 0x00, 0xFF, 0x3F, 0x80, 0x00, 0xFF, 0x3F, 0xC0, 0x01, 0xFF, 0x1F,
  0xE0, 0x07, 0xFF, 0x1F, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0xFF, 0xBF, 0x07,
  0xFF, 0xFF, 0x3F, 0x01, 0xFF, 0xFE, 0x3F, 0x00, 0x7F, 0xF8, 0x3F, 0x00,
  0x0F, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF1,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0x0B, 0xEF, 0xC0, 0x1F, 0xF8, 0x00,
  0xFF, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0xFF, 0x00,
  0x3E, 0x1F, 0x80, 0x00, 0xC3, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x90, 0x00,
  0x03, 0xF3, 0x80, 0x00, 0xFE, 0x7F, 0x00, 0xFF, 0x8F, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFE, 0x00, 0x03, 0xFE, 0x0C, 0x07, 0xFF, 0xF0, 0x0F, 0xFF,
  0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x01, 0xFD, 0xF8, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x0F, 0xF7, 0xF0, 0x00,
  0x1F, 0xEF, 0xE0, 0x00, 0x7F, 0xCF, 0xF0, 0x03, 0xFF, 0x9F, 0xF8, 0x3F,
  0xDF, 0x1F, 0xFF, 0xFF, 0x3E, 0x1F, 0xFF, 0xFC, 0x7C, 0x1F, 0xFF, 0xF0,
  0xF8, 0x0F, 0xFF, 0x81, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xEF, 0xC0, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x00, 0x7E, 0x3F, 0x80,
  0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x7E,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x03, 0xF8, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x7E, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x1F, 0x83,
  0xF0, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x07,
  0xE3, 0xF0, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0x00, 0x0F, 0x9F, 0x80, 0x00,
  0x01, 0xFB, 0xF0, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7E, 0x7E, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7F, 0xE0,
  0x00, 0xFC, 0x7E, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFB,
  0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xBE, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0xFB, 0xF0, 0x01, 0xF8, 0x3F, 0x80, 0x1F, 0x9F, 0x00, 0x1F, 0x81, 0xF8,
  0x01, 0xF1, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0x1F, 0x80, 0x3F, 0x01,
  0xF8, 0x03, 0xF1, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x0F, 0x80, 0x3F,
  0x00, 0xFC, 0x03, 0xE0, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0,
  0x7E, 0x00, 0xFC, 0x07, 0xE0, 0x7C, 0x07, 0xE0, 0x07, 0xE0, 0x7C, 0x07,
  0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xC0, 0x7E, 0x07, 0xC0, 0x07, 0xE0, 0xFC,
  0x03, 0xE0, 0xFC, 0x00, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0xC0, 0x03, 0xF0,
  0xF8, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x3F, 0x0F, 0x80, 0x03,
  0xF1, 0xF8, 0x01, 0xF1, 0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x9F, 0x80,
  0x01, 0xF9, 0xF0, 0x01, 0xF9, 0xF0, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0x9F,
  0x00, 0x01, 0xFB, 0xE0, 0x00, 0xFB, 0xF0, 0x00, 0x0F, 0xBE, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x0F,
  0xE0, 0x3F, 0x00, 0x03, 0xF0, 0x0F, 0xE0, 0x01, 0xFC, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x01, 0xFC,
  0x0F, 0xE0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x01,
  0xFC, 0xFE, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xF3,
  0xF0, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x03,
  0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x7F, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x1F,
  0xC7, 0xF0, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x0F, 0xEF, 0xC0, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0x7F, 0x1F, 0x80,
  0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x7E,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x03, 0xF8, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x01, 0xF8, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x00, 0x7E, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x1F, 0x83,
  0xF0, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x07,
  0xE3, 0xF0, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00,
  0x00, 0xFB, 0xF0, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0C, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xC0, 0x07,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x80, 0x1F, 0xFC, 0x00, 0xFF,
  0xC0, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0,
  0x03, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0x38, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0x3F,
  0xFF, 0x80, 0x03, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x80,
  0x00, 0x3F, 0xF8,
};

const GFXglyph NotoSans_Regular68pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 8, 50, 18, 5, -49 },
  { 51, 19, 18, 28, 4, -49 },
  { 94, 40, 49, 44, 2, -49 },
  { 339, 31, 56, 39, 4, -52 },
  { 556, 50, 50, 57, 3, -49 },
  { 869, 46, 50, 50, 4, -49 },
  { 1157, 7, 18, 15, 4, -49 },
  { 1173, 15, 60, 20, 3, -49 },
  { 1286, 16, 60, 20, 2, -49 },
  { 1406, 32, 31, 37, 3, -52 },
  { 1530, 32, 32, 39, 3, -40 },
  { 1658, 10, 17, 18, 3, -8 },
  { 1680, 16, 5, 22, 3, -21 },
  { 1690, 8, 9, 18, 5, -8 },
  { 1699, 24, 49, 25, 1, -49 },
  { 1846, 33, 50, 39, 3, -49 },
  { 2053, 18, 49, 39, 6, -49 },
  { 2164, 32, 49, 39, 3, -49 },
  { 2360, 32, 50, 39, 3, -49 },
  { 2560, 37, 49, 39, 1, -49 },
  { 2787, 31, 50, 39, 4, -49 },
  { 2981, 32, 50, 39, 4, -49 },
  { 3181, 33, 49, 39, 3, -49 },
  { 3384, 33, 50, 39, 3, -49 },
  { 3591, 32, 50, 39, 3, -49 },
  { 3791, 8, 38, 18, 5, -37 },
  { 3829, 11, 46, 18, 2, -37 },
  { 3893, 32, 33, 39, 3, -41 },
  { 4025, 31, 18, 39, 4, -33 },
  { 4095, 32, 33, 39, 3, -41 },
  { 4227, 27, 50, 30, 1, -49 },
  { 4396, 53, 55, 61, 4, -49 },
  { 4761, 43, 49, 43, 0, -49 },
  { 5025, 34, 49, 44, 7, -49 },
  { 5234, 37, 50, 43, 4, -49 },
  { 5466, 38, 49, 50, 7, -49 },
  { 5699, 27, 49, 38, 7, -49 },
  { 5865, 27, 49, 35, 7, -49 },
  { 6031, 40, 50, 50, 4, -49 },
  { 6281, 37, 49, 50, 7, -49 },
  { 6508, 17, 49, 23, 3, -49 },
  { 6613, 17, 62, 19, -5, -49 },
  { 6745, 35, 49, 42, 7, -49 },
  { 6960, 27, 49, 36, 7, -49 },
  { 7126, 48, 49, 62, 7, -49 },
  { 7420, 38, 49, 52, 7, -49 },
  { 7653, 45, 50, 53, 4, -49 },
  { 7935, 31, 49, 41, 7, -49 },
  { 8125, 45, 61, 53, 4, -49 },
  { 8469, 34, 49, 42, 7, -49 },
  { 8678, 31, 50, 37, 3, -49 },
  { 8872, 36, 49, 38, 1, -49 },
  { 9093, 38, 50, 50, 6, -49 },
  { 9331, 41, 49, 41, 0, -49 },
  { 9583, 61, 49, 63, 1, -49 },
  { 9957, 40, 49, 40, 0, -49 },
  { 10202, 38, 49, 38, 0, -49 },
  { 10435, 33, 49, 39, 3, -49 },
  { 10638, 16, 60, 22, 5, -49 },
  { 10758, 24, 49, 25, 1, -49 },
  { 10905, 15, 60, 22, 2, -49 },
  { 11018, 33, 31, 39, 3, -49 },
  { 11146, 30, 4, 30, 0, 6 },
  { 11161, 13, 11, 19, 3, -52 },
  { 11179, 30, 38, 38, 3, -37 },
  { 11322, 32, 53, 42, 6, -52 },
  { 11534, 26, 38, 33, 4, -37 },
  { 11658, 32, 53, 42, 4, -52 },
  { 11870, 31, 38, 38, 4, -37 },
  { 12018, 25, 52, 23, 1, -52 },
  { 12181, 32, 53, 42, 4, -37 },
  { 12393, 31, 52, 42, 6, -52 },
  { 12595, 7, 50, 18, 5, -50 },
  { 12639, 16, 66, 18, -4, -50 },
  { 12771, 30, 52, 36, 6, -52 },
  { 12966, 6, 52, 18, 6, -52 },
  { 13005, 52, 37, 64, 6, -37 },
  { 13246, 31, 37, 42, 6, -37 },
  { 13390, 33, 38, 41, 4, -37 },
  { 13547, 32, 53, 42, 6, -37 },
  { 13759, 32, 53, 42, 4, -37 },
  { 13971, 21, 37, 28, 6, -37 },
  { 14069, 27, 38, 33, 3, -37 },
  { 14198, 22, 46, 25, 1, -45 },
  { 14325, 31, 37, 42, 5, -36 },
  { 14469, 35, 36, 35, 0, -36 },
  { 14627, 52, 37, 53, 1, -37 },
  { 14868, 34, 36, 36, 1, -36 },
  { 15021, 35, 52, 35, 0, -36 },
  { 15249, 26, 36, 32, 3, -36 },
  { 15366, 22, 60, 26, 2, -49 },
  { 15531, 5, 68, 37, 16, -52 },
  { 15574, 22, 60, 26, 2, -49 },
  { 15739, 32, 8, 39, 3, -28 },
};

const GFXfont NotoSans_Regular68pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Regular68pt7bBitmaps,
  (GFXglyph *)NotoSans_Regular68pt7bGlyphs,
  0x20, 0x7E, 93
};

#endif // _NOTOSANS_REGULAR68PT7B_H_
