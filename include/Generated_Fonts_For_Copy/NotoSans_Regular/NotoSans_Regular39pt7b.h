#ifndef _NOTOSANS_REGULAR39PT7B_H_
#define _NOTOSANS_REGULAR39PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Regular.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Regular39pt7bBitmaps[] PROGMEM = {
  0x00, 0xF7, 0xBD, 0xEF, 0x7B, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x98, 0xC0, 0x00, 0x0C, 0xF7, 0xFF, 0xE2, 0x00, 0xE1, 0xF8, 0x7E, 0x1F,
  0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x70, 0x00, 0x60, 0x70,
  0x01, 0xC0, 0xE0, 0x03, 0x81, 0x80, 0x07, 0x07, 0x00, 0x0E, 0x0E, 0x00,
  0x18, 0x1C, 0x00, 0x70, 0x38, 0x00, 0xE0, 0x60, 0x7F, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xF8, 0x0C, 0x0E, 0x00, 0x38, 0x18, 0x00, 0x70,
  0x70, 0x00, 0xE0, 0xE0, 0x01, 0xC1, 0xC0, 0x03, 0x03, 0x81, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xE0, 0x70, 0x70, 0x00, 0xC0, 0xE0,
  0x03, 0x81, 0x80, 0x07, 0x03, 0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x1C, 0x00,
  0x30, 0x38, 0x00, 0xE0, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x07, 0xFE, 0x07, 0xFF, 0xE3, 0xFF, 0xF9, 0xE3, 0x0C,
  0x70, 0xC0, 0x3C, 0x30, 0x0F, 0x0C, 0x01, 0xC3, 0x00, 0x78, 0xC0, 0x1F,
  0xB0, 0x03, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x0C,
  0xF8, 0x03, 0x0F, 0x00, 0xC1, 0xC0, 0x30, 0x70, 0x0C, 0x1E, 0x03, 0x0F,
  0xF0, 0xCF, 0xBF, 0xFF, 0xCF, 0xFF, 0xE0, 0xFF, 0xE0, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x1F, 0x00, 0x0E, 0x01, 0xFE, 0x00,
  0x70, 0x1E, 0x70, 0x07, 0x00, 0xE1, 0xC0, 0x38, 0x0E, 0x0E, 0x03, 0x80,
  0x70, 0x70, 0x38, 0x03, 0x81, 0x81, 0xC0, 0x1C, 0x0C, 0x1C, 0x00, 0xE0,
  0x60, 0xE0, 0x07, 0x03, 0x0E, 0x00, 0x38, 0x38, 0x70, 0x01, 0xC1, 0xC7,
  0x1F, 0x0E, 0x0E, 0x39, 0xFC, 0x38, 0x73, 0x9E, 0xF1, 0xE7, 0x38, 0xE1,
  0xC7, 0xF9, 0xCE, 0x0E, 0x1F, 0x1C, 0x70, 0x70, 0x00, 0xE3, 0x81, 0x80,
  0x0E, 0x1C, 0x0C, 0x00, 0x70, 0xE0, 0x70, 0x07, 0x07, 0x03, 0x00, 0x38,
  0x38, 0x18, 0x03, 0x81, 0xC1, 0xC0, 0x38, 0x0E, 0x0E, 0x01, 0xC0, 0x38,
  0x70, 0x1C, 0x01, 0xC7, 0x00, 0xE0, 0x07, 0xF8, 0x0E, 0x00, 0x1F, 0x80,
  0x03, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x78, 0x3C,
  0x00, 0x1C, 0x07, 0x80, 0x07, 0x01, 0xE0, 0x01, 0xC0, 0x78, 0x00, 0x70,
  0x1C, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC7, 0x80, 0x00, 0xF3, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x78, 0xF9, 0xF0, 0x1C, 0x7C, 0x3E, 0x07, 0x1E, 0x07, 0xC3, 0xCF, 0x00,
  0xF8, 0xE3, 0xC0, 0x1F, 0x78, 0xF0, 0x03, 0xFC, 0x3C, 0x00, 0x7F, 0x0F,
  0x00, 0x0F, 0x83, 0xE0, 0x07, 0xF0, 0x7C, 0x07, 0xFE, 0x0F, 0xFF, 0xE7,
  0xC1, 0xFF, 0xF0, 0xF8, 0x3F, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x07,
  0x87, 0x83, 0x83, 0x83, 0xC1, 0xC1, 0xE0, 0xF0, 0x70, 0x38, 0x3C, 0x1E,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0xC1, 0xE0, 0xF0, 0x38, 0x1E, 0x0F, 0x03, 0x81, 0xE0, 0x70, 0x3C, 0x0E,
  0x03, 0x80, 0xF0, 0x38, 0x0E, 0x07, 0x81, 0xC0, 0xF0, 0x38, 0x1E, 0x0F,
  0x03, 0x81, 0xC0, 0xF0, 0x78, 0x3C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x07, 0x83, 0xC1, 0xC1, 0xE0, 0xF0,
  0xF0, 0x70, 0x78, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x0E, 0x1C, 0x1B, 0xF3, 0x7F, 0xFF,
  0xFF, 0xDF, 0xFF, 0xC0, 0x3E, 0x00, 0x0D, 0xC0, 0x07, 0x78, 0x03, 0xCE,
  0x01, 0xE3, 0xC0, 0xF8, 0x78, 0x1C, 0x1E, 0x01, 0x02, 0x00, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x3B, 0xDE, 0xF7, 0x3B, 0xDC, 0xE6, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x67, 0xBF, 0xFF, 0x10, 0x00, 0x1C, 0x00, 0xF0,
  0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0,
  0x07, 0x80, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0,
  0x07, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0,
  0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0x07, 0xF8, 0x03,
  0xFF, 0x01, 0xFF, 0xE0, 0xF0, 0x3C, 0x78, 0x07, 0x9E, 0x00, 0xE7, 0x00,
  0x39, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0x70, 0x03, 0xDC, 0x00, 0xF7, 0x80,
  0x38, 0xE0, 0x1E, 0x3C, 0x0F, 0x07, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xE0,
  0x00, 0xE0, 0x7C, 0x1F, 0x87, 0xF3, 0xEE, 0xF9, 0xFC, 0x79, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x07, 0xF8, 0x0F, 0xFF, 0x87, 0xFF, 0xF3, 0xE0, 0x3C,
  0x60, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xF8, 0x0F, 0xFF, 0x8F, 0xFF,
  0xF1, 0xC0, 0x3C, 0x40, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x0F, 0xFC, 0x03,
  0xFC, 0x00, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E,
  0xC0, 0x0F, 0xBF, 0xFF, 0xCF, 0xFF, 0xE1, 0xFF, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3B,
  0x80, 0x03, 0xDC, 0x00, 0x1C, 0xE0, 0x01, 0xC7, 0x00, 0x1E, 0x38, 0x00,
  0xE1, 0xC0, 0x0E, 0x0E, 0x00, 0xE0, 0x70, 0x0F, 0x03, 0x80, 0x70, 0x1C,
  0x07, 0x00, 0xE0, 0x78, 0x07, 0x03, 0x80, 0x38, 0x38, 0x01, 0xC1, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x3F,
  0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xFF, 0xE0, 0x7F, 0xFE, 0x1F, 0xFF, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x1E, 0xC0, 0x0F, 0xBF, 0xFF, 0xCF, 0xFF, 0xE0,
  0xFF, 0xE0, 0x00, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x03, 0xCF, 0xF8, 0xF7, 0xFF, 0x3F, 0xC7, 0xEF, 0xC0, 0x7B,
  0xE0, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0x70,
  0x01, 0xDC, 0x00, 0x77, 0x80, 0x3C, 0xE0, 0x0F, 0x3C, 0x07, 0x87, 0xFF,
  0xC0, 0xFF, 0xE0, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00,
  0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00,
  0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x07, 0xF8, 0x07, 0xFF,
  0x83, 0xFF, 0xF1, 0xF0, 0x1E, 0x78, 0x03, 0x9C, 0x00, 0xE7, 0x00, 0x39,
  0xC0, 0x0E, 0x78, 0x03, 0x9E, 0x01, 0xE3, 0xE0, 0xF0, 0x7C, 0xF8, 0x0F,
  0xFC, 0x00, 0xFE, 0x00, 0xFF, 0xC0, 0xF8, 0xFC, 0x7C, 0x0F, 0x9E, 0x01,
  0xFF, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x0F, 0x78, 0x07, 0x9F, 0xCF, 0xE3, 0xFF, 0xF0, 0x3F, 0xF0, 0x07,
  0xF8, 0x07, 0xFF, 0x03, 0xFF, 0xE1, 0xF0, 0x3C, 0x78, 0x07, 0xBC, 0x00,
  0xEF, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0xC0, 0x0F, 0xF0, 0x03, 0xDE, 0x01, 0xF7, 0xC1, 0xDC, 0xFF, 0xF7, 0x0F,
  0xF1, 0xC0, 0xF0, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01,
  0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x3E, 0x0C, 0xFF, 0x03, 0xFF, 0x80,
  0xFF, 0x80, 0xF7, 0xFF, 0xE6, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x67, 0xBF, 0xFF, 0x10, 0x3C, 0x7C, 0xF9, 0xE1, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x78, 0xF1, 0xC7, 0x8F, 0x1C,
  0x38, 0x61, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x3C, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x0F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF0, 0x00, 0x0C, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80,
  0x00, 0x30, 0x00, 0x0F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3C,
  0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0x3C, 0x00, 0x0C, 0x00, 0x00, 0x1F, 0xF0, 0xFF, 0xFC, 0x7F, 0xFE,
  0x70, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F,
  0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x03, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x78, 0x00, 0x1E, 0x01,
  0xE0, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x1C, 0x38,
  0x07, 0xFC, 0x1C, 0x70, 0x3F, 0xF8, 0x39, 0xC0, 0xF0, 0x70, 0x33, 0x83,
  0xC0, 0xE0, 0x77, 0x07, 0x01, 0xC0, 0xEC, 0x1E, 0x03, 0x81, 0xF8, 0x38,
  0x07, 0x03, 0xF0, 0x70, 0x0E, 0x07, 0xE0, 0xE0, 0x1C, 0x0F, 0xC1, 0xC0,
  0x38, 0x1B, 0x83, 0x80, 0xF0, 0x77, 0x07, 0x81, 0xE0, 0xE6, 0x07, 0x07,
  0xC3, 0x8E, 0x0F, 0xFD, 0xFF, 0x1C, 0x0F, 0xF1, 0xFC, 0x38, 0x03, 0x81,
  0xE0, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x10, 0x00, 0x7E, 0x01, 0xE0, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x70, 0x00, 0x03, 0xB8, 0x00,
  0x03, 0xDE, 0x00, 0x01, 0xC7, 0x00, 0x00, 0xE3, 0x80, 0x00, 0xF1, 0xE0,
  0x00, 0x70, 0x70, 0x00, 0x78, 0x38, 0x00, 0x38, 0x1E, 0x00, 0x1C, 0x07,
  0x00, 0x1E, 0x03, 0xC0, 0x0E, 0x00, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xC0, 0x07, 0x81, 0xC0, 0x03, 0xC0, 0xE0,
  0x00, 0xE0, 0xF0, 0x00, 0x78, 0x70, 0x00, 0x1C, 0x78, 0x00, 0x0F, 0x3C,
  0x00, 0x07, 0x9C, 0x00, 0x01, 0xDE, 0x00, 0x00, 0xF0, 0xFF, 0xF0, 0x1F,
  0xFF, 0xC3, 0xFF, 0xFE, 0x70, 0x0F, 0xCE, 0x00, 0x3D, 0xC0, 0x07, 0xB8,
  0x00, 0x77, 0x00, 0x0E, 0xE0, 0x01, 0xDC, 0x00, 0x7B, 0x80, 0x0E, 0x70,
  0x07, 0xCF, 0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0xFF, 0xC7, 0x00, 0x3E, 0xE0,
  0x03, 0xDC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x0F, 0xDF, 0xFF, 0xF3, 0xFF,
  0xFC, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0xC1, 0xFF, 0xFE,
  0x1F, 0x80, 0x61, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x10, 0x3F, 0xFF,
  0x80, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF8, 0x38, 0x07, 0xF0, 0xE0, 0x03, 0xE3, 0x80, 0x07, 0xCE, 0x00,
  0x0F, 0xB8, 0x00, 0x1E, 0xE0, 0x00, 0x7B, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x1E, 0xE0, 0x00, 0x7B, 0x80, 0x03, 0xCE, 0x00, 0x1F, 0x38, 0x00, 0xF8,
  0xE0, 0x1F, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x0F, 0xE0, 0x1C, 0x1F, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x0F,
  0x70, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F,
  0x3C, 0x00, 0x0F, 0x3E, 0x00, 0x0F, 0x1F, 0x00, 0x0F, 0x0F, 0xC0, 0x0F,
  0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x70, 0xFF,
  0xFF, 0xF7, 0xF0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x0F, 0xCF, 0xFF, 0xFF, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0xF0,
  0x3C, 0x1E, 0xFF, 0xBF, 0xCF, 0xE0, 0xE0, 0x01, 0xFE, 0x00, 0x3E, 0xE0,
  0x07, 0xCE, 0x00, 0x78, 0xE0, 0x0F, 0x0E, 0x01, 0xE0, 0xE0, 0x3C, 0x0E,
  0x07, 0x80, 0xE0, 0xF0, 0x0E, 0x1E, 0x00, 0xE3, 0xC0, 0x0E, 0x78, 0x00,
  0xE7, 0x80, 0x0E, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0x9E, 0x00, 0xF1, 0xF0,
  0x0E, 0x0F, 0x00, 0xE0, 0x78, 0x0E, 0x03, 0xC0, 0xE0, 0x3E, 0x0E, 0x01,
  0xE0, 0xE0, 0x0F, 0x0E, 0x00, 0x78, 0xE0, 0x07, 0xCE, 0x00, 0x3C, 0xE0,
  0x01, 0xEE, 0x00, 0x0F, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xFE, 0xE0, 0x00, 0xFF, 0xEE, 0x00, 0x0E, 0xFE, 0xF0, 0x00,
  0xEF, 0xE7, 0x00, 0x1C, 0xFE, 0x70, 0x01, 0xCF, 0xE7, 0x80, 0x3C, 0xFE,
  0x38, 0x03, 0x8F, 0xE3, 0xC0, 0x38, 0xFE, 0x1C, 0x07, 0x0F, 0xE1, 0xC0,
  0x70, 0xFE, 0x1E, 0x07, 0x0F, 0xE0, 0xE0, 0xE0, 0xFE, 0x0E, 0x0E, 0x0F,
  0xE0, 0xF1, 0xE0, 0xFE, 0x07, 0x1C, 0x0F, 0xE0, 0x79, 0xC0, 0xFE, 0x03,
  0xB8, 0x0F, 0xE0, 0x3B, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0x00,
  0xFE, 0x01, 0xF0, 0x0F, 0xE0, 0x1F, 0x00, 0xFE, 0x00, 0xE0, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x7E, 0xF0, 0x01, 0xF9, 0xE0, 0x07, 0xE7, 0x80, 0x1F,
  0x8F, 0x00, 0x7E, 0x3E, 0x01, 0xF8, 0x78, 0x07, 0xE0, 0xF0, 0x1F, 0x83,
  0xC0, 0x7E, 0x07, 0x81, 0xF8, 0x0F, 0x07, 0xE0, 0x3C, 0x1F, 0x80, 0x78,
  0x7E, 0x00, 0xF1, 0xF8, 0x03, 0xC7, 0xE0, 0x07, 0x9F, 0x80, 0x0F, 0x7E,
  0x00, 0x3D, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xC0, 0x3E, 0x01, 0xF8, 0x1F, 0x00, 0x1E, 0x0F, 0x80, 0x03, 0xC3,
  0xC0, 0x00, 0x79, 0xE0, 0x00, 0x1E, 0x78, 0x00, 0x03, 0x9E, 0x00, 0x00,
  0xF7, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xDC,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0x3D, 0xE0, 0x00, 0x0E, 0x78, 0x00, 0x07,
  0x8F, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x7C, 0x0F, 0x80,
  0x7E, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0xFF,
  0xE0, 0x3F, 0xFF, 0x0F, 0xFF, 0xE3, 0x80, 0xFC, 0xE0, 0x0F, 0xB8, 0x01,
  0xEE, 0x00, 0x3B, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3B,
  0x80, 0x1E, 0xE0, 0x0F, 0xB8, 0x07, 0xCF, 0xFF, 0xE3, 0xFF, 0xF0, 0xFF,
  0xF0, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0,
  0x3E, 0x01, 0xF8, 0x1F, 0x00, 0x1E, 0x0F, 0x80, 0x03, 0xC3, 0xC0, 0x00,
  0x79, 0xE0, 0x00, 0x1E, 0x78, 0x00, 0x03, 0x9E, 0x00, 0x00, 0xF7, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xDC, 0x00, 0x00,
  0xF7, 0x80, 0x00, 0x3D, 0xE0, 0x00, 0x0E, 0x78, 0x00, 0x07, 0x8F, 0x00,
  0x01, 0xE3, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x7C, 0x0F, 0x80, 0x7E, 0x01,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0xFF, 0xE0, 0x0F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x0E, 0x03, 0xF0, 0xE0, 0x0F, 0x8E, 0x00, 0x78, 0xE0,
  0x03, 0x8E, 0x00, 0x3C, 0xE0, 0x03, 0xCE, 0x00, 0x3C, 0xE0, 0x03, 0x8E,
  0x00, 0x78, 0xE0, 0x0F, 0x0E, 0x0F, 0xF0, 0xFF, 0xFC, 0x0F, 0xFF, 0x00,
  0xFF, 0xF8, 0x0E, 0x07, 0x80, 0xE0, 0x3C, 0x0E, 0x01, 0xC0, 0xE0, 0x1E,
  0x0E, 0x00, 0xF0, 0xE0, 0x0F, 0x0E, 0x00, 0x78, 0xE0, 0x03, 0xCE, 0x00,
  0x3C, 0xE0, 0x01, 0xEE, 0x00, 0x1F, 0x07, 0xFE, 0x07, 0xFF, 0xE3, 0xFF,
  0xF9, 0xF0, 0x1C, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E,
  0xC0, 0x0F, 0xBF, 0xFF, 0xCF, 0xFF, 0xE1, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xCF,
  0x00, 0x1E, 0x7C, 0x03, 0xE1, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x0F, 0xFC,
  0x00, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3D, 0xC0, 0x00, 0x7B, 0xC0, 0x00,
  0xE3, 0x80, 0x03, 0xC7, 0x80, 0x07, 0x8F, 0x00, 0x1E, 0x0E, 0x00, 0x3C,
  0x1E, 0x00, 0x70, 0x3C, 0x01, 0xE0, 0x38, 0x03, 0xC0, 0x78, 0x07, 0x00,
  0xF0, 0x1E, 0x00, 0xE0, 0x3C, 0x01, 0xE0, 0x70, 0x03, 0xC1, 0xE0, 0x03,
  0x83, 0xC0, 0x07, 0x87, 0x00, 0x07, 0x1E, 0x00, 0x0E, 0x3C, 0x00, 0x1E,
  0x70, 0x00, 0x1D, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF7, 0x00, 0x0F, 0x00, 0x0E, 0x78, 0x01, 0xF8, 0x01, 0xE7,
  0x80, 0x1F, 0x80, 0x1E, 0x38, 0x01, 0xF8, 0x01, 0xE3, 0xC0, 0x1F, 0x80,
  0x1C, 0x3C, 0x03, 0xFC, 0x03, 0xC3, 0xC0, 0x39, 0xC0, 0x3C, 0x1C, 0x03,
  0x9C, 0x03, 0xC1, 0xE0, 0x79, 0xE0, 0x38, 0x1E, 0x07, 0x0E, 0x07, 0x81,
  0xE0, 0x70, 0xE0, 0x78, 0x0E, 0x07, 0x0F, 0x07, 0x00, 0xF0, 0xF0, 0xF0,
  0x70, 0x0F, 0x0E, 0x07, 0x0F, 0x00, 0x70, 0xE0, 0x70, 0xF0, 0x07, 0x1E,
  0x07, 0x8E, 0x00, 0x79, 0xC0, 0x38, 0xE0, 0x07, 0x9C, 0x03, 0x9E, 0x00,
  0x39, 0xC0, 0x3D, 0xE0, 0x03, 0xBC, 0x01, 0xDC, 0x00, 0x3B, 0x80, 0x1D,
  0xC0, 0x03, 0xF8, 0x01, 0xDC, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x78, 0x00, 0x3C, 0x70, 0x00, 0xF0, 0xF0, 0x01,
  0xE0, 0xF0, 0x07, 0x80, 0xE0, 0x0E, 0x01, 0xE0, 0x3C, 0x01, 0xE0, 0xF0,
  0x01, 0xC1, 0xC0, 0x03, 0xC7, 0x80, 0x03, 0x9E, 0x00, 0x07, 0xB8, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x7F, 0x00, 0x01, 0xEE, 0x00, 0x03, 0x9E, 0x00, 0x0F, 0x1E, 0x00, 0x1C,
  0x1C, 0x00, 0x78, 0x3C, 0x01, 0xE0, 0x3C, 0x03, 0x80, 0x78, 0x0F, 0x00,
  0x78, 0x3C, 0x00, 0x70, 0x70, 0x00, 0xF1, 0xE0, 0x00, 0xF7, 0x80, 0x01,
  0xF0, 0xF0, 0x00, 0x3D, 0xE0, 0x00, 0xE7, 0x80, 0x07, 0x8F, 0x00, 0x1C,
  0x3C, 0x00, 0xF0, 0x78, 0x07, 0x81, 0xE0, 0x1E, 0x03, 0xC0, 0xF0, 0x0F,
  0x03, 0xC0, 0x1E, 0x1E, 0x00, 0x38, 0x70, 0x00, 0xF3, 0xC0, 0x01, 0xCE,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F,
  0xFF, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x01, 0xC0, 0x07, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x38,
  0x00, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0xC0, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xB8, 0x00,
  0x39, 0xC0, 0x03, 0x1C, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0xE0, 0x70,
  0x0E, 0x07, 0x01, 0xC0, 0x38, 0x1C, 0x03, 0x83, 0x80, 0x1C, 0x38, 0x01,
  0xC7, 0x00, 0x0E, 0x70, 0x00, 0xEF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xF1, 0xE1, 0xE1, 0xE1, 0xC1, 0xC0, 0x07, 0xF8, 0x1F, 0xFF, 0x0F,
  0xFF, 0xC3, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x3F, 0x87, 0xFF, 0xCF, 0xFF, 0xEF, 0x80, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F, 0xDF, 0x3E, 0xEF,
  0xFE, 0x71, 0xFE, 0x38, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x7F, 0x83, 0xDF, 0xFC, 0x7F, 0xFF, 0xCF, 0xC0, 0x79, 0xF0,
  0x07, 0xBE, 0x00, 0xF7, 0x80, 0x0E, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x0E, 0xF8, 0x03, 0xDF, 0x00, 0x7B, 0xF0, 0x1E, 0x77, 0xDF, 0xCE, 0x7F,
  0xF1, 0xC7, 0xF8, 0x00, 0x03, 0xFE, 0x1F, 0xFC, 0x7F, 0xF9, 0xF0, 0x17,
  0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0x78, 0x04, 0x7F, 0xF8, 0x7F, 0xF0, 0x7F, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0xFF, 0x3C, 0x7F, 0xF7, 0x9F, 0xFF,
  0xF3, 0xC0, 0x7E, 0xF0, 0x07, 0xDE, 0x00, 0xFB, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0x78, 0x01, 0xEF, 0x00, 0x7C, 0xF0, 0x1F,
  0x9F, 0xDF, 0xF1, 0xFF, 0xCE, 0x0F, 0xF1, 0xC0, 0x03, 0xF8, 0x03, 0xFF,
  0x81, 0xFF, 0xF0, 0xF0, 0x3E, 0x78, 0x07, 0x9E, 0x00, 0xE7, 0x00, 0x3F,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x80,
  0x21, 0xFF, 0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0x00, 0x00, 0xF8, 0x0F, 0xF0,
  0x7F, 0xC3, 0xC1, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0xFF, 0xCF, 0xFF, 0x3F, 0xFC, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x00, 0x07, 0xF8, 0xE3, 0xFF, 0x9C, 0x7F, 0xFB, 0x9E, 0x03, 0xF7, 0x80,
  0x3E, 0xF0, 0x07, 0xDC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xDC, 0x00,
  0x7B, 0xC0, 0x0F, 0x78, 0x03, 0xE7, 0x80, 0xFC, 0xFE, 0xFF, 0x8F, 0xFE,
  0xF0, 0x7F, 0x9E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xC0, 0x00, 0x78, 0x80, 0x1F, 0x1F, 0xDF, 0xC3, 0xFF, 0xF0, 0x3F, 0xF8,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x7F, 0x0F,
  0x7F, 0xF3, 0xFF, 0xFE, 0xFC, 0x07, 0xBE, 0x00, 0xFF, 0x80, 0x3F, 0xC0,
  0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x70, 0x6F, 0xFF, 0x60,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x03, 0x03, 0xC1, 0xE0, 0xF0, 0x30, 0x00, 0x00, 0x00, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xDB, 0xEF, 0xF7, 0xE0, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x07, 0xFC, 0x03, 0xDE, 0x03, 0xCF, 0x03, 0xC7, 0x83,
  0xC3, 0xC3, 0xC1, 0xE3, 0xC0, 0xF3, 0xC0, 0x7B, 0xC0, 0x3F, 0xE0, 0x1F,
  0xF8, 0x0F, 0xFC, 0x07, 0xCF, 0x03, 0xC3, 0xC1, 0xE0, 0xF0, 0xF0, 0x78,
  0x78, 0x1E, 0x3C, 0x07, 0x9E, 0x03, 0xEF, 0x00, 0xF7, 0x80, 0x3C, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE3, 0xFC, 0x0F, 0xE3, 0x9F, 0xF8, 0xFF, 0xEF, 0xFF, 0xF7,
  0xFF, 0xBF, 0x03, 0xF8, 0x0F, 0xF8, 0x07, 0xC0, 0x3F, 0xC0, 0x1F, 0x00,
  0x7F, 0x00, 0x38, 0x01, 0xFC, 0x00, 0xE0, 0x07, 0xF0, 0x03, 0x80, 0x1F,
  0xC0, 0x0E, 0x00, 0x7F, 0x00, 0x38, 0x01, 0xFC, 0x00, 0xE0, 0x07, 0xF0,
  0x03, 0x80, 0x1F, 0xC0, 0x0E, 0x00, 0x7F, 0x00, 0x38, 0x01, 0xFC, 0x00,
  0xE0, 0x07, 0xF0, 0x03, 0x80, 0x1F, 0xC0, 0x0E, 0x00, 0x7F, 0x00, 0x38,
  0x01, 0xFC, 0x00, 0xE0, 0x07, 0xF0, 0x03, 0x80, 0x1C, 0xE1, 0xFE, 0x39,
  0xFF, 0xCF, 0xFF, 0xFB, 0xF0, 0x1E, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xC0, 0x03, 0xFC, 0x01,
  0xFF, 0xE0, 0x7F, 0xFE, 0x1E, 0x03, 0xE7, 0x80, 0x3C, 0xF0, 0x03, 0xDC,
  0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xDC, 0x00, 0x7B, 0xC0, 0x0F, 0x78,
  0x03, 0xC7, 0x80, 0xF8, 0x7E, 0xFE, 0x07, 0xFF, 0x80, 0x3F, 0xC0, 0xE1,
  0xFC, 0x1C, 0xFF, 0xE3, 0xFF, 0xFE, 0x7E, 0x03, 0xCF, 0x80, 0x3D, 0xE0,
  0x07, 0xBC, 0x00, 0x77, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x77, 0xC0,
  0x1E, 0xF8, 0x03, 0xDF, 0x80, 0xF3, 0xFE, 0xFE, 0x7B, 0xFF, 0x8F, 0x3F,
  0xC1, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0xF8, 0xE3, 0xFF, 0x9C, 0xFF, 0xFB, 0x9E, 0x03, 0xF7, 0x80, 0x3E, 0xF0,
  0x07, 0xDC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7B, 0xC0,
  0x0F, 0x78, 0x03, 0xE7, 0x80, 0xFC, 0xFE, 0xFF, 0x8F, 0xFE, 0xF0, 0x7F,
  0x9E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0xE1,
  0xFF, 0x1F, 0xB9, 0xFD, 0xDC, 0x0F, 0xC0, 0x7C, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x1F, 0xF8,
  0x7F, 0xFD, 0xFF, 0xF7, 0x80, 0x4E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x7C,
  0x00, 0x7E, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x07, 0xC0, 0x03,
  0xC0, 0x07, 0x80, 0x07, 0x00, 0x1F, 0x00, 0x3F, 0xE3, 0xF7, 0xFF, 0xC7,
  0xFF, 0x00, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1E,
  0x01, 0xFB, 0x0F, 0xF0, 0x7F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xDE, 0x03, 0xF7, 0xF7, 0xDC,
  0xFF, 0xE7, 0x1F, 0xF1, 0xC0, 0xF0, 0x00, 0xF7, 0x00, 0x0E, 0x78, 0x01,
  0xE7, 0x80, 0x1E, 0x38, 0x01, 0xC3, 0xC0, 0x3C, 0x3C, 0x03, 0x81, 0xC0,
  0x78, 0x1E, 0x07, 0x80, 0xE0, 0x70, 0x0E, 0x0F, 0x00, 0xF0, 0xE0, 0x07,
  0x0E, 0x00, 0x71, 0xE0, 0x07, 0x9C, 0x00, 0x39, 0xC0, 0x03, 0xBC, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x07,
  0x80, 0x1D, 0xC0, 0x1F, 0x00, 0xF7, 0x80, 0x7C, 0x03, 0xDE, 0x03, 0xF0,
  0x0E, 0x38, 0x0E, 0xE0, 0x38, 0xE0, 0x3B, 0x81, 0xE3, 0xC1, 0xEE, 0x07,
  0x0F, 0x07, 0x3C, 0x1C, 0x1C, 0x1C, 0x70, 0xF0, 0x70, 0x71, 0xC3, 0xC1,
  0xE3, 0x87, 0x0E, 0x03, 0x8E, 0x0E, 0x38, 0x0E, 0x38, 0x39, 0xE0, 0x39,
  0xC0, 0xE7, 0x00, 0xF7, 0x03, 0xDC, 0x01, 0xDC, 0x07, 0x70, 0x07, 0x70,
  0x1D, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0xF8, 0x03,
  0xE0, 0x03, 0xC0, 0x0F, 0x80, 0xF0, 0x03, 0xEF, 0x00, 0x78, 0xF0, 0x1E,
  0x1E, 0x07, 0x81, 0xE0, 0xE0, 0x1E, 0x3C, 0x01, 0xCF, 0x00, 0x3D, 0xC0,
  0x03, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80,
  0x0F, 0x78, 0x03, 0xC7, 0x00, 0x70, 0xF0, 0x1E, 0x0F, 0x07, 0x80, 0xE1,
  0xE0, 0x1E, 0x3C, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x00, 0xF7, 0x00, 0x0E,
  0x78, 0x01, 0xE7, 0x80, 0x1E, 0x38, 0x01, 0xC3, 0xC0, 0x3C, 0x1C, 0x03,
  0x81, 0xE0, 0x38, 0x1E, 0x07, 0x80, 0xE0, 0x70, 0x0F, 0x0F, 0x00, 0x70,
  0xF0, 0x07, 0x0E, 0x00, 0x79, 0xE0, 0x03, 0x9C, 0x00, 0x39, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0xC0, 0x0D, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x01, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x1C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x38, 0x0F, 0xC0, 0xFE, 0x0F, 0x80, 0x78, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x3C, 0x07, 0xC0, 0xFC, 0x07, 0xC0, 0x3F, 0x80, 0x1E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0xC0, 0x1E, 0x00, 0x7F, 0x01, 0xF8, 0x07, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xE0, 0x07, 0xE0, 0x3F, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1E, 0x00, 0x7C, 0x01, 0xF8, 0x07, 0xC0, 0xFE, 0x0F, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0,
  0x07, 0x80, 0x7C, 0x1F, 0xC0, 0xFC, 0x07, 0x80, 0x00, 0x3F, 0x80, 0x7F,
  0xF8, 0x3F, 0xFF, 0xFF, 0x03, 0xFE, 0x80, 0x1F, 0x00,
};

const GFXglyph NotoSans_Regular39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 5, 29, 10, 3, -28 },
  { 20, 10, 10, 16, 3, -28 },
  { 33, 23, 28, 25, 1, -28 },
  { 114, 18, 32, 22, 2, -30 },
  { 186, 29, 28, 32, 2, -28 },
  { 288, 26, 28, 29, 2, -28 },
  { 379, 3, 10, 9, 3, -28 },
  { 383, 9, 34, 12, 2, -28 },
  { 422, 9, 34, 12, 1, -28 },
  { 461, 18, 18, 21, 2, -30 },
  { 502, 18, 19, 22, 2, -23 },
  { 545, 5, 10, 10, 2, -5 },
  { 552, 9, 3, 13, 2, -12 },
  { 556, 5, 6, 10, 3, -5 },
  { 560, 14, 28, 15, 0, -28 },
  { 609, 18, 28, 22, 2, -28 },
  { 672, 11, 28, 22, 3, -28 },
  { 711, 18, 28, 22, 2, -28 },
  { 774, 18, 28, 22, 2, -28 },
  { 837, 21, 28, 22, 1, -28 },
  { 911, 18, 28, 22, 2, -28 },
  { 974, 18, 28, 22, 2, -28 },
  { 1037, 18, 28, 22, 2, -28 },
  { 1100, 18, 28, 22, 2, -28 },
  { 1163, 18, 28, 22, 2, -28 },
  { 1226, 5, 22, 10, 3, -21 },
  { 1240, 7, 26, 10, 1, -21 },
  { 1263, 18, 19, 22, 2, -24 },
  { 1306, 18, 11, 22, 2, -19 },
  { 1331, 18, 19, 22, 2, -24 },
  { 1374, 16, 29, 17, 0, -28 },
  { 1432, 31, 31, 35, 2, -28 },
  { 1553, 25, 28, 25, 0, -28 },
  { 1641, 19, 28, 25, 4, -28 },
  { 1708, 21, 28, 25, 2, -28 },
  { 1782, 22, 28, 28, 4, -28 },
  { 1859, 15, 28, 22, 4, -28 },
  { 1912, 15, 28, 20, 4, -28 },
  { 1965, 24, 28, 28, 2, -28 },
  { 2049, 21, 28, 29, 4, -28 },
  { 2123, 10, 28, 13, 2, -28 },
  { 2158, 10, 35, 11, -3, -28 },
  { 2202, 20, 28, 24, 4, -28 },
  { 2272, 15, 28, 20, 4, -28 },
  { 2325, 28, 28, 35, 4, -28 },
  { 2423, 22, 28, 30, 4, -28 },
  { 2500, 26, 28, 30, 2, -28 },
  { 2591, 18, 28, 24, 4, -28 },
  { 2654, 26, 35, 30, 2, -28 },
  { 2768, 20, 28, 24, 4, -28 },
  { 2838, 18, 28, 21, 2, -28 },
  { 2901, 21, 28, 22, 0, -28 },
  { 2975, 21, 28, 29, 4, -28 },
  { 3049, 23, 28, 23, 0, -28 },
  { 3130, 36, 28, 36, 0, -28 },
  { 3256, 23, 28, 23, 0, -28 },
  { 3337, 22, 28, 22, 0, -28 },
  { 3414, 20, 28, 22, 1, -28 },
  { 3484, 9, 34, 13, 3, -28 },
  { 3523, 14, 28, 15, 0, -28 },
  { 3572, 9, 34, 13, 1, -28 },
  { 3611, 20, 18, 22, 1, -28 },
  { 3656, 17, 2, 17, 0, 4 },
  { 3661, 7, 6, 11, 2, -30 },
  { 3667, 17, 21, 22, 2, -21 },
  { 3712, 19, 30, 24, 3, -30 },
  { 3784, 15, 21, 19, 2, -21 },
  { 3824, 19, 30, 24, 2, -30 },
  { 3896, 18, 21, 22, 2, -21 },
  { 3944, 14, 30, 13, 1, -30 },
  { 3997, 19, 30, 24, 2, -21 },
  { 4069, 18, 30, 24, 3, -30 },
  { 4137, 4, 29, 10, 3, -29 },
  { 4152, 9, 38, 10, -2, -29 },
  { 4195, 17, 30, 21, 3, -30 },
  { 4259, 4, 30, 10, 3, -30 },
  { 4274, 30, 21, 36, 3, -21 },
  { 4353, 18, 21, 24, 3, -21 },
  { 4401, 19, 21, 24, 2, -21 },
  { 4451, 19, 30, 24, 3, -21 },
  { 4523, 19, 30, 24, 2, -21 },
  { 4595, 13, 21, 16, 3, -21 },
  { 4630, 15, 21, 19, 2, -21 },
  { 4670, 12, 26, 14, 1, -26 },
  { 4709, 18, 21, 24, 3, -21 },
  { 4757, 20, 21, 20, 0, -21 },
  { 4810, 30, 21, 31, 0, -21 },
  { 4889, 19, 21, 21, 1, -21 },
  { 4939, 20, 30, 20, 0, -21 },
  { 5014, 15, 21, 18, 2, -21 },
  { 5054, 13, 34, 15, 1, -28 },
  { 5110, 3, 39, 21, 9, -30 },
  { 5125, 13, 34, 15, 1, -28 },
  { 5181, 18, 5, 22, 2, -16 },
};

const GFXfont NotoSans_Regular39pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Regular39pt7bBitmaps,
  (GFXglyph *)NotoSans_Regular39pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _NOTOSANS_REGULAR39PT7B_H_
