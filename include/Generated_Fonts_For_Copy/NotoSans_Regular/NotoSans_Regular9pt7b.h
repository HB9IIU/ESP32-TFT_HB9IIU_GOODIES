#ifndef _NOTOSANS_REGULAR9PT7B_H_
#define _NOTOSANS_REGULAR9PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Regular.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Regular9pt7bBitmaps[] PROGMEM = {
  0x00, 0xF4, 0xF0, 0x29, 0xF5, 0x3E, 0x51, 0x40, 0x4E, 0xCC, 0x7D, 0x64,
  0x41, 0x4A, 0xA5, 0xB5, 0xA5, 0x49, 0x80, 0x20, 0xA1, 0x41, 0x05, 0x51,
  0x1D, 0x80, 0xC0, 0x5A, 0x94, 0xD5, 0x5C, 0x25, 0x5C, 0xA0, 0x27, 0xC8,
  0x40, 0x60, 0xE0, 0x80, 0x25, 0x25, 0x00, 0x22, 0xA3, 0x18, 0xA5, 0xC0,
  0xD5, 0x50, 0x26, 0x84, 0x22, 0x23, 0xE0, 0x64, 0x84, 0xC1, 0x87, 0xC0,
  0x11, 0x95, 0x2F, 0x88, 0xE8, 0xE1, 0x1E, 0x32, 0x11, 0xE8, 0xA5, 0xC0,
  0xF8, 0x84, 0x42, 0x20, 0x22, 0x92, 0x65, 0x45, 0xC0, 0x22, 0xA2, 0xB2,
  0x89, 0xC0, 0x88, 0x40, 0x60, 0x3E, 0x18, 0x30, 0xFF, 0xC0, 0xE0, 0xCD,
  0x80, 0x69, 0x12, 0x40, 0x40, 0x7D, 0x77, 0x2E, 0x5B, 0xD0, 0x1E, 0x00,
  0x30, 0xC5, 0x1E, 0x8A, 0x10, 0xF9, 0xE9, 0x9F, 0x2D, 0x88, 0x88, 0x70,
  0xF4, 0x63, 0x18, 0xF8, 0xF3, 0xC9, 0xC0, 0xF3, 0xC9, 0x00, 0x36, 0x61,
  0x28, 0xC5, 0xE0, 0x8C, 0x7F, 0x18, 0xC4, 0xE9, 0x25, 0xC0, 0x24, 0x92,
  0x4E, 0x95, 0x31, 0x4A, 0x4C, 0x92, 0x49, 0xC0, 0x87, 0x3C, 0xED, 0xB6,
  0x50, 0x8E, 0x6B, 0x59, 0xC4, 0x36, 0x63, 0x18, 0xC5, 0xC0, 0xF9, 0x9E,
  0x88, 0x36, 0x63, 0x18, 0xC5, 0xC2, 0x08, 0xF9, 0x9E, 0x99, 0x32, 0x60,
  0xC1, 0x07, 0xC0, 0xF9, 0x08, 0x42, 0x10, 0x8C, 0x63, 0x18, 0xF8, 0x8A,
  0x54, 0xA3, 0x10, 0x99, 0x59, 0x55, 0x66, 0x66, 0x22, 0xCA, 0x88, 0x65,
  0x44, 0x8A, 0x94, 0x42, 0x10, 0xF8, 0x88, 0x44, 0x7C, 0xEA, 0xAC, 0x89,
  0x22, 0x40, 0xD5, 0x5C, 0x22, 0x95, 0x10, 0xF0, 0xD0, 0x71, 0x79, 0x70,
  0x88, 0xE9, 0x99, 0xE0, 0x74, 0x84, 0x70, 0x08, 0x5E, 0x98, 0xC5, 0xE0,
  0x72, 0x7E, 0x87, 0x00, 0x6B, 0xA4, 0x90, 0x7A, 0x62, 0x97, 0x85, 0xC0,
  0x88, 0xE9, 0x99, 0x90, 0xBE, 0x20, 0x92, 0x49, 0xC0, 0x88, 0xBC, 0xCA,
  0xB0, 0xFE, 0xED, 0x26, 0x4C, 0x99, 0x20, 0xE9, 0x99, 0x90, 0x72, 0x62,
  0x97, 0x00, 0xE9, 0x99, 0xE8, 0x80, 0x7A, 0x63, 0x17, 0x84, 0x20, 0xF2,
  0x48, 0x78, 0x61, 0xF0, 0x5D, 0x24, 0xC0, 0x99, 0x99, 0xF0, 0x8C, 0x94,
  0xC2, 0x00, 0x93, 0x25, 0xB3, 0x64, 0x40, 0x9A, 0x88, 0xA9, 0x80, 0x8C,
  0x94, 0xC2, 0x13, 0x00, 0xF2, 0x24, 0xF0, 0x69, 0x44, 0x98, 0xFF, 0x80,
  0xC9, 0x14, 0xB0, 0xF8,
};

const GFXglyph NotoSans_Regular9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 6, 2, 1, -6 },
  { 2, 2, 2, 4, 1, -6 },
  { 3, 6, 6, 6, 0, -6 },
  { 8, 4, 8, 5, 1, -7 },
  { 12, 7, 7, 7, 0, -7 },
  { 19, 7, 7, 7, 0, -7 },
  { 26, 1, 2, 2, 1, -6 },
  { 27, 2, 7, 3, 0, -6 },
  { 29, 2, 7, 3, 0, -6 },
  { 31, 5, 4, 5, 0, -7 },
  { 34, 5, 4, 5, 0, -5 },
  { 37, 2, 2, 2, 0, -1 },
  { 38, 3, 1, 3, 0, -3 },
  { 39, 1, 1, 2, 1, -1 },
  { 40, 3, 6, 3, 0, -6 },
  { 43, 5, 7, 5, 0, -7 },
  { 48, 2, 6, 5, 1, -6 },
  { 50, 5, 7, 5, 0, -7 },
  { 55, 5, 7, 5, 0, -7 },
  { 60, 5, 6, 5, 0, -6 },
  { 64, 4, 6, 5, 1, -6 },
  { 67, 5, 7, 5, 0, -7 },
  { 72, 5, 6, 5, 0, -6 },
  { 76, 5, 7, 5, 0, -7 },
  { 81, 5, 7, 5, 0, -7 },
  { 86, 1, 5, 2, 1, -5 },
  { 87, 2, 6, 2, 0, -5 },
  { 89, 5, 4, 5, 0, -5 },
  { 92, 5, 2, 5, 0, -4 },
  { 94, 5, 4, 5, 0, -5 },
  { 97, 4, 7, 4, 0, -7 },
  { 101, 7, 7, 8, 1, -6 },
  { 108, 6, 6, 6, 0, -6 },
  { 113, 4, 6, 6, 1, -6 },
  { 116, 4, 7, 6, 1, -7 },
  { 120, 5, 6, 7, 1, -6 },
  { 124, 3, 6, 5, 1, -6 },
  { 127, 3, 6, 5, 1, -6 },
  { 130, 5, 7, 7, 1, -7 },
  { 135, 5, 6, 7, 1, -6 },
  { 139, 3, 6, 3, 0, -6 },
  { 142, 3, 8, 2, -1, -6 },
  { 145, 5, 6, 6, 1, -6 },
  { 149, 3, 6, 5, 1, -6 },
  { 152, 6, 6, 8, 1, -6 },
  { 157, 5, 6, 7, 1, -6 },
  { 161, 5, 7, 7, 1, -7 },
  { 166, 4, 6, 5, 1, -6 },
  { 169, 5, 9, 7, 1, -7 },
  { 175, 4, 6, 6, 1, -6 },
  { 178, 5, 7, 5, 0, -7 },
  { 183, 5, 6, 5, 0, -6 },
  { 187, 5, 6, 7, 1, -6 },
  { 191, 5, 6, 5, 0, -6 },
  { 195, 8, 6, 8, 0, -6 },
  { 201, 5, 6, 5, 0, -6 },
  { 205, 5, 6, 5, 0, -6 },
  { 209, 5, 6, 5, 0, -6 },
  { 213, 2, 7, 3, 1, -6 },
  { 215, 3, 6, 3, 0, -6 },
  { 218, 2, 7, 3, 0, -6 },
  { 220, 5, 4, 5, 0, -6 },
  { 223, 4, 1, 4, 0, 1 },
  { 224, 2, 2, 3, 0, -7 },
  { 225, 4, 5, 5, 0, -5 },
  { 228, 4, 7, 6, 1, -7 },
  { 232, 4, 5, 4, 0, -5 },
  { 235, 5, 7, 6, 0, -7 },
  { 240, 5, 5, 5, 0, -5 },
  { 244, 3, 7, 3, 0, -7 },
  { 247, 5, 7, 6, 0, -5 },
  { 252, 4, 7, 6, 1, -7 },
  { 256, 1, 7, 2, 1, -7 },
  { 257, 3, 9, 2, -1, -7 },
  { 261, 4, 7, 5, 1, -7 },
  { 265, 1, 7, 2, 1, -7 },
  { 266, 7, 5, 8, 1, -5 },
  { 271, 4, 5, 6, 1, -5 },
  { 274, 5, 5, 5, 0, -5 },
  { 278, 4, 7, 6, 1, -5 },
  { 282, 5, 7, 6, 0, -5 },
  { 287, 3, 5, 4, 1, -5 },
  { 289, 4, 5, 4, 0, -5 },
  { 292, 3, 6, 3, 0, -6 },
  { 295, 4, 5, 6, 1, -5 },
  { 298, 5, 5, 5, 0, -5 },
  { 302, 7, 5, 7, 0, -5 },
  { 307, 5, 5, 5, 0, -5 },
  { 311, 5, 7, 5, 0, -5 },
  { 316, 4, 5, 4, 0, -5 },
  { 319, 3, 7, 3, 0, -6 },
  { 322, 1, 9, 5, 2, -7 },
  { 324, 3, 7, 3, 0, -6 },
  { 327, 5, 1, 5, 0, -4 },
};

const GFXfont NotoSans_Regular9pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Regular9pt7bBitmaps,
  (GFXglyph *)NotoSans_Regular9pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _NOTOSANS_REGULAR9PT7B_H_
