#ifndef _NOTOSANS_REGULAR36PT7B_H_
#define _NOTOSANS_REGULAR36PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Regular.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Regular36pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xEE, 0xEE, 0xEE, 0x66, 0x66, 0x66, 0x60, 0x00,
  0xFF, 0xFF, 0x40, 0xF1, 0xFC, 0x77, 0x1D, 0xC7, 0x61, 0xD8, 0x76, 0x1D,
  0x87, 0x60, 0xD8, 0x30, 0x00, 0xE0, 0xC0, 0x06, 0x0E, 0x00, 0x70, 0x70,
  0x03, 0x83, 0x80, 0x1C, 0x18, 0x00, 0xE0, 0xC0, 0x06, 0x06, 0x00, 0x30,
  0x70, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xC0, 0xE0, 0xC0, 0x06, 0x0E, 0x00,
  0x30, 0x70, 0x03, 0x83, 0x80, 0x1C, 0x18, 0x00, 0xE0, 0xC0, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0x83, 0x83, 0x80, 0x1C, 0x1C, 0x00, 0xE0, 0xC0, 0x06,
  0x06, 0x00, 0x30, 0x70, 0x01, 0x83, 0x80, 0x1C, 0x1C, 0x00, 0xE0, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x01, 0xFF, 0x83, 0xFF, 0xF3,
  0xFF, 0xF1, 0xC6, 0x09, 0xE3, 0x00, 0xE1, 0x80, 0x70, 0xC0, 0x3C, 0x60,
  0x0F, 0xB0, 0x03, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFC, 0x01,
  0x9F, 0x00, 0xC3, 0x80, 0x61, 0xE0, 0x30, 0xF0, 0x18, 0x76, 0x0C, 0x7B,
  0xFF, 0xF9, 0xFF, 0xF8, 0x7F, 0xF0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x1E, 0x00, 0x18, 0x1F, 0xE0, 0x0E, 0x07, 0x38, 0x07,
  0x03, 0x87, 0x01, 0xC0, 0xE1, 0xC0, 0xE0, 0x38, 0x30, 0x38, 0x0C, 0x0C,
  0x1C, 0x03, 0x03, 0x06, 0x00, 0xC0, 0xC3, 0x80, 0x30, 0x30, 0xC0, 0x0E,
  0x0C, 0x71, 0xC3, 0x87, 0x39, 0xFC, 0xE1, 0xCE, 0x7F, 0x9C, 0xE7, 0x38,
  0x63, 0xF9, 0xCE, 0x1C, 0x7C, 0xE3, 0x07, 0x00, 0x38, 0xC1, 0xC0, 0x1C,
  0x70, 0x30, 0x06, 0x1C, 0x0C, 0x03, 0x83, 0x07, 0x01, 0xC0, 0xC1, 0xC0,
  0x70, 0x30, 0x70, 0x38, 0x0E, 0x1C, 0x0E, 0x03, 0x8E, 0x07, 0x00, 0x7F,
  0x83, 0xC0, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x1C, 0x1E, 0x00, 0x3C, 0x0E, 0x00, 0x38, 0x0E, 0x00, 0x3C, 0x0E,
  0x00, 0x1C, 0x1E, 0x00, 0x1E, 0x1C, 0x00, 0x0E, 0x7C, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xE0, 0x1E, 0x3C, 0xF0,
  0x1C, 0x78, 0x78, 0x1C, 0xF0, 0x3E, 0x3C, 0xE0, 0x1F, 0x38, 0xE0, 0x0F,
  0xF8, 0xE0, 0x07, 0xF0, 0xE0, 0x03, 0xE0, 0xF0, 0x03, 0xF0, 0x78, 0x07,
  0xF8, 0x7F, 0x7F, 0x7C, 0x3F, 0xFE, 0x3E, 0x0F, 0xF8, 0x1F, 0xFF, 0x77,
  0x66, 0x66, 0x66, 0x03, 0x83, 0x83, 0x83, 0xC1, 0xC0, 0xE0, 0xE0, 0x70,
  0x78, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xF0, 0x38, 0x1C, 0x0F, 0x03, 0x81, 0xE0,
  0x70, 0x1C, 0x07, 0xE0, 0x70, 0x38, 0x38, 0x1C, 0x1C, 0x1E, 0x0E, 0x0E,
  0x0F, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x0F, 0x0E, 0x0E, 0x1E, 0x1C, 0x1C, 0x38, 0x38, 0x70, 0xE0, 0x01,
  0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0C, 0x03, 0x86, 0x1D,
  0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x01, 0xF0, 0x01, 0xDC, 0x00, 0xE7,
  0x00, 0xF3, 0xC0, 0xF0, 0xF0, 0x78, 0x70, 0x08, 0x10, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x3C, 0xF3,
  0x8E, 0x79, 0xC7, 0x18, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x40,
  0x00, 0x38, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x38, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1C, 0x00,
  0xE0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x00, 0x07, 0xE0, 0x0F, 0xFC, 0x0F,
  0xFF, 0x07, 0x03, 0xC7, 0x80, 0xE3, 0x80, 0x7B, 0xC0, 0x1D, 0xC0, 0x0E,
  0xE0, 0x07, 0x70, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xDE,
  0x00, 0xE7, 0x00, 0x73, 0x80, 0x78, 0xE0, 0x78, 0x7C, 0xF8, 0x1F, 0xFC,
  0x03, 0xF8, 0x00, 0x01, 0xC0, 0xF0, 0xFC, 0x7F, 0x3D, 0xFE, 0x76, 0x1D,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x0F, 0xE0, 0x1F, 0xFC, 0x1F, 0xFF, 0x1E, 0x03, 0xC6, 0x00, 0xE0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x03, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xF0, 0x3F, 0xFC,
  0x3F, 0xFF, 0x1E, 0x03, 0xC4, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1C, 0x00,
  0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x01, 0xFF, 0x00, 0xFC, 0x00,
  0x7F, 0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x7A, 0x00, 0x3D, 0xF0, 0xFC, 0xFF,
  0xFC, 0x3F, 0xF8, 0x00, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x01, 0xDC, 0x00, 0x73, 0x80, 0x0E, 0x70, 0x03,
  0x8E, 0x00, 0xE1, 0xC0, 0x1C, 0x38, 0x07, 0x07, 0x01, 0xC0, 0xE0, 0x38,
  0x1C, 0x0E, 0x03, 0x83, 0x80, 0x70, 0xE0, 0x0E, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x3F, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF,
  0x87, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1D, 0xF8, 0x0F, 0xFF, 0x07, 0xFF, 0xC0, 0x01, 0xF0,
  0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x7A, 0x00, 0x79, 0xF8, 0xFC, 0xFF, 0xFC, 0x3F,
  0xF8, 0x00, 0x00, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0x83, 0xC0, 0x03, 0xC0,
  0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38,
  0xFE, 0x1C, 0xFF, 0x8E, 0xF7, 0xE7, 0xC0, 0x7B, 0xC0, 0x1D, 0xE0, 0x0F,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x77, 0x00, 0x7B, 0xC0,
  0x38, 0xE0, 0x3C, 0x7C, 0x7C, 0x1F, 0xFC, 0x03, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00,
  0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0,
  0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0E, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF,
  0x8F, 0x01, 0xC7, 0x00, 0xF3, 0x80, 0x39, 0xC0, 0x1C, 0xE0, 0x0E, 0x70,
  0x0E, 0x1C, 0x0F, 0x0F, 0x8F, 0x03, 0xFF, 0x00, 0x7E, 0x00, 0xFF, 0xC0,
  0xF1, 0xF0, 0xF0, 0x3C, 0xF0, 0x0F, 0x70, 0x03, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x3B, 0xC0, 0x3C, 0xF8, 0x3C, 0x3F, 0xFC, 0x07,
  0xFC, 0x00, 0x07, 0xE0, 0x0F, 0xFC, 0x0F, 0xFF, 0x0F, 0x03, 0xC7, 0x00,
  0xE7, 0x00, 0x3B, 0x80, 0x1D, 0xC0, 0x0E, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFE, 0x00, 0xF7, 0x00, 0xFB, 0xE1, 0xFC, 0xFF, 0xDE, 0x3F, 0xCE,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0xF0, 0x00, 0xF0, 0x43, 0xF0, 0x3F, 0xF0, 0x1F, 0xE0, 0x00, 0x6F, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x40, 0x18, 0xF3, 0xCF,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0xE7, 0x9E,
  0x71, 0xC6, 0x38, 0xE0, 0x00, 0x00, 0x80, 0x01, 0xC0, 0x03, 0xE0, 0x07,
  0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x78,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xFC,
  0x00, 0x3F, 0x00, 0x03, 0x80, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x70, 0x00, 0x3E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F,
  0x80, 0x03, 0xC0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFE, 0x01, 0xF8,
  0x01, 0xF0, 0x00, 0xE0, 0x00, 0x40, 0x00, 0x00, 0x1F, 0xE1, 0xFF, 0xF1,
  0xFF, 0xF3, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x1C, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0xE0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0E, 0x00, 0x08, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x3C, 0x00,
  0xF0, 0x0F, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0xE3,
  0x80, 0x78, 0x0E, 0x30, 0x1F, 0xF0, 0x77, 0x07, 0xFF, 0x07, 0x70, 0x70,
  0x30, 0x76, 0x0E, 0x03, 0x03, 0xE0, 0xE0, 0x70, 0x3E, 0x1C, 0x07, 0x03,
  0xE1, 0xC0, 0x70, 0x3E, 0x1C, 0x07, 0x03, 0xE1, 0xC0, 0x70, 0x7E, 0x1C,
  0x07, 0x07, 0xE0, 0xE0, 0xF0, 0xEE, 0x0F, 0x1F, 0x9E, 0x60, 0x7F, 0x9F,
  0xC7, 0x03, 0xF0, 0xF8, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x40, 0x07, 0xC0, 0xF8, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x3B,
  0x80, 0x00, 0xE3, 0x80, 0x01, 0xC7, 0x00, 0x07, 0x8F, 0x00, 0x0E, 0x0E,
  0x00, 0x1C, 0x1C, 0x00, 0x70, 0x1C, 0x00, 0xE0, 0x38, 0x03, 0xC0, 0x78,
  0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x70, 0x01, 0xC0,
  0xE0, 0x03, 0x83, 0x80, 0x07, 0x87, 0x00, 0x07, 0x1E, 0x00, 0x0F, 0x38,
  0x00, 0x0E, 0x70, 0x00, 0x1D, 0xC0, 0x00, 0x3C, 0xFF, 0xC0, 0x3F, 0xFF,
  0x8F, 0xFF, 0xF3, 0xC0, 0x3E, 0xF0, 0x07, 0xBC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xBC, 0x00, 0xEF, 0x00, 0xF3, 0xFF, 0xF8, 0xFF,
  0xF8, 0x3F, 0xFF, 0xCF, 0x00, 0xFB, 0xC0, 0x0F, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x7B,
  0xFF, 0xFE, 0xFF, 0xFF, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x3F, 0xFF,
  0x07, 0xFF, 0xE1, 0xF8, 0x06, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0x7E, 0x07, 0xFF, 0xE0, 0x1F, 0xFC,
  0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xE0, 0x3F, 0x8F, 0x00,
  0x3E, 0x78, 0x00, 0xF3, 0xC0, 0x03, 0xDE, 0x00, 0x0E, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x1D, 0xE0, 0x01, 0xEF, 0x00, 0x1E, 0x78, 0x01, 0xF3, 0xC0, 0x3F,
  0x1F, 0xFF, 0xF0, 0xFF, 0xFE, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0xBC,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0xFF, 0xDF, 0xFF,
  0xBF, 0xFF, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x00,
  0x7F, 0xC0, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xE0, 0x0C, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x07, 0xFF, 0xC0,
  0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3D, 0xC0, 0x00,
  0xF7, 0x80, 0x03, 0xDE, 0x00, 0x0F, 0x3C, 0x00, 0x3C, 0xF8, 0x00, 0xF1,
  0xF0, 0x03, 0xC3, 0xFE, 0xFF, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xFF, 0xFF, 0xF3, 0xF0, 0x78, 0x1E, 0x07, 0x81,
  0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78,
  0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0xFF, 0xFF,
  0xF0, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0E,
  0x03, 0x81, 0xEF, 0xF3, 0xF8, 0xF8, 0x00, 0xF0, 0x01, 0xFE, 0x00, 0x7B,
  0xC0, 0x1E, 0x78, 0x07, 0x8F, 0x01, 0xE1, 0xE0, 0x78, 0x3C, 0x0E, 0x07,
  0x83, 0x80, 0xF0, 0xE0, 0x1E, 0x3C, 0x03, 0xCF, 0x00, 0x7B, 0xC0, 0x0F,
  0xF8, 0x01, 0xFF, 0x80, 0x3E, 0x78, 0x07, 0x87, 0x80, 0xF0, 0xF0, 0x1E,
  0x0F, 0x03, 0xC0, 0xF0, 0x78, 0x0F, 0x0F, 0x01, 0xE1, 0xE0, 0x1E, 0x3C,
  0x01, 0xE7, 0x80, 0x1C, 0xF0, 0x03, 0xDE, 0x00, 0x3C, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0x00,
  0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xEE,
  0x00, 0x0F, 0xFB, 0x80, 0x07, 0x7E, 0x70, 0x01, 0xDF, 0x9C, 0x00, 0x77,
  0xE7, 0x00, 0x39, 0xF8, 0xE0, 0x0E, 0x7E, 0x38, 0x07, 0x1F, 0x8F, 0x01,
  0xC7, 0xE1, 0xC0, 0x71, 0xF8, 0x70, 0x38, 0x7E, 0x0E, 0x0E, 0x1F, 0x83,
  0x83, 0x87, 0xE0, 0xE1, 0xC1, 0xF8, 0x1C, 0x70, 0x7E, 0x07, 0x38, 0x1F,
  0x81, 0xEE, 0x07, 0xE0, 0x3B, 0x81, 0xF8, 0x0F, 0xC0, 0x7E, 0x01, 0xF0,
  0x1F, 0x80, 0x78, 0x07, 0xE0, 0x1E, 0x01, 0xF8, 0x03, 0x80, 0x70, 0xF0,
  0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x03,
  0xF7, 0x80, 0x1F, 0x9C, 0x00, 0xFC, 0xF0, 0x07, 0xE3, 0xC0, 0x3F, 0x1E,
  0x01, 0xF8, 0x78, 0x0F, 0xC1, 0xC0, 0x7E, 0x0F, 0x03, 0xF0, 0x3C, 0x1F,
  0x80, 0xE0, 0xFC, 0x07, 0x87, 0xE0, 0x1E, 0x3F, 0x00, 0x71, 0xF8, 0x03,
  0xCF, 0xC0, 0x0F, 0x7E, 0x00, 0x3B, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0x00, 0xF8, 0x3E, 0x00, 0x3C, 0x3C,
  0x00, 0x3C, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x70,
  0x00, 0x0E, 0x70, 0x00, 0x0E, 0x78, 0x00, 0x1E, 0x38, 0x00, 0x1C, 0x3C,
  0x00, 0x3C, 0x1F, 0x00, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01,
  0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xFC, 0x3F, 0xFF, 0x9E, 0x07, 0xEF, 0x00,
  0xF7, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x01, 0xEF, 0x01, 0xF7, 0xFF, 0xF3, 0xFF, 0xE1, 0xFF, 0xC0,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0x00, 0xF8, 0x3E, 0x00,
  0x3C, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x0E, 0x70, 0x00,
  0x0E, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x78, 0x00, 0x1E, 0x38, 0x00,
  0x1C, 0x3C, 0x00, 0x3C, 0x1F, 0x00, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF,
  0xE0, 0x01, 0xFF, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7E, 0xFF, 0xE0,
  0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x78, 0x1F, 0x8F, 0x00, 0xF1, 0xE0, 0x0F,
  0x3C, 0x01, 0xE7, 0x80, 0x1C, 0xF0, 0x03, 0x9E, 0x00, 0xF3, 0xC0, 0x1C,
  0x78, 0x07, 0x8F, 0x07, 0xE1, 0xFF, 0xF8, 0x3F, 0xFC, 0x07, 0x83, 0x80,
  0xF0, 0x78, 0x1E, 0x07, 0x83, 0xC0, 0x70, 0x78, 0x0F, 0x0F, 0x00, 0xE1,
  0xE0, 0x1E, 0x3C, 0x01, 0xE7, 0x80, 0x1C, 0xF0, 0x03, 0xDE, 0x00, 0x3C,
  0x07, 0xF8, 0x1F, 0xFE, 0x3F, 0xFE, 0x78, 0x06, 0xF0, 0x00, 0xF0, 0x00,
  0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3F, 0x80,
  0x1F, 0xE0, 0x07, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x80, 0x1E, 0xFE, 0xFE,
  0xFF, 0xFC, 0x7F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0x70,
  0x00, 0xE7, 0x80, 0x1E, 0x3C, 0x03, 0xE3, 0xFD, 0xFC, 0x0F, 0xFF, 0x80,
  0x7F, 0xE0, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xE7, 0x00, 0x07, 0x9E, 0x00,
  0x1C, 0x78, 0x00, 0x70, 0xE0, 0x03, 0xC3, 0xC0, 0x0E, 0x07, 0x00, 0x38,
  0x1C, 0x01, 0xE0, 0x78, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x0F,
  0x03, 0x80, 0x1C, 0x0E, 0x00, 0x70, 0x78, 0x01, 0xE1, 0xC0, 0x03, 0x8F,
  0x00, 0x0E, 0x38, 0x00, 0x1C, 0xE0, 0x00, 0x73, 0x80, 0x01, 0xDC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0xB8, 0x00, 0xF0, 0x03, 0xDC, 0x00,
  0xF8, 0x01, 0xCF, 0x00, 0x7C, 0x00, 0xE3, 0x80, 0x3F, 0x00, 0x71, 0xC0,
  0x3B, 0x80, 0x78, 0xE0, 0x1D, 0xC0, 0x38, 0x78, 0x0E, 0xE0, 0x1C, 0x1C,
  0x07, 0x38, 0x0E, 0x0E, 0x07, 0x1C, 0x0F, 0x07, 0x03, 0x8E, 0x07, 0x03,
  0xC1, 0xC3, 0x83, 0x80, 0xE1, 0xC1, 0xC1, 0xC0, 0x70, 0xE0, 0xE1, 0xE0,
  0x38, 0x70, 0x78, 0xE0, 0x1E, 0x78, 0x1C, 0x70, 0x07, 0x38, 0x0E, 0x38,
  0x03, 0x9C, 0x07, 0x38, 0x01, 0xCE, 0x01, 0xDC, 0x00, 0x7E, 0x00, 0xEE,
  0x00, 0x3F, 0x00, 0x77, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0x0F, 0xC0, 0x0F,
  0x80, 0x03, 0xC0, 0x07, 0xC0, 0x01, 0xE0, 0x03, 0xE0, 0x00, 0xF0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x73, 0xC0, 0x07, 0x8F, 0x00, 0x38, 0x38, 0x03,
  0x81, 0xE0, 0x3C, 0x07, 0x81, 0xC0, 0x1C, 0x1C, 0x00, 0xF1, 0xE0, 0x03,
  0x8E, 0x00, 0x0E, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x00,
  0x00, 0x7C, 0x00, 0x07, 0xF0, 0x00, 0x3B, 0x80, 0x03, 0x9E, 0x00, 0x1C,
  0x78, 0x01, 0xC1, 0xC0, 0x1E, 0x0F, 0x00, 0xE0, 0x38, 0x0E, 0x00, 0xE0,
  0xF0, 0x07, 0x87, 0x00, 0x1C, 0x78, 0x00, 0xF7, 0x80, 0x03, 0xC0, 0xF0,
  0x00, 0x77, 0x00, 0x0F, 0x78, 0x00, 0xE3, 0x80, 0x1E, 0x3C, 0x01, 0xC1,
  0xC0, 0x3C, 0x1E, 0x03, 0x80, 0xE0, 0x70, 0x0F, 0x07, 0x00, 0x70, 0xE0,
  0x03, 0x9E, 0x00, 0x39, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFC, 0x00,
  0x0E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x0E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0,
  0x03, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x80,
  0x1E, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00,
  0x70, 0x03, 0xC0, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x01,
  0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0xC0, 0x03,
  0x70, 0x01, 0xCE, 0x00, 0x73, 0x80, 0x18, 0x70, 0x0E, 0x1C, 0x03, 0x03,
  0x81, 0xC0, 0xE0, 0x60, 0x1C, 0x38, 0x07, 0x0C, 0x00, 0xE7, 0x00, 0x3B,
  0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x78, 0x38, 0x1C,
  0x0E, 0x07, 0x01, 0x80, 0x3F, 0xF0, 0xFF, 0xF1, 0xC0, 0xF0, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x7E, 0x3F, 0xFC, 0xFF, 0xFB, 0xC0,
  0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x3F, 0xF1, 0xFD,
  0xFF, 0x99, 0xFE, 0x30, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC1, 0xC0, 0xE7, 0xF8, 0x77,
  0xFF, 0x3F, 0x07, 0x9F, 0x01, 0xEF, 0x00, 0x77, 0x80, 0x3F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x3F, 0xC0, 0x1D, 0xF0, 0x1E, 0xFE, 0x3E, 0x77, 0xFE, 0x31,
  0xFE, 0x00, 0x00, 0xC0, 0x3F, 0xF1, 0xFF, 0xCF, 0x86, 0x78, 0x01, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xFC, 0xF1, 0xFF, 0xC1,
  0xFE, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x07, 0x07, 0x0F, 0xF3, 0x8F, 0xFD, 0xCF, 0x07,
  0xEF, 0x01, 0xF7, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3D,
  0xC0, 0x1E, 0xF0, 0x1F, 0x3E, 0x3F, 0x8F, 0xFD, 0xC3, 0xFC, 0xE0, 0x01,
  0xC0, 0x0F, 0xF8, 0x1F, 0xFC, 0x3C, 0x1E, 0x78, 0x0F, 0x70, 0x07, 0xF0,
  0x07, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xE0,
  0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x7C, 0x01, 0x3F, 0x1F, 0x1F,
  0xFF, 0x07, 0xFE, 0x00, 0x40, 0x3F, 0xC3, 0xFC, 0x1E, 0x21, 0xE0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x07, 0xFF, 0x3F, 0xF8, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x00, 0x03, 0xC0, 0x07, 0xF9, 0xC7, 0xFE, 0xE7, 0x83, 0xF7, 0x80, 0xFB,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0E, 0xE0, 0x0F, 0x78,
  0x0F, 0x9F, 0x1F, 0xC7, 0xFE, 0xE1, 0xFE, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x0F, 0x40, 0x07, 0x38, 0x0F, 0x9F, 0xFF, 0x87, 0xFF,
  0x80, 0x1C, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0xE0, 0xE7, 0xFC, 0xEF, 0xFE, 0xFC,
  0x1F, 0xF8, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0x4E, 0xFE, 0x40,
  0x00, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xE0, 0x02,
  0x03, 0x81, 0xE0, 0xE0, 0x20, 0x00, 0x00, 0x00, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x0F,
  0x7F, 0x3F, 0x8E, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x1E, 0xE0, 0x3C,
  0xE0, 0x78, 0xE0, 0xF0, 0xE1, 0xE0, 0xE3, 0xC0, 0xE7, 0x80, 0xEF, 0x00,
  0xEF, 0x00, 0xFF, 0x80, 0xFB, 0x80, 0xF3, 0xC0, 0xE1, 0xE0, 0xE0, 0xF0,
  0xE0, 0x78, 0xE0, 0x78, 0xE0, 0x3C, 0xE0, 0x1E, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x0C,
  0x0E, 0x7F, 0x87, 0xFC, 0xEF, 0xFC, 0xFF, 0xEF, 0xC1, 0xFC, 0x1E, 0xF8,
  0x0F, 0x80, 0xEF, 0x00, 0xF0, 0x0F, 0xF0, 0x0F, 0x00, 0x7E, 0x00, 0xF0,
  0x07, 0xE0, 0x0F, 0x00, 0x7E, 0x00, 0xE0, 0x07, 0xE0, 0x0E, 0x00, 0x7E,
  0x00, 0xE0, 0x07, 0xE0, 0x0E, 0x00, 0x7E, 0x00, 0xE0, 0x07, 0xE0, 0x0E,
  0x00, 0x7E, 0x00, 0xE0, 0x07, 0xE0, 0x0E, 0x00, 0x7E, 0x00, 0xE0, 0x07,
  0xE0, 0x0E, 0x00, 0x7E, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0xE7, 0xFC, 0xEF,
  0xFE, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0x00,
  0xC0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xF0, 0x7C, 0x78, 0x07, 0x1C, 0x00,
  0xEF, 0x00, 0x3B, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xF7, 0x00, 0x39, 0xC0, 0x1E, 0x38,
  0x07, 0x0F, 0x87, 0xC1, 0xFF, 0xE0, 0x1F, 0xE0, 0x00, 0xE0, 0x73, 0xFC,
  0x3B, 0xFF, 0x9F, 0x83, 0xCF, 0x80, 0xF7, 0x80, 0x3B, 0xC0, 0x1F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0E, 0xF8, 0x0F, 0x7F, 0x1F, 0x3B, 0xFF,
  0x1C, 0xFF, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80,
  0x07, 0xF9, 0xC7, 0xFE, 0xE7, 0x83, 0xF7, 0x80, 0xFB, 0x80, 0x3F, 0xC0,
  0x1F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1E, 0xE0, 0x0F, 0x78, 0x0F, 0x9F, 0x1F,
  0xC7, 0xFE, 0xE1, 0xFE, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0xFC, 0x7F, 0xBF, 0xF7, 0x8F, 0x81, 0xF0, 0x3C, 0x07, 0x80, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x00, 0x03, 0x80, 0xFF, 0xE7, 0xFF, 0xBC, 0x0C, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFC, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x0F, 0x80, 0x3B, 0xC3, 0xEF,
  0xFF, 0x1F, 0xF0, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x81, 0xFF, 0xFF,
  0xF9, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x47, 0xF8, 0x7F,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x1F, 0x7C, 0x7F, 0x7F, 0xF7,
  0x1F, 0xE7, 0xF0, 0x01, 0xDC, 0x00, 0xF7, 0x00, 0x39, 0xE0, 0x0E, 0x38,
  0x07, 0x0E, 0x01, 0xC1, 0xC0, 0xF0, 0x70, 0x38, 0x1E, 0x0E, 0x03, 0x87,
  0x80, 0xE1, 0xC0, 0x3C, 0x70, 0x07, 0x38, 0x01, 0xCE, 0x00, 0x3B, 0x80,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0xF0, 0x0F, 0x00,
  0xF7, 0x00, 0xF0, 0x0E, 0x70, 0x0F, 0x80, 0xE7, 0x81, 0xF8, 0x0E, 0x38,
  0x1D, 0x81, 0xE3, 0x81, 0x9C, 0x1C, 0x38, 0x39, 0xC1, 0xC1, 0xC3, 0x9C,
  0x1C, 0x1C, 0x38, 0xE3, 0x81, 0xC7, 0x0E, 0x38, 0x1C, 0x70, 0xE3, 0x80,
  0xE7, 0x07, 0x38, 0x0E, 0xE0, 0x77, 0x00, 0xEE, 0x07, 0x70, 0x0E, 0xE0,
  0x77, 0x00, 0x7C, 0x03, 0x70, 0x07, 0xC0, 0x3E, 0x00, 0x7C, 0x03, 0xE0,
  0x03, 0x80, 0x1E, 0x00, 0xF0, 0x07, 0xBC, 0x07, 0x8F, 0x03, 0x83, 0x83,
  0x81, 0xE3, 0xC0, 0x79, 0xC0, 0x1D, 0xC0, 0x0F, 0xE0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0xEE, 0x00, 0xF7, 0x80, 0x71, 0xC0, 0x70, 0x70,
  0x78, 0x3C, 0x78, 0x0F, 0x38, 0x03, 0xBC, 0x01, 0xE0, 0xF0, 0x01, 0xDC,
  0x00, 0xF7, 0x00, 0x38, 0xE0, 0x0E, 0x38, 0x07, 0x8F, 0x01, 0xC1, 0xC0,
  0xF0, 0x70, 0x38, 0x0E, 0x0E, 0x03, 0x87, 0x80, 0xF1, 0xC0, 0x1C, 0x70,
  0x07, 0x3C, 0x00, 0xEE, 0x00, 0x3B, 0x80, 0x0F, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C,
  0x00, 0x0E, 0x00, 0x07, 0x80, 0x3F, 0xC0, 0x0F, 0xE0, 0x01, 0xC0, 0x00,
  0x7F, 0xFC, 0xFF, 0xF8, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x80, 0x1E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x78, 0x01, 0xE0,
  0x03, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x70, 0x1F, 0x03, 0xF0, 0x78, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x7C, 0x0F, 0x80,
  0xF8, 0x03, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x7F, 0x01, 0xF0, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x80,
  0xFC, 0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0xE0, 0x1F, 0x01, 0xF0, 0x7C,
  0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x1E, 0x0F, 0xC0, 0xF8, 0x0C, 0x00, 0x3E, 0x00, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF0, 0x1F, 0xE8, 0x01, 0xC0,
};

const GFXglyph NotoSans_Regular36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 4, 27, 10, 3, -26 },
  { 15, 10, 10, 15, 2, -26 },
  { 28, 21, 26, 23, 1, -26 },
  { 97, 17, 29, 21, 2, -27 },
  { 159, 26, 26, 30, 2, -26 },
  { 244, 24, 26, 26, 2, -26 },
  { 322, 4, 10, 8, 2, -26 },
  { 327, 9, 32, 11, 1, -26 },
  { 363, 8, 32, 11, 1, -26 },
  { 395, 17, 16, 20, 1, -27 },
  { 429, 17, 17, 21, 2, -21 },
  { 466, 6, 9, 10, 1, -4 },
  { 473, 9, 3, 12, 1, -11 },
  { 477, 4, 5, 10, 3, -4 },
  { 480, 13, 26, 13, 0, -26 },
  { 523, 17, 26, 21, 2, -26 },
  { 579, 10, 26, 21, 3, -26 },
  { 612, 17, 26, 21, 2, -26 },
  { 668, 17, 26, 21, 2, -26 },
  { 724, 19, 26, 21, 1, -26 },
  { 786, 17, 26, 21, 2, -26 },
  { 842, 17, 26, 21, 2, -26 },
  { 898, 17, 26, 21, 2, -26 },
  { 954, 17, 26, 21, 2, -26 },
  { 1010, 17, 26, 21, 2, -26 },
  { 1066, 4, 21, 10, 3, -20 },
  { 1077, 6, 25, 10, 1, -20 },
  { 1096, 17, 18, 21, 2, -22 },
  { 1135, 17, 10, 21, 2, -18 },
  { 1157, 17, 18, 21, 2, -22 },
  { 1196, 15, 27, 16, 0, -26 },
  { 1247, 28, 29, 32, 2, -26 },
  { 1349, 23, 26, 23, 0, -26 },
  { 1424, 18, 26, 23, 3, -26 },
  { 1483, 20, 26, 23, 2, -26 },
  { 1548, 21, 26, 26, 3, -26 },
  { 1617, 15, 26, 20, 3, -26 },
  { 1666, 15, 26, 19, 3, -26 },
  { 1715, 22, 26, 26, 2, -26 },
  { 1787, 20, 26, 27, 3, -26 },
  { 1852, 10, 26, 12, 1, -26 },
  { 1885, 10, 33, 10, -3, -26 },
  { 1927, 19, 26, 22, 3, -26 },
  { 1989, 15, 26, 19, 3, -26 },
  { 2038, 26, 26, 33, 3, -26 },
  { 2123, 21, 26, 27, 3, -26 },
  { 2192, 24, 26, 28, 2, -26 },
  { 2270, 17, 26, 22, 3, -26 },
  { 2326, 24, 32, 28, 2, -26 },
  { 2422, 19, 26, 22, 3, -26 },
  { 2484, 16, 26, 20, 2, -26 },
  { 2536, 20, 26, 20, 0, -26 },
  { 2601, 20, 26, 26, 3, -26 },
  { 2666, 22, 26, 22, 0, -26 },
  { 2738, 33, 26, 33, 0, -26 },
  { 2846, 21, 26, 21, 0, -26 },
  { 2915, 20, 26, 20, 0, -26 },
  { 2980, 18, 26, 21, 1, -26 },
  { 3039, 8, 32, 12, 3, -26 },
  { 3071, 13, 26, 13, 0, -26 },
  { 3114, 8, 32, 12, 1, -26 },
  { 3146, 18, 16, 21, 1, -26 },
  { 3182, 16, 3, 16, 0, 3 },
  { 3188, 8, 6, 10, 1, -28 },
  { 3194, 15, 20, 20, 2, -20 },
  { 3232, 17, 27, 22, 3, -27 },
  { 3290, 14, 20, 17, 2, -20 },
  { 3325, 17, 27, 22, 2, -27 },
  { 3383, 16, 20, 20, 2, -20 },
  { 3423, 13, 28, 12, 1, -28 },
  { 3469, 17, 29, 22, 2, -20 },
  { 3531, 16, 27, 22, 3, -27 },
  { 3585, 4, 27, 9, 3, -27 },
  { 3599, 9, 36, 9, -2, -27 },
  { 3640, 16, 27, 19, 3, -27 },
  { 3694, 3, 27, 9, 3, -27 },
  { 3705, 28, 20, 34, 3, -20 },
  { 3775, 16, 20, 22, 3, -20 },
  { 3815, 18, 20, 22, 2, -20 },
  { 3860, 17, 29, 22, 3, -20 },
  { 3922, 17, 29, 22, 2, -20 },
  { 3984, 11, 20, 15, 3, -20 },
  { 4012, 14, 20, 17, 2, -20 },
  { 4047, 11, 24, 13, 1, -24 },
  { 4080, 16, 19, 22, 3, -19 },
  { 4118, 18, 19, 18, 0, -19 },
  { 4161, 28, 19, 28, 0, -19 },
  { 4228, 17, 19, 19, 1, -19 },
  { 4269, 18, 28, 18, 0, -19 },
  { 4332, 15, 19, 17, 1, -19 },
  { 4368, 12, 32, 14, 1, -26 },
  { 4416, 2, 36, 20, 9, -27 },
  { 4425, 12, 32, 14, 1, -26 },
  { 4473, 17, 5, 21, 2, -15 },
};

const GFXfont NotoSans_Regular36pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Regular36pt7bBitmaps,
  (GFXglyph *)NotoSans_Regular36pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _NOTOSANS_REGULAR36PT7B_H_
