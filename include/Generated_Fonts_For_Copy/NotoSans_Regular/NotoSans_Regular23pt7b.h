#ifndef _NOTOSANS_REGULAR23PT7B_H_
#define _NOTOSANS_REGULAR23PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Regular.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Regular23pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x6D, 0xB6, 0xDB, 0x01, 0xBE, 0xE6, 0xCD, 0x1A, 0x34, 0x68,
  0x80, 0x04, 0x60, 0x63, 0x03, 0x18, 0x18, 0xCF, 0xFF, 0xFF, 0xFC, 0x63,
  0x03, 0x18, 0x18, 0xC0, 0x84, 0x3F, 0xFC, 0x63, 0x03, 0x18, 0x18, 0xC0,
  0x84, 0x04, 0x60, 0x04, 0x00, 0x80, 0xFF, 0x3A, 0x66, 0x41, 0x88, 0x19,
  0x03, 0xE0, 0x3F, 0x00, 0xF8, 0x13, 0x82, 0x30, 0x47, 0x09, 0xFF, 0xF1,
  0xF8, 0x04, 0x00, 0x80, 0x38, 0x00, 0x3E, 0x06, 0x11, 0x06, 0x18, 0xC2,
  0x0C, 0x63, 0x06, 0x33, 0x03, 0x19, 0x81, 0x8D, 0x9C, 0x44, 0xDB, 0x3E,
  0xD8, 0xCE, 0x4C, 0x60, 0x66, 0x30, 0x23, 0x18, 0x31, 0x8C, 0x30, 0xC6,
  0x18, 0x36, 0x18, 0x0F, 0x00, 0x0E, 0x00, 0x1F, 0x80, 0x31, 0xC0, 0x30,
  0xC0, 0x30, 0xC0, 0x31, 0xC0, 0x1B, 0x80, 0x1F, 0x00, 0x1E, 0x00, 0x37,
  0x06, 0x63, 0x8C, 0xE1, 0xCC, 0xC0, 0xF8, 0xC0, 0x78, 0x60, 0x78, 0x7F,
  0xFC, 0x3F, 0x87, 0xED, 0x24, 0x80, 0x19, 0x98, 0xC6, 0x63, 0x18, 0xC6,
  0x31, 0x8C, 0x61, 0x8C, 0x61, 0x8C, 0x30, 0xC3, 0x18, 0x63, 0x1C, 0x63,
  0x18, 0xC6, 0x31, 0x8C, 0xC6, 0x33, 0x31, 0x80, 0x0C, 0x01, 0x80, 0x30,
  0x72, 0xEF, 0xFE, 0x1C, 0x06, 0x81, 0xD8, 0x71, 0x82, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x41, 0xFF, 0xFF, 0xF8, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x00, 0x6D, 0xAD, 0x80, 0xFF, 0xC0, 0xDF, 0x00, 0x03, 0x03, 0x06,
  0x06, 0x04, 0x0C, 0x0C, 0x18, 0x18, 0x18, 0x30, 0x30, 0x30, 0x60, 0x60,
  0xC0, 0x0E, 0x07, 0xF1, 0xC7, 0x30, 0x66, 0x0F, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x06, 0xC1, 0x98, 0x31, 0xFC, 0x1F,
  0x00, 0x1C, 0xF6, 0xF3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0E, 0x0F, 0xF3, 0x87, 0x20, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0E,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x07, 0xFF, 0xFF,
  0xE0, 0x0E, 0x0F, 0xF3, 0x87, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x1C,
  0x1E, 0x00, 0x78, 0x03, 0x00, 0x30, 0x06, 0x00, 0xE0, 0x37, 0xBE, 0xFF,
  0x00, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x07, 0x80, 0x6C, 0x03, 0x60, 0x33,
  0x03, 0x18, 0x18, 0xC1, 0x86, 0x18, 0x30, 0xFF, 0xFF, 0xFF, 0x80, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x7F, 0xCC, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x1F, 0xC3, 0xFE, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x30, 0x07, 0x01,
  0xBF, 0xE3, 0xF8, 0x03, 0xC3, 0xF8, 0xE0, 0x18, 0x06, 0x00, 0xC0, 0x18,
  0x06, 0x7C, 0xD9, 0xDC, 0x1F, 0x01, 0xE0, 0x34, 0x06, 0xC0, 0xD8, 0x39,
  0xDE, 0x1F, 0x80, 0xFF, 0xE0, 0x0C, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x00,
  0x60, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x01,
  0xC0, 0x0E, 0x07, 0xF1, 0xC3, 0x30, 0x66, 0x0C, 0xC1, 0x9C, 0x71, 0xFC,
  0x1F, 0x07, 0x71, 0x83, 0x60, 0x3C, 0x07, 0x80, 0xF8, 0x3B, 0x8E, 0x3F,
  0x80, 0x0E, 0x07, 0xF1, 0xC7, 0x30, 0x6C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0x60, 0xEF, 0xEC, 0x79, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x62, 0x38, 0x7E,
  0x00, 0xDF, 0x00, 0x00, 0x03, 0x7C, 0x6D, 0x80, 0x00, 0x01, 0xB7, 0xB4,
  0x00, 0x20, 0x1C, 0x0F, 0x07, 0x03, 0x81, 0xC0, 0x3C, 0x01, 0xE0, 0x07,
  0x80, 0x3C, 0x01, 0x80, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x78, 0x3C,
  0x1E, 0x1E, 0x03, 0x00, 0x00, 0x1C, 0x7F, 0x90, 0xE0, 0x30, 0x18, 0x0C,
  0x06, 0x06, 0x0E, 0x06, 0x06, 0x03, 0x00, 0x00, 0x00, 0x60, 0x38, 0x18,
  0x00, 0x03, 0xFC, 0x03, 0x81, 0xC1, 0x80, 0x38, 0xC0, 0x06, 0x60, 0xF8,
  0xD8, 0xFE, 0x34, 0x31, 0x87, 0x18, 0x61, 0xC6, 0x18, 0x71, 0x86, 0x1C,
  0x61, 0x8F, 0x18, 0xE2, 0x43, 0xEF, 0x98, 0x20, 0x83, 0x00, 0x00, 0xE0,
  0x00, 0x1F, 0x3C, 0x01, 0xFE, 0x00, 0x03, 0x80, 0x07, 0x00, 0x1A, 0x00,
  0x36, 0x00, 0xCC, 0x01, 0x8C, 0x03, 0x18, 0x0C, 0x30, 0x18, 0x30, 0x3F,
  0xE0, 0xFF, 0xE1, 0x80, 0xC6, 0x01, 0x8C, 0x01, 0x98, 0x03, 0x60, 0x07,
  0xFF, 0xCC, 0x1E, 0xC0, 0x6C, 0x06, 0xC0, 0x6C, 0x06, 0xC3, 0xCF, 0xF8,
  0xC1, 0xEC, 0x06, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x06, 0xFF, 0xEF, 0xF8,
  0x03, 0xC0, 0x7F, 0xC7, 0x0C, 0x70, 0x07, 0x00, 0x30, 0x01, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0xFE, 0x0F, 0xF0, 0xFF, 0xC6, 0x0F, 0x30, 0x1D, 0x80, 0x7C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x7C,
  0x03, 0x60, 0x73, 0xFF, 0x1F, 0xE0, 0xFF, 0xE0, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0xFF, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0xFF, 0xFF,
  0xFF, 0xE0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0xFF, 0xFF, 0xE0, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x01, 0xE0, 0x3F, 0xF1, 0xE1, 0x8E,
  0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xE0, 0xFF, 0x83, 0xF6,
  0x00, 0xD8, 0x03, 0x60, 0x0D, 0xC0, 0x33, 0x80, 0xC7, 0xFF, 0x07, 0xFC,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x7F,
  0xFF, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xFC, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC7, 0xBF, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x3B, 0xFE, 0xC0, 0x7C, 0x0C, 0xC1, 0x8C, 0x30, 0xC7,
  0x0C, 0xE0, 0xDC, 0x0F, 0xC0, 0xFE, 0x0C, 0x60, 0xC3, 0x0C, 0x38, 0xC1,
  0xCC, 0x0C, 0xC0, 0x6C, 0x07, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0xFF, 0xFF, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x03, 0x7B, 0x01, 0xBD, 0x80, 0xDE, 0x60, 0xCF,
  0x30, 0x67, 0x98, 0x23, 0xC6, 0x31, 0xE3, 0x18, 0xF1, 0x98, 0x78, 0x6C,
  0x3C, 0x36, 0x1E, 0x0E, 0x0F, 0x07, 0x07, 0x83, 0x03, 0xE0, 0x1F, 0x80,
  0xFE, 0x07, 0xB0, 0x3D, 0xC1, 0xE6, 0x0F, 0x18, 0x78, 0xE3, 0xC3, 0x1E,
  0x0C, 0xF0, 0x77, 0x81, 0xBC, 0x07, 0xE0, 0x3F, 0x00, 0xF8, 0x03, 0x03,
  0xC0, 0x0F, 0xF0, 0x3C, 0x3C, 0x30, 0x0C, 0x70, 0x0E, 0x60, 0x06, 0x60,
  0x06, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0x60, 0x06, 0x60, 0x06, 0x60,
  0x06, 0x70, 0x0E, 0x38, 0x1C, 0x1F, 0xF8, 0x0F, 0xF0, 0xFF, 0x98, 0x7B,
  0x03, 0x60, 0x7C, 0x07, 0x80, 0xF0, 0x36, 0x0E, 0xFF, 0x9F, 0x83, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x03, 0xC0, 0x0F, 0xF0, 0x3C,
  0x3C, 0x30, 0x0C, 0x70, 0x0E, 0x60, 0x06, 0x60, 0x06, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0x60, 0x06, 0x60, 0x06, 0x60, 0x06, 0x70, 0x0E, 0x38,
  0x1C, 0x1F, 0xF8, 0x0F, 0xF0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x1E, 0xFF, 0x8C, 0x3C, 0xC0, 0xCC, 0x06, 0xC0, 0x6C, 0x0E, 0xC0, 0xCF,
  0xF8, 0xFF, 0x0C, 0x30, 0xC3, 0x8C, 0x18, 0xC1, 0xCC, 0x0C, 0xC0, 0x6C,
  0x07, 0x0F, 0x07, 0xF9, 0xC3, 0x70, 0x0C, 0x01, 0xC0, 0x18, 0x03, 0xC0,
  0x1F, 0x00, 0xF0, 0x07, 0x00, 0x60, 0x0E, 0x01, 0xA0, 0x37, 0xFE, 0xFF,
  0x00, 0xFF, 0xF8, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3E, 0x03,
  0x30, 0x38, 0xFF, 0x83, 0xF8, 0xC0, 0x1D, 0x80, 0x66, 0x01, 0x9C, 0x0C,
  0x30, 0x30, 0xC0, 0xC3, 0x86, 0x06, 0x18, 0x18, 0xE0, 0x33, 0x00, 0xCC,
  0x03, 0x70, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x00, 0xC0, 0xE0, 0x70, 0x1B,
  0x03, 0x81, 0xD8, 0x1E, 0x0C, 0xC1, 0xB0, 0x63, 0x0D, 0x83, 0x18, 0x64,
  0x38, 0xC2, 0x31, 0x86, 0x31, 0x8C, 0x19, 0x8C, 0x60, 0xCC, 0x36, 0x06,
  0xC1, 0xB0, 0x36, 0x0D, 0x80, 0xF0, 0x2C, 0x07, 0x01, 0xC0, 0x38, 0x0E,
  0x01, 0xC0, 0x70, 0xE0, 0x39, 0x81, 0x8E, 0x18, 0x31, 0x80, 0xCC, 0x06,
  0xC0, 0x1C, 0x00, 0x60, 0x07, 0x80, 0x6C, 0x03, 0x30, 0x31, 0xC3, 0x06,
  0x18, 0x19, 0x80, 0xDC, 0x03, 0xE0, 0x3B, 0x01, 0x8C, 0x18, 0x60, 0xC1,
  0x8C, 0x0C, 0x60, 0x36, 0x01, 0xB0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0xFF, 0xE0, 0x1C, 0x03, 0x00,
  0xC0, 0x38, 0x06, 0x01, 0x80, 0x70, 0x0C, 0x03, 0x00, 0xE0, 0x18, 0x06,
  0x01, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31,
  0x8C, 0x63, 0x18, 0xC6, 0x3F, 0xF0, 0xE0, 0x60, 0x60, 0x30, 0x30, 0x30,
  0x18, 0x18, 0x0C, 0x0C, 0x0C, 0x06, 0x06, 0x06, 0x03, 0x03, 0xF8, 0xC6,
  0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xFF, 0xF0, 0x04,
  0x01, 0x80, 0x38, 0x0D, 0x01, 0xB0, 0x63, 0x0C, 0x63, 0x06, 0x60, 0xC8,
  0x0F, 0x01, 0x80, 0xFF, 0xFF, 0xF0, 0xC3, 0x0C, 0x30, 0x04, 0x1F, 0xE2,
  0x1C, 0x03, 0x00, 0xC0, 0x33, 0xFD, 0xC3, 0xC0, 0xF0, 0x3C, 0x1F, 0xDF,
  0x7E, 0xC0, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x41, 0xBF, 0x3C, 0x77,
  0x06, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x81, 0xF8, 0x37, 0xDE,
  0xDF, 0x00, 0x06, 0x1F, 0xDC, 0x2C, 0x06, 0x06, 0x03, 0x01, 0x80, 0xE0,
  0x30, 0x18, 0x07, 0xF1, 0xF8, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0xC6,
  0x7E, 0xDC, 0x7B, 0x03, 0x60, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x06, 0xC0,
  0xD8, 0x39, 0xDF, 0x1F, 0x60, 0x06, 0x07, 0xF0, 0xC7, 0x30, 0x66, 0x07,
  0x80, 0xFF, 0xFE, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x1F, 0xE1, 0xFC, 0x07,
  0x07, 0xC6, 0x03, 0x01, 0x81, 0xC3, 0xFC, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x00, 0x0C, 0x07, 0xED, 0xC7,
  0xB0, 0x36, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x6C, 0x0D, 0x83, 0x9C,
  0xF1, 0xF6, 0x00, 0xC0, 0x18, 0x03, 0x61, 0xCF, 0xF0, 0x10, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC6, 0x37, 0xEF, 0x1F, 0x83, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xC0, 0xFC, 0x3F, 0xFF,
  0xFF, 0xC0, 0x18, 0xC6, 0x00, 0x0C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63,
  0x18, 0xC6, 0x33, 0xF9, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x70,
  0x6C, 0x33, 0x18, 0xCC, 0x36, 0x0F, 0x83, 0xB0, 0xCE, 0x31, 0x8C, 0x33,
  0x06, 0xC1, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x06, 0x04, 0x37, 0xEF,
  0xEF, 0x1A, 0x1B, 0x83, 0x07, 0xC0, 0xC0, 0xF0, 0x30, 0x3C, 0x0C, 0x0F,
  0x03, 0x03, 0xC0, 0xC0, 0xF0, 0x30, 0x3C, 0x0C, 0x0F, 0x03, 0x03, 0xC0,
  0xC0, 0xC0, 0x06, 0x37, 0xEF, 0x1F, 0x83, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xC0, 0x06, 0x03, 0xF8, 0x70, 0xC6,
  0x06, 0x60, 0x6C, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x76, 0x06, 0x60, 0x63,
  0x9C, 0x1F, 0x80, 0x06, 0x1B, 0xF3, 0xC7, 0x70, 0x6C, 0x0F, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x1F, 0x83, 0x7D, 0xED, 0xF1, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x00, 0x04, 0x07, 0xED, 0xC7, 0xB0, 0x36,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x6C, 0x0D, 0x83, 0x9D, 0xF1, 0xF6,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x07, 0xBF, 0xC7,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x00, 0x0C, 0x3F, 0xF8,
  0x58, 0x0C, 0x03, 0x80, 0xF8, 0x1E, 0x03, 0x80, 0xC0, 0x7C, 0xEF, 0xE0,
  0x10, 0x30, 0x30, 0xFF, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30,
  0x30, 0x39, 0x1F, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x7F, 0x7D, 0xF9, 0xC0, 0x76, 0x06, 0x60, 0xE7, 0x0C,
  0x30, 0xC3, 0x18, 0x19, 0x81, 0x98, 0x1B, 0x00, 0xF0, 0x0F, 0x00, 0xE0,
  0xE0, 0xC0, 0xD8, 0x78, 0x66, 0x1E, 0x19, 0x87, 0x86, 0x33, 0x33, 0x0C,
  0xCC, 0xC3, 0x33, 0x30, 0xC8, 0x6C, 0x1E, 0x1E, 0x07, 0x87, 0x81, 0xC0,
  0xE0, 0x30, 0x38, 0x60, 0x73, 0x0C, 0x19, 0xC1, 0xD8, 0x0F, 0x00, 0x60,
  0x0F, 0x00, 0xF8, 0x19, 0x83, 0x0C, 0x70, 0xEE, 0x07, 0xE0, 0x76, 0x06,
  0x60, 0x63, 0x0C, 0x30, 0xC3, 0x1C, 0x19, 0x81, 0x98, 0x0B, 0x00, 0xF0,
  0x0F, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0xF8, 0x04, 0x00,
  0xFF, 0x81, 0xC0, 0xC0, 0xC0, 0xC0, 0x60, 0x60, 0x60, 0x70, 0x30, 0x3F,
  0xFF, 0xF0, 0x0E, 0x38, 0x61, 0x83, 0x06, 0x0C, 0x18, 0x71, 0x81, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x38, 0x30, 0x78, 0x10, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xE0, 0xE0, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x18, 0x0C, 0x71,
  0xC3, 0x06, 0x0C, 0x18, 0x30, 0x63, 0x84, 0x00, 0x30, 0x3F, 0xCE, 0x1F,
  0x80,
};

const GFXglyph NotoSans_Regular23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 3, 16, 6, 2, -16 },
  { 7, 7, 6, 9, 1, -16 },
  { 13, 13, 16, 15, 1, -16 },
  { 39, 11, 18, 13, 1, -17 },
  { 64, 17, 17, 19, 1, -17 },
  { 101, 16, 17, 17, 1, -17 },
  { 135, 3, 6, 5, 1, -16 },
  { 138, 5, 20, 7, 1, -16 },
  { 151, 5, 20, 7, 1, -16 },
  { 164, 11, 10, 13, 1, -17 },
  { 178, 11, 11, 13, 1, -14 },
  { 194, 3, 6, 6, 1, -3 },
  { 197, 5, 2, 7, 1, -7 },
  { 199, 3, 3, 6, 2, -3 },
  { 201, 8, 16, 9, 0, -16 },
  { 217, 11, 17, 13, 1, -17 },
  { 241, 6, 16, 13, 2, -16 },
  { 253, 11, 17, 13, 1, -17 },
  { 277, 11, 17, 13, 1, -17 },
  { 301, 13, 17, 13, 0, -17 },
  { 329, 11, 16, 13, 1, -16 },
  { 351, 11, 17, 13, 1, -17 },
  { 375, 11, 16, 13, 1, -16 },
  { 397, 11, 17, 13, 1, -17 },
  { 421, 11, 17, 13, 1, -17 },
  { 445, 3, 13, 6, 2, -13 },
  { 450, 3, 16, 6, 1, -13 },
  { 456, 11, 11, 13, 1, -14 },
  { 472, 11, 6, 13, 1, -11 },
  { 481, 11, 11, 13, 1, -14 },
  { 497, 9, 17, 10, 0, -17 },
  { 517, 18, 18, 21, 1, -16 },
  { 558, 15, 16, 15, 0, -16 },
  { 588, 12, 16, 15, 2, -16 },
  { 612, 13, 17, 15, 1, -17 },
  { 640, 13, 16, 17, 2, -16 },
  { 666, 9, 16, 13, 2, -16 },
  { 684, 9, 16, 12, 2, -16 },
  { 702, 14, 17, 17, 1, -17 },
  { 732, 13, 16, 17, 2, -16 },
  { 758, 6, 16, 8, 1, -16 },
  { 770, 6, 20, 6, -2, -16 },
  { 785, 12, 16, 14, 2, -16 },
  { 809, 9, 16, 12, 2, -16 },
  { 827, 17, 16, 21, 2, -16 },
  { 861, 13, 16, 17, 2, -16 },
  { 887, 16, 17, 18, 1, -17 },
  { 921, 11, 16, 14, 2, -16 },
  { 943, 16, 21, 18, 1, -17 },
  { 985, 12, 16, 14, 2, -16 },
  { 1009, 11, 17, 13, 1, -17 },
  { 1033, 13, 16, 13, 0, -16 },
  { 1059, 13, 16, 17, 2, -16 },
  { 1085, 14, 16, 14, 0, -16 },
  { 1113, 21, 16, 21, 0, -16 },
  { 1155, 13, 16, 13, 0, -16 },
  { 1181, 13, 16, 13, 0, -16 },
  { 1207, 11, 16, 13, 1, -16 },
  { 1229, 5, 20, 8, 2, -16 },
  { 1242, 8, 16, 9, 0, -16 },
  { 1258, 5, 20, 8, 1, -16 },
  { 1271, 11, 11, 13, 1, -17 },
  { 1287, 10, 2, 10, 0, 2 },
  { 1290, 5, 4, 6, 1, -18 },
  { 1293, 10, 13, 13, 1, -13 },
  { 1310, 11, 17, 14, 2, -17 },
  { 1334, 9, 13, 11, 1, -13 },
  { 1349, 11, 17, 14, 1, -17 },
  { 1373, 11, 13, 13, 1, -13 },
  { 1391, 9, 18, 8, 0, -18 },
  { 1412, 11, 19, 14, 1, -13 },
  { 1439, 10, 17, 14, 2, -17 },
  { 1461, 2, 17, 6, 2, -17 },
  { 1466, 5, 23, 6, -1, -17 },
  { 1481, 10, 17, 12, 2, -17 },
  { 1503, 2, 17, 6, 2, -17 },
  { 1508, 18, 13, 22, 2, -13 },
  { 1538, 10, 13, 14, 2, -13 },
  { 1555, 12, 13, 14, 1, -13 },
  { 1575, 11, 19, 14, 2, -13 },
  { 1602, 11, 19, 14, 1, -13 },
  { 1629, 7, 13, 10, 2, -13 },
  { 1641, 9, 13, 11, 1, -13 },
  { 1656, 8, 15, 8, 0, -15 },
  { 1671, 10, 12, 14, 2, -12 },
  { 1686, 12, 12, 12, 0, -12 },
  { 1704, 18, 12, 18, 0, -12 },
  { 1731, 12, 12, 12, 0, -12 },
  { 1749, 12, 18, 12, 0, -12 },
  { 1776, 9, 12, 11, 1, -12 },
  { 1790, 7, 20, 9, 1, -16 },
  { 1808, 2, 23, 13, 5, -17 },
  { 1814, 7, 20, 9, 1, -16 },
  { 1832, 11, 3, 13, 1, -10 },
};

const GFXfont NotoSans_Regular23pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Regular23pt7bBitmaps,
  (GFXglyph *)NotoSans_Regular23pt7bGlyphs,
  0x20, 0x7E, 31
};

#endif // _NOTOSANS_REGULAR23PT7B_H_
