#ifndef _NOTOSANS_REGULAR22PT7B_H_
#define _NOTOSANS_REGULAR22PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Regular.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Regular22pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0x3F, 0xEE, 0x89, 0x12, 0x24, 0x48, 0x80, 0x0C,
  0x60, 0x62, 0x03, 0x10, 0x10, 0x80, 0x8C, 0x7F, 0xFC, 0x63, 0x03, 0x10,
  0x10, 0x80, 0x8C, 0x3F, 0xFC, 0x63, 0x03, 0x10, 0x10, 0x80, 0x8C, 0x0C,
  0x60, 0x04, 0x01, 0x01, 0xF1, 0xFF, 0x64, 0x71, 0x0C, 0x41, 0xD0, 0x3E,
  0x03, 0xE0, 0x5C, 0x13, 0x04, 0xE1, 0x3F, 0xF9, 0xFC, 0x04, 0x01, 0x00,
  0x38, 0x08, 0x6C, 0x18, 0xC4, 0x30, 0xC4, 0x30, 0xC6, 0x60, 0xC6, 0x40,
  0xC4, 0xCC, 0xC4, 0x9E, 0x6D, 0xB3, 0x39, 0x23, 0x03, 0x21, 0x06, 0x21,
  0x06, 0x21, 0x0C, 0x33, 0x08, 0x33, 0x18, 0x1E, 0x1F, 0x00, 0x7F, 0x00,
  0xC6, 0x01, 0x86, 0x03, 0x18, 0x06, 0x70, 0x07, 0xC0, 0x0E, 0x00, 0x3E,
  0x0C, 0xC6, 0x1B, 0x06, 0x66, 0x06, 0xCC, 0x07, 0x1C, 0x0E, 0x1F, 0xF7,
  0x1F, 0xC7, 0xE9, 0x24, 0x80, 0x19, 0x8C, 0xC6, 0x63, 0x18, 0xC6, 0x31,
  0x8C, 0x63, 0x0C, 0x61, 0x8E, 0xC6, 0x18, 0xC3, 0x18, 0xC3, 0x18, 0xC6,
  0x31, 0x98, 0xC6, 0x63, 0x30, 0x0C, 0x03, 0x00, 0xC2, 0x31, 0xFF, 0xCF,
  0xC1, 0xE0, 0x4C, 0x33, 0x1C, 0x60, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0xFF,
  0xFF, 0xF0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x6D, 0xED, 0x00, 0xFF,
  0xC0, 0xFC, 0x03, 0x03, 0x06, 0x06, 0x04, 0x0C, 0x0C, 0x18, 0x18, 0x18,
  0x30, 0x30, 0x20, 0x60, 0x60, 0xC0, 0x1E, 0x07, 0xF1, 0x86, 0x30, 0x6C,
  0x0D, 0x81, 0xB0, 0x36, 0x02, 0xC0, 0x78, 0x0B, 0x03, 0x60, 0x66, 0x0C,
  0xC3, 0x8E, 0xE0, 0xF8, 0x0C, 0x77, 0xFB, 0x4C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x1E, 0x3F, 0xE4, 0x18, 0x03, 0x00, 0xC0, 0x30,
  0x18, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0F, 0xFF, 0xFF,
  0x3F, 0x3F, 0xE4, 0x1C, 0x03, 0x00, 0xC0, 0x30, 0x38, 0xF8, 0x3F, 0x80,
  0x70, 0x0C, 0x03, 0x00, 0xC0, 0x3E, 0x3B, 0xFC, 0x00, 0xC0, 0x1C, 0x03,
  0xC0, 0x2C, 0x06, 0xC0, 0xCC, 0x18, 0xC1, 0x8C, 0x30, 0xC6, 0x0C, 0x60,
  0xCF, 0xFF, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x7F, 0x9F, 0xE6, 0x01,
  0x80, 0x60, 0x18, 0x07, 0xE1, 0xFE, 0x01, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x3E, 0x79, 0xFC, 0x07, 0x83, 0xF0, 0xC0, 0x30, 0x06, 0x00, 0x80,
  0x33, 0xC6, 0xFC, 0xE0, 0xD8, 0x1B, 0x01, 0xE0, 0x36, 0x0C, 0xC1, 0x8E,
  0xE0, 0xF8, 0xFF, 0xFF, 0xFC, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0xC0,
  0x18, 0x06, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x01, 0x80,
  0x1F, 0x1F, 0xE6, 0x0D, 0x03, 0x60, 0xD8, 0x33, 0x38, 0x78, 0x3F, 0x18,
  0x7C, 0x0F, 0x01, 0xC0, 0x70, 0x37, 0x1C, 0xFC, 0x1E, 0x1F, 0xE6, 0x1B,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x83, 0x73, 0xCF, 0xB0, 0x0C, 0x03, 0x01,
  0x80, 0x64, 0x71, 0xF8, 0xFC, 0x00, 0x3F, 0x6D, 0x80, 0x00, 0x0D, 0xED,
  0xA0, 0x00, 0x40, 0x70, 0x70, 0x70, 0x70, 0x38, 0x07, 0x80, 0x3C, 0x03,
  0xC0, 0x30, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0xC0, 0x3C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x30, 0x78, 0x78, 0x78, 0x30, 0x00, 0x3E,
  0x7F, 0x90, 0x60, 0x30, 0x18, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x06, 0x03,
  0x00, 0x00, 0xC0, 0x60, 0x30, 0x01, 0xF0, 0x01, 0xFF, 0x01, 0xC0, 0x60,
  0xC0, 0x0C, 0x20, 0x01, 0x98, 0xFE, 0x24, 0x31, 0x89, 0x18, 0x62, 0xC4,
  0x18, 0xF1, 0x04, 0x2C, 0x41, 0x0B, 0x18, 0xE6, 0x43, 0xEF, 0x18, 0x61,
  0x86, 0x00, 0x00, 0xE0, 0x00, 0x1F, 0xF8, 0x01, 0xFC, 0x00, 0x03, 0x00,
  0x0C, 0x00, 0x78, 0x01, 0xE0, 0x0C, 0xC0, 0x33, 0x00, 0xCC, 0x06, 0x18,
  0x18, 0x60, 0x7F, 0xC3, 0xFF, 0x0C, 0x0C, 0x60, 0x19, 0x80, 0x66, 0x01,
  0xB0, 0x03, 0xFE, 0x1F, 0xFB, 0x03, 0x60, 0x7C, 0x07, 0x81, 0xB0, 0x37,
  0xF8, 0xFF, 0xD8, 0x1F, 0x01, 0xE0, 0x3C, 0x07, 0x81, 0xFF, 0xF7, 0xFC,
  0x07, 0xE1, 0xFF, 0x38, 0x17, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0C, 0x00,
  0xC0, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x70, 0x03, 0x80, 0x1F, 0xF0, 0xFF,
  0xFE, 0x07, 0xFE, 0x30, 0x39, 0x80, 0xEC, 0x03, 0x60, 0x1B, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0D, 0x80, 0x6C, 0x07, 0x60, 0x73, 0xFF,
  0x1F, 0xE0, 0xFF, 0xFF, 0xF0, 0x18, 0x0C, 0x06, 0x03, 0x01, 0xFF, 0xFF,
  0xE0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xFF, 0xE0, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0x07, 0xF0, 0xFF, 0xCE, 0x02, 0x60, 0x06, 0x00, 0x30, 0x03,
  0x80, 0x18, 0x00, 0xC0, 0xFE, 0x00, 0xD8, 0x06, 0xC0, 0x37, 0x01, 0x9C,
  0x0C, 0x7F, 0xE1, 0xFF, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xFF, 0xE3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC7, 0x3F, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x3F, 0xBC, 0xC0, 0x6C, 0x0C, 0xC1, 0x8C,
  0x30, 0xC7, 0x0C, 0xE0, 0xDC, 0x0D, 0x80, 0xFC, 0x0E, 0xE0, 0xC7, 0x0C,
  0x30, 0xC1, 0x8C, 0x1C, 0xC0, 0xEC, 0x07, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0xFF,
  0xFF, 0xE0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0B, 0xD8, 0x1B, 0xD8,
  0x1B, 0xD8, 0x13, 0xCC, 0x33, 0xCC, 0x33, 0xC6, 0x63, 0xC6, 0x63, 0xC6,
  0x43, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x83, 0xC1, 0x83, 0xE0, 0x1F, 0x00,
  0xFC, 0x07, 0xE0, 0x3D, 0x81, 0xE6, 0x0F, 0x30, 0x78, 0xC3, 0xC7, 0x1E,
  0x18, 0xF0, 0x67, 0x83, 0xBC, 0x0D, 0xE0, 0x3F, 0x01, 0xF8, 0x07, 0x07,
  0xC0, 0x3F, 0xE0, 0xE0, 0xE3, 0x80, 0x66, 0x00, 0xCC, 0x01, 0xF8, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x0D, 0x80, 0x1B, 0x00, 0x66, 0x00, 0xC6,
  0x03, 0x07, 0xFE, 0x07, 0xF0, 0xFE, 0x3F, 0xEC, 0x1F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x07, 0xFF, 0xBF, 0x8C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0x07, 0xC0, 0x3F, 0xE0, 0xE0, 0xE3, 0x80, 0x66, 0x00, 0xCC, 0x01,
  0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x0D, 0x80, 0x1B, 0x00, 0x66,
  0x00, 0xC6, 0x03, 0x07, 0xFE, 0x07, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0xFE, 0x1F, 0xF3, 0x07, 0x60, 0x6C, 0x0D, 0x81, 0xB0,
  0x36, 0x0C, 0xFF, 0x1F, 0xC3, 0x0C, 0x61, 0xCC, 0x19, 0x81, 0xB0, 0x36,
  0x03, 0x1F, 0x1F, 0xF6, 0x0B, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xF0, 0x0F,
  0x00, 0xE0, 0x0C, 0x03, 0x00, 0xC0, 0x3F, 0xFB, 0xFC, 0xFF, 0xFF, 0xFF,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x36, 0x06, 0x7F, 0xE1, 0xF8, 0xC0, 0x1E, 0x00,
  0xD8, 0x0C, 0xC0, 0x63, 0x03, 0x18, 0x30, 0xC1, 0x83, 0x0C, 0x18, 0xC0,
  0xC6, 0x03, 0x30, 0x1B, 0x00, 0xD8, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0xC0,
  0x60, 0x36, 0x07, 0x03, 0x60, 0xF0, 0x36, 0x0F, 0x06, 0x60, 0xD0, 0x63,
  0x09, 0x86, 0x31, 0x98, 0x63, 0x19, 0x8C, 0x31, 0x8C, 0xC1, 0xB0, 0xCC,
  0x1B, 0x0C, 0x81, 0xB0, 0x58, 0x1A, 0x07, 0x80, 0xA0, 0x78, 0x0E, 0x03,
  0x00, 0xE0, 0x30, 0xE0, 0x33, 0x01, 0x8C, 0x18, 0x71, 0x81, 0x8C, 0x06,
  0xC0, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x6C, 0x03, 0x60, 0x31, 0x83, 0x0E,
  0x18, 0x31, 0x80, 0xD8, 0x07, 0xC0, 0x36, 0x03, 0x60, 0x63, 0x06, 0x30,
  0xC1, 0x8C, 0x19, 0x80, 0xF8, 0x0F, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0xFF, 0xFF, 0xFC, 0x03, 0x00, 0xC0, 0x38,
  0x06, 0x01, 0x80, 0x70, 0x0C, 0x03, 0x00, 0xE0, 0x18, 0x06, 0x00, 0xC0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xF1, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63,
  0x18, 0xC6, 0x3E, 0xC0, 0x60, 0x60, 0x60, 0x30, 0x30, 0x10, 0x18, 0x18,
  0x0C, 0x0C, 0x0C, 0x06, 0x06, 0x02, 0x03, 0xFF, 0x11, 0x11, 0x11, 0x11,
  0x11, 0x11, 0x11, 0x11, 0xF0, 0x0C, 0x01, 0x80, 0x78, 0x0D, 0x03, 0x30,
  0x62, 0x08, 0x63, 0x04, 0x40, 0xD8, 0x0C, 0xFF, 0xC0, 0xC6, 0x31, 0x1F,
  0x1F, 0xE0, 0x18, 0x03, 0x00, 0xCF, 0xF7, 0x0F, 0x03, 0xC1, 0xF0, 0x7E,
  0x7D, 0xFB, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x37, 0xCF, 0xFB, 0x87,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3E, 0x1F, 0xCE, 0x9F, 0x00,
  0x1F, 0x9F, 0xD8, 0x0C, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xE0, 0x30, 0x1E,
  0xE3, 0xF0, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x3C, 0xCF, 0xFB,
  0x07, 0x60, 0xF8, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0xC0, 0xD8, 0x3B, 0x9F,
  0x3F, 0x60, 0x1F, 0x0F, 0xE6, 0x0D, 0x83, 0xC0, 0xFF, 0xFC, 0x03, 0x00,
  0x60, 0x18, 0x03, 0x9C, 0x7F, 0x0F, 0x8F, 0x86, 0x06, 0x03, 0x03, 0xF3,
  0xF8, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x00, 0x1E, 0x67, 0xFD, 0x83, 0xB0, 0x7C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xE0, 0x6C, 0x1D, 0xC7, 0x9F, 0xB0, 0x06, 0x00, 0xC0, 0x33, 0x0E, 0x7F,
  0x80, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x37, 0xCF, 0xFB, 0x87, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xC0, 0xF0,
  0xFF, 0xFF, 0xFF, 0x18, 0xC0, 0x01, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C,
  0x63, 0x18, 0xC7, 0x7F, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x6C, 0x33, 0x18, 0xCC, 0x36, 0x0F, 0x83, 0xE0, 0xCC, 0x31, 0x8C, 0x73,
  0x0C, 0xC1, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x9F, 0x1E, 0x7F, 0xFF,
  0xB8, 0x70, 0xF8, 0x38, 0x3C, 0x18, 0x1E, 0x0C, 0x0F, 0x06, 0x07, 0x83,
  0x03, 0xC1, 0x81, 0xE0, 0xC0, 0xF0, 0x60, 0x78, 0x30, 0x30, 0x9F, 0x3F,
  0xEE, 0x1F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0x1F, 0x07, 0xF9, 0x83, 0x30, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0x60, 0x6C, 0x18, 0xE7, 0x0F, 0xC0, 0xDF, 0x3F, 0xEE, 0x1F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF8, 0x7F, 0x3B, 0x7C, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x00, 0x1E, 0x67, 0xFD, 0x83, 0xB0, 0x7C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xE0, 0xEC, 0x1D, 0xCF, 0x9F, 0xB0, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x8F, 0xFF, 0x86, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x00, 0x3F, 0x3F, 0xB0, 0x18, 0x0E, 0x03, 0xE0, 0x7C, 0x06,
  0x01, 0x80, 0xB1, 0xDF, 0xC0, 0x10, 0x20, 0xC3, 0xFF, 0xE6, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x07, 0x47, 0x80, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x7E, 0x7D, 0xFB, 0xC0, 0x7C,
  0x0D, 0x83, 0x30, 0x63, 0x0C, 0x63, 0x0C, 0x60, 0xD8, 0x1B, 0x01, 0x60,
  0x38, 0x07, 0x00, 0xC0, 0xC1, 0xB0, 0xE0, 0xD8, 0x70, 0xCC, 0x2C, 0x66,
  0x36, 0x31, 0x99, 0x18, 0xC8, 0xD8, 0x6C, 0x6C, 0x16, 0x36, 0x0E, 0x0A,
  0x07, 0x07, 0x03, 0x83, 0x80, 0x60, 0x66, 0x18, 0xC6, 0x0C, 0xC0, 0xF0,
  0x1C, 0x03, 0x80, 0x78, 0x19, 0x86, 0x31, 0xC3, 0x70, 0x30, 0xC0, 0x6C,
  0x0D, 0x83, 0x30, 0x63, 0x0C, 0x63, 0x04, 0x60, 0xC8, 0x1B, 0x01, 0x60,
  0x38, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0xC0, 0xF0, 0x00, 0xFF, 0xFF,
  0x03, 0x06, 0x0C, 0x0C, 0x18, 0x30, 0x60, 0x60, 0xFF, 0xFF, 0x06, 0x3C,
  0x61, 0x83, 0x06, 0x0C, 0x18, 0x31, 0xC3, 0x81, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x30, 0x78, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x81, 0xC0, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x38, 0x1C, 0x79, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0xE3, 0x80, 0x7C, 0x73, 0xF8, 0x38,
};

const GFXglyph NotoSans_Regular22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 2, 16, 6, 2, -16 },
  { 5, 7, 6, 9, 1, -16 },
  { 11, 13, 16, 14, 1, -16 },
  { 37, 10, 18, 13, 1, -17 },
  { 60, 16, 16, 18, 1, -16 },
  { 92, 15, 16, 16, 1, -16 },
  { 122, 3, 6, 5, 1, -16 },
  { 125, 5, 19, 7, 1, -16 },
  { 137, 5, 19, 7, 1, -16 },
  { 149, 10, 10, 12, 1, -17 },
  { 162, 10, 11, 13, 1, -13 },
  { 176, 3, 6, 6, 1, -3 },
  { 179, 5, 2, 7, 1, -7 },
  { 181, 2, 3, 6, 2, -3 },
  { 182, 8, 16, 8, 0, -16 },
  { 198, 11, 16, 13, 1, -16 },
  { 220, 6, 16, 13, 2, -16 },
  { 232, 10, 16, 13, 1, -16 },
  { 252, 10, 16, 13, 1, -16 },
  { 272, 12, 16, 13, 0, -16 },
  { 296, 10, 16, 13, 1, -16 },
  { 316, 11, 16, 13, 1, -16 },
  { 338, 11, 16, 13, 1, -16 },
  { 360, 10, 16, 13, 1, -16 },
  { 380, 10, 16, 13, 1, -16 },
  { 400, 2, 12, 6, 2, -12 },
  { 403, 3, 15, 6, 1, -12 },
  { 409, 10, 10, 13, 1, -13 },
  { 422, 10, 6, 13, 1, -11 },
  { 430, 10, 10, 13, 1, -13 },
  { 443, 9, 16, 10, 0, -16 },
  { 461, 18, 18, 20, 1, -16 },
  { 502, 14, 16, 14, 0, -16 },
  { 530, 11, 16, 14, 2, -16 },
  { 552, 12, 16, 14, 1, -16 },
  { 576, 13, 16, 16, 2, -16 },
  { 602, 9, 16, 12, 2, -16 },
  { 620, 9, 16, 11, 2, -16 },
  { 638, 13, 16, 16, 1, -16 },
  { 664, 12, 16, 16, 2, -16 },
  { 688, 6, 16, 7, 1, -16 },
  { 700, 6, 20, 6, -2, -16 },
  { 715, 12, 16, 14, 2, -16 },
  { 739, 9, 16, 12, 2, -16 },
  { 757, 16, 16, 20, 2, -16 },
  { 789, 13, 16, 17, 2, -16 },
  { 815, 15, 16, 17, 1, -16 },
  { 845, 10, 16, 13, 2, -16 },
  { 865, 15, 20, 17, 1, -16 },
  { 903, 11, 16, 14, 2, -16 },
  { 925, 10, 16, 12, 1, -16 },
  { 945, 12, 16, 12, 0, -16 },
  { 969, 12, 16, 16, 2, -16 },
  { 993, 13, 16, 13, 0, -16 },
  { 1019, 20, 16, 20, 0, -16 },
  { 1059, 13, 16, 13, 0, -16 },
  { 1085, 12, 16, 12, 0, -16 },
  { 1109, 11, 16, 13, 1, -16 },
  { 1131, 5, 19, 7, 2, -16 },
  { 1143, 8, 16, 8, 0, -16 },
  { 1159, 4, 19, 7, 1, -16 },
  { 1169, 11, 10, 13, 1, -16 },
  { 1183, 10, 1, 10, 0, 2 },
  { 1185, 4, 4, 6, 1, -17 },
  { 1187, 10, 12, 12, 1, -12 },
  { 1202, 10, 17, 14, 2, -17 },
  { 1224, 9, 12, 11, 1, -12 },
  { 1238, 11, 17, 14, 1, -17 },
  { 1262, 10, 12, 12, 1, -12 },
  { 1277, 9, 17, 8, 0, -17 },
  { 1297, 11, 17, 14, 1, -12 },
  { 1321, 10, 17, 14, 2, -17 },
  { 1343, 2, 16, 6, 2, -16 },
  { 1347, 5, 21, 6, -1, -16 },
  { 1361, 10, 17, 12, 2, -17 },
  { 1383, 2, 17, 6, 2, -17 },
  { 1388, 17, 12, 21, 2, -12 },
  { 1414, 10, 12, 14, 2, -12 },
  { 1429, 11, 12, 13, 1, -12 },
  { 1446, 10, 17, 14, 2, -12 },
  { 1468, 11, 17, 14, 1, -12 },
  { 1492, 7, 12, 9, 2, -12 },
  { 1503, 9, 12, 11, 1, -12 },
  { 1517, 7, 15, 8, 0, -15 },
  { 1531, 10, 12, 14, 2, -12 },
  { 1546, 11, 12, 11, 0, -12 },
  { 1563, 17, 12, 17, 0, -12 },
  { 1589, 11, 12, 12, 0, -12 },
  { 1606, 11, 17, 11, 0, -12 },
  { 1630, 8, 12, 10, 1, -12 },
  { 1642, 7, 19, 8, 1, -16 },
  { 1659, 2, 22, 12, 5, -17 },
  { 1665, 7, 19, 8, 1, -16 },
  { 1682, 10, 3, 13, 1, -9 },
};

const GFXfont NotoSans_Regular22pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Regular22pt7bBitmaps,
  (GFXglyph *)NotoSans_Regular22pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _NOTOSANS_REGULAR22PT7B_H_
