#ifndef _NOTOSANS_REGULAR70PT7B_H_
#define _NOTOSANS_REGULAR70PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Regular.ttf
// Size: 70pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Regular70pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F,
  0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xF8, 0xFC, 0x7E, 0x1F, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3E, 0x1F, 0x0F, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x8F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0x8F, 0x00, 0xFC,
  0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8,
  0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3E, 0xFC, 0x07, 0xDF, 0x00, 0xFB, 0xE0,
  0x1F, 0x7C, 0x03, 0xE7, 0x80, 0x7C, 0xF0, 0x0F, 0x9E, 0x01, 0xF3, 0xC0,
  0x1E, 0x78, 0x03, 0xCF, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xF0, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0x80, 0x1E, 0x00, 0x00, 0x0F,
  0x80, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x1F,
  0x00, 0x00, 0x07, 0x80, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFB, 0xCF, 0xF8, 0x7F,
  0x83, 0xC0, 0x78, 0x7F, 0x03, 0xC0, 0x08, 0x7E, 0x03, 0xC0, 0x00, 0xFE,
  0x03, 0xC0, 0x00, 0xFC, 0x03, 0xC0, 0x00, 0xFC, 0x03, 0xC0, 0x00, 0xFC,
  0x03, 0xC0, 0x00, 0xFE, 0x03, 0xC0, 0x00, 0x7E, 0x03, 0xC0, 0x00, 0x7F,
  0x03, 0xC0, 0x00, 0x7F, 0xC3, 0xC0, 0x00, 0x3F, 0xFB, 0xC0, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xC7, 0xFE, 0x00,
  0x03, 0xC0, 0xFE, 0x00, 0x03, 0xC0, 0x7F, 0x00, 0x03, 0xC0, 0x3F, 0x00,
  0x03, 0xC0, 0x3F, 0x00, 0x03, 0xC0, 0x3F, 0x00, 0x03, 0xC0, 0x3F, 0x00,
  0x03, 0xC0, 0x3F, 0x00, 0x03, 0xC0, 0x7F, 0x80, 0x03, 0xC0, 0x7E, 0xF0,
  0x03, 0xC1, 0xFE, 0xFF, 0x03, 0xCF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xF8,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x7E, 0x00, 0x01,
  0xF0, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x1F,
  0x80, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x0F,
  0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0xF8, 0x03, 0xE0, 0x00,
  0x0F, 0xC0, 0x0F, 0x80, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0xF8, 0x07, 0xC0,
  0x00, 0x0F, 0xC0, 0x0F, 0x80, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0xF8,
  0x3F, 0x00, 0xE0, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0xFF, 0xC0, 0x7C, 0x01,
  0xF8, 0x7E, 0x1F, 0xFE, 0x07, 0xC0, 0x1F, 0x07, 0xC3, 0xFF, 0xF0, 0x3E,
  0x01, 0xF0, 0xFC, 0x7F, 0xFF, 0x83, 0xE0, 0x3F, 0x0F, 0x87, 0xE0, 0xFC,
  0x3F, 0x07, 0xE1, 0xF8, 0xFC, 0x07, 0xC1, 0xFF, 0xFE, 0x1F, 0x0F, 0x80,
  0x7E, 0x0F, 0xFF, 0xC3, 0xE0, 0xF8, 0x03, 0xE0, 0x7F, 0xF8, 0x7E, 0x0F,
  0x80, 0x3E, 0x03, 0xFF, 0x07, 0xC1, 0xF8, 0x03, 0xE0, 0x07, 0x00, 0xFC,
  0x1F, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x81, 0xF0, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x1F, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x01, 0xF0, 0x01, 0xF0, 0x00,
  0x03, 0xF0, 0x1F, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x1F, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x01, 0xF0, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x03, 0xF0, 0x00,
  0xF8, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x07, 0xE0,
  0x00, 0xF8, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x0F,
  0x80, 0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x1F, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x00,
  0x01, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x00, 0x07,
  0xF0, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x0F, 0xC0, 0x7F, 0xEF, 0xF0, 0x00, 0x3F, 0x81, 0xFF, 0x0F,
  0xF0, 0x00, 0x7E, 0x07, 0xFC, 0x0F, 0xF0, 0x00, 0xFC, 0x0F, 0xE0, 0x0F,
  0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xF0, 0x07, 0xE0, 0x7F, 0x00, 0x0F,
  0xF0, 0x0F, 0xC1, 0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0x83, 0xF8, 0x00, 0x0F,
  0xF0, 0x7E, 0x07, 0xE0, 0x00, 0x0F, 0xF1, 0xFC, 0x0F, 0xC0, 0x00, 0x0F,
  0xF7, 0xF0, 0x1F, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x3F, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x7E, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0xF0, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x07, 0xF8, 0x00, 0x0F, 0xFF,
  0xF0, 0x07, 0xFC, 0x00, 0xFF, 0xEF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x8F,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xEF, 0xBE, 0x79, 0xE7, 0x9E, 0x79, 0xE0, 0x00, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x07,
  0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x1F,
  0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x1F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x03,
  0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x0F,
  0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x01,
  0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xFC, 0x01,
  0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x0F,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x40, 0x01, 0xF0, 0x00, 0x9E, 0x00, 0xF0, 0x03, 0xCF, 0xE0,
  0x78, 0x1F, 0xEF, 0xFF, 0x3C, 0x7F, 0xF7, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x03, 0xE7, 0xC0, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x03, 0xF8, 0xFC, 0x00,
  0x01, 0xF8, 0x7F, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x01, 0xFC, 0x0F, 0xE0,
  0x00, 0xFE, 0x03, 0xF8, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x7E,
  0x00, 0x0F, 0x00, 0x3C, 0x00, 0x01, 0x80, 0x08, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F,
  0x8F, 0xE3, 0xF8, 0xFC, 0x3F, 0x0F, 0xC7, 0xE1, 0xF8, 0x7C, 0x1F, 0x0F,
  0xC3, 0xE0, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x7E, 0x3F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFE,
  0x3C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0x80,
  0x7F, 0x80, 0x3F, 0x80, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0xFC, 0x07, 0xF0,
  0x00, 0x3F, 0x81, 0xF8, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x01, 0xFC, 0x3F,
  0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x03, 0xF1,
  0xF8, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x07,
  0xE7, 0xE0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00,
  0x1F, 0x9F, 0x80, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xDF,
  0x80, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x7E,
  0x7E, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x01,
  0xF9, 0xF8, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x3F, 0x8F, 0xC0, 0x00,
  0x0F, 0xE3, 0xF0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0xFC, 0x3F, 0x80,
  0x00, 0x7F, 0x07, 0xE0, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x0F, 0xE0, 0x3F,
  0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x01, 0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x0F,
  0xFE, 0x03, 0xFF, 0xC1, 0xFF, 0xF8, 0x7F, 0xBF, 0x1F, 0xE7, 0xE7, 0xF8,
  0xFF, 0xFE, 0x1F, 0xBF, 0x03, 0xF3, 0xC0, 0x7E, 0x30, 0x0F, 0xC4, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0xC1, 0xFF, 0x80, 0x1F, 0xF0, 0x7E, 0x00, 0x07, 0xF8, 0x1E, 0x00, 0x01,
  0xFC, 0x04, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0x00, 0x1F, 0xF0,
  0x7C, 0x00, 0x03, 0xF8, 0x18, 0x00, 0x00, 0xFE, 0x08, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0xD0, 0x00, 0x00, 0x1F, 0xEE, 0x00, 0x00, 0x1F,
  0xE7, 0xE0, 0x00, 0x3F, 0xE3, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x01, 0xF7, 0xC0, 0x00, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x00, 0x3E, 0x7C,
  0x00, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x00,
  0x3F, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0xFC, 0x00, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x07, 0x80, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x08, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x80, 0x00, 0x01, 0xFC, 0xE0, 0x00, 0x07, 0xF8,
  0xFC, 0x00, 0x1F, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xC3, 0xC0, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x7F, 0xF0, 0x07, 0xE0, 0xFF, 0xFE, 0x03, 0xF1,
  0xFF, 0xFF, 0x81, 0xF9, 0xFF, 0xFF, 0xF0, 0xFD, 0xFF, 0xFF, 0xF8, 0x7F,
  0xF8, 0x01, 0xFE, 0x3F, 0xF0, 0x00, 0x7F, 0x9F, 0xF0, 0x00, 0x1F, 0xCF,
  0xF0, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x00, 0xFD,
  0xF8, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01,
  0xFB, 0xF0, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00,
  0x7E, 0x7F, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3F, 0x8F, 0xE0, 0x00,
  0x1F, 0x83, 0xF8, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x1F, 0xC0, 0x7F, 0x80,
  0x3F, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0x8F,
  0xFF, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0x00, 0x03, 0xF8, 0x1F, 0x80,
  0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0x7E,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x0F,
  0xE0, 0x07, 0xFC, 0x07, 0xF0, 0x00, 0xFF, 0xC7, 0xF8, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07,
  0xFC, 0x1F, 0xF8, 0x03, 0xFC, 0x01, 0xFF, 0x01, 0xFC, 0x00, 0x1F, 0xE0,
  0xFE, 0x00, 0x03, 0xFC, 0x3F, 0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x0F,
  0xE7, 0xE0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00,
  0x1F, 0xBF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x7E, 0x7E, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x07, 0xE7, 0xF0,
  0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0x7F, 0x0F,
  0xF8, 0x00, 0x7F, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xE0, 0x3F, 0x80,
  0x07, 0xF8, 0x3F, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7F, 0x1F, 0xC0,
  0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x03, 0xF3, 0xF0,
  0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x01, 0xFD,
  0xFC, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFF, 0x3F, 0x80, 0x00, 0xFF,
  0x9F, 0xE0, 0x00, 0xFF, 0xC7, 0xF8, 0x01, 0xFF, 0xE1, 0xFF, 0xFF, 0xFB,
  0xF0, 0x7F, 0xFF, 0xF9, 0xF8, 0x1F, 0xFF, 0xF8, 0xFC, 0x07, 0xFF, 0xF8,
  0x7E, 0x00, 0xFF, 0xE0, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x3C, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x08, 0x3F, 0x1F, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x7F, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x7F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFC,
  0x78, 0x01, 0x00, 0xFC, 0x1F, 0xE1, 0xFE, 0x1F, 0xF1, 0xFF, 0x1F, 0xE1,
  0xFE, 0x0F, 0xE0, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x1F, 0xE1, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x83,
  0xF0, 0x3F, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0x78, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x7F,
  0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xFC, 0x7E, 0x00, 0x3F, 0xC3, 0x80, 0x01, 0xFE, 0x20,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x03, 0xE0, 0x00,
  0x7F, 0xFE, 0x00, 0x3E, 0x0F, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x7C, 0x1F,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x7C, 0x7E, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0xF8, 0xF8, 0x00, 0xFF, 0x01, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xF8, 0x01,
  0xF0, 0x03, 0xE7, 0xE0, 0x0F, 0xE0, 0x03, 0xE0, 0x03, 0xEF, 0x80, 0x1F,
  0x80, 0x07, 0xC0, 0x07, 0xDF, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x0F, 0xBE,
  0x00, 0xFC, 0x00, 0x1F, 0x00, 0x1F, 0xFC, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x3F, 0xF0, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x7F, 0xE0, 0x0F, 0xC0, 0x00,
  0xF8, 0x00, 0xFF, 0xC0, 0x1F, 0x80, 0x01, 0xF0, 0x01, 0xFF, 0x80, 0x3F,
  0x00, 0x03, 0xE0, 0x03, 0xFF, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x07, 0xFE,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x1F, 0x7C, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x3E, 0xF8, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x7D, 0xF0, 0x07, 0xE0, 0x01,
  0xFC, 0x01, 0xF3, 0xE0, 0x07, 0xC0, 0x03, 0xF8, 0x03, 0xE7, 0xE0, 0x0F,
  0xC0, 0x0F, 0xF0, 0x0F, 0xC7, 0xC0, 0x1F, 0xC0, 0x1F, 0xF0, 0x1F, 0x0F,
  0x80, 0x1F, 0xC0, 0xF9, 0xF0, 0xFC, 0x1F, 0x00, 0x1F, 0xFF, 0xF3, 0xFF,
  0xF8, 0x3F, 0x00, 0x1F, 0xFF, 0xC3, 0xFF, 0xE0, 0x3E, 0x00, 0x1F, 0xFF,
  0x03, 0xFF, 0x80, 0x7C, 0x00, 0x1F, 0xF8, 0x03, 0xFC, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xFF, 0xF8, 0x7F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x00, 0x00, 0xFD, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x3E, 0x00, 0x00,
  0x00, 0x03, 0xF1, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x00,
  0x01, 0xF8, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x3F, 0x00, 0x00, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x0F,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x00, 0x00,
  0xFC, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x3F, 0x00, 0x00, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x1F,
  0x80, 0x00, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x8F, 0xC0,
  0x00, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF7, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFF, 0xC1, 0xF8, 0x03, 0xFF, 0xFC, 0x3F, 0x00, 0x00, 0xFF, 0xC7, 0xE0,
  0x00, 0x07, 0xF8, 0xFC, 0x00, 0x00, 0x7F, 0x9F, 0x80, 0x00, 0x07, 0xF3,
  0xF0, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x01,
  0xF9, 0xF8, 0x00, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0x0F, 0xE7, 0xE0, 0x00,
  0x01, 0xFC, 0xFC, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x07, 0xE3, 0xF0,
  0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x3F, 0xC1,
  0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0xF8, 0x7E, 0x00, 0x00, 0xFF, 0x8F, 0xC0, 0x00, 0x07, 0xF9, 0xF8,
  0x00, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x00, 0xFE,
  0xFC, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFE, 0xFC,
  0x00, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x07, 0xFB, 0xF0, 0x00, 0x01, 0xFE,
  0x7E, 0x00, 0x00, 0xFF, 0xCF, 0xC0, 0x01, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFE, 0x00, 0x3F, 0x80, 0xFF, 0xC0, 0x00, 0x1C, 0x03, 0xFE, 0x00,
  0x00, 0x10, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x10, 0x07, 0xFF, 0x80, 0x07, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0xFC, 0x00, 0x03, 0xFF,
  0x80, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x00,
  0x01, 0xFC, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xCF, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x0F, 0xF0, 0x07, 0xFE, 0x00, 0x00, 0x78, 0x03, 0xFE, 0x00, 0x00,
  0x02, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x00, 0x07,
  0xF7, 0xF0, 0x00, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x00, 0x07, 0xF3, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x00,
  0x1F, 0xC3, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x00, 0x01, 0xFC,
  0x1F, 0xF8, 0x00, 0x00, 0x7F, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x7F,
  0xF8, 0x00, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFC, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x03, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x30, 0x7F,
  0xCF, 0xFF, 0xE3, 0xFF, 0xF8, 0xFF, 0xFC, 0x3F, 0xFC, 0x0F, 0xFC, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x00,
  0x3F, 0x8F, 0xC0, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x00, 0xFF, 0x0F, 0xC0,
  0x00, 0x1F, 0xE0, 0xFC, 0x00, 0x03, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x80,
  0xFC, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x1F,
  0xC0, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xC0,
  0x0F, 0xE0, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x00,
  0xFC, 0x07, 0xF8, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x00, 0xFC, 0x0F, 0xE0,
  0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0x0F, 0xC7,
  0xF0, 0x00, 0x00, 0xFC, 0xFF, 0x00, 0x00, 0x0F, 0xDF, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x0F, 0xFC, 0xFF, 0x00, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0x0F, 0xE0,
  0x3F, 0x80, 0x00, 0xFC, 0x03, 0xFC, 0x00, 0x0F, 0xC0, 0x1F, 0xE0, 0x00,
  0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xC0, 0x03, 0xFC, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x0F, 0xC0,
  0x00, 0xFE, 0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x0F, 0xC0, 0x00, 0x7F, 0x80,
  0xFC, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x01,
  0xFE, 0x0F, 0xC0, 0x00, 0x0F, 0xF0, 0xFC, 0x00, 0x00, 0x7F, 0x0F, 0xC0,
  0x00, 0x03, 0xF8, 0xFC, 0x00, 0x00, 0x3F, 0xCF, 0xC0, 0x00, 0x01, 0xFE,
  0xFC, 0x00, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xBF, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xEF, 0xC0, 0x00, 0x00, 0x0F, 0xBF, 0xFB, 0xF0, 0x00, 0x00, 0x07, 0xEF,
  0xFE, 0x7E, 0x00, 0x00, 0x01, 0xF3, 0xFF, 0x9F, 0x80, 0x00, 0x00, 0xFC,
  0xFF, 0xE7, 0xE0, 0x00, 0x00, 0x3F, 0x3F, 0xF8, 0xFC, 0x00, 0x00, 0x0F,
  0x8F, 0xFE, 0x3F, 0x00, 0x00, 0x07, 0xE3, 0xFF, 0xC7, 0xE0, 0x00, 0x01,
  0xF8, 0xFF, 0xF1, 0xF8, 0x00, 0x00, 0x7C, 0x7F, 0xFC, 0x7E, 0x00, 0x00,
  0x3F, 0x1F, 0xFF, 0x0F, 0xC0, 0x00, 0x0F, 0x87, 0xFF, 0xC3, 0xF0, 0x00,
  0x07, 0xE1, 0xFF, 0xF0, 0xFC, 0x00, 0x01, 0xF8, 0x7F, 0xFC, 0x1F, 0x80,
  0x00, 0x7C, 0x1F, 0xFF, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xFF, 0xC0, 0xFC,
  0x00, 0x0F, 0xC1, 0xFF, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0x7F, 0xFC, 0x0F,
  0xC0, 0x01, 0xF8, 0x1F, 0xFF, 0x01, 0xF8, 0x00, 0x7C, 0x07, 0xFF, 0xC0,
  0x7E, 0x00, 0x3F, 0x01, 0xFF, 0xF0, 0x1F, 0x80, 0x0F, 0xC0, 0x7F, 0xFC,
  0x03, 0xF0, 0x03, 0xE0, 0x1F, 0xFF, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xFF,
  0xC0, 0x1F, 0x80, 0x7C, 0x01, 0xFF, 0xF0, 0x07, 0xE0, 0x3F, 0x00, 0x7F,
  0xFC, 0x01, 0xF8, 0x0F, 0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0x03, 0xE0, 0x07,
  0xFF, 0xC0, 0x0F, 0xC1, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xF0, 0x7E, 0x00,
  0x7F, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0x8F, 0xC0,
  0x07, 0xFF, 0xC0, 0x03, 0xF3, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFD, 0xF8,
  0x00, 0x7F, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF,
  0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F,
  0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xF7, 0xF0, 0x00, 0x00, 0x7F, 0xE7, 0xF0, 0x00, 0x00, 0xFF, 0xCF,
  0xE0, 0x00, 0x01, 0xFF, 0x8F, 0xE0, 0x00, 0x03, 0xFF, 0x0F, 0xE0, 0x00,
  0x07, 0xFE, 0x1F, 0xC0, 0x00, 0x0F, 0xFC, 0x1F, 0xC0, 0x00, 0x1F, 0xF8,
  0x3F, 0xC0, 0x00, 0x3F, 0xF0, 0x3F, 0x80, 0x00, 0x7F, 0xF0, 0x3F, 0x80,
  0x00, 0xFF, 0xE0, 0x7F, 0x80, 0x01, 0xFF, 0xC0, 0x7F, 0x00, 0x03, 0xFF,
  0x80, 0x7F, 0x00, 0x07, 0xFF, 0x00, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0xFE,
  0x00, 0x1F, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0xF8, 0x01, 0xFE, 0x00, 0x7F,
  0xF0, 0x01, 0xFC, 0x00, 0xFF, 0xE0, 0x01, 0xFC, 0x01, 0xFF, 0xC0, 0x03,
  0xF8, 0x03, 0xFF, 0x80, 0x03, 0xF8, 0x07, 0xFF, 0x00, 0x07, 0xF8, 0x0F,
  0xFE, 0x00, 0x07, 0xF0, 0x1F, 0xFC, 0x00, 0x07, 0xF0, 0x3F, 0xF8, 0x00,
  0x0F, 0xF0, 0x7F, 0xF0, 0x00, 0x0F, 0xE0, 0xFF, 0xE0, 0x00, 0x0F, 0xE1,
  0xFF, 0xC0, 0x00, 0x1F, 0xE3, 0xFF, 0x80, 0x00, 0x1F, 0xC7, 0xFF, 0x00,
  0x00, 0x1F, 0xCF, 0xFE, 0x00, 0x00, 0x3F, 0xDF, 0xFC, 0x00, 0x00, 0x3F,
  0xBF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x8F,
  0xE0, 0x00, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF9, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xDF, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xF7, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0x00, 0x00, 0xFE,
  0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE3,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x05, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x03, 0xFF, 0xF8, 0xFC, 0x00, 0x0F, 0xFC,
  0xFC, 0x00, 0x03, 0xFC, 0xFC, 0x00, 0x01, 0xFE, 0xFC, 0x00, 0x00, 0xFE,
  0xFC, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7E,
  0xFC, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x01, 0xFC,
  0xFC, 0x00, 0x03, 0xFC, 0xFC, 0x00, 0x07, 0xF8, 0xFC, 0x00, 0x3F, 0xF8,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xC3, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x00, 0x00, 0xFE,
  0x7F, 0x00, 0x00, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE7,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x7E,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0xDF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x00,
  0x01, 0xFD, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0x9F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x00, 0x03,
  0xF8, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x07,
  0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x05,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0x00, 0x03,
  0xFF, 0x07, 0xE0, 0x00, 0x1F, 0xE0, 0xFC, 0x00, 0x01, 0xFE, 0x1F, 0x80,
  0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x3F, 0x8F,
  0xC0, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0x1F,
  0xC7, 0xE0, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x00, 0x7F, 0x1F, 0x80, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x7F, 0x0F, 0xC0,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x01, 0xFE, 0x07,
  0xE0, 0x01, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xE0,
  0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x07, 0xF0, 0x03,
  0xF0, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0xFE,
  0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00,
  0x1F, 0xC0, 0xFC, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x83, 0xF0,
  0x00, 0x03, 0xF8, 0x7E, 0x00, 0x00, 0x7F, 0x8F, 0xC0, 0x00, 0x07, 0xF1,
  0xF8, 0x00, 0x00, 0xFF, 0x3F, 0x00, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x00,
  0xFE, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x0F, 0xFC, 0x00,
  0xFE, 0x3F, 0xC0, 0x00, 0x38, 0x7F, 0x00, 0x00, 0x10, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF4, 0x00, 0x00, 0x0F,
  0xEE, 0x00, 0x00, 0x7F, 0x9F, 0xC0, 0x03, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x00, 0x0F,
  0xCF, 0xC0, 0x00, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0x00, 0x7F, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xDF, 0x80, 0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0x03,
  0xF9, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0xCF, 0xC0, 0x00, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xCF,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFC, 0x3F,
  0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0xFD, 0xF0,
  0x00, 0x07, 0xF0, 0x7E, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x0F, 0xC0, 0xFC,
  0x00, 0x03, 0xE7, 0xE0, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x0F, 0xCF, 0xC0,
  0x00, 0x7F, 0x03, 0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0xFE, 0x03, 0xF0,
  0x00, 0x3F, 0x1F, 0x80, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x7C, 0x3F, 0x00,
  0x03, 0xF0, 0x0F, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xE0, 0x1F, 0xC0,
  0x03, 0xF0, 0x7E, 0x00, 0x1F, 0xC0, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x7E, 0x00, 0x7F, 0x00,
  0x3F, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x03, 0xF0, 0x03,
  0xF0, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x3F,
  0x80, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0x07, 0xE0, 0x3F,
  0x00, 0x1F, 0x80, 0xFC, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x3F, 0x01, 0xF8,
  0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0xFC, 0x1F, 0x80,
  0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFE, 0x1F, 0x80,
  0x03, 0xF0, 0xFE, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x03, 0xF1, 0xF8, 0x00,
  0x01, 0xF8, 0xFC, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x03, 0xF1, 0xF8, 0x00,
  0x0F, 0xC7, 0xE0, 0x00, 0x07, 0xF3, 0xE0, 0x00, 0x0F, 0x9F, 0xC0, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00,
  0x3F, 0x7E, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00,
  0x1F, 0x7C, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00,
  0xFB, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x07, 0xE0,
  0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x83, 0xF0, 0x00, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x00, 0x03, 0xF1,
  0xF8, 0x00, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xBF, 0x80, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x00, 0x1F, 0x87,
  0xF0, 0x00, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x7E, 0x00,
  0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x07,
  0xE0, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x01, 0xF8, 0x00, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x00, 0x01, 0xFC,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x00, 0x1F,
  0x83, 0xF8, 0x00, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x00, 0x0F, 0xC7, 0xF0,
  0x00, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7D, 0xF0, 0x00,
  0x00, 0x3E, 0x7E, 0x00, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x07, 0xC3, 0xF0,
  0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3E, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x01, 0xF0,
  0x07, 0xE0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x07, 0xC0, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x3E, 0x00,
  0xF8, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x00,
  0x7C, 0x7C, 0x00, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x03, 0xEF, 0xC0, 0x00,
  0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFE, 0x03,
  0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0x00, 0x1F, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0x80, 0xFE, 0x00, 0xFF, 0x00, 0xE0, 0x00, 0xFF, 0x01, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0xF1, 0xFF, 0x80, 0x07, 0xE7, 0xF8, 0x00, 0x0F, 0xDF, 0xE0, 0x00, 0x1F,
  0xBF, 0x80, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xBF, 0x80, 0x03, 0xFF, 0x7F,
  0x80, 0x1F, 0xFE, 0x7F, 0xE1, 0xFE, 0xFC, 0xFF, 0xFF, 0xF9, 0xF8, 0xFF,
  0xFF, 0xE1, 0xF0, 0xFF, 0xFF, 0x83, 0xE0, 0x7F, 0xFC, 0x07, 0xC0, 0x0F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x0F, 0xFC, 0x00, 0xFC, 0x3F, 0xFF,
  0x80, 0x7E, 0x3F, 0xFF, 0xF0, 0x3F, 0x3F, 0xFF, 0xFC, 0x1F, 0xBF, 0xFF,
  0xFF, 0x0F, 0xFF, 0x80, 0xFF, 0xC7, 0xFE, 0x00, 0x1F, 0xE3, 0xFE, 0x00,
  0x07, 0xF9, 0xFE, 0x00, 0x01, 0xFC, 0xFF, 0x00, 0x00, 0x7F, 0x7F, 0x00,
  0x00, 0x3F, 0xBF, 0x80, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x0F,
  0xDF, 0xE0, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x07, 0xE7, 0xFC, 0x00, 0x07,
  0xF3, 0xFF, 0x00, 0x07, 0xF9, 0xFF, 0xC0, 0x07, 0xF8, 0xFF, 0xFF, 0x3F,
  0xF8, 0x7C, 0xFF, 0xFF, 0xF8, 0x3E, 0x3F, 0xFF, 0xF8, 0x1F, 0x07, 0xFF,
  0xF8, 0x0F, 0x81, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFC, 0x1F, 0xF8, 0x1F, 0x87, 0xFC, 0x00, 0x30, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x01, 0x1F, 0xF0,
  0x01, 0xE1, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x7F, 0xE0, 0x3F, 0x00, 0xFF, 0xFE, 0x1F, 0x81, 0xFF, 0xFF, 0x8F,
  0xC1, 0xFF, 0xFF, 0xE7, 0xE1, 0xFF, 0xFF, 0xFB, 0xF1, 0xFF, 0x80, 0xFF,
  0xF8, 0xFF, 0x00, 0x0F, 0xFC, 0xFF, 0x00, 0x03, 0xFE, 0x7F, 0x00, 0x00,
  0xFF, 0x7F, 0x00, 0x00, 0x7F, 0xBF, 0x80, 0x00, 0x1F, 0xDF, 0x80, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xBF,
  0x00, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x07, 0xF7,
  0xF0, 0x00, 0x07, 0xF9, 0xFC, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0x07, 0xFE,
  0x3F, 0xE0, 0x07, 0xFF, 0x0F, 0xFE, 0x7F, 0xFF, 0x83, 0xFF, 0xFF, 0xEF,
  0xC0, 0xFF, 0xFF, 0xE3, 0xE0, 0x3F, 0xFF, 0xC1, 0xF0, 0x07, 0xFF, 0xC0,
  0xF8, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x01,
  0xFC, 0x3F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00,
  0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x04, 0x0F, 0xF8, 0x00, 0x3C, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x20, 0x00, 0x01, 0xFF, 0xE0,
  0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF,
  0xE0, 0x0F, 0xE0, 0x08, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFC, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x0F, 0x80, 0x7F, 0xFF, 0x07, 0xC0, 0x7F, 0xFF,
  0xC3, 0xE0, 0xFF, 0xFF, 0xF1, 0xF0, 0xFF, 0xFF, 0xFC, 0xF8, 0x7F, 0xC0,
  0x7F, 0xFC, 0x7F, 0x80, 0x0F, 0xFE, 0x7F, 0x80, 0x01, 0xFF, 0x3F, 0x80,
  0x00, 0x7F, 0xBF, 0x80, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0x0F, 0xEF, 0xC0,
  0x00, 0x07, 0xF7, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F,
  0xDF, 0x80, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x03,
  0xF9, 0xF8, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x01, 0xFE, 0x3F, 0x80, 0x01,
  0xFF, 0x1F, 0xE0, 0x03, 0xFF, 0x87, 0xFF, 0x0F, 0xFF, 0xC1, 0xFF, 0xFF,
  0xF7, 0xE0, 0x7F, 0xFF, 0xF3, 0xF0, 0x1F, 0xFF, 0xF1, 0xF8, 0x03, 0xFF,
  0xE0, 0xFC, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x20, 0x00, 0x01, 0xFC, 0x1E, 0x00, 0x03, 0xFE, 0x0F,
  0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x07, 0xFE, 0x00, 0xFC, 0x1F, 0xFF, 0xC0, 0xFC, 0x7F, 0xFF, 0xE0,
  0xFC, 0xFF, 0xFF, 0xF8, 0xFD, 0xFF, 0xFF, 0xF8, 0xFF, 0xF8, 0x07, 0xFC,
  0xFF, 0xE0, 0x01, 0xFC, 0xFF, 0x80, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0xFE,
  0xFF, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x7E,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0x08, 0x7E, 0x7E, 0xFF,
  0xFF, 0x7F, 0x7E, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x00, 0x04, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xF0, 0x07, 0xF8, 0x01,
  0xFC, 0x00, 0xFC, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF8,
  0x03, 0xF9, 0xC7, 0xFC, 0xFF, 0xFE, 0x7F, 0xFE, 0x3F, 0xFE, 0x1F, 0xFE,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x01, 0xFE, 0xFC, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x0F,
  0xE3, 0xF0, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0xFE, 0x0F, 0xC0, 0x03, 0xF8,
  0x1F, 0x80, 0x0F, 0xE0, 0x3F, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0xFE, 0x00,
  0xFC, 0x03, 0xF8, 0x01, 0xF8, 0x0F, 0xE0, 0x03, 0xF0, 0x3F, 0x80, 0x07,
  0xE0, 0xFE, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x3F,
  0x1F, 0x80, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0xFD, 0xFE, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xF9,
  0xFC, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x7E, 0x03,
  0xFC, 0x00, 0xFC, 0x03, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x03,
  0xF8, 0x07, 0xE0, 0x07, 0xF8, 0x0F, 0xC0, 0x07, 0xF0, 0x1F, 0x80, 0x07,
  0xF0, 0x3F, 0x00, 0x0F, 0xF0, 0x7E, 0x00, 0x0F, 0xF0, 0xFC, 0x00, 0x0F,
  0xE1, 0xF8, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x1F, 0xE7, 0xE0, 0x00, 0x1F,
  0xEF, 0xC0, 0x00, 0x1F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0x07, 0xFC,
  0x00, 0x0F, 0xFC, 0x03, 0xE0, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x0F, 0x87,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x3E, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8,
  0xFD, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF3, 0xFF, 0xC0, 0x7F, 0xDF, 0xC0,
  0x7F, 0xCF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xBF, 0xE0, 0x00, 0xFF,
  0xE0, 0x00, 0xFE, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFB, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0xF8, 0x07, 0xFF, 0x00, 0xF8, 0x1F, 0xFF, 0xC0, 0xF8, 0x7F,
  0xFF, 0xF0, 0xF8, 0xFF, 0xFF, 0xF8, 0xFD, 0xFF, 0xFF, 0xF8, 0xFF, 0xF8,
  0x07, 0xFC, 0xFF, 0xC0, 0x01, 0xFC, 0xFF, 0x80, 0x00, 0xFE, 0xFF, 0x00,
  0x00, 0xFE, 0xFF, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x7E, 0xFE, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xF0, 0x0F, 0xF8,
  0x07, 0xF8, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x00,
  0x7F, 0x07, 0xE0, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x00, 0x7E, 0x3F, 0x00,
  0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0x1F, 0xBF,
  0x80, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x0F,
  0xDF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xBF, 0x00,
  0x00, 0x03, 0xF7, 0xF0, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x0F, 0xCF,
  0xC0, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0x7F, 0x07, 0xE0, 0x00,
  0x1F, 0xC0, 0xFF, 0x00, 0x07, 0xF0, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0xFF,
  0xE7, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF8, 0x07, 0xFE, 0x00, 0x7C, 0x1F, 0xFF, 0xC0, 0x3E, 0x1F, 0xFF,
  0xF8, 0x1F, 0x1F, 0xFF, 0xFE, 0x0F, 0xDF, 0xFF, 0xFF, 0x87, 0xFF, 0xC0,
  0x7F, 0xE3, 0xFF, 0x00, 0x0F, 0xF1, 0xFF, 0x00, 0x03, 0xFC, 0xFF, 0x00,
  0x00, 0xFE, 0x7F, 0x80, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x1F, 0xDF, 0xC0,
  0x00, 0x07, 0xEF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x07,
  0xF7, 0xF8, 0x00, 0x07, 0xF3, 0xFE, 0x00, 0x03, 0xF9, 0xFF, 0x80, 0x03,
  0xF8, 0xFF, 0xE0, 0x07, 0xFC, 0x7F, 0xFF, 0xBF, 0xFC, 0x3F, 0x7F, 0xFF,
  0xFC, 0x1F, 0x9F, 0xFF, 0xFC, 0x0F, 0xC3, 0xFF, 0xFC, 0x07, 0xE0, 0xFF,
  0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x0F, 0x80, 0x7F, 0xFF, 0x07, 0xC0, 0x7F, 0xFF, 0xC3,
  0xE0, 0xFF, 0xFF, 0xF1, 0xF0, 0xFF, 0xFF, 0xFD, 0xF8, 0x7F, 0xC0, 0x7F,
  0xFC, 0x7F, 0x80, 0x07, 0xFE, 0x7F, 0x80, 0x01, 0xFF, 0x3F, 0x80, 0x00,
  0x7F, 0xBF, 0x80, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0x0F, 0xEF, 0xC0, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xDF,
  0x80, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x03, 0xFB,
  0xF8, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x03, 0xFE, 0x7F, 0x80, 0x03, 0xFF,
  0x1F, 0xF0, 0x03, 0xFF, 0x87, 0xFF, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0xF7,
  0xE0, 0x7F, 0xFF, 0xF3, 0xF0, 0x1F, 0xFF, 0xE1, 0xF8, 0x03, 0xFF, 0xC0,
  0xFC, 0x00, 0x1E, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0xF8,
  0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0xFE, 0xF8, 0xFF,
  0xFB, 0xE7, 0xFC, 0x6F, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x03,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0x9F, 0xE0, 0x0F, 0xCF, 0xE0, 0x00, 0x33, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xBF, 0xC0, 0xFF, 0xEF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xC0, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFF, 0x3C, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x07, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0x7F,
  0x80, 0x0F, 0xFE, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xF8, 0xFF,
  0xFF, 0xF1, 0xF0, 0xFF, 0xFF, 0xC3, 0xE0, 0x7F, 0xFE, 0x07, 0xC0, 0x07,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7E,
  0x7E, 0x00, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0x03, 0xF8, 0x1F, 0x80, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x03, 0xF0,
  0x0F, 0xC0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x1F, 0x80,
  0x01, 0xF8, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0xFC, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x7E, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0xFC, 0x00,
  0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x00, 0x1F, 0x9F,
  0x80, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x00,
  0xFB, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0xFE, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0x3F, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xF9, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0xFB, 0xE0, 0x00, 0xFC, 0x3F,
  0x00, 0x07, 0xDF, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x7E, 0xFC, 0x00, 0x3F,
  0x07, 0xE0, 0x03, 0xF7, 0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x1F, 0x1F, 0x00,
  0x1F, 0x81, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x0F, 0xE0, 0x0F, 0xC7,
  0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x80, 0x7F,
  0x01, 0xF8, 0x3F, 0x01, 0xFC, 0x01, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0xC0,
  0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x3F, 0x03,
  0xF0, 0x01, 0xF8, 0x3E, 0x00, 0xF8, 0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x07,
  0xE1, 0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0xF8,
  0x00, 0xF8, 0x7E, 0x00, 0x0F, 0xCF, 0xC0, 0x07, 0xE7, 0xE0, 0x00, 0x7E,
  0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x03, 0xF3, 0xE0, 0x01, 0xF9, 0xF8, 0x00,
  0x1F, 0x9F, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x7C, 0xF8, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC7, 0xF0,
  0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0xFE, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x3F, 0x80,
  0xFE, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x07,
  0xF1, 0xFC, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0xFD, 0xF8, 0x00, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x0F, 0xE3, 0xF8, 0x00,
  0x03, 0xF8, 0x3F, 0x80, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x7F,
  0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x7F,
  0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x01, 0xFD,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x7E, 0x7E, 0x00, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x00, 0xFE, 0x3F,
  0x00, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x1F,
  0x81, 0xF8, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0xFC, 0x00,
  0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0x1F, 0x80,
  0x1F, 0x80, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x00,
  0xFC, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x7E, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x03, 0xF0,
  0xFC, 0x00, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x00,
  0x1F, 0x9F, 0x80, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x00, 0x0F, 0xDF, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x04, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC,
  0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x03, 0xFE, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x7C, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0x80,
  0x03, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xC0, 0x01, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x8F, 0xFF, 0xC0, 0x00, 0xDF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFD, 0x80, 0x00, 0x7F, 0xFC, 0x80,
  0x00, 0x07, 0xF0, 0x00,
};

const GFXglyph NotoSans_Regular70pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 9, 51, 19, 5, -50 },
  { 59, 19, 18, 29, 5, -50 },
  { 102, 41, 50, 45, 2, -50 },
  { 359, 32, 57, 40, 4, -53 },
  { 587, 52, 52, 58, 3, -51 },
  { 925, 47, 52, 51, 4, -51 },
  { 1231, 6, 18, 16, 5, -50 },
  { 1245, 16, 61, 21, 3, -50 },
  { 1367, 16, 61, 21, 2, -50 },
  { 1489, 33, 31, 39, 3, -53 },
  { 1617, 33, 34, 40, 3, -42 },
  { 1758, 10, 17, 19, 3, -8 },
  { 1780, 17, 5, 23, 3, -21 },
  { 1791, 9, 9, 19, 5, -8 },
  { 1802, 24, 50, 26, 1, -50 },
  { 1952, 34, 52, 40, 3, -51 },
  { 2173, 19, 50, 40, 6, -50 },
  { 2292, 33, 51, 40, 3, -51 },
  { 2503, 33, 52, 40, 3, -51 },
  { 2718, 38, 50, 40, 1, -50 },
  { 2956, 32, 51, 40, 4, -50 },
  { 3160, 33, 52, 40, 4, -51 },
  { 3375, 34, 50, 40, 3, -50 },
  { 3588, 34, 52, 40, 3, -51 },
  { 3809, 33, 52, 40, 3, -51 },
  { 4024, 9, 40, 19, 5, -39 },
  { 4069, 12, 48, 19, 2, -39 },
  { 4141, 33, 35, 40, 3, -43 },
  { 4286, 32, 19, 40, 4, -34 },
  { 4362, 33, 35, 40, 3, -43 },
  { 4507, 28, 52, 30, 1, -51 },
  { 4689, 55, 56, 63, 4, -50 },
  { 5074, 45, 50, 45, 0, -50 },
  { 5356, 35, 50, 46, 7, -50 },
  { 5575, 38, 52, 44, 4, -51 },
  { 5822, 40, 50, 51, 7, -50 },
  { 6072, 28, 50, 39, 7, -50 },
  { 6247, 28, 50, 36, 7, -50 },
  { 6422, 42, 52, 51, 4, -51 },
  { 6695, 38, 50, 52, 7, -50 },
  { 6933, 18, 50, 24, 3, -50 },
  { 7046, 18, 63, 19, -5, -50 },
  { 7188, 36, 50, 43, 7, -50 },
  { 7413, 28, 50, 37, 7, -50 },
  { 7588, 50, 50, 63, 7, -50 },
  { 7901, 39, 50, 53, 7, -50 },
  { 8145, 46, 52, 55, 4, -51 },
  { 8444, 32, 50, 42, 7, -50 },
  { 8644, 46, 63, 55, 4, -51 },
  { 9007, 35, 50, 44, 7, -50 },
  { 9226, 31, 52, 38, 4, -51 },
  { 9428, 37, 50, 39, 1, -50 },
  { 9660, 39, 51, 51, 6, -50 },
  { 9909, 42, 50, 42, 0, -50 },
  { 10172, 63, 50, 65, 1, -50 },
  { 10566, 41, 50, 41, 0, -50 },
  { 10823, 40, 50, 40, 0, -50 },
  { 11073, 34, 50, 40, 3, -50 },
  { 11286, 15, 61, 23, 6, -50 },
  { 11401, 24, 50, 26, 1, -50 },
  { 11551, 15, 61, 23, 2, -50 },
  { 11666, 34, 31, 40, 3, -50 },
  { 11798, 31, 5, 31, 0, 6 },
  { 11818, 14, 12, 20, 3, -54 },
  { 11839, 31, 39, 39, 3, -38 },
  { 11991, 33, 54, 43, 6, -53 },
  { 12214, 27, 39, 34, 4, -38 },
  { 12346, 33, 54, 43, 4, -53 },
  { 12569, 32, 39, 39, 4, -38 },
  { 12725, 26, 54, 24, 1, -54 },
  { 12901, 33, 55, 43, 4, -38 },
  { 13128, 32, 53, 43, 6, -53 },
  { 13340, 8, 52, 18, 5, -52 },
  { 13392, 17, 69, 18, -4, -52 },
  { 13539, 31, 53, 37, 6, -53 },
  { 13745, 6, 53, 18, 6, -53 },
  { 13785, 54, 38, 65, 6, -38 },
  { 14042, 32, 38, 43, 6, -38 },
  { 14194, 35, 39, 42, 4, -38 },
  { 14365, 33, 55, 43, 6, -38 },
  { 14592, 33, 55, 43, 4, -38 },
  { 14819, 22, 38, 29, 6, -38 },
  { 14924, 26, 39, 34, 4, -38 },
  { 15051, 23, 47, 25, 1, -46 },
  { 15187, 31, 39, 43, 6, -38 },
  { 15339, 36, 38, 36, 0, -38 },
  { 15510, 53, 38, 55, 1, -38 },
  { 15762, 35, 38, 37, 1, -38 },
  { 15929, 36, 55, 36, 0, -38 },
  { 16177, 27, 38, 33, 3, -38 },
  { 16306, 22, 61, 27, 2, -50 },
  { 16474, 5, 70, 39, 17, -53 },
  { 16518, 23, 61, 27, 2, -50 },
  { 16694, 33, 9, 40, 3, -29 },
};

const GFXfont NotoSans_Regular70pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Regular70pt7bBitmaps,
  (GFXglyph *)NotoSans_Regular70pt7bGlyphs,
  0x20, 0x7E, 95
};

#endif // _NOTOSANS_REGULAR70PT7B_H_
