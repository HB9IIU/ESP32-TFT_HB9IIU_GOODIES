#ifndef _NOTOSANS_REGULAR8PT7B_H_
#define _NOTOSANS_REGULAR8PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Regular.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Regular8pt7bBitmaps[] PROGMEM = {
  0x00, 0xF4, 0xF0, 0x31, 0xBE, 0xAF, 0xB0, 0x2F, 0x63, 0x3E, 0x4A, 0xAB,
  0x57, 0x2D, 0xB0, 0x61, 0x46, 0x19, 0x99, 0xF0, 0xC0, 0x5A, 0xA4, 0x95,
  0x5C, 0x2F, 0x67, 0x22, 0xF2, 0x60, 0xC0, 0x80, 0x25, 0x29, 0x00, 0x69,
  0x99, 0x97, 0x75, 0x50, 0xE1, 0x12, 0x4F, 0xE1, 0x17, 0x1F, 0x13, 0x59,
  0xF1, 0x74, 0xE1, 0x1F, 0x34, 0xAD, 0x97, 0xF1, 0x12, 0x24, 0x69, 0x57,
  0x97, 0x69, 0x97, 0x16, 0x90, 0x42, 0x80, 0x16, 0xC3, 0xFF, 0xC2, 0x3C,
  0xE4, 0xA0, 0x80, 0x38, 0x8A, 0xED, 0x5B, 0xE8, 0x0E, 0x00, 0x21, 0x14,
  0xE8, 0xC4, 0xE9, 0xAD, 0x9E, 0x3A, 0x21, 0x04, 0x3C, 0xE9, 0x99, 0x9E,
  0xF2, 0x79, 0xC0, 0xF2, 0x79, 0x00, 0x3A, 0x21, 0x34, 0xBC, 0x99, 0x9F,
  0x99, 0xD5, 0x70, 0x55, 0x56, 0x9A, 0xCC, 0xA9, 0x92, 0x49, 0xC0, 0x8C,
  0x77, 0xBA, 0xD4, 0x99, 0xDB, 0xB9, 0x31, 0x28, 0x61, 0x45, 0xE0, 0xF6,
  0xF9, 0x00, 0x31, 0x28, 0x61, 0x45, 0xE0, 0x80, 0xE9, 0xAC, 0xA9, 0x78,
  0x43, 0x1F, 0xF2, 0x22, 0x22, 0x99, 0x99, 0x9F, 0x8C, 0x94, 0xA6, 0x10,
  0x93, 0x25, 0x6B, 0x56, 0xC8, 0x80, 0x9A, 0x88, 0x45, 0x4C, 0x8A, 0x98,
  0x42, 0x10, 0xF1, 0x24, 0x4F, 0xFE, 0x91, 0x24, 0x40, 0xD5, 0x5C, 0x26,
  0x59, 0xF0, 0xC0, 0x77, 0x97, 0x9A, 0xDB, 0xC0, 0x78, 0x87, 0x13, 0x59,
  0x97, 0x7F, 0x87, 0x6F, 0x24, 0x80, 0x79, 0x97, 0x17, 0x9A, 0xDB, 0x40,
  0xBC, 0xBF, 0x93, 0xCD, 0x40, 0xFC, 0xFE, 0x9A, 0x69, 0xF6, 0xD0, 0x79,
  0x97, 0xF6, 0xF9, 0x00, 0x79, 0x97, 0x11, 0xEA, 0xE8, 0xF0, 0x79, 0x26,
  0xB6, 0xF0, 0x95, 0x66, 0x96, 0xD6, 0x92, 0xD6, 0x69, 0x95, 0x62, 0x4C,
  0xE5, 0x70, 0x29, 0x64, 0x98, 0xFF, 0x89, 0x34, 0xB0, 0xF0,
};

const GFXglyph NotoSans_Regular8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 6, 2, 1, -6 },
  { 2, 2, 2, 3, 1, -6 },
  { 3, 5, 6, 5, 0, -6 },
  { 7, 4, 6, 5, 0, -6 },
  { 10, 6, 6, 7, 0, -6 },
  { 15, 6, 6, 6, 0, -6 },
  { 20, 1, 2, 2, 0, -6 },
  { 21, 2, 7, 2, 0, -6 },
  { 23, 2, 7, 2, 0, -6 },
  { 25, 4, 4, 4, 0, -6 },
  { 27, 4, 4, 5, 0, -5 },
  { 29, 2, 2, 2, 0, -1 },
  { 30, 2, 1, 3, 0, -3 },
  { 31, 1, 1, 2, 1, -1 },
  { 32, 3, 6, 3, 0, -6 },
  { 35, 4, 6, 5, 0, -6 },
  { 38, 2, 6, 5, 1, -6 },
  { 40, 4, 6, 5, 0, -6 },
  { 43, 4, 6, 5, 0, -6 },
  { 46, 4, 6, 5, 0, -6 },
  { 49, 4, 6, 5, 0, -6 },
  { 52, 4, 6, 5, 0, -6 },
  { 55, 4, 6, 5, 0, -6 },
  { 58, 4, 6, 5, 0, -6 },
  { 61, 4, 6, 5, 0, -6 },
  { 64, 1, 4, 2, 1, -4 },
  { 65, 2, 5, 2, 0, -4 },
  { 67, 4, 4, 5, 0, -5 },
  { 69, 4, 2, 5, 0, -4 },
  { 70, 4, 4, 5, 0, -5 },
  { 72, 3, 6, 3, 0, -6 },
  { 75, 7, 7, 7, 0, -6 },
  { 82, 5, 6, 5, 0, -6 },
  { 86, 4, 6, 5, 1, -6 },
  { 89, 5, 6, 5, 0, -6 },
  { 93, 4, 6, 6, 1, -6 },
  { 96, 3, 6, 4, 1, -6 },
  { 99, 3, 6, 4, 1, -6 },
  { 102, 5, 6, 6, 0, -6 },
  { 106, 4, 6, 6, 1, -6 },
  { 109, 2, 6, 3, 0, -6 },
  { 111, 2, 8, 2, -1, -6 },
  { 113, 4, 6, 5, 1, -6 },
  { 116, 3, 6, 4, 1, -6 },
  { 119, 5, 6, 7, 1, -6 },
  { 123, 4, 6, 6, 1, -6 },
  { 126, 6, 6, 6, 0, -6 },
  { 131, 3, 6, 5, 1, -6 },
  { 134, 6, 7, 6, 0, -6 },
  { 140, 4, 6, 5, 1, -6 },
  { 143, 4, 6, 4, 0, -6 },
  { 146, 4, 6, 4, 0, -6 },
  { 149, 4, 6, 6, 1, -6 },
  { 152, 5, 6, 5, 0, -6 },
  { 156, 7, 6, 7, 0, -6 },
  { 162, 5, 6, 5, 0, -6 },
  { 166, 5, 6, 5, 0, -6 },
  { 170, 4, 6, 5, 0, -6 },
  { 173, 1, 7, 3, 1, -6 },
  { 174, 3, 6, 3, 0, -6 },
  { 177, 2, 7, 3, 0, -6 },
  { 179, 4, 4, 5, 0, -6 },
  { 181, 4, 1, 4, 0, 0 },
  { 182, 2, 1, 2, 0, -6 },
  { 183, 4, 4, 4, 0, -4 },
  { 185, 3, 6, 5, 1, -6 },
  { 188, 4, 4, 4, 0, -4 },
  { 190, 4, 6, 5, 0, -6 },
  { 193, 4, 4, 5, 0, -4 },
  { 195, 3, 6, 3, 0, -6 },
  { 198, 4, 6, 5, 0, -4 },
  { 201, 3, 6, 5, 1, -6 },
  { 204, 1, 6, 2, 1, -6 },
  { 205, 1, 8, 2, 0, -6 },
  { 206, 3, 6, 4, 1, -6 },
  { 209, 1, 6, 2, 1, -6 },
  { 210, 6, 4, 7, 1, -4 },
  { 213, 3, 4, 5, 1, -4 },
  { 215, 4, 4, 5, 0, -4 },
  { 217, 3, 6, 5, 1, -4 },
  { 220, 4, 6, 5, 0, -4 },
  { 223, 2, 4, 3, 1, -4 },
  { 224, 3, 4, 4, 0, -4 },
  { 226, 3, 5, 3, 0, -5 },
  { 228, 3, 4, 5, 1, -4 },
  { 230, 4, 4, 4, 0, -4 },
  { 232, 6, 4, 6, 0, -4 },
  { 235, 4, 4, 4, 0, -4 },
  { 237, 4, 6, 4, 0, -4 },
  { 240, 3, 4, 4, 0, -4 },
  { 242, 3, 7, 3, 0, -6 },
  { 245, 1, 8, 4, 2, -6 },
  { 246, 3, 7, 3, 0, -6 },
  { 249, 4, 1, 5, 0, -3 },
};

const GFXfont NotoSans_Regular8pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Regular8pt7bBitmaps,
  (GFXglyph *)NotoSans_Regular8pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _NOTOSANS_REGULAR8PT7B_H_
