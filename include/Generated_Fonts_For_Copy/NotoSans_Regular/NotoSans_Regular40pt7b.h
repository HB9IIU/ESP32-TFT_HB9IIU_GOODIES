#ifndef _NOTOSANS_REGULAR40PT7B_H_
#define _NOTOSANS_REGULAR40PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Regular.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Regular40pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xBD, 0xEF, 0x79, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x00, 0x00, 0x77, 0xFF, 0xFF, 0x10, 0xE1, 0xFC, 0x3F, 0x87,
  0xF0, 0xFE, 0x1D, 0xC3, 0xB8, 0x77, 0x0E, 0xE0, 0xDC, 0x1B, 0x83, 0x00,
  0x00, 0x70, 0x30, 0x00, 0x70, 0x70, 0x00, 0x60, 0x70, 0x00, 0xE0, 0x70,
  0x00, 0xE0, 0x70, 0x00, 0xE0, 0x60, 0x00, 0xE0, 0xE0, 0x00, 0xC0, 0xE0,
  0x01, 0xC0, 0xE0, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0x01, 0x81, 0xC0, 0x03, 0x81, 0xC0, 0x03, 0x81, 0xC0, 0x03, 0x81, 0x80,
  0x03, 0x83, 0x80, 0x03, 0x83, 0x80, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFC, 0x07, 0x07, 0x00, 0x07, 0x07, 0x00, 0x06, 0x07, 0x00,
  0x0E, 0x07, 0x00, 0x0E, 0x06, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x0E, 0x00,
  0x0C, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x01, 0xFE,
  0x01, 0xFF, 0xFC, 0x7F, 0xFF, 0x1F, 0x39, 0xE3, 0xC7, 0x04, 0x70, 0xE0,
  0x1E, 0x1C, 0x01, 0xC3, 0x80, 0x38, 0x70, 0x07, 0xCE, 0x00, 0x7F, 0xC0,
  0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0x9F,
  0x00, 0x70, 0xE0, 0x0E, 0x1E, 0x01, 0xC3, 0xC0, 0x38, 0x7C, 0x07, 0x1E,
  0xF0, 0xEF, 0xDF, 0xFF, 0xF3, 0xFF, 0xFC, 0x0F, 0xFC, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x1F, 0x00, 0x07, 0x01, 0xFE,
  0x00, 0x78, 0x1F, 0xF0, 0x03, 0x80, 0xE1, 0xC0, 0x38, 0x0E, 0x0E, 0x01,
  0xC0, 0x70, 0x30, 0x1C, 0x03, 0x81, 0xC0, 0xE0, 0x1C, 0x0E, 0x0E, 0x00,
  0xE0, 0x70, 0x70, 0x07, 0x03, 0x87, 0x00, 0x38, 0x1C, 0x78, 0x01, 0xC0,
  0xE3, 0x82, 0x0E, 0x06, 0x38, 0xFE, 0x30, 0x71, 0xCF, 0xF1, 0xC3, 0x9C,
  0xF1, 0xCF, 0xF8, 0xE7, 0x07, 0x3F, 0xCE, 0x38, 0x38, 0x78, 0x71, 0xC1,
  0xC0, 0x07, 0x1C, 0x0E, 0x00, 0x78, 0xE0, 0x70, 0x03, 0x87, 0x03, 0x80,
  0x38, 0x38, 0x1C, 0x01, 0xC0, 0xC0, 0xE0, 0x1C, 0x07, 0x07, 0x00, 0xE0,
  0x38, 0x38, 0x0E, 0x01, 0xC3, 0xC0, 0x70, 0x07, 0x1C, 0x07, 0x00, 0x3F,
  0xE0, 0x78, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x38, 0x07,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0xE0, 0x3C, 0x00, 0x1E, 0x07, 0x80, 0x01,
  0xC1, 0xE0, 0x00, 0x3C, 0x78, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFB, 0xC0, 0x1C, 0x3E,
  0x3C, 0x07, 0x8F, 0x03, 0xC0, 0xF1, 0xE0, 0x3C, 0x1C, 0x78, 0x03, 0xC7,
  0x8F, 0x00, 0x3C, 0xE1, 0xE0, 0x03, 0xFC, 0x3C, 0x00, 0x3F, 0x07, 0x80,
  0x03, 0xE0, 0x78, 0x01, 0xFE, 0x0F, 0x80, 0xFF, 0xE0, 0xFF, 0xFF, 0x3E,
  0x0F, 0xFF, 0x83, 0xE0, 0xFF, 0xC0, 0x3E, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x07, 0x83, 0x83, 0x83, 0xC1, 0xC1, 0xE0, 0xE0, 0xF0, 0x78, 0x38, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xE0, 0xF0, 0x78, 0x1C, 0x0F, 0x07, 0x81, 0xC0, 0xF0, 0x38,
  0x1E, 0x07, 0x81, 0xE0, 0xF0, 0x38, 0x0E, 0x07, 0x81, 0xC0, 0xF0, 0x38,
  0x1E, 0x0F, 0x03, 0x81, 0xE0, 0xF0, 0x78, 0x3C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xC1, 0xE0,
  0xF0, 0xF0, 0x78, 0x38, 0x3C, 0x3C, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x30, 0x30, 0x3F, 0x8C, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x78, 0x00, 0x3F, 0x00, 0x1D, 0xE0, 0x07,
  0x38, 0x03, 0xCF, 0x01, 0xE1, 0xE0, 0xF8, 0x7C, 0x0C, 0x0C, 0x01, 0x02,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x3D, 0xE7, 0x9E, 0x79, 0xCF, 0x38, 0xE3, 0x80, 0xFF, 0xFF, 0xFF,
  0xE0, 0x77, 0xFF, 0xFF, 0x10, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0E,
  0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x1E,
  0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1C,
  0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x00, 0x03, 0xF8, 0x01, 0xFF,
  0x80, 0x7F, 0xFC, 0x1F, 0x07, 0x83, 0xC0, 0x78, 0xF0, 0x07, 0x1E, 0x00,
  0xF3, 0x80, 0x0E, 0xF0, 0x01, 0xDE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1C, 0xE0, 0x03,
  0x9C, 0x00, 0xF3, 0xC0, 0x1E, 0x38, 0x07, 0x87, 0x81, 0xF0, 0x7F, 0xFC,
  0x07, 0xFF, 0x00, 0x7F, 0xC0, 0x01, 0xC0, 0xF0, 0x7C, 0x7F, 0x3F, 0xDE,
  0x7F, 0x1F, 0x87, 0x41, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x03, 0xF0, 0x03, 0xFF, 0xC1, 0xFF,
  0xFC, 0x7E, 0x0F, 0xC7, 0x00, 0x78, 0x40, 0x07, 0x00, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00,
  0x70, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x07, 0xF8, 0x07, 0xFF, 0xC1, 0xFF, 0xFC, 0x7C, 0x07,
  0xC6, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x1F, 0xF0,
  0x03, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E,
  0x00, 0x03, 0xD8, 0x01, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0x07, 0xFF, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x03,
  0xB8, 0x00, 0x1D, 0xC0, 0x01, 0xCE, 0x00, 0x1E, 0x70, 0x00, 0xE3, 0x80,
  0x0E, 0x1C, 0x00, 0xF0, 0xE0, 0x0F, 0x07, 0x00, 0x70, 0x38, 0x07, 0x01,
  0xC0, 0x78, 0x0E, 0x03, 0x80, 0x70, 0x38, 0x03, 0x83, 0xC0, 0x1C, 0x1C,
  0x00, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x7F, 0xFF, 0x1F, 0xFF, 0xC7, 0xFF, 0xF1,
  0xFF, 0xFC, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC6, 0x00, 0xFF, 0xF8, 0x3F, 0xFF,
  0x87, 0xDF, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00,
  0x0F, 0xB0, 0x07, 0xCF, 0xFF, 0xE3, 0xFF, 0xF0, 0x7F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x3F, 0xF0, 0x1F, 0xFE, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x7C, 0x0F, 0x3F, 0xF1, 0xEF, 0xFF, 0x3F, 0x81, 0xF7, 0xE0,
  0x1E, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x00,
  0x1E, 0xE0, 0x03, 0xDC, 0x00, 0x7B, 0xC0, 0x0E, 0x3C, 0x03, 0xC7, 0xC0,
  0xF8, 0x7F, 0xFE, 0x07, 0xFF, 0x80, 0x3F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78,
  0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00,
  0x07, 0x80, 0x01, 0xF0, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC,
  0x1E, 0x07, 0xC7, 0x80, 0x3C, 0xF0, 0x07, 0x9C, 0x00, 0xF3, 0x80, 0x1E,
  0x78, 0x03, 0xCF, 0x00, 0x70, 0xF0, 0x1E, 0x0F, 0x87, 0x80, 0xFF, 0xE0,
  0x0F, 0xF0, 0x01, 0xFF, 0x00, 0xFF, 0xF0, 0x3E, 0x1F, 0x8F, 0x00, 0xF1,
  0xC0, 0x0F, 0x78, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x01, 0xCF, 0x00, 0x78, 0xFE, 0xFE, 0x0F, 0xFF, 0x80,
  0xFF, 0xC0, 0x03, 0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xF8, 0x1F, 0x0F, 0x87,
  0x80, 0x78, 0xE0, 0x07, 0x3C, 0x00, 0xF7, 0x80, 0x0E, 0xF0, 0x01, 0xDC,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1E, 0xE0, 0x07, 0xDE,
  0x01, 0xF9, 0xFD, 0xFF, 0x1F, 0xFD, 0xE1, 0xFE, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x07, 0xC0, 0xEF, 0xF0, 0x1F, 0xFC, 0x03, 0xFE, 0x00, 0x77,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xBF, 0xFF,
  0xF8, 0x80, 0x1C, 0x7C, 0xF9, 0xF3, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0xF1, 0xE3, 0xC7, 0x1E, 0x38, 0x70,
  0xE3, 0x80, 0x00, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3C, 0x00, 0x01, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xC0, 0x00, 0x1E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x1E, 0x00, 0x03, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x3F, 0xFC, 0xFF, 0xFE, 0x78, 0x3E, 0x40, 0x0F, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0xF8, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x07, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x03, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xF8,
  0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x07, 0x80, 0x00, 0x78, 0x0F, 0x00,
  0x00, 0x38, 0x1E, 0x00, 0x00, 0x1C, 0x1C, 0x03, 0xF0, 0x1C, 0x38, 0x0F,
  0xFE, 0x0E, 0x38, 0x1F, 0xFE, 0x0E, 0x70, 0x3C, 0x0E, 0x06, 0x70, 0x78,
  0x0E, 0x06, 0x70, 0x70, 0x0E, 0x07, 0x60, 0x70, 0x0E, 0x07, 0xE0, 0xF0,
  0x0E, 0x07, 0xE0, 0xE0, 0x0E, 0x07, 0xE0, 0xE0, 0x1E, 0x06, 0xE0, 0xF0,
  0x1C, 0x0E, 0xE0, 0x70, 0x1E, 0x0E, 0xE0, 0x70, 0x3E, 0x1C, 0x70, 0x78,
  0x36, 0x1C, 0x70, 0x3F, 0xE7, 0xF8, 0x70, 0x1F, 0xC3, 0xF0, 0x78, 0x07,
  0x00, 0xC0, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x01, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x07, 0x78, 0x00, 0x03, 0xCE, 0x00,
  0x00, 0xE3, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x1E, 0x1C, 0x00, 0x07, 0x07,
  0x80, 0x03, 0xC0, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x38, 0x0F, 0x00, 0x1E,
  0x01, 0xC0, 0x07, 0x00, 0x78, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xF0, 0x1E, 0x00, 0x3C, 0x07, 0x80, 0x07, 0x81, 0xC0, 0x01,
  0xE0, 0xF0, 0x00, 0x38, 0x38, 0x00, 0x0F, 0x1E, 0x00, 0x03, 0xC7, 0x80,
  0x00, 0x79, 0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x03, 0xC0, 0xFF, 0x80, 0x0F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xE0, 0x07, 0xCE, 0x00, 0x3E,
  0xE0, 0x01, 0xEE, 0x00, 0x1E, 0xE0, 0x01, 0xEE, 0x00, 0x1E, 0xE0, 0x01,
  0xCE, 0x00, 0x3C, 0xE0, 0x3F, 0x8F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF8, 0xE0, 0x03, 0xCE, 0x00, 0x1E, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1E, 0xE0, 0x03, 0xEE,
  0x00, 0x7E, 0xFF, 0xFF, 0xCF, 0xFF, 0xF0, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFC, 0x3E, 0x0F, 0x80, 0x08,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x20, 0x7F, 0xFF,
  0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x03,
  0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0E, 0x00, 0x3E, 0x1C, 0x00, 0x3E, 0x38,
  0x00, 0x3E, 0x70, 0x00, 0x3C, 0xE0, 0x00, 0x3D, 0xC0, 0x00, 0x7B, 0x80,
  0x00, 0xF7, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0xF7, 0x00, 0x01, 0xEE, 0x00, 0x03, 0xDC, 0x00, 0x0F, 0x38, 0x00, 0x1E,
  0x70, 0x00, 0x78, 0xE0, 0x03, 0xF1, 0xC0, 0x3F, 0xC3, 0xFF, 0xFE, 0x07,
  0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFE, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFE, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07,
  0xF0, 0x7E, 0x0F, 0x80, 0x02, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x03, 0xFF, 0xF0,
  0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x70, 0x00, 0x07, 0x78, 0x00, 0x07, 0x78,
  0x00, 0x07, 0x78, 0x00, 0x07, 0x3C, 0x00, 0x07, 0x3C, 0x00, 0x07, 0x1E,
  0x00, 0x07, 0x1F, 0x00, 0x07, 0x0F, 0xC0, 0x07, 0x07, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3C, 0xFF, 0xFF, 0xFF, 0xFC, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E,
  0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81,
  0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x87, 0xF3, 0xFF,
  0xFF, 0xC0, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x0F, 0x07, 0xFF, 0xEF, 0xF3, 0xF8, 0x30,
  0x00, 0xE0, 0x00, 0xF7, 0x00, 0x0F, 0x38, 0x00, 0xF1, 0xC0, 0x0F, 0x8E,
  0x00, 0xF8, 0x70, 0x07, 0x83, 0x80, 0x78, 0x1C, 0x07, 0x80, 0xE0, 0x78,
  0x07, 0x07, 0x80, 0x38, 0x78, 0x01, 0xC7, 0x80, 0x0E, 0x78, 0x00, 0x77,
  0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xF9, 0xF0, 0x07, 0x87, 0x80,
  0x38, 0x1E, 0x01, 0xC0, 0xF8, 0x0E, 0x03, 0xE0, 0x70, 0x0F, 0x03, 0x80,
  0x3C, 0x1C, 0x01, 0xF0, 0xE0, 0x07, 0x87, 0x00, 0x1E, 0x38, 0x00, 0x79,
  0xC0, 0x03, 0xEE, 0x00, 0x0F, 0x80, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFE, 0xE0, 0x00,
  0x77, 0xEE, 0x00, 0x07, 0x7E, 0xF0, 0x00, 0xF7, 0xE7, 0x00, 0x0E, 0x7E,
  0x78, 0x00, 0xE7, 0xE3, 0x80, 0x1C, 0x7E, 0x38, 0x01, 0xC7, 0xE3, 0xC0,
  0x3C, 0x7E, 0x1C, 0x03, 0x87, 0xE1, 0xC0, 0x38, 0x7E, 0x1E, 0x07, 0x87,
  0xE0, 0xE0, 0x70, 0x7E, 0x0F, 0x07, 0x07, 0xE0, 0x70, 0xE0, 0x7E, 0x07,
  0x0E, 0x07, 0xE0, 0x79, 0xE0, 0x7E, 0x03, 0x9C, 0x07, 0xE0, 0x3D, 0xC0,
  0x7E, 0x03, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x0F, 0x00, 0x7E, 0x00, 0xF0, 0x07, 0xE0, 0x0F, 0x00, 0x70, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x01,
  0xFF, 0xC0, 0x03, 0xFB, 0xC0, 0x07, 0xF7, 0xC0, 0x0F, 0xE7, 0x80, 0x1F,
  0xC7, 0x80, 0x3F, 0x8F, 0x80, 0x7F, 0x0F, 0x00, 0xFE, 0x0F, 0x01, 0xFC,
  0x1E, 0x03, 0xF8, 0x1E, 0x07, 0xF0, 0x1E, 0x0F, 0xE0, 0x3C, 0x1F, 0xC0,
  0x3C, 0x3F, 0x80, 0x3C, 0x7F, 0x00, 0x78, 0xFE, 0x00, 0x79, 0xFC, 0x00,
  0xFB, 0xF8, 0x00, 0xF7, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xF0, 0x3F, 0x01,
  0xF0, 0x01, 0xF0, 0x3C, 0x00, 0x1F, 0x0F, 0x00, 0x01, 0xE1, 0xE0, 0x00,
  0x1E, 0x78, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x07, 0x38,
  0x00, 0x00, 0xF7, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x3D, 0xE0,
  0x00, 0x07, 0x3C, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x3C, 0xF0, 0x00, 0x07,
  0x8F, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFE, 0x00,
  0xFF, 0x80, 0x3F, 0xFF, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0xE0, 0x0F, 0xB8,
  0x01, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xB8, 0x03, 0xEE, 0x03, 0xF3, 0xFF, 0xF8,
  0xFF, 0xFC, 0x3F, 0xF8, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFE,
  0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xF0, 0x3F, 0x01, 0xF0, 0x01, 0xF0, 0x3C,
  0x00, 0x1F, 0x0F, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x1E, 0x78, 0x00, 0x03,
  0xCF, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x07, 0x38, 0x00, 0x00, 0xF7, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x07, 0x3C, 0x00,
  0x01, 0xE7, 0x80, 0x00, 0x3C, 0xF0, 0x00, 0x07, 0x8F, 0x00, 0x01, 0xE1,
  0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0xFF, 0xC0, 0x0F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0xE0, 0x0F, 0x8E, 0x00, 0x3C, 0xE0,
  0x03, 0xCE, 0x00, 0x3C, 0xE0, 0x03, 0xCE, 0x00, 0x3C, 0xE0, 0x03, 0xCE,
  0x00, 0x3C, 0xE0, 0x07, 0x8E, 0x00, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xC0,
  0xFF, 0xF8, 0x0E, 0x07, 0x80, 0xE0, 0x3C, 0x0E, 0x03, 0xC0, 0xE0, 0x1E,
  0x0E, 0x00, 0xF0, 0xE0, 0x0F, 0x0E, 0x00, 0x78, 0xE0, 0x07, 0xCE, 0x00,
  0x3C, 0xE0, 0x01, 0xEE, 0x00, 0x1E, 0xE0, 0x00, 0xF0, 0x03, 0xFC, 0x03,
  0xFF, 0xE3, 0xFF, 0xF9, 0xF8, 0x3E, 0x78, 0x00, 0x9E, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x01, 0xF8, 0x00,
  0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x07, 0xB8, 0x03, 0xEF, 0xFF, 0xF3, 0xFF, 0xF8,
  0x7F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xEF,
  0x00, 0x07, 0xBC, 0x00, 0x1E, 0x78, 0x00, 0xF0, 0xF8, 0x07, 0xC3, 0xFF,
  0xFE, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0x70, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x3C, 0x00,
  0x3C, 0x3C, 0x00, 0x3C, 0x1C, 0x00, 0x38, 0x1E, 0x00, 0x78, 0x1E, 0x00,
  0x78, 0x0E, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x00,
  0xE0, 0x07, 0x81, 0xE0, 0x07, 0x81, 0xE0, 0x03, 0x81, 0xC0, 0x03, 0xC3,
  0xC0, 0x03, 0xC3, 0xC0, 0x01, 0xC3, 0x80, 0x01, 0xE7, 0x80, 0x00, 0xE7,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00,
  0x70, 0x00, 0x7B, 0xC0, 0x07, 0xC0, 0x03, 0x9E, 0x00, 0x3E, 0x00, 0x3C,
  0xF0, 0x01, 0xF0, 0x01, 0xE3, 0x80, 0x1F, 0xC0, 0x0F, 0x1E, 0x00, 0xEE,
  0x00, 0x70, 0xF0, 0x07, 0x70, 0x07, 0x87, 0x80, 0x3B, 0x80, 0x3C, 0x1C,
  0x03, 0xDE, 0x01, 0xE0, 0xF0, 0x1C, 0x70, 0x0E, 0x07, 0x80, 0xE3, 0x80,
  0xF0, 0x3C, 0x0F, 0x1E, 0x07, 0x80, 0xE0, 0x70, 0x70, 0x38, 0x07, 0x83,
  0x83, 0x81, 0xC0, 0x3C, 0x3C, 0x1E, 0x1E, 0x01, 0xE1, 0xE0, 0xF0, 0xF0,
  0x07, 0x0E, 0x03, 0x87, 0x00, 0x3C, 0x70, 0x1C, 0x38, 0x01, 0xE7, 0x80,
  0xF3, 0xC0, 0x07, 0x38, 0x03, 0x9E, 0x00, 0x39, 0xC0, 0x1C, 0xE0, 0x01,
  0xEE, 0x00, 0xF7, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x3F, 0x00, 0x1F,
  0xC0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x1E, 0xF0, 0x00, 0x78, 0xF0, 0x01, 0xE0, 0xF0, 0x03,
  0xC1, 0xE0, 0x0F, 0x01, 0xE0, 0x1C, 0x01, 0xE0, 0x78, 0x03, 0xC1, 0xE0,
  0x03, 0xC3, 0x80, 0x03, 0x8F, 0x00, 0x07, 0xBC, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0xFE, 0x00, 0x03, 0xDE, 0x00, 0x07, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x38,
  0x3C, 0x00, 0xF0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x00, 0x78, 0x1E, 0x00,
  0xF0, 0x78, 0x00, 0xF0, 0xF0, 0x00, 0xF3, 0xC0, 0x01, 0xEF, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x1E, 0xE0, 0x00, 0x79, 0xE0, 0x00, 0xF1, 0xE0, 0x03,
  0xC3, 0xC0, 0x07, 0x03, 0xC0, 0x1E, 0x07, 0x80, 0x38, 0x07, 0x80, 0xF0,
  0x0F, 0x03, 0xC0, 0x0F, 0x07, 0x80, 0x1E, 0x1E, 0x00, 0x1E, 0x3C, 0x00,
  0x3C, 0xF0, 0x00, 0x3D, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFE, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xFF, 0xFF,
  0xFF, 0xE0, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80,
  0x07, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x78, 0x00, 0x70, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0xFF, 0xFF, 0xFF,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x06, 0x70, 0x01, 0xCE, 0x00, 0x30, 0xE0, 0x0E, 0x1C, 0x01, 0xC1,
  0xC0, 0x70, 0x38, 0x0E, 0x03, 0x83, 0x80, 0x70, 0x70, 0x07, 0x1C, 0x00,
  0xE3, 0x80, 0x0E, 0xE0, 0x01, 0xDC, 0x00, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xF0, 0xF0, 0x78, 0x3C, 0x1C, 0x0E, 0x07, 0x01, 0xF0, 0x0F, 0xFF,
  0x0F, 0xFF, 0xC3, 0x81, 0xE1, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0xFF, 0xC7, 0xFF, 0xE7, 0xFF, 0xF7, 0xC0, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xFC, 0x07,
  0xEF, 0xDF, 0x77, 0xFF, 0x38, 0xFF, 0x0C, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0xF8, 0x1E, 0x7F, 0xC3, 0xDF, 0xFE, 0x7F, 0x07, 0xCF,
  0xC0, 0x3D, 0xF0, 0x03, 0xBE, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x7B, 0xF0, 0x1F, 0x7F,
  0xFF, 0xCE, 0x7F, 0xF1, 0xC7, 0xFC, 0x00, 0x01, 0xF8, 0x07, 0xFF, 0x1F,
  0xFE, 0x3F, 0x0E, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0x70, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x01, 0x1F, 0xFF, 0x0F,
  0xFF, 0x07, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x03, 0xE0,
  0xE1, 0xFF, 0x9C, 0x7F, 0xFB, 0x9F, 0x07, 0xF3, 0xC0, 0x3E, 0xF0, 0x03,
  0xDE, 0x00, 0x7B, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7B, 0x80, 0x0F,
  0x78, 0x01, 0xEF, 0x00, 0x7C, 0xF0, 0x1F, 0x9F, 0xFF, 0x71, 0xFF, 0xCE,
  0x0F, 0xF1, 0xC0, 0x01, 0xF0, 0x00, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0x07,
  0xC3, 0xC0, 0x78, 0xF0, 0x07, 0x9E, 0x00, 0xF3, 0x80, 0x0E, 0xF0, 0x01,
  0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x03,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x07, 0xFE, 0x00, 0x00, 0x60, 0x0F, 0xF0,
  0x7F, 0xC3, 0xE3, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x0F, 0xFF, 0x3F, 0xFC, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x00, 0x03, 0xF0, 0x01, 0xFF, 0x9C, 0x7F, 0xFB, 0x9F, 0x87,
  0xF3, 0xC0, 0x3E, 0xF0, 0x03, 0xDE, 0x00, 0x7B, 0x80, 0x0F, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3B, 0x80, 0x0F, 0x78, 0x01, 0xEF, 0x00, 0x7C, 0xF0, 0x1F,
  0x8F, 0xDF, 0x71, 0xFF, 0xEE, 0x0F, 0xF1, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x90, 0x01, 0xE3, 0xF1, 0xFC,
  0x7F, 0xFF, 0x0F, 0xFF, 0x80, 0x07, 0x80, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x78, 0x3C, 0xFF, 0xCF, 0x7F, 0xFB, 0xFC, 0x3F, 0xFC, 0x03,
  0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x70, 0xFF, 0xF7, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x83, 0xC1, 0xE0, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xF1, 0xEF, 0xF7,
  0xF0, 0xC0, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x03,
  0xEF, 0x01, 0xF3, 0xC0, 0xF8, 0xF0, 0x3C, 0x3C, 0x1E, 0x0F, 0x0F, 0x03,
  0xC7, 0x80, 0xF3, 0xC0, 0x3D, 0xE0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0xFD,
  0xE0, 0x3E, 0x7C, 0x0F, 0x0F, 0x03, 0xC1, 0xE0, 0xF0, 0x3C, 0x3C, 0x0F,
  0x8F, 0x01, 0xE3, 0xC0, 0x3C, 0xF0, 0x07, 0xBC, 0x01, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xF8, 0x07, 0xC1, 0xC7, 0xFC, 0x3F, 0xF3, 0xDF, 0xFC, 0xFF,
  0xF7, 0xF0, 0x7F, 0xC3, 0xEF, 0xC0, 0x7E, 0x01, 0xFF, 0x00, 0x78, 0x03,
  0xFE, 0x00, 0xF0, 0x03, 0xF8, 0x01, 0xE0, 0x07, 0xF0, 0x03, 0xC0, 0x0F,
  0xE0, 0x07, 0x80, 0x1F, 0xC0, 0x0F, 0x00, 0x3F, 0x80, 0x1E, 0x00, 0x7F,
  0x00, 0x3C, 0x00, 0xFE, 0x00, 0x78, 0x01, 0xFC, 0x00, 0xF0, 0x03, 0xF8,
  0x01, 0xE0, 0x07, 0xF0, 0x03, 0xC0, 0x0F, 0xE0, 0x07, 0x80, 0x1F, 0xC0,
  0x0F, 0x00, 0x3F, 0x80, 0x1E, 0x00, 0x7F, 0x00, 0x3C, 0x00, 0xFE, 0x00,
  0x78, 0x01, 0xC0, 0x00, 0xF8, 0x38, 0xFF, 0xCF, 0x7F, 0xFB, 0xFC, 0x3F,
  0xFC, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x70, 0x01, 0xF8, 0x00, 0x7F, 0xE0, 0x1F, 0xFF,
  0x83, 0xF0, 0xFC, 0x3C, 0x03, 0xC7, 0x80, 0x1E, 0x78, 0x00, 0xE7, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xF7, 0x00, 0x0F, 0x78, 0x01, 0xE3,
  0xC0, 0x1E, 0x3E, 0x03, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x3F, 0xE0,
  0x00, 0xF8, 0x1C, 0x7F, 0xC3, 0xDF, 0xFE, 0x7F, 0x87, 0xCF, 0xC0, 0x3D,
  0xF0, 0x07, 0xBE, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x7B, 0xF0, 0x1F, 0x7F, 0xFF, 0xCF,
  0x7F, 0xF1, 0xE7, 0xFC, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x01, 0xFF, 0x9C, 0x7F, 0xFB, 0x9F,
  0x07, 0xF3, 0xC0, 0x3E, 0xF0, 0x03, 0xDE, 0x00, 0x7B, 0x80, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x7B, 0x80, 0x0F, 0x78, 0x01, 0xEF, 0x00, 0x7C, 0xF0,
  0x1F, 0x8F, 0xFF, 0x71, 0xFF, 0xCE, 0x0F, 0xF1, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0xFF, 0x1F, 0xF9,
  0xFF, 0xFF, 0x1F, 0xE0, 0x7E, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x00, 0x07, 0xF0, 0x7F, 0xFD,
  0xFF, 0xFB, 0xC0, 0xEF, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x7C,
  0x00, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x07, 0xC0, 0x07,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1F, 0x00, 0x7F, 0xE7, 0xEF, 0xFF, 0x8F,
  0xFE, 0x00, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x7F, 0xFB,
  0xFF, 0xC3, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x78, 0x03, 0xF7, 0x0F, 0xF8, 0x3F, 0xC0, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xDE,
  0x03, 0xF7, 0xFF, 0xFC, 0xFF, 0xF7, 0x1F, 0xF1, 0xC0, 0xF0, 0x00, 0xF7,
  0x00, 0x0F, 0x78, 0x01, 0xE7, 0x80, 0x1E, 0x3C, 0x01, 0xC3, 0xC0, 0x3C,
  0x1C, 0x03, 0xC1, 0xE0, 0x38, 0x1E, 0x07, 0x80, 0xE0, 0x78, 0x0F, 0x07,
  0x00, 0x70, 0xF0, 0x07, 0x0E, 0x00, 0x78, 0xE0, 0x03, 0x9E, 0x00, 0x39,
  0xC0, 0x03, 0xDC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF0, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0xF0, 0x0F, 0x80, 0x39, 0xE0, 0x1F,
  0x80, 0x71, 0xC0, 0x3F, 0x01, 0xE3, 0x80, 0xEE, 0x03, 0xC7, 0x81, 0xDE,
  0x07, 0x0F, 0x03, 0x9C, 0x0E, 0x0E, 0x0F, 0x38, 0x3C, 0x1C, 0x1C, 0x70,
  0x78, 0x3C, 0x38, 0xF0, 0xE0, 0x78, 0xF0, 0xE1, 0xC0, 0x71, 0xC1, 0xC7,
  0x80, 0xE3, 0x83, 0xCE, 0x01, 0xEF, 0x03, 0x9C, 0x01, 0xDC, 0x07, 0x78,
  0x03, 0xB8, 0x0E, 0xF0, 0x07, 0x70, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80,
  0x0F, 0x80, 0x3F, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF8, 0x03, 0xEF, 0x00, 0x78, 0xF0, 0x1E, 0x0F, 0x07, 0x80, 0xE0, 0xF0,
  0x1E, 0x3C, 0x01, 0xEF, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0x78, 0x03, 0xC7, 0x80,
  0x70, 0x78, 0x1E, 0x0F, 0x07, 0x80, 0xF1, 0xE0, 0x0F, 0x3C, 0x01, 0xEF,
  0x00, 0x1E, 0xF0, 0x00, 0xF7, 0x80, 0x0F, 0x78, 0x00, 0xE3, 0x80, 0x1E,
  0x3C, 0x01, 0xE3, 0xC0, 0x3C, 0x1C, 0x03, 0xC1, 0xE0, 0x38, 0x0E, 0x07,
  0x80, 0xF0, 0x78, 0x0F, 0x07, 0x00, 0x70, 0xF0, 0x07, 0x8F, 0x00, 0x38,
  0xE0, 0x03, 0x9E, 0x00, 0x3D, 0xC0, 0x01, 0xDC, 0x00, 0x1F, 0xC0, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00,
  0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x08, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xE0, 0x00, 0x30, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x08, 0x07, 0xC0, 0x7E, 0x07, 0xE0, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x01, 0xE0, 0xFE, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x00, 0xF0, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xF8, 0x0F, 0xC0, 0x3E, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xC0, 0x3F, 0x80,
  0xFC, 0x00, 0xF0, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xF8, 0x07,
  0xC0, 0x7E, 0x07, 0xE0, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0xFE,
  0x07, 0xE0, 0x3E, 0x00, 0x1E, 0x00, 0x2F, 0xF8, 0x0F, 0xFF, 0xE7, 0xF0,
  0xFF, 0xF8, 0x07, 0xF9, 0x00, 0x04, 0x00,
};

const GFXglyph NotoSans_Regular40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 5, 30, 11, 3, -29 },
  { 20, 11, 11, 16, 3, -29 },
  { 36, 24, 29, 26, 1, -29 },
  { 123, 19, 32, 23, 2, -30 },
  { 199, 29, 29, 33, 2, -29 },
  { 305, 27, 29, 29, 2, -29 },
  { 403, 3, 11, 9, 3, -29 },
  { 408, 9, 35, 12, 2, -29 },
  { 448, 9, 35, 12, 1, -29 },
  { 488, 18, 18, 22, 2, -30 },
  { 529, 19, 20, 23, 2, -24 },
  { 577, 6, 10, 11, 2, -5 },
  { 585, 9, 3, 13, 2, -12 },
  { 589, 5, 6, 11, 3, -5 },
  { 593, 14, 29, 15, 0, -29 },
  { 644, 19, 29, 23, 2, -29 },
  { 713, 10, 29, 23, 4, -29 },
  { 750, 19, 29, 23, 2, -29 },
  { 819, 19, 29, 23, 2, -29 },
  { 888, 21, 29, 23, 1, -29 },
  { 965, 18, 29, 23, 3, -29 },
  { 1031, 19, 29, 23, 2, -29 },
  { 1100, 19, 29, 23, 2, -29 },
  { 1169, 19, 29, 23, 2, -29 },
  { 1238, 19, 29, 23, 2, -29 },
  { 1307, 5, 23, 11, 3, -22 },
  { 1322, 7, 27, 11, 1, -22 },
  { 1346, 19, 19, 23, 2, -24 },
  { 1392, 19, 10, 23, 2, -19 },
  { 1416, 19, 19, 23, 2, -24 },
  { 1462, 16, 30, 17, 0, -29 },
  { 1522, 32, 33, 36, 2, -29 },
  { 1654, 26, 29, 26, 0, -29 },
  { 1749, 20, 29, 26, 4, -29 },
  { 1822, 22, 29, 25, 2, -29 },
  { 1902, 23, 29, 29, 4, -29 },
  { 1986, 16, 29, 22, 4, -29 },
  { 2044, 16, 29, 21, 4, -29 },
  { 2102, 24, 29, 29, 2, -29 },
  { 2189, 22, 29, 30, 4, -29 },
  { 2269, 10, 29, 14, 2, -29 },
  { 2306, 10, 37, 11, -3, -29 },
  { 2353, 21, 29, 25, 4, -29 },
  { 2430, 16, 29, 21, 4, -29 },
  { 2488, 28, 29, 36, 4, -29 },
  { 2590, 23, 29, 30, 4, -29 },
  { 2674, 27, 29, 31, 2, -29 },
  { 2772, 18, 29, 24, 4, -29 },
  { 2838, 27, 36, 31, 2, -29 },
  { 2960, 20, 29, 25, 4, -29 },
  { 3033, 18, 29, 22, 2, -29 },
  { 3099, 22, 29, 22, 0, -29 },
  { 3179, 22, 29, 29, 4, -29 },
  { 3259, 24, 29, 24, 0, -29 },
  { 3346, 37, 29, 37, 0, -29 },
  { 3481, 23, 29, 23, 0, -29 },
  { 3565, 23, 29, 23, 0, -29 },
  { 3649, 19, 29, 23, 2, -29 },
  { 3718, 9, 35, 13, 3, -29 },
  { 3758, 15, 29, 15, 0, -29 },
  { 3813, 9, 35, 13, 1, -29 },
  { 3853, 19, 18, 23, 2, -29 },
  { 3896, 18, 2, 18, 0, 4 },
  { 3901, 8, 7, 11, 2, -31 },
  { 3908, 17, 22, 22, 2, -22 },
  { 3955, 19, 30, 25, 3, -30 },
  { 4027, 16, 22, 19, 2, -22 },
  { 4071, 19, 30, 25, 2, -30 },
  { 4143, 19, 22, 23, 2, -22 },
  { 4196, 14, 31, 14, 1, -31 },
  { 4251, 19, 32, 25, 2, -22 },
  { 4327, 18, 30, 25, 3, -30 },
  { 4395, 4, 29, 10, 3, -29 },
  { 4410, 9, 39, 10, -2, -29 },
  { 4454, 18, 30, 21, 3, -30 },
  { 4522, 4, 30, 10, 3, -30 },
  { 4537, 31, 22, 37, 3, -22 },
  { 4623, 18, 22, 25, 3, -22 },
  { 4673, 20, 22, 24, 2, -22 },
  { 4728, 19, 32, 25, 3, -22 },
  { 4804, 19, 32, 25, 2, -22 },
  { 4880, 13, 22, 17, 3, -22 },
  { 4916, 15, 22, 19, 2, -22 },
  { 4958, 13, 26, 14, 1, -26 },
  { 5001, 18, 21, 25, 3, -21 },
  { 5049, 20, 21, 20, 0, -21 },
  { 5102, 31, 21, 31, 0, -21 },
  { 5184, 19, 21, 21, 1, -21 },
  { 5234, 20, 31, 20, 0, -21 },
  { 5312, 15, 21, 19, 2, -21 },
  { 5352, 13, 35, 15, 1, -29 },
  { 5409, 2, 40, 22, 10, -30 },
  { 5419, 13, 35, 15, 1, -29 },
  { 5476, 19, 6, 23, 2, -17 },
};

const GFXfont NotoSans_Regular40pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Regular40pt7bBitmaps,
  (GFXglyph *)NotoSans_Regular40pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _NOTOSANS_REGULAR40PT7B_H_
