#ifndef _NOTOSANS_REGULAR49PT7B_H_
#define _NOTOSANS_REGULAR49PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Regular.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Regular49pt7bBitmaps[] PROGMEM = {
  0x00, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0x9E, 0x79, 0xE7,
  0x9C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x70, 0x00, 0x00, 0x01, 0xCF,
  0xBF, 0xFF, 0xEF, 0x9C, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0x78,
  0x79, 0xC0, 0xE7, 0x03, 0x9C, 0x0E, 0x70, 0x39, 0xC0, 0xE7, 0x03, 0x9C,
  0x0E, 0x70, 0x38, 0x00, 0x1E, 0x03, 0x80, 0x00, 0xE0, 0x3C, 0x00, 0x07,
  0x01, 0xE0, 0x00, 0x78, 0x0E, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x1E, 0x03,
  0x80, 0x00, 0xE0, 0x1C, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x38, 0x0F, 0x00,
  0x03, 0xC0, 0x70, 0x0F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0x03, 0xC0, 0x70, 0x00, 0x1E, 0x03,
  0x80, 0x00, 0xE0, 0x3C, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x38, 0x0F, 0x00,
  0x03, 0xC0, 0x70, 0x00, 0x1E, 0x03, 0x80, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF0, 0x1E, 0x03,
  0x80, 0x00, 0xF0, 0x1C, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x38, 0x0F, 0x00,
  0x01, 0xC0, 0x70, 0x00, 0x1E, 0x03, 0x80, 0x00, 0xF0, 0x1C, 0x00, 0x07,
  0x01, 0xE0, 0x00, 0x38, 0x0F, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x01, 0xFF, 0x00,
  0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x7E, 0x78, 0x73, 0xE1,
  0xE0, 0x4F, 0x07, 0x80, 0x3C, 0x1E, 0x00, 0xF0, 0x78, 0x03, 0xE1, 0xE0,
  0x0F, 0x87, 0x80, 0x1F, 0x1E, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x01,
  0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x07,
  0xBF, 0x80, 0x1E, 0x1F, 0x00, 0x78, 0x3C, 0x01, 0xE0, 0xF0, 0x07, 0x83,
  0xC0, 0x1E, 0x0F, 0x00, 0x78, 0x7F, 0x01, 0xE3, 0xFF, 0xC7, 0xFF, 0xBF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xE1, 0xFF, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x0F, 0xE0, 0x00, 0x3C, 0x01, 0xFF, 0x00, 0x07, 0x80, 0x3F, 0xF8, 0x00,
  0x78, 0x03, 0x83, 0xC0, 0x0F, 0x00, 0x78, 0x3C, 0x00, 0xE0, 0x07, 0x81,
  0xC0, 0x1E, 0x00, 0x70, 0x1E, 0x01, 0xC0, 0x07, 0x01, 0xE0, 0x3C, 0x00,
  0xF0, 0x1E, 0x07, 0x80, 0x0F, 0x01, 0xE0, 0x78, 0x00, 0xF0, 0x1E, 0x0F,
  0x00, 0x0F, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0x1E, 0x1E, 0x00, 0x07, 0x01,
  0xE1, 0xC0, 0x00, 0x70, 0x1E, 0x3C, 0x7F, 0x87, 0x81, 0xC3, 0x8F, 0xFC,
  0x78, 0x3C, 0x79, 0xFF, 0xC3, 0xC3, 0xCF, 0x1E, 0x1E, 0x3F, 0xF8, 0xF1,
  0xC0, 0xE1, 0xFF, 0x1E, 0x3C, 0x0F, 0x0F, 0xE1, 0xE3, 0xC0, 0xF0, 0x00,
  0x3C, 0x3C, 0x07, 0x00, 0x03, 0x83, 0x80, 0x70, 0x00, 0x78, 0x38, 0x07,
  0x00, 0x07, 0x03, 0x80, 0x70, 0x00, 0xF0, 0x38, 0x07, 0x00, 0x1E, 0x03,
  0x80, 0x70, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0x3C, 0x03, 0xC0, 0xF0, 0x03,
  0xC0, 0x3C, 0x0F, 0x00, 0x78, 0x01, 0xC0, 0xE0, 0x07, 0x80, 0x1E, 0x1E,
  0x00, 0xF0, 0x00, 0xFF, 0xE0, 0x0E, 0x00, 0x0F, 0xFC, 0x01, 0xE0, 0x00,
  0x7F, 0x80, 0x00, 0x10, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0xF8,
  0x0F, 0x80, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x01,
  0xE0, 0x3E, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0x83, 0xF7, 0xE0, 0x07,
  0x83, 0xF1, 0xF8, 0x03, 0xC3, 0xF0, 0x7E, 0x03, 0xE1, 0xF0, 0x1F, 0x81,
  0xE1, 0xF0, 0x07, 0xE0, 0xF0, 0xF0, 0x01, 0xF8, 0xF8, 0x78, 0x00, 0x7E,
  0xF8, 0x3C, 0x00, 0x1F, 0xFC, 0x1E, 0x00, 0x07, 0xFC, 0x0F, 0x00, 0x01,
  0xFC, 0x07, 0xC0, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0xFF, 0x80, 0xFC, 0x01,
  0xFF, 0xE0, 0x7F, 0xC7, 0xFD, 0xF8, 0x1F, 0xFF, 0xFC, 0x7E, 0x07, 0xFF,
  0xF8, 0x1F, 0x80, 0xFF, 0xF0, 0x07, 0xF0, 0xFF, 0xFF, 0xF7, 0xB9, 0xCE,
  0x73, 0x9C, 0xE7, 0x00, 0x01, 0xE0, 0x78, 0x1F, 0x03, 0xC0, 0xF0, 0x1E,
  0x07, 0x80, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x1E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1F, 0x03, 0xE0, 0x7C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xE0,
  0x3C, 0x07, 0x80, 0xF8, 0x0F, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x3C, 0x07,
  0xC0, 0x78, 0x07, 0x80, 0xF8, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x1F, 0x00,
  0xF0, 0x0F, 0x80, 0x78, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x3C, 0x03, 0xE0,
  0x3E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x3E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x0F, 0x80,
  0xF0, 0x1F, 0x01, 0xE0, 0x3C, 0x07, 0xC0, 0x78, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x38, 0x1C, 0x0E, 0xFF, 0x39, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x7B, 0xC0, 0x01, 0xE7, 0xC0, 0x07, 0xC7, 0x80, 0x0F, 0x0F,
  0x80, 0x3E, 0x0F, 0x80, 0xFC, 0x1F, 0x80, 0x70, 0x1C, 0x00, 0x20, 0x20,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x3E, 0x7C,
  0xF9, 0xF3, 0xC7, 0x9F, 0x3C, 0x78, 0xE3, 0xC7, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x73, 0xEF, 0xFF, 0xFB, 0xE7, 0x00, 0x00, 0x07, 0xC0,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x10, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF,
  0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xC3, 0xF0, 0x1F, 0x00, 0xF8, 0x3E, 0x00,
  0x78, 0x3C, 0x00, 0x7C, 0x3C, 0x00, 0x3C, 0x7C, 0x00, 0x3E, 0x78, 0x00,
  0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00,
  0x1E, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x78, 0x00,
  0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00,
  0x1E, 0x7C, 0x00, 0x3E, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x7C, 0x1E, 0x00,
  0x7C, 0x1F, 0x00, 0xF8, 0x0F, 0xC3, 0xF0, 0x07, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x00, 0x78, 0x07, 0xC0, 0x7E, 0x0F, 0xF0, 0xFF,
  0x8F, 0xBD, 0xF9, 0xFF, 0x8F, 0x78, 0x79, 0x83, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC3, 0xFC, 0x3F,
  0xC7, 0xC0, 0x0F, 0x87, 0x00, 0x0F, 0x84, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0xC1,
  0xFF, 0xFF, 0xC7, 0xF8, 0x1F, 0xC7, 0x80, 0x0F, 0x84, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x01, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x0F, 0xFF,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xB0, 0x00, 0x3F, 0x7E,
  0x03, 0xFC, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xC0, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xDE, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x79,
  0xE0, 0x00, 0x3E, 0x78, 0x00, 0x0F, 0x1E, 0x00, 0x07, 0x87, 0x80, 0x03,
  0xC1, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x78, 0x1E, 0x00, 0x3C, 0x07, 0x80,
  0x0F, 0x01, 0xE0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x07,
  0x80, 0x78, 0x01, 0xE0, 0x3C, 0x00, 0x78, 0x1E, 0x00, 0x1E, 0x07, 0x80,
  0x07, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFC, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xE0, 0xE0, 0x3F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xEC, 0x00, 0x1F, 0x3F, 0x03, 0xFC, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xE0,
  0x0F, 0xFF, 0xC0, 0x3F, 0x80, 0x80, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x0F, 0xE0, 0x3C, 0x7F,
  0xF0, 0x79, 0xFF, 0xF8, 0xF7, 0xFF, 0xF1, 0xFE, 0x01, 0xF3, 0xF0, 0x01,
  0xF7, 0xC0, 0x03, 0xEF, 0x80, 0x03, 0xDE, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0xF3,
  0xC0, 0x01, 0xE7, 0xC0, 0x07, 0xC7, 0x80, 0x0F, 0x8F, 0x80, 0x3E, 0x0F,
  0xC1, 0xF8, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x07,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0x81, 0xF8, 0x3E, 0x00, 0x7C, 0x3C,
  0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C,
  0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0xF8, 0x0F,
  0xC1, 0xF0, 0x07, 0xE7, 0xE0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x1F, 0x83, 0xF8, 0x3F, 0x00, 0xFC, 0x3C,
  0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x7C,
  0x00, 0x3E, 0x7E, 0x00, 0x7C, 0x3F, 0x00, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x3F,
  0xFF, 0x80, 0xFC, 0x1F, 0x83, 0xE0, 0x0F, 0x87, 0x80, 0x0F, 0x1F, 0x00,
  0x0F, 0x3C, 0x00, 0x1E, 0x78, 0x00, 0x3E, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xEF, 0x00, 0x03, 0xDE, 0x00, 0x07,
  0xBE, 0x00, 0x1F, 0x7C, 0x00, 0x7E, 0x7C, 0x01, 0xFC, 0x7F, 0xBF, 0x78,
  0x7F, 0xFC, 0xF0, 0x7F, 0xF1, 0xE0, 0x3F, 0x83, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x08, 0x0F,
  0xE0, 0x1F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x73, 0xEF,
  0xFF, 0xFB, 0xE7, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xCF, 0xBF, 0xFF, 0xEF, 0x9C, 0x1C, 0x3E, 0x7E, 0x7F, 0x3E,
  0x3E, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x3E, 0x3E, 0x7C, 0x7C, 0x7C, 0x78, 0x78,
  0xF0, 0xF0, 0xF0, 0xE0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x01,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x7E,
  0x0F, 0xE6, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x7F,
  0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x00, 0x01, 0xE3, 0xC0, 0x1F, 0xFE, 0x07, 0x8F, 0x00,
  0xFF, 0xFC, 0x0E, 0x78, 0x07, 0xFF, 0xE0, 0x3D, 0xE0, 0x3E, 0x03, 0x80,
  0xF7, 0x01, 0xE0, 0x0E, 0x01, 0xFC, 0x07, 0x80, 0x38, 0x07, 0xF0, 0x3C,
  0x00, 0xE0, 0x1F, 0xC0, 0xF0, 0x07, 0x80, 0x7F, 0x03, 0xC0, 0x1E, 0x01,
  0xF8, 0x0F, 0x00, 0x78, 0x07, 0xE0, 0x38, 0x01, 0xE0, 0x1F, 0x80, 0xE0,
  0x07, 0x80, 0xFE, 0x03, 0xC0, 0x1E, 0x03, 0xF8, 0x0F, 0x00, 0x78, 0x0E,
  0xF0, 0x3C, 0x03, 0xE0, 0x7B, 0xC0, 0x78, 0x1D, 0xC3, 0xCF, 0x01, 0xF9,
  0xF7, 0x9F, 0x1C, 0x03, 0xFF, 0x9F, 0xF8, 0x78, 0x07, 0xFC, 0x3F, 0xC1,
  0xE0, 0x03, 0x80, 0x18, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0x80, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00,
  0x07, 0xBC, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00,
  0x78, 0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x07,
  0x83, 0xE0, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x78,
  0x0F, 0x80, 0x01, 0xF0, 0x0F, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x0F, 0x80,
  0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0x80, 0x01,
  0xE0, 0x1E, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x1F,
  0x3E, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x78, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF8, 0xF0, 0x01, 0xFC, 0xF0, 0x00, 0x7E, 0xF0, 0x00,
  0x3E, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x3E, 0xF0, 0x00,
  0x3E, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x7C, 0xF0, 0x01,
  0xF8, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF8, 0xF0, 0x00, 0xFC, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3E, 0xF0, 0x00,
  0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x1F,
  0xFC, 0xFF, 0x0F, 0xE0, 0x01, 0x83, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x08, 0x1F, 0xFC, 0xFE, 0x03, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0xF0, 0x01, 0xFE,
  0x0F, 0x00, 0x03, 0xF0, 0xF0, 0x00, 0x1F, 0x8F, 0x00, 0x00, 0xFC, 0xF0,
  0x00, 0x07, 0xCF, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x03, 0xEF, 0x00, 0x00,
  0x3E, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1E,
  0xF0, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x03, 0xEF, 0x00,
  0x00, 0x7C, 0xF0, 0x00, 0x07, 0xCF, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x1F,
  0x8F, 0x00, 0x07, 0xF0, 0xF0, 0x01, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xFF, 0xFE,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0x1F,
  0xE0, 0x7F, 0x00, 0x0E, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0x0F, 0x7C, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x1E,
  0x7C, 0x00, 0x00, 0xF1, 0xF0, 0x00, 0x07, 0x8F, 0xE0, 0x00, 0x3C, 0x3F,
  0x80, 0x01, 0xE0, 0xFF, 0xE1, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x3E, 0xFF, 0xF7, 0xFF, 0x3F, 0xF1, 0xFE,
  0x00, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x3C, 0x00, 0x1F, 0x9E, 0x00,
  0x0F, 0x8F, 0x00, 0x0F, 0x87, 0x80, 0x0F, 0x83, 0xC0, 0x0F, 0x81, 0xE0,
  0x0F, 0x80, 0xF0, 0x0F, 0x80, 0x78, 0x0F, 0x80, 0x3C, 0x0F, 0x80, 0x1E,
  0x0F, 0x80, 0x0F, 0x0F, 0x80, 0x07, 0x87, 0xC0, 0x03, 0xC7, 0xC0, 0x01,
  0xE7, 0xC0, 0x00, 0xF7, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00,
  0x1F, 0x8F, 0x80, 0x0F, 0x87, 0xE0, 0x07, 0x81, 0xF0, 0x03, 0xC0, 0x7C,
  0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0xC0, 0x78, 0x03, 0xE0, 0x3C, 0x00,
  0xF8, 0x1E, 0x00, 0x3E, 0x0F, 0x00, 0x1F, 0x87, 0x80, 0x07, 0xC3, 0xC0,
  0x01, 0xF1, 0xE0, 0x00, 0x7C, 0xF0, 0x00, 0x3F, 0x78, 0x00, 0x0F, 0xBC,
  0x00, 0x03, 0xE0, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0xF0, 0x00, 0x03,
  0xDF, 0xFE, 0x00, 0x00, 0x7B, 0xFF, 0xE0, 0x00, 0x0F, 0x7F, 0xBC, 0x00,
  0x03, 0xDF, 0xF7, 0x80, 0x00, 0x7B, 0xFE, 0x78, 0x00, 0x0F, 0x7F, 0xCF,
  0x00, 0x03, 0xCF, 0xF9, 0xF0, 0x00, 0x79, 0xFF, 0x1E, 0x00, 0x1E, 0x3F,
  0xE3, 0xC0, 0x03, 0xC7, 0xFC, 0x7C, 0x00, 0x78, 0xFF, 0x87, 0x80, 0x1E,
  0x1F, 0xF0, 0xF0, 0x03, 0xC3, 0xFE, 0x0F, 0x00, 0x70, 0x7F, 0xC1, 0xE0,
  0x1E, 0x0F, 0xF8, 0x3E, 0x03, 0xC1, 0xFF, 0x03, 0xC0, 0xF0, 0x3F, 0xE0,
  0x78, 0x1E, 0x07, 0xFC, 0x0F, 0x83, 0xC0, 0xFF, 0x80, 0xF0, 0xF0, 0x1F,
  0xF0, 0x1E, 0x1E, 0x03, 0xFE, 0x01, 0xE7, 0x80, 0x7F, 0xC0, 0x3C, 0xF0,
  0x0F, 0xF8, 0x07, 0xDE, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x0F,
  0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0x80, 0x1F, 0xF0,
  0x03, 0xF0, 0x03, 0xFE, 0x00, 0x3C, 0x00, 0x7F, 0xC0, 0x07, 0x80, 0x0F,
  0x80, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFB, 0xE0, 0x00,
  0x7F, 0xBE, 0x00, 0x0F, 0xF7, 0xC0, 0x01, 0xFE, 0x7C, 0x00, 0x3F, 0xC7,
  0xC0, 0x07, 0xF8, 0xF8, 0x00, 0xFF, 0x0F, 0x80, 0x1F, 0xE1, 0xF8, 0x03,
  0xFC, 0x1F, 0x00, 0x7F, 0x81, 0xF0, 0x0F, 0xF0, 0x3E, 0x01, 0xFE, 0x03,
  0xE0, 0x3F, 0xC0, 0x3E, 0x07, 0xF8, 0x07, 0xC0, 0xFF, 0x00, 0x7C, 0x1F,
  0xE0, 0x07, 0xC3, 0xFC, 0x00, 0xF8, 0x7F, 0x80, 0x0F, 0x8F, 0xF0, 0x00,
  0xF9, 0xFE, 0x00, 0x1F, 0x1F, 0xC0, 0x01, 0xF3, 0xF8, 0x00, 0x1F, 0x7F,
  0x00, 0x03, 0xEF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFE, 0x3F, 0xE0, 0x0F, 0xE0, 0x03, 0xF0,
  0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x00, 0x7C,
  0x3C, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x1E,
  0x78, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0x78, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0x3E,
  0x3E, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xFC,
  0x1F, 0x80, 0x01, 0xF8, 0x0F, 0xE0, 0x03, 0xF0, 0x07, 0xFE, 0x3F, 0xE0,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0xF0,
  0x03, 0xFB, 0xC0, 0x07, 0xEF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0x00, 0x07, 0xBC, 0x00, 0x3E, 0xF0, 0x03, 0xF3, 0xC0,
  0xFF, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xE0, 0xFF, 0xFE, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFE, 0x3F, 0xE0, 0x0F, 0xE0, 0x03,
  0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x00,
  0x7C, 0x3C, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00,
  0x1E, 0x78, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x1F, 0x78, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00,
  0x3E, 0x3E, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00,
  0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x0F, 0xE0, 0x03, 0xF0, 0x07, 0xFE, 0x3F,
  0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0x00, 0x3F,
  0x87, 0x80, 0x07, 0xC3, 0xC0, 0x01, 0xF1, 0xE0, 0x00, 0xF8, 0xF0, 0x00,
  0x7C, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x8F, 0x00,
  0x07, 0xC7, 0x80, 0x03, 0xE3, 0xC0, 0x03, 0xE1, 0xE0, 0x03, 0xF0, 0xF0,
  0x0F, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x80,
  0xF0, 0x07, 0xC0, 0x78, 0x01, 0xF0, 0x3C, 0x00, 0x7C, 0x1E, 0x00, 0x3E,
  0x0F, 0x00, 0x0F, 0x87, 0x80, 0x07, 0xC3, 0xC0, 0x01, 0xF1, 0xE0, 0x00,
  0x7C, 0xF0, 0x00, 0x3E, 0x78, 0x00, 0x0F, 0xBC, 0x00, 0x07, 0xE0, 0x01,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF, 0x1F, 0xC3, 0xF0,
  0x03, 0x8F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0xB8, 0x00, 0x3E, 0x7F, 0x83, 0xFC, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0x80, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x0F, 0xBE, 0x00,
  0x01, 0xF7, 0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x87, 0xE0, 0x07, 0xE0,
  0xFF, 0x87, 0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x00, 0xF8, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x07, 0xDE, 0x00, 0x00,
  0x3E, 0xF8, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0xF0,
  0xF8, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xC0, 0xF8,
  0x00, 0x3E, 0x03, 0xC0, 0x01, 0xF0, 0x1F, 0x00, 0x0F, 0x00, 0xF8, 0x00,
  0xF8, 0x03, 0xC0, 0x07, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x03, 0xE0,
  0x03, 0xC0, 0x1F, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x78, 0x0F, 0x80, 0x03,
  0xC0, 0x78, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x78, 0x3E, 0x00, 0x03, 0xE1,
  0xE0, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x78, 0xF8, 0x00, 0x03, 0xC7, 0x80,
  0x00, 0x1F, 0x3C, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x03, 0xDE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xFF, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xE7, 0x80, 0x03, 0xF8, 0x00, 0x3E, 0x78, 0x00, 0x3F, 0x80, 0x03,
  0xE7, 0xC0, 0x03, 0xFC, 0x00, 0x3C, 0x7C, 0x00, 0x7B, 0xC0, 0x03, 0xC3,
  0xC0, 0x07, 0xBC, 0x00, 0x7C, 0x3C, 0x00, 0x7B, 0xC0, 0x07, 0xC3, 0xE0,
  0x07, 0x9E, 0x00, 0x78, 0x3E, 0x00, 0xF1, 0xE0, 0x07, 0x81, 0xE0, 0x0F,
  0x1E, 0x00, 0xF8, 0x1E, 0x00, 0xF1, 0xF0, 0x0F, 0x81, 0xF0, 0x1F, 0x0F,
  0x00, 0xF0, 0x1F, 0x01, 0xE0, 0xF0, 0x0F, 0x00, 0xF0, 0x1E, 0x0F, 0x81,
  0xF0, 0x0F, 0x03, 0xE0, 0x78, 0x1F, 0x00, 0xF8, 0x3C, 0x07, 0x81, 0xE0,
  0x0F, 0x83, 0xC0, 0x78, 0x1E, 0x00, 0x78, 0x3C, 0x03, 0xC3, 0xE0, 0x07,
  0x87, 0xC0, 0x3C, 0x3E, 0x00, 0x7C, 0x78, 0x03, 0xC3, 0xC0, 0x03, 0xC7,
  0x80, 0x3E, 0x3C, 0x00, 0x3C, 0x78, 0x01, 0xE7, 0xC0, 0x03, 0xCF, 0x00,
  0x1E, 0x78, 0x00, 0x3E, 0xF0, 0x01, 0xE7, 0x80, 0x01, 0xEF, 0x00, 0x0F,
  0x78, 0x00, 0x1E, 0xF0, 0x00, 0xF7, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x01, 0xF1, 0xF0, 0x00, 0x1F, 0x07, 0x80, 0x01, 0xF0, 0x3E, 0x00, 0x0F,
  0x00, 0xF8, 0x00, 0xF8, 0x07, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x78, 0x00,
  0x7C, 0x07, 0xC0, 0x03, 0xE0, 0x3C, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3C,
  0x3E, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x1E, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xDE, 0x00, 0x00, 0x3C, 0xF8, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x1E, 0x0F,
  0x00, 0x01, 0xE0, 0x7C, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0xF0, 0x0F, 0x80,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x00, 0xF0, 0x07, 0x80, 0x07, 0xC0, 0x7C,
  0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x3C, 0x00, 0x03, 0xE3, 0xE0, 0x00,
  0x0F, 0xBE, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3E,
  0x7C, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0x81, 0xF0,
  0x00, 0xF8, 0x1F, 0x00, 0x0F, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0x80, 0x3E,
  0x00, 0x7C, 0x03, 0xE0, 0x03, 0xC0, 0x7C, 0x00, 0x3E, 0x07, 0x80, 0x01,
  0xE0, 0xF8, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0xF1, 0xF0, 0x00, 0x0F, 0x9E,
  0x00, 0x00, 0x7B, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7C,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x38, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0xEF, 0x00, 0x01, 0xE7, 0x00, 0x01, 0xC7, 0x80,
  0x03, 0xC3, 0x80, 0x03, 0x83, 0xC0, 0x07, 0x81, 0xC0, 0x07, 0x01, 0xE0,
  0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x1E, 0x00, 0x70, 0x1E, 0x00, 0x78,
  0x3C, 0x00, 0x38, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x1C, 0x78, 0x00, 0x1E,
  0x70, 0x00, 0x0E, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0x07, 0xC0, 0xF8, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x00, 0x7E, 0x00, 0x0F, 0xFF, 0x01, 0xFF, 0xFE, 0x03,
  0xFF, 0xFC, 0x0F, 0x01, 0xF8, 0x20, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x0F, 0xFF,
  0x03, 0xFF, 0xFC, 0x3F, 0xFF, 0xF3, 0xFF, 0x07, 0xDF, 0x80, 0x1F, 0x7C,
  0x00, 0x7D, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xE0, 0x03, 0xF7, 0xC0, 0x1F, 0xDF, 0x81, 0xEF, 0x3F, 0xFF, 0x3C,
  0xFF, 0xF8, 0xF0, 0xFF, 0xC3, 0xC0, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x78, 0x07, 0x8F, 0xFE, 0x0F, 0x3F, 0xFE, 0x1E, 0xFF, 0xFE, 0x3F, 0xC0,
  0x7E, 0x7F, 0x00, 0x7E, 0xFC, 0x00, 0x7D, 0xF0, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0x7E,
  0x00, 0x3E, 0xFE, 0x00, 0xFD, 0xFF, 0x07, 0xF3, 0xDF, 0xFF, 0xC7, 0x9F,
  0xFF, 0x0E, 0x0F, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x7F, 0xFC, 0x3F, 0xFF,
  0x8F, 0xFF, 0xE3, 0xF8, 0x1C, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x09,
  0xFC, 0x1E, 0x1F, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x03, 0xE0, 0x78, 0x3F, 0xF8, 0xF0, 0xFF, 0xF9, 0xE3,
  0xFF, 0xFB, 0xCF, 0xC0, 0x7F, 0xBF, 0x00, 0x7F, 0x7C, 0x00, 0x7E, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07,
  0xDE, 0x00, 0x0F, 0xBE, 0x00, 0x3F, 0x3E, 0x00, 0xFE, 0x7F, 0x07, 0xFC,
  0x7F, 0xFF, 0x78, 0x7F, 0xFC, 0xF0, 0x3F, 0xE1, 0xE0, 0x00, 0x78, 0x00,
  0x0F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0x03, 0xF0, 0xF8,
  0x03, 0xE7, 0xC0, 0x0F, 0x9E, 0x00, 0x1E, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x87, 0xF0, 0x3E, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x1F, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0x82, 0x07, 0xC0, 0x01,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x01, 0xFF, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF, 0x80, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x0F, 0xFE, 0x3C, 0x3F, 0xFE, 0x78, 0xFF, 0xFE, 0xF3,
  0xF0, 0x1F, 0xEF, 0xC0, 0x1F, 0xDF, 0x00, 0x1F, 0xBC, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xF7, 0x80, 0x03,
  0xEF, 0x80, 0x0F, 0xCF, 0x80, 0x3F, 0x9F, 0xC1, 0xFF, 0x1F, 0xFF, 0xDE,
  0x1F, 0xFF, 0x3C, 0x0F, 0xF8, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x40,
  0x01, 0xF8, 0xF0, 0x07, 0xE1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x03, 0xFF,
  0xF8, 0x00, 0x3F, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x01, 0xE0, 0x3C,
  0x3F, 0xF0, 0xF3, 0xFF, 0xF3, 0xDF, 0xFF, 0xEF, 0xF8, 0x1F, 0xBF, 0x80,
  0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3C, 0x77,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3D, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF,
  0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xE0, 0x00, 0xE0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x3E, 0xFF, 0xEF, 0xFC, 0xFF, 0x83, 0xE0, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0xBC, 0x00, 0x7C, 0xF0, 0x03, 0xE3, 0xC0, 0x1F,
  0x0F, 0x00, 0xF8, 0x3C, 0x07, 0xC0, 0xF0, 0x3F, 0x03, 0xC0, 0xF8, 0x0F,
  0x07, 0xC0, 0x3C, 0x3E, 0x00, 0xF1, 0xF0, 0x03, 0xCF, 0x80, 0x0F, 0x7E,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFB, 0xE0, 0x0F, 0x87, 0xC0,
  0x3C, 0x1F, 0x80, 0xF0, 0x3E, 0x03, 0xC0, 0x7C, 0x0F, 0x00, 0xF8, 0x3C,
  0x03, 0xF0, 0xF0, 0x07, 0xC3, 0xC0, 0x0F, 0x8F, 0x00, 0x1F, 0x3C, 0x00,
  0x7E, 0xF0, 0x00, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x1E, 0x00, 0x1F, 0x03, 0xC7, 0xFF, 0x03, 0xFF, 0x0F, 0x3F, 0xFE, 0x3F,
  0xFF, 0x3D, 0xFF, 0xFD, 0xFF, 0xFC, 0xFF, 0x03, 0xF7, 0x81, 0xFB, 0xF8,
  0x03, 0xF8, 0x03, 0xEF, 0xC0, 0x0F, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0x00,
  0x1F, 0xF8, 0x00, 0x7C, 0x00, 0x7F, 0xE0, 0x01, 0xE0, 0x00, 0xFF, 0x80,
  0x07, 0x80, 0x03, 0xFE, 0x00, 0x1E, 0x00, 0x0F, 0xF8, 0x00, 0x78, 0x00,
  0x3F, 0xC0, 0x01, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0x80, 0x03, 0xFC, 0x00,
  0x1E, 0x00, 0x0F, 0xF0, 0x00, 0x78, 0x00, 0x3F, 0xC0, 0x01, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0x80, 0x03, 0xFC, 0x00, 0x1E, 0x00, 0x0F, 0xF0, 0x00,
  0x78, 0x00, 0x3F, 0xC0, 0x01, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0x80, 0x03,
  0xFC, 0x00, 0x1E, 0x00, 0x0F, 0xF0, 0x00, 0x78, 0x00, 0x3F, 0xC0, 0x01,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x1F, 0x03, 0xC3,
  0xFF, 0x8F, 0x3F, 0xFF, 0x3D, 0xFF, 0xFE, 0xFF, 0x01, 0xFB, 0xF8, 0x01,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x3F,
  0x01, 0xF8, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0x3C, 0x78, 0x00, 0x3E, 0xF8,
  0x00, 0x1E, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x7C,
  0x00, 0x3E, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0xFC, 0x1F, 0x81, 0xF8, 0x0F,
  0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x3E, 0x01, 0xE3,
  0xFF, 0x83, 0xCF, 0xFF, 0x87, 0xBF, 0xFF, 0x8F, 0xF0, 0x1F, 0x9F, 0xC0,
  0x1F, 0xBF, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x03, 0xDF, 0x80, 0x0F, 0xBF,
  0x80, 0x3F, 0x7F, 0xC1, 0xFC, 0xF7, 0xFF, 0xF1, 0xE7, 0xFF, 0xC3, 0xC3,
  0xFE, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x0F, 0xFE, 0x3C, 0x3F, 0xFE, 0x78, 0xFF, 0xFE,
  0xF3, 0xF0, 0x1F, 0xEF, 0xC0, 0x1F, 0xDF, 0x00, 0x1F, 0xBC, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xF7, 0x80,
  0x03, 0xEF, 0x80, 0x0F, 0xCF, 0x80, 0x3F, 0x9F, 0xC1, 0xFF, 0x1F, 0xFF,
  0xDE, 0x1F, 0xFF, 0x3C, 0x0F, 0xF8, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x3F, 0xF0, 0xFE, 0xF1, 0xFE,
  0xF3, 0xFE, 0xF7, 0xC2, 0xFF, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0x00, 0xF8, 0x01, 0xFF, 0xF0, 0x7F, 0xFF, 0x9F, 0xFF, 0xE7, 0xC0, 0x1C,
  0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x01,
  0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0x01, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xD0, 0x00, 0xFB, 0xC0, 0x3E, 0x7F, 0xFF, 0xCF,
  0xFF, 0xE0, 0xFF, 0xF8, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x1F, 0x00, 0x7F, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x80, 0x0F, 0xC1, 0x07, 0xFF, 0x07, 0xFF, 0x01, 0xFF, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFD, 0xF0, 0x07, 0xF7, 0xE0, 0x7F,
  0xCF, 0xFF, 0xEF, 0x1F, 0xFF, 0x3C, 0x3F, 0xF0, 0xF0, 0xF8, 0x00, 0x0F,
  0xBC, 0x00, 0x07, 0x9F, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xC3, 0xC0, 0x01,
  0xE1, 0xF0, 0x01, 0xF0, 0x78, 0x00, 0xF0, 0x3C, 0x00, 0xF8, 0x1F, 0x00,
  0x7C, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x1E, 0x00, 0x78,
  0x0F, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x03,
  0xE3, 0xE0, 0x00, 0xF1, 0xE0, 0x00, 0x78, 0xF0, 0x00, 0x3E, 0xF0, 0x00,
  0x0F, 0x78, 0x00, 0x07, 0xBC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0xC0, 0x07, 0xBE, 0x00, 0x7F, 0x00, 0x3C, 0xF0, 0x03, 0xF8,
  0x01, 0xE7, 0x80, 0x3F, 0xC0, 0x1F, 0x3C, 0x01, 0xEE, 0x00, 0xF1, 0xF0,
  0x0F, 0x78, 0x07, 0x87, 0x80, 0xF3, 0xC0, 0x7C, 0x3C, 0x07, 0x9E, 0x03,
  0xE1, 0xF0, 0x3C, 0x78, 0x1E, 0x0F, 0x81, 0xE3, 0xC0, 0xF0, 0x3C, 0x1E,
  0x1E, 0x0F, 0x81, 0xE0, 0xF0, 0x78, 0x78, 0x0F, 0x87, 0x83, 0xC3, 0xC0,
  0x3C, 0x78, 0x1E, 0x1E, 0x01, 0xE3, 0xC0, 0xF1, 0xF0, 0x0F, 0x1E, 0x03,
  0xCF, 0x00, 0x7D, 0xE0, 0x1E, 0x78, 0x01, 0xEF, 0x00, 0xF3, 0xC0, 0x0F,
  0x78, 0x03, 0xFC, 0x00, 0x7B, 0x80, 0x1F, 0xE0, 0x01, 0xDC, 0x00, 0xFF,
  0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x3C,
  0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0xF8, 0x0F, 0x01, 0xF0, 0x0F,
  0x81, 0xE0, 0x07, 0xC3, 0xE0, 0x03, 0xE7, 0xC0, 0x01, 0xE7, 0x80, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xE7, 0x80, 0x03,
  0xE7, 0xC0, 0x07, 0xC3, 0xE0, 0x0F, 0x81, 0xE0, 0x0F, 0x81, 0xF0, 0x1F,
  0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x3C, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xBC, 0x00, 0x07, 0x9F, 0x00, 0x07, 0xC7,
  0x80, 0x03, 0xE3, 0xC0, 0x01, 0xE1, 0xF0, 0x01, 0xF0, 0x78, 0x00, 0xF0,
  0x3E, 0x00, 0x78, 0x0F, 0x00, 0x7C, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x3E,
  0x00, 0xF0, 0x1F, 0x00, 0x7C, 0x0F, 0x00, 0x1E, 0x0F, 0x80, 0x0F, 0x07,
  0x80, 0x07, 0xC3, 0xC0, 0x01, 0xE3, 0xE0, 0x00, 0xF1, 0xE0, 0x00, 0x3C,
  0xF0, 0x00, 0x1E, 0xF8, 0x00, 0x0F, 0x78, 0x00, 0x03, 0xBC, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x80, 0x01, 0xE0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x03, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0xFF, 0x00, 0xFF, 0x01,
  0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x7F, 0x80, 0xFE, 0x00, 0xF8, 0x00, 0xFF,
  0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF8, 0x00, 0xFF, 0x00,
  0x7F, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0xF0, 0x01, 0xF8, 0x03, 0xF8, 0x07, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0xF0, 0x0F, 0xE0, 0x07, 0xC0, 0x3F, 0x81, 0xFC, 0x03, 0xC0, 0x0F,
  0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x07,
  0xE0, 0x7F, 0x80, 0xFE, 0x01, 0xF0, 0x03, 0x80, 0x00, 0x3F, 0xE0, 0x03,
  0x7F, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFE, 0xC0, 0x1F, 0xFC,
  0x80, 0x03, 0xF0,
};

const GFXglyph NotoSans_Regular49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 6, 36, 13, 4, -35 },
  { 28, 14, 13, 20, 3, -35 },
  { 51, 29, 35, 32, 1, -35 },
  { 178, 22, 40, 28, 3, -37 },
  { 288, 36, 35, 41, 2, -35 },
  { 446, 33, 36, 36, 3, -36 },
  { 595, 5, 13, 11, 3, -35 },
  { 604, 11, 43, 15, 2, -35 },
  { 664, 12, 43, 15, 1, -35 },
  { 729, 23, 22, 27, 2, -37 },
  { 793, 23, 24, 28, 2, -29 },
  { 862, 7, 12, 13, 2, -6 },
  { 873, 12, 4, 16, 2, -15 },
  { 879, 6, 7, 13, 4, -6 },
  { 885, 18, 35, 18, 0, -35 },
  { 964, 24, 36, 28, 2, -36 },
  { 1072, 13, 35, 28, 4, -35 },
  { 1129, 23, 35, 28, 2, -35 },
  { 1230, 23, 35, 28, 2, -35 },
  { 1331, 26, 35, 28, 1, -35 },
  { 1445, 22, 35, 28, 3, -35 },
  { 1542, 23, 35, 28, 3, -35 },
  { 1643, 24, 35, 28, 2, -35 },
  { 1748, 24, 35, 28, 2, -35 },
  { 1853, 23, 35, 28, 2, -35 },
  { 1954, 6, 28, 13, 4, -27 },
  { 1975, 8, 33, 13, 2, -27 },
  { 2008, 24, 24, 28, 2, -30 },
  { 2080, 22, 13, 28, 3, -24 },
  { 2116, 24, 24, 28, 2, -30 },
  { 2188, 19, 36, 21, 1, -35 },
  { 2274, 38, 39, 44, 3, -35 },
  { 2460, 31, 35, 31, 0, -35 },
  { 2596, 24, 35, 32, 5, -35 },
  { 2701, 26, 35, 31, 3, -35 },
  { 2815, 28, 35, 36, 5, -35 },
  { 2938, 19, 35, 27, 5, -35 },
  { 3022, 19, 35, 25, 5, -35 },
  { 3106, 29, 35, 36, 3, -35 },
  { 3233, 27, 35, 36, 5, -35 },
  { 3352, 13, 35, 17, 2, -35 },
  { 3409, 13, 44, 13, -4, -35 },
  { 3481, 25, 35, 30, 5, -35 },
  { 3591, 19, 35, 26, 5, -35 },
  { 3675, 35, 35, 44, 5, -35 },
  { 3829, 27, 35, 37, 5, -35 },
  { 3948, 32, 36, 38, 3, -36 },
  { 4092, 22, 35, 30, 5, -35 },
  { 4189, 32, 44, 38, 3, -36 },
  { 4365, 25, 35, 30, 5, -35 },
  { 4475, 23, 35, 27, 2, -35 },
  { 4576, 27, 35, 27, 0, -35 },
  { 4695, 27, 35, 36, 4, -35 },
  { 4814, 29, 35, 29, 0, -35 },
  { 4941, 44, 35, 46, 1, -35 },
  { 5134, 29, 35, 29, 0, -35 },
  { 5261, 28, 35, 28, 0, -35 },
  { 5384, 24, 35, 28, 2, -35 },
  { 5489, 11, 43, 16, 4, -35 },
  { 5549, 18, 35, 18, 0, -35 },
  { 5628, 11, 43, 16, 1, -35 },
  { 5688, 24, 22, 28, 2, -35 },
  { 5754, 22, 4, 22, 0, 4 },
  { 5765, 10, 8, 14, 2, -38 },
  { 5775, 22, 27, 27, 2, -27 },
  { 5850, 23, 37, 30, 4, -37 },
  { 5957, 19, 27, 24, 3, -27 },
  { 6022, 23, 37, 30, 3, -37 },
  { 6129, 22, 27, 28, 3, -27 },
  { 6204, 18, 37, 17, 1, -37 },
  { 6288, 23, 39, 30, 3, -27 },
  { 6401, 22, 37, 30, 4, -37 },
  { 6503, 5, 36, 13, 4, -36 },
  { 6526, 12, 48, 13, -3, -36 },
  { 6598, 22, 37, 26, 4, -37 },
  { 6700, 4, 37, 13, 4, -37 },
  { 6719, 38, 27, 46, 4, -27 },
  { 6848, 22, 27, 30, 4, -27 },
  { 6923, 24, 27, 30, 3, -27 },
  { 7004, 23, 39, 30, 4, -27 },
  { 7117, 23, 39, 30, 3, -27 },
  { 7230, 16, 27, 20, 4, -27 },
  { 7284, 19, 27, 23, 2, -27 },
  { 7349, 16, 32, 18, 1, -32 },
  { 7413, 22, 26, 30, 4, -26 },
  { 7485, 25, 26, 25, 0, -26 },
  { 7567, 37, 26, 39, 1, -26 },
  { 7688, 24, 26, 26, 1, -26 },
  { 7766, 25, 38, 25, 0, -26 },
  { 7885, 19, 26, 23, 2, -26 },
  { 7947, 16, 43, 19, 1, -35 },
  { 8033, 3, 49, 27, 12, -37 },
  { 8052, 15, 43, 19, 2, -35 },
  { 8133, 24, 6, 28, 2, -20 },
};

const GFXfont NotoSans_Regular49pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Regular49pt7bBitmaps,
  (GFXglyph *)NotoSans_Regular49pt7bGlyphs,
  0x20, 0x7E, 67
};

#endif // _NOTOSANS_REGULAR49PT7B_H_
