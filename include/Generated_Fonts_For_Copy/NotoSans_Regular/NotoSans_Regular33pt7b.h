#ifndef _NOTOSANS_REGULAR33PT7B_H_
#define _NOTOSANS_REGULAR33PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Regular.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Regular33pt7bBitmaps[] PROGMEM = {
  0x00, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x76, 0x60, 0x00, 0x7F,
  0xF7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3B, 0x0D, 0x86, 0xC3, 0x61, 0x80,
  0x01, 0xC3, 0x80, 0x30, 0x60, 0x06, 0x0C, 0x00, 0xC1, 0x80, 0x38, 0x30,
  0x07, 0x0E, 0x00, 0xC1, 0x83, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC,
  0x1C, 0x38, 0x03, 0x06, 0x00, 0x60, 0xC0, 0x0C, 0x18, 0x03, 0x83, 0x07,
  0xFF, 0xFE, 0xFF, 0xFF, 0xC1, 0x83, 0x00, 0x30, 0x60, 0x06, 0x0C, 0x01,
  0xC3, 0x80, 0x38, 0x70, 0x06, 0x0C, 0x00, 0xC1, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0xFF, 0xC3, 0xFF, 0xCF, 0xE7, 0xB8, 0xC0, 0x71, 0x80,
  0xE3, 0x01, 0xC6, 0x03, 0xCC, 0x03, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0xFF, 0x01, 0x9F, 0x03, 0x0E, 0x06, 0x1C, 0x0C, 0x3C, 0x18, 0x7F, 0x37,
  0xDF, 0xFF, 0x3F, 0xFC, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x3C, 0x00, 0x70, 0x7F, 0x00, 0xE0, 0x63, 0x00, 0xC0, 0xE3, 0x81, 0xC0,
  0xC1, 0x81, 0x80, 0xC1, 0x83, 0x80, 0xC1, 0x83, 0x00, 0xC1, 0x87, 0x00,
  0xC1, 0x8E, 0x00, 0xC1, 0x8E, 0x00, 0xC1, 0x9C, 0xFC, 0xE3, 0x99, 0xFE,
  0x67, 0x39, 0x8E, 0x7F, 0x33, 0x86, 0x1C, 0x73, 0x87, 0x00, 0x63, 0x87,
  0x00, 0xE3, 0x07, 0x01, 0xC3, 0x07, 0x01, 0xC3, 0x87, 0x03, 0x83, 0x87,
  0x03, 0x03, 0x86, 0x07, 0x01, 0x8E, 0x06, 0x01, 0xFE, 0x0E, 0x00, 0xFC,
  0x07, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x0E, 0x0F, 0x00, 0x38,
  0x1C, 0x00, 0xE0, 0x70, 0x03, 0x81, 0xC0, 0x0F, 0x0E, 0x00, 0x1C, 0x78,
  0x00, 0x3F, 0xC0, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0xC0, 0x39,
  0xE7, 0x81, 0xC7, 0x0F, 0x07, 0x38, 0x1E, 0x1C, 0xE0, 0x3C, 0xE3, 0x80,
  0x7F, 0x8E, 0x00, 0xFC, 0x38, 0x01, 0xE0, 0xF0, 0x0F, 0xC1, 0xF0, 0xFB,
  0xC3, 0xFF, 0xC7, 0x87, 0xFC, 0x0F, 0xFF, 0xFE, 0xDB, 0x60, 0x07, 0x0E,
  0x0E, 0x1C, 0x18, 0x38, 0x38, 0x70, 0x70, 0x70, 0x70, 0x60, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0x70, 0x70, 0x70, 0x70, 0x70, 0x38, 0x38, 0x1C,
  0x1C, 0x0E, 0x07, 0xE0, 0x70, 0x70, 0x38, 0x38, 0x1C, 0x1C, 0x0E, 0x0E,
  0x0E, 0x0E, 0x0E, 0x06, 0x07, 0x07, 0x07, 0x07, 0x0E, 0x0E, 0x0E, 0x0E,
  0x0E, 0x1C, 0x1C, 0x1C, 0x38, 0x38, 0x70, 0xE0, 0x03, 0xC0, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x81, 0x81, 0x71, 0x8E, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0xC0, 0x07, 0xE0, 0x0E, 0x70, 0x0E, 0x70, 0x1C, 0x38, 0x3C, 0x3C,
  0x04, 0x20, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x39, 0xCE, 0xE7, 0x39,
  0x9C, 0xFF, 0xFF, 0x7F, 0xF7, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x00,
  0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x06,
  0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x30,
  0x07, 0x00, 0x70, 0x0E, 0x00, 0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xC1,
  0xC7, 0x01, 0xDC, 0x03, 0xB8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3B, 0x80, 0xE7, 0x01, 0xC7, 0x8F, 0x07, 0xFC,
  0x07, 0xF0, 0x03, 0x83, 0xC3, 0xE7, 0xF7, 0xBF, 0x9D, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x0F, 0xC0, 0x7F, 0xE3, 0xFF, 0xE7, 0x01,
  0xE4, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x07, 0xE0, 0x3F, 0xF8, 0x7F, 0xFC, 0x70, 0x1E, 0x20, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0xF8,
  0x0F, 0xE0, 0x0F, 0xF8, 0x00, 0x3E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x80, 0x0E, 0xF0, 0x3E, 0xFF, 0xFC,
  0x7F, 0xF0, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0D,
  0xC0, 0x0E, 0xE0, 0x0E, 0x70, 0x07, 0x38, 0x07, 0x1C, 0x07, 0x0E, 0x03,
  0x07, 0x03, 0x83, 0x83, 0x81, 0xC1, 0x80, 0xE1, 0xC0, 0x71, 0xC0, 0x38,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x3F, 0xF8, 0xFF, 0xF1, 0xFF, 0xE3, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x01,
  0xFF, 0xC3, 0xFF, 0xC0, 0x07, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE8, 0x01, 0xDC, 0x0F, 0x3F, 0xFC,
  0x3F, 0xF0, 0x01, 0xFC, 0x0F, 0xF8, 0x7F, 0xF0, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC3, 0xC3, 0xBF, 0xE7, 0xFF,
  0xEF, 0x81, 0xDE, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3B, 0x80, 0x77, 0x81, 0xC7, 0x87, 0x87, 0xFE, 0x07, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03,
  0x80, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x07,
  0xC0, 0x7F, 0xE1, 0xFB, 0xE3, 0x80, 0xEE, 0x01, 0xDC, 0x01, 0xB8, 0x03,
  0x38, 0x0E, 0x70, 0x1C, 0x78, 0xF0, 0x7F, 0xC0, 0x7E, 0x01, 0xFF, 0x07,
  0x9F, 0x1C, 0x0F, 0x70, 0x0F, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0x00,
  0x7E, 0x01, 0xEF, 0x07, 0x9F, 0xFE, 0x0F, 0xF8, 0x07, 0xC0, 0x3F, 0xE1,
  0xFF, 0xE3, 0x81, 0xCE, 0x01, 0xDC, 0x01, 0xB8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0xF7, 0x87, 0xE7, 0xFD, 0xC7, 0xF3,
  0x80, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x80,
  0x3E, 0x1F, 0xF8, 0x3F, 0xC0, 0x7F, 0xF7, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xF7, 0x3B, 0xDE, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xEF,
  0x73, 0x9C, 0xCE, 0x70, 0x00, 0x02, 0x00, 0x1C, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x00, 0xE0, 0x01, 0xF0, 0x00, 0xFC,
  0x00, 0x3E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0x80, 0x01, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x80, 0x01, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0E, 0x00, 0xFC, 0x07, 0xE0,
  0x3E, 0x03, 0xF0, 0x1F, 0x80, 0x38, 0x00, 0x40, 0x00, 0x0F, 0xC7, 0xFF,
  0x9F, 0xFE, 0xC0, 0x70, 0x03, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x38,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x00, 0x06, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x1E, 0x00,
  0xF0, 0x0E, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x38, 0xC0,
  0xFF, 0x0E, 0x70, 0x7F, 0xE1, 0x98, 0x38, 0x30, 0x7E, 0x1C, 0x0C, 0x1F,
  0x87, 0x03, 0x07, 0xC1, 0x80, 0xC1, 0xF0, 0x60, 0x30, 0x7C, 0x18, 0x0C,
  0x1F, 0x06, 0x07, 0x06, 0xC1, 0x81, 0xC1, 0xB8, 0x70, 0xF8, 0xCE, 0x0F,
  0xF7, 0xF1, 0x81, 0xF8, 0xF8, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x40, 0x0F, 0xC1, 0xE0, 0x00, 0xFF, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x3E, 0x00,
  0x01, 0xB0, 0x00, 0x0D, 0x80, 0x00, 0xEE, 0x00, 0x07, 0x70, 0x00, 0x71,
  0xC0, 0x03, 0x8E, 0x00, 0x1C, 0x30, 0x01, 0xC1, 0xC0, 0x0E, 0x0E, 0x00,
  0xE0, 0x38, 0x07, 0x01, 0xC0, 0x3F, 0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xFF,
  0xC0, 0xE0, 0x0F, 0x0E, 0x00, 0x38, 0x70, 0x01, 0xC7, 0x00, 0x07, 0x38,
  0x00, 0x39, 0xC0, 0x01, 0xDC, 0x00, 0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x3F,
  0xFF, 0x9C, 0x03, 0xCE, 0x00, 0xF7, 0x00, 0x3B, 0x80, 0x1D, 0xC0, 0x0E,
  0xE0, 0x0E, 0x70, 0x07, 0x3F, 0xFF, 0x1F, 0xFC, 0x0F, 0xFF, 0xC7, 0x00,
  0xF3, 0x80, 0x1D, 0xC0, 0x0E, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xEE, 0x00, 0xF7, 0xFF, 0xF3, 0xFF, 0xF1, 0xFF, 0xE0, 0x00, 0xFE,
  0x01, 0xFF, 0xF0, 0xFF, 0xF8, 0x7C, 0x06, 0x3C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00,
  0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0xE0,
  0xFF, 0xF8, 0x0F, 0xFE, 0xFF, 0x00, 0x1F, 0xFF, 0x03, 0xFF, 0xF8, 0x70,
  0x0F, 0x8E, 0x00, 0x79, 0xC0, 0x07, 0xB8, 0x00, 0x77, 0x00, 0x0E, 0xE0,
  0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xDC, 0x00, 0x3B, 0x80,
  0x0F, 0x70, 0x03, 0xCE, 0x01, 0xF1, 0xFF, 0xFC, 0x3F, 0xFF, 0x07, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xFE,
  0x0F, 0xFF, 0xE1, 0xF0, 0x04, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0,
  0x00, 0x77, 0x00, 0x07, 0x78, 0x00, 0x73, 0xC0, 0x07, 0x3E, 0x00, 0x71,
  0xFC, 0x1F, 0x07, 0xFF, 0xF0, 0x3F, 0xFC, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xFF, 0xFF, 0xCF, 0x83, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE3, 0xFF, 0xFF, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC1, 0xF1, 0xEF,
  0xE7, 0xE0, 0xE0, 0x03, 0xF0, 0x03, 0xB8, 0x03, 0x9C, 0x03, 0x8E, 0x03,
  0x87, 0x03, 0x83, 0x83, 0xC1, 0xC3, 0xC0, 0xE3, 0xC0, 0x73, 0xC0, 0x39,
  0xC0, 0x1D, 0xE0, 0x0F, 0xF8, 0x07, 0xDE, 0x03, 0xC7, 0x01, 0xC1, 0xC0,
  0xE0, 0xF0, 0x70, 0x3C, 0x38, 0x0E, 0x1C, 0x03, 0x8E, 0x01, 0xE7, 0x00,
  0x7B, 0x80, 0x1D, 0xC0, 0x07, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x37, 0xEE,
  0x00, 0x77, 0xEE, 0x00, 0x77, 0xEE, 0x00, 0x67, 0xE7, 0x00, 0xE7, 0xE7,
  0x00, 0xE7, 0xE3, 0x00, 0xC7, 0xE3, 0x81, 0xC7, 0xE3, 0x81, 0x87, 0xE1,
  0xC3, 0x87, 0xE1, 0xC3, 0x87, 0xE1, 0xC3, 0x07, 0xE0, 0xE7, 0x07, 0xE0,
  0xE7, 0x07, 0xE0, 0x6E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7C, 0x07, 0xE0,
  0x3C, 0x07, 0xE0, 0x3C, 0x07, 0xE0, 0x38, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x01, 0xFB, 0xC0,
  0x3F, 0x38, 0x07, 0xE7, 0x80, 0xFC, 0x70, 0x1F, 0x87, 0x03, 0xF0, 0xF0,
  0x7E, 0x0E, 0x0F, 0xC0, 0xE1, 0xF8, 0x1E, 0x3F, 0x01, 0xC7, 0xE0, 0x1C,
  0xFC, 0x03, 0xDF, 0x80, 0x3B, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x0F, 0x01, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0xFF,
  0xFC, 0x07, 0x80, 0x78, 0x3C, 0x00, 0xF1, 0xE0, 0x01, 0xC7, 0x00, 0x03,
  0x9C, 0x00, 0x0E, 0xF0, 0x00, 0x3B, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00,
  0x0E, 0xF0, 0x00, 0x39, 0xC0, 0x00, 0xE7, 0x80, 0x07, 0x8E, 0x00, 0x3C,
  0x3C, 0x01, 0xE0, 0x7E, 0x1F, 0x80, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0xFE,
  0x01, 0xFF, 0xE3, 0xFF, 0xE7, 0x01, 0xEE, 0x01, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0x01, 0xEF, 0xFF, 0x9F,
  0xFE, 0x3F, 0xE0, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x01, 0xFC, 0x00, 0x1F,
  0xFE, 0x00, 0xFF, 0xFC, 0x07, 0x80, 0x78, 0x3C, 0x00, 0xF1, 0xE0, 0x01,
  0xC7, 0x00, 0x03, 0x9C, 0x00, 0x0E, 0xF0, 0x00, 0x3B, 0x80, 0x00, 0xFE,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x03, 0xF8, 0x00, 0x0E, 0xF0, 0x00, 0x39, 0xC0, 0x00, 0xE7, 0x80, 0x07,
  0x8E, 0x00, 0x3C, 0x3C, 0x01, 0xE0, 0x7E, 0x1F, 0x80, 0xFF, 0xF8, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0xFF, 0x00, 0x7F, 0xF8, 0x3F,
  0xFF, 0x1C, 0x07, 0x8E, 0x01, 0xE7, 0x00, 0x73, 0x80, 0x39, 0xC0, 0x1C,
  0xE0, 0x0E, 0x70, 0x07, 0x38, 0x07, 0x1C, 0x0F, 0x8F, 0xFF, 0x07, 0xFF,
  0x03, 0x83, 0x81, 0xC0, 0xE0, 0xE0, 0x70, 0x70, 0x1C, 0x38, 0x0F, 0x1C,
  0x03, 0x8E, 0x00, 0xE7, 0x00, 0x7B, 0x80, 0x1D, 0xC0, 0x0F, 0x07, 0xE0,
  0x7F, 0xF9, 0xFF, 0xF3, 0x80, 0x4E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x00, 0x1F, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE8,
  0x01, 0xDE, 0x1F, 0x3F, 0xFC, 0x7F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1D, 0xC0, 0x0E, 0x78, 0x07,
  0x8F, 0x87, 0xC1, 0xFF, 0xE0, 0x3F, 0xF0, 0xE0, 0x00, 0x7E, 0x00, 0x0E,
  0x70, 0x00, 0xE7, 0x00, 0x0E, 0x78, 0x01, 0xC3, 0x80, 0x1C, 0x38, 0x01,
  0xC1, 0xC0, 0x38, 0x1C, 0x03, 0x81, 0xC0, 0x78, 0x0E, 0x07, 0x00, 0xE0,
  0x70, 0x0E, 0x0F, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0x71, 0xC0, 0x03,
  0x9C, 0x00, 0x39, 0xC0, 0x03, 0xB8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0xF0, 0x03, 0x80, 0x1D, 0xC0,
  0x1E, 0x00, 0x77, 0x00, 0x78, 0x01, 0xDC, 0x01, 0xF0, 0x0E, 0x78, 0x0F,
  0xC0, 0x38, 0xE0, 0x3B, 0x00, 0xE3, 0x80, 0xEE, 0x03, 0x8E, 0x03, 0x38,
  0x1C, 0x1C, 0x1C, 0xE0, 0x70, 0x70, 0x71, 0x81, 0xC1, 0xC1, 0xC7, 0x07,
  0x07, 0x0E, 0x1C, 0x38, 0x0E, 0x38, 0x30, 0xE0, 0x38, 0xE0, 0xE3, 0x80,
  0xE3, 0x03, 0x8E, 0x03, 0x9C, 0x0E, 0x70, 0x07, 0x70, 0x1D, 0xC0, 0x1D,
  0xC0, 0x77, 0x00, 0x76, 0x01, 0xD8, 0x01, 0xF8, 0x03, 0xE0, 0x03, 0xE0,
  0x0F, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x70, 0x01,
  0xC0, 0x70, 0x01, 0xEF, 0x00, 0x38, 0xE0, 0x0E, 0x0E, 0x01, 0xC1, 0xC0,
  0x70, 0x1C, 0x1C, 0x01, 0xC3, 0x80, 0x38, 0xE0, 0x03, 0xB8, 0x00, 0x3F,
  0x00, 0x07, 0xC0, 0x00, 0x70, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0xEE,
  0x00, 0x1C, 0xE0, 0x07, 0x1C, 0x01, 0xC1, 0xC0, 0x38, 0x1C, 0x0E, 0x03,
  0x83, 0x80, 0x38, 0x70, 0x07, 0x9C, 0x00, 0x77, 0x80, 0x07, 0xE0, 0x01,
  0xEE, 0x00, 0x39, 0xC0, 0x0F, 0x1C, 0x01, 0xC3, 0x80, 0x70, 0x38, 0x0E,
  0x07, 0x03, 0x80, 0x70, 0x70, 0x0E, 0x1C, 0x00, 0xE3, 0x80, 0x1E, 0xE0,
  0x01, 0xDC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x7F, 0xFF, 0x3F, 0xFF, 0x9F,
  0xFF, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x07, 0xFF, 0xE0,
  0xE0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0x80, 0x18, 0x01, 0xC0,
  0x1C, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x00, 0x38,
  0x03, 0x80, 0x1C, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x60, 0x07,
  0xFF, 0xFF, 0xF8, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1,
  0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x3F,
  0xFF, 0xE0, 0x01, 0x80, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x76,
  0x00, 0x33, 0x80, 0x38, 0xC0, 0x18, 0x70, 0x1C, 0x18, 0x0C, 0x0E, 0x0E,
  0x03, 0x06, 0x01, 0xC3, 0x00, 0x63, 0x80, 0x3B, 0x80, 0x0E, 0xFF, 0xFF,
  0xFF, 0xFC, 0xF0, 0xF0, 0xE0, 0xE0, 0xE0, 0x0F, 0xE1, 0xFF, 0xC3, 0xCF,
  0x88, 0x0F, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x7F, 0x1F, 0xFD, 0xFC,
  0x7F, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xFE, 0x03, 0xFC, 0x3F, 0x7F,
  0xDC, 0xFE, 0x30, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x73, 0xF0, 0xEF, 0xF9, 0xFD, 0xFB, 0xC0, 0x77,
  0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFE, 0x03, 0xBE, 0x0F, 0x6F, 0xFC,
  0xC7, 0xF0, 0x07, 0xF0, 0xFF, 0xCF, 0xFC, 0xF0, 0x07, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x78,
  0x01, 0xC0, 0x07, 0x82, 0x3F, 0xF0, 0x7F, 0x80, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x87, 0xE3, 0x1F,
  0xF6, 0x7D, 0xFD, 0xE0, 0x7B, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0xEE,
  0x03, 0xDF, 0x0F, 0x9F, 0xFB, 0x0F, 0xE6, 0x07, 0xE0, 0x3F, 0xE0, 0xF9,
  0xE3, 0xC0, 0xE7, 0x01, 0xDC, 0x01, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E,
  0x06, 0x1F, 0xFC, 0x1F, 0xF0, 0x03, 0xF8, 0x3F, 0x83, 0xC4, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x03, 0xFC, 0xFF, 0xE7, 0xFF, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x0F, 0xC6,
  0x3F, 0xEC, 0xFB, 0xFB, 0xC0, 0xF7, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xFE, 0x01,
  0xDC, 0x07, 0xBC, 0x1F, 0x3F, 0xF6, 0x1F, 0xCC, 0x00, 0x18, 0x00, 0x30,
  0x00, 0xE0, 0x01, 0xD0, 0x07, 0xBF, 0xFE, 0x7F, 0xF8, 0x3F, 0xC0, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x71, 0xF0, 0xEF, 0xF9, 0xFD, 0xFB, 0xC0, 0x77, 0x80, 0xFE, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0E, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x07, 0x07, 0x00, 0x00,
  0x00, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x0F,
  0xFE, 0xFE, 0xF8, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x0F, 0xE0, 0x7B, 0x83, 0xCE, 0x1E, 0x38, 0xF0,
  0xE3, 0x83, 0x9C, 0x0E, 0xE0, 0x3F, 0x80, 0xFF, 0x03, 0xDE, 0x0E, 0x38,
  0x38, 0x70, 0xE1, 0xE3, 0x83, 0xCE, 0x07, 0x38, 0x0E, 0xE0, 0x3C, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xC7, 0xE0, 0xFC,
  0x67, 0xF8, 0xFF, 0xBF, 0xBE, 0xF7, 0xDE, 0x07, 0xC0, 0xFF, 0x01, 0xE0,
  0x3F, 0x00, 0xE0, 0x1F, 0x80, 0x70, 0x0F, 0xC0, 0x38, 0x07, 0xE0, 0x1C,
  0x03, 0xF0, 0x0E, 0x01, 0xF8, 0x07, 0x00, 0xFC, 0x03, 0x80, 0x7E, 0x01,
  0xC0, 0x3F, 0x00, 0xE0, 0x1F, 0x80, 0x70, 0x0F, 0xC0, 0x38, 0x07, 0xE0,
  0x1C, 0x03, 0xF0, 0x0E, 0x01, 0xC0, 0xC7, 0xE1, 0x9F, 0xF3, 0xFB, 0xF7,
  0x80, 0xEF, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1C, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0x7C, 0x78, 0x1E,
  0x70, 0x0E, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0x70, 0x0E, 0x70, 0x0E, 0x3C, 0x3C,
  0x1F, 0xF8, 0x0F, 0xF0, 0xC7, 0xE1, 0x9F, 0xF3, 0xFB, 0xF7, 0x80, 0xEF,
  0x01, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xFC, 0x07, 0x7C, 0x1E, 0xFF, 0xF9,
  0xCF, 0xE3, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x00, 0x0F, 0xC6, 0x3F, 0xEC, 0xFB, 0xDB, 0xC0,
  0xF7, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x7E, 0x00, 0xFE, 0x01, 0xDC, 0x07, 0xBE, 0x1F, 0x3F,
  0xF6, 0x1F, 0xCC, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0xC3, 0xF3, 0xFD, 0xFF, 0xE0, 0xF0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x00, 0x1F, 0xC7, 0xFF, 0xF9, 0xEE, 0x00, 0xC0,
  0x0E, 0x00, 0xF0, 0x07, 0xC0, 0x3F, 0x80, 0xFC, 0x03, 0xE0, 0x0F, 0x00,
  0x70, 0x07, 0x00, 0x7C, 0x0F, 0xFF, 0xEF, 0xFC, 0x18, 0x06, 0x01, 0x80,
  0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xF0, 0x1F, 0xC3, 0xF0,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x01,
  0xFC, 0x03, 0xF8, 0x0F, 0xF8, 0x3F, 0x7F, 0xEE, 0x7F, 0x9C, 0xE0, 0x03,
  0xF8, 0x03, 0x9C, 0x01, 0xCE, 0x01, 0xE3, 0x80, 0xE1, 0xC0, 0x70, 0xE0,
  0x70, 0x38, 0x38, 0x1C, 0x1C, 0x0E, 0x1C, 0x03, 0x8E, 0x01, 0xC7, 0x00,
  0x67, 0x00, 0x3B, 0x80, 0x1D, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x1E, 0x01, 0xDC, 0x07, 0x80, 0xE7, 0x01, 0xE0, 0x39, 0xC0,
  0xFC, 0x0E, 0x30, 0x3F, 0x07, 0x0E, 0x0C, 0xC1, 0xC3, 0x87, 0x30, 0x70,
  0xE1, 0xCE, 0x1C, 0x1C, 0x73, 0x8E, 0x07, 0x18, 0x63, 0x81, 0xCE, 0x1C,
  0xE0, 0x73, 0x87, 0x30, 0x0C, 0xC0, 0xDC, 0x03, 0xF0, 0x3F, 0x00, 0xFC,
  0x0F, 0xC0, 0x1E, 0x01, 0xE0, 0x07, 0x80, 0x78, 0x01, 0xE0, 0x1E, 0x00,
  0xE0, 0x0F, 0x70, 0x1E, 0x78, 0x1C, 0x38, 0x38, 0x1C, 0x78, 0x0E, 0x70,
  0x0E, 0xE0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xE0, 0x0E, 0xE0,
  0x1E, 0x70, 0x1C, 0x78, 0x38, 0x38, 0x78, 0x1C, 0x70, 0x0E, 0xE0, 0x0F,
  0xE0, 0x03, 0xB8, 0x03, 0x9C, 0x01, 0xCE, 0x00, 0xE3, 0x80, 0xE1, 0xC0,
  0x70, 0x70, 0x70, 0x38, 0x38, 0x1C, 0x1C, 0x07, 0x1C, 0x03, 0x8E, 0x00,
  0xC7, 0x00, 0x77, 0x00, 0x3B, 0x80, 0x0D, 0x80, 0x07, 0xC0, 0x01, 0xE0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C,
  0x01, 0xBE, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xFB, 0xFF, 0xDF,
  0xFE, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x70, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x40, 0xF0, 0x7C, 0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x1C, 0x1F, 0x0F, 0x03, 0xE0, 0x3C, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xF8,
  0x1F, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x80, 0x1E, 0x03, 0xF0, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x0F, 0x80, 0xF8, 0x1F, 0x0F, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x03, 0x80,
  0xF0, 0x7C, 0x0F, 0x00, 0x3C, 0x03, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xE8,
  0x01, 0x00,
};

const GFXglyph NotoSans_Regular33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 4, 24, 9, 2, -24 },
  { 13, 9, 9, 13, 2, -24 },
  { 24, 19, 24, 21, 1, -24 },
  { 81, 15, 27, 19, 2, -25 },
  { 132, 24, 24, 27, 2, -24 },
  { 204, 22, 24, 24, 2, -24 },
  { 270, 3, 9, 7, 2, -24 },
  { 274, 8, 29, 10, 1, -24 },
  { 303, 8, 29, 10, 1, -24 },
  { 332, 16, 15, 18, 1, -25 },
  { 362, 15, 16, 19, 2, -20 },
  { 392, 5, 8, 9, 1, -4 },
  { 397, 8, 2, 11, 1, -10 },
  { 399, 4, 4, 9, 2, -4 },
  { 401, 12, 24, 12, 0, -24 },
  { 437, 15, 24, 19, 2, -24 },
  { 482, 9, 24, 19, 3, -24 },
  { 509, 15, 24, 19, 2, -24 },
  { 554, 16, 24, 19, 1, -24 },
  { 602, 17, 24, 19, 1, -24 },
  { 653, 15, 24, 19, 2, -24 },
  { 698, 15, 24, 19, 2, -24 },
  { 743, 16, 24, 19, 1, -24 },
  { 791, 15, 24, 19, 2, -24 },
  { 836, 15, 24, 19, 2, -24 },
  { 881, 4, 18, 9, 2, -18 },
  { 890, 5, 22, 9, 1, -18 },
  { 904, 15, 16, 19, 2, -20 },
  { 934, 15, 9, 19, 2, -16 },
  { 951, 15, 16, 19, 2, -20 },
  { 981, 13, 24, 14, 0, -24 },
  { 1020, 26, 27, 30, 2, -24 },
  { 1108, 21, 24, 21, 0, -24 },
  { 1171, 17, 24, 21, 3, -24 },
  { 1222, 18, 24, 21, 2, -24 },
  { 1276, 19, 24, 24, 3, -24 },
  { 1333, 13, 24, 18, 3, -24 },
  { 1372, 13, 24, 17, 3, -24 },
  { 1411, 20, 24, 24, 2, -24 },
  { 1471, 18, 24, 24, 3, -24 },
  { 1525, 9, 24, 11, 1, -24 },
  { 1552, 9, 30, 9, -3, -24 },
  { 1586, 17, 24, 20, 3, -24 },
  { 1637, 13, 24, 17, 3, -24 },
  { 1676, 24, 24, 30, 3, -24 },
  { 1748, 19, 24, 25, 3, -24 },
  { 1805, 22, 24, 26, 2, -24 },
  { 1871, 15, 24, 20, 3, -24 },
  { 1916, 22, 30, 26, 2, -24 },
  { 1999, 17, 24, 21, 3, -24 },
  { 2050, 15, 24, 18, 2, -24 },
  { 2095, 18, 24, 18, 0, -24 },
  { 2149, 18, 24, 24, 3, -24 },
  { 2203, 20, 24, 20, 0, -24 },
  { 2263, 30, 24, 31, 0, -24 },
  { 2353, 19, 24, 19, 0, -24 },
  { 2410, 19, 24, 19, 0, -24 },
  { 2467, 17, 24, 19, 1, -24 },
  { 2518, 7, 29, 11, 3, -24 },
  { 2544, 12, 24, 12, 0, -24 },
  { 2580, 7, 29, 11, 1, -24 },
  { 2606, 17, 15, 19, 1, -24 },
  { 2638, 15, 2, 15, 0, 3 },
  { 2642, 7, 5, 9, 1, -25 },
  { 2647, 14, 18, 19, 2, -18 },
  { 2679, 15, 25, 20, 3, -25 },
  { 2726, 13, 18, 16, 2, -18 },
  { 2756, 15, 25, 20, 2, -25 },
  { 2803, 15, 18, 19, 2, -18 },
  { 2837, 13, 25, 11, 0, -25 },
  { 2878, 15, 26, 20, 2, -18 },
  { 2927, 15, 25, 20, 3, -25 },
  { 2974, 3, 24, 9, 3, -24 },
  { 2983, 8, 32, 9, -2, -24 },
  { 3015, 14, 25, 18, 3, -25 },
  { 3059, 3, 25, 9, 3, -25 },
  { 3069, 25, 18, 31, 3, -18 },
  { 3126, 15, 18, 20, 3, -18 },
  { 3160, 16, 18, 20, 2, -18 },
  { 3196, 15, 26, 20, 3, -18 },
  { 3245, 15, 26, 20, 2, -18 },
  { 3294, 10, 18, 14, 3, -18 },
  { 3317, 12, 18, 16, 2, -18 },
  { 3344, 10, 22, 12, 1, -22 },
  { 3372, 15, 18, 20, 3, -18 },
  { 3406, 17, 18, 17, 0, -18 },
  { 3445, 26, 18, 26, 0, -18 },
  { 3504, 16, 18, 17, 1, -18 },
  { 3540, 17, 26, 17, 0, -18 },
  { 3596, 13, 18, 16, 1, -18 },
  { 3626, 10, 29, 13, 1, -24 },
  { 3663, 2, 33, 18, 8, -25 },
  { 3672, 11, 29, 13, 1, -24 },
  { 3712, 15, 5, 19, 2, -14 },
};

const GFXfont NotoSans_Regular33pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Regular33pt7bBitmaps,
  (GFXglyph *)NotoSans_Regular33pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _NOTOSANS_REGULAR33PT7B_H_
