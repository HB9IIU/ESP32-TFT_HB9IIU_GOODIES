#ifndef _NOTOSANS_REGULAR60PT7B_H_
#define _NOTOSANS_REGULAR60PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Regular.ttf
// Size: 60pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Regular60pt7bBitmaps[] PROGMEM = {
  0x00, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0x7F, 0x7E, 0x3C, 0xFC, 0x1F, 0xFE,
  0x0F, 0xBE, 0x07, 0xDF, 0x03, 0xEF, 0x81, 0xF7, 0xC0, 0xFB, 0xE0, 0x7D,
  0xF0, 0x3E, 0x78, 0x0F, 0x3C, 0x07, 0x9E, 0x03, 0xCF, 0x01, 0xE7, 0x80,
  0xF3, 0xC0, 0x79, 0xE0, 0x38, 0xE0, 0x1C, 0x00, 0x03, 0xC0, 0x1E, 0x00,
  0x00, 0x3C, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x7C, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x3C, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x78, 0x00,
  0x00, 0xF0, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x78, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x01, 0xE0, 0x1F, 0x00, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x1E,
  0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x3C,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF0,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x01, 0xE0,
  0x1F, 0x00, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00,
  0x3C, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF1, 0xFF, 0x79, 0xFE, 0x3F, 0x0F,
  0x03, 0x8F, 0xC1, 0xE0, 0x01, 0xF0, 0x3C, 0x00, 0x3E, 0x07, 0x80, 0x07,
  0xC0, 0xF0, 0x00, 0xF8, 0x1E, 0x00, 0x1F, 0x03, 0xC0, 0x03, 0xF0, 0x78,
  0x00, 0x7F, 0x0F, 0x00, 0x07, 0xFD, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xE3, 0xFC, 0x00,
  0x3C, 0x1F, 0x80, 0x07, 0x81, 0xF8, 0x00, 0xF0, 0x1F, 0x00, 0x1E, 0x03,
  0xE0, 0x03, 0xC0, 0x7C, 0x00, 0x78, 0x0F, 0x80, 0x0F, 0x03, 0xF8, 0x01,
  0xE0, 0xFD, 0xE0, 0x3C, 0x7F, 0xBF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xF0,
  0x01, 0xFF, 0xC0, 0x00, 0x1E, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xE0, 0x03,
  0xE3, 0xF0, 0x00, 0x3C, 0x00, 0x7C, 0x1F, 0x00, 0x07, 0xC0, 0x07, 0x80,
  0xF8, 0x00, 0x78, 0x00, 0x78, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x78,
  0x01, 0xF0, 0x00, 0xF8, 0x07, 0x80, 0x1F, 0x00, 0x0F, 0x00, 0x78, 0x03,
  0xE0, 0x00, 0xF0, 0x07, 0xC0, 0x3C, 0x00, 0x0F, 0x00, 0x7C, 0x07, 0xC0,
  0x00, 0xF0, 0x07, 0xC0, 0x78, 0x00, 0x0F, 0x00, 0x7C, 0x0F, 0x80, 0x00,
  0xF0, 0x07, 0xC0, 0xF0, 0x00, 0x0F, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xF0,
  0x07, 0xC3, 0xE0, 0x00, 0x0F, 0x80, 0x78, 0x3E, 0x1F, 0xE0, 0xF8, 0x07,
  0x87, 0xC3, 0xFF, 0x07, 0x80, 0xF8, 0x78, 0x7F, 0xF8, 0x7C, 0x0F, 0x8F,
  0x8F, 0xFF, 0xC7, 0xC1, 0xF0, 0xF0, 0xF0, 0x7C, 0x3F, 0x3F, 0x1F, 0x1F,
  0x03, 0xE1, 0xFF, 0xE1, 0xE1, 0xE0, 0x1E, 0x0F, 0xFC, 0x3E, 0x1E, 0x01,
  0xE0, 0x7F, 0x87, 0xC3, 0xE0, 0x1F, 0x00, 0x00, 0x7C, 0x3E, 0x01, 0xF0,
  0x00, 0x0F, 0x83, 0xE0, 0x1F, 0x00, 0x00, 0xF0, 0x3E, 0x01, 0xF0, 0x00,
  0x1F, 0x03, 0xE0, 0x0F, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0xF0, 0x00, 0x3E,
  0x03, 0xE0, 0x1F, 0x00, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x00, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x00, 0xF8, 0x01, 0xE0,
  0x1E, 0x00, 0x1F, 0x00, 0x1E, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x3E,
  0x00, 0x3E, 0x00, 0x0F, 0x03, 0xE0, 0x03, 0xC0, 0x00, 0xFC, 0xFC, 0x00,
  0x7C, 0x00, 0x07, 0xFF, 0x80, 0x07, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0x81, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x1F,
  0x00, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x07, 0xE0, 0x00,
  0x03, 0xE0, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00,
  0x00, 0xFD, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xF8,
  0x0F, 0xE3, 0xF8, 0x00, 0xFC, 0x0F, 0xE0, 0xFE, 0x00, 0x7C, 0x0F, 0xC0,
  0x3F, 0x80, 0x3E, 0x0F, 0xE0, 0x0F, 0xE0, 0x3F, 0x07, 0xE0, 0x03, 0xF8,
  0x1F, 0x03, 0xE0, 0x00, 0xFE, 0x1F, 0x83, 0xF0, 0x00, 0x3F, 0x8F, 0x81,
  0xF8, 0x00, 0x0F, 0xEF, 0xC0, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x7E, 0x00,
  0x00, 0xFF, 0xE0, 0x3F, 0x00, 0x00, 0x3F, 0xE0, 0x1F, 0x80, 0x00, 0x0F,
  0xE0, 0x07, 0xE0, 0x00, 0x0F, 0xF8, 0x03, 0xF0, 0x00, 0x0F, 0xFE, 0x01,
  0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xEF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xE3, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0xFE, 0x01, 0xFF, 0xFF, 0x80,
  0x3F, 0x80, 0x3F, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x60, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xBE, 0xFB, 0xEF, 0xBE, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9C,
  0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x7C,
  0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xF8,
  0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0xF8, 0x01, 0xF0, 0x07, 0xE0,
  0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF0,
  0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xC0,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x07, 0x00, 0xF0,
  0x07, 0x7F, 0x07, 0x07, 0xF7, 0xFE, 0x73, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x0F, 0x8F, 0x80,
  0x01, 0xF8, 0xFC, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x7E,
  0x03, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0x3E, 0x03, 0xE0, 0x00, 0xC0, 0x18,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0xC7, 0xE1, 0xF8, 0x7E,
  0x1F, 0x0F, 0xC3, 0xF0, 0xF8, 0x3E, 0x0F, 0x87, 0xC1, 0xF0, 0x78, 0x1E,
  0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0x7E,
  0xFF, 0xFF, 0xFF, 0x7F, 0x7E, 0x3C, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0xFE, 0x07, 0xF0, 0x1F, 0x80, 0x1F, 0x81,
  0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x7C, 0x7E, 0x00,
  0x07, 0xE7, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x03, 0xF7,
  0xC0, 0x00, 0x3F, 0x7C, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E, 0x3E, 0x00,
  0x07, 0xE3, 0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0xFC,
  0x1F, 0x80, 0x1F, 0x80, 0xFE, 0x07, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0xFF, 0x03, 0xFF, 0x07,
  0xFF, 0x0F, 0xFF, 0x3F, 0x9F, 0x7F, 0x1F, 0xFE, 0x1F, 0x7C, 0x1F, 0x38,
  0x1F, 0x10, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0xFF, 0xC0, 0xFF, 0x87, 0xE0, 0x03, 0xF8,
  0x38, 0x00, 0x0F, 0xC1, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0,
  0xFF, 0x80, 0x7F, 0x87, 0xC0, 0x01, 0xFC, 0x30, 0x00, 0x0F, 0xC2, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7E, 0x80, 0x00, 0x0F, 0xEC, 0x00, 0x01, 0xFC, 0xFC,
  0x00, 0x7F, 0x8F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xF7, 0xC0,
  0x00, 0x01, 0xF7, 0xC0, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x03, 0xE7, 0xC0,
  0x00, 0x07, 0xC7, 0xC0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x0F, 0x87, 0xC0,
  0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0xC0,
  0x00, 0x7C, 0x07, 0xC0, 0x00, 0xF8, 0x07, 0xC0, 0x01, 0xF0, 0x07, 0xC0,
  0x01, 0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x07, 0xC0, 0x1F, 0x00, 0x07, 0xC0,
  0x1F, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x07, 0xC0,
  0xF8, 0x00, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x3C,
  0x07, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE8, 0x00, 0x01, 0xF9, 0x80, 0x00, 0x7F, 0x3F, 0x00, 0x7F, 0xC7,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xE0, 0x04, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x07, 0xE0, 0x03, 0xE1, 0xFF, 0xE0, 0x1F, 0x3F,
  0xFF, 0xC0, 0xFB, 0xFF, 0xFF, 0x0F, 0xFF, 0x87, 0xFC, 0x7F, 0xE0, 0x07,
  0xF3, 0xFE, 0x00, 0x1F, 0x9F, 0xE0, 0x00, 0x7E, 0xFE, 0x00, 0x03, 0xF7,
  0xE0, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x03, 0xEF, 0xC0,
  0x00, 0x1F, 0x3E, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x07, 0xCF, 0x80, 0x00,
  0x3E, 0x7C, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0xFC,
  0x7E, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x7E, 0x0F, 0xE0, 0x07, 0xE0, 0x3F,
  0x80, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x00,
  0xFC, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x03, 0xE7,
  0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x3E, 0x3E, 0x00,
  0x07, 0xE3, 0xE0, 0x00, 0x7C, 0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x01, 0xF8,
  0x0F, 0xE0, 0x3F, 0x00, 0x7F, 0x8F, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xFE,
  0x00, 0xFF, 0x1F, 0xF0, 0x1F, 0xC0, 0x7F, 0x83, 0xF0, 0x01, 0xFC, 0x7E,
  0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0x7E, 0x00,
  0x03, 0xE7, 0xF0, 0x00, 0x7E, 0x3F, 0x80, 0x1F, 0xC3, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x68, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xE0, 0x7F, 0x03, 0xF8, 0x01, 0xF8, 0x3F,
  0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x07, 0xCF, 0xC0, 0x00,
  0x3E, 0xFC, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x3F, 0x7C, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x7F,
  0x7E, 0x00, 0x0F, 0xF3, 0xF0, 0x01, 0xFF, 0x3F, 0xE0, 0xFD, 0xF1, 0xFF,
  0xFF, 0x9F, 0x0F, 0xFF, 0xF1, 0xF0, 0x3F, 0xFE, 0x1F, 0x00, 0xFF, 0x03,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x10, 0x03, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0x7F, 0x7E, 0x3C, 0x0F, 0x07,
  0xE3, 0xF8, 0xFF, 0x3F, 0xCF, 0xE1, 0xF8, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x7E, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3E, 0x0F, 0x87, 0xC1, 0xF0, 0x7C, 0x1E, 0x0F, 0x83, 0xC0,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xC7, 0xF0, 0x3F,
  0xCE, 0x00, 0x1F, 0xD0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x7C, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x7F, 0xF0, 0x07, 0xC3, 0xE0, 0x03,
  0xFF, 0xF8, 0x07, 0x87, 0x80, 0x1F, 0xFF, 0xF0, 0x0F, 0x1F, 0x00, 0x7F,
  0xFF, 0xE0, 0x1F, 0x3C, 0x01, 0xF8, 0x03, 0xC0, 0x1E, 0x78, 0x07, 0xE0,
  0x07, 0x80, 0x3D, 0xF0, 0x0F, 0x80, 0x0F, 0x00, 0x7B, 0xE0, 0x3E, 0x00,
  0x1E, 0x00, 0xF7, 0x80, 0x7C, 0x00, 0x7C, 0x01, 0xEF, 0x00, 0xF8, 0x00,
  0xF8, 0x03, 0xDE, 0x01, 0xE0, 0x01, 0xF0, 0x07, 0xBC, 0x03, 0xC0, 0x03,
  0xE0, 0x0F, 0x78, 0x0F, 0x80, 0x07, 0xC0, 0x1F, 0xF0, 0x1F, 0x00, 0x0F,
  0x80, 0x3F, 0xE0, 0x1E, 0x00, 0x1F, 0x00, 0x7F, 0xC0, 0x3C, 0x00, 0x3E,
  0x01, 0xF7, 0x80, 0x78, 0x00, 0xFC, 0x03, 0xCF, 0x00, 0xF8, 0x01, 0xF8,
  0x07, 0x9E, 0x01, 0xF0, 0x07, 0xF0, 0x1F, 0x3C, 0x01, 0xF0, 0x0E, 0xF0,
  0x7C, 0x7C, 0x03, 0xFC, 0x7D, 0xF3, 0xF0, 0xF8, 0x03, 0xFF, 0xF1, 0xFF,
  0xE0, 0xF0, 0x03, 0xFF, 0xC3, 0xFF, 0x81, 0xF0, 0x01, 0xFE, 0x03, 0xFC,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFB, 0xE0,
  0x00, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x00,
  0x7C, 0x7C, 0x00, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x00, 0x0F, 0x87, 0xC0,
  0x00, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0xFC, 0x00, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x07, 0xC0,
  0x3E, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0x7E, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x07, 0xC3,
  0xE0, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00,
  0x00, 0xF9, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC3, 0xE0, 0x00, 0xFF, 0x8F, 0x80,
  0x00, 0xFF, 0x3E, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x03, 0xF3, 0xE0, 0x00,
  0x07, 0xCF, 0x80, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x01,
  0xF3, 0xE0, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0xF8,
  0xF8, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x7F, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFC, 0x3E, 0x00, 0x07, 0xF8, 0xF8, 0x00, 0x07, 0xF3, 0xE0, 0x00,
  0x0F, 0xEF, 0x80, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xBE,
  0x00, 0x00, 0xFE, 0xF8, 0x00, 0x07, 0xF3, 0xE0, 0x00, 0x3F, 0xCF, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xC1, 0xFE, 0x07, 0xFC, 0x00, 0x1C, 0x0F, 0xF0, 0x00, 0x04, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x04, 0x07, 0xFF, 0x80, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00,
  0x7A, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x3E,
  0x00, 0x0F, 0xFC, 0x0F, 0x80, 0x00, 0x7F, 0x83, 0xE0, 0x00, 0x07, 0xF0,
  0xF8, 0x00, 0x00, 0xFE, 0x3E, 0x00, 0x00, 0x1F, 0xCF, 0x80, 0x00, 0x03,
  0xF3, 0xE0, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x00, 0x1F, 0xBE, 0x00, 0x00,
  0x07, 0xEF, 0x80, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0x07, 0xEF, 0x80, 0x00,
  0x01, 0xFB, 0xE0, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x00, 0x7F, 0x3E, 0x00,
  0x00, 0x1F, 0x8F, 0x80, 0x00, 0x0F, 0xE3, 0xE0, 0x00, 0x0F, 0xF0, 0xF8,
  0x00, 0x07, 0xF8, 0x3E, 0x00, 0x0F, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x00,
  0x0F, 0x01, 0xFE, 0x00, 0x00, 0x20, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x07, 0xDF, 0x80,
  0x00, 0x00, 0xFB, 0xF0, 0x00, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0x03, 0xE7,
  0xF0, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0x0F, 0x8F, 0xE0, 0x00, 0x01,
  0xF0, 0xFF, 0x00, 0x00, 0x3E, 0x0F, 0xF8, 0x00, 0x07, 0xC0, 0xFF, 0xE0,
  0x07, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFE, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x3F, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E,
  0x00, 0xFE, 0xE3, 0xFC, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xC0,
  0xF8, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x0F, 0xC7,
  0xC0, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0xFE, 0x1F, 0x00, 0x03, 0xF8, 0x3E,
  0x00, 0x07, 0xE0, 0x7C, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x7E, 0x01, 0xF0,
  0x01, 0xF8, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x0F, 0x80,
  0x7E, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x7C, 0x1F,
  0xC0, 0x00, 0xF8, 0x3F, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x03, 0xE3, 0xF0,
  0x00, 0x07, 0xCF, 0xE0, 0x00, 0x0F, 0xBF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xDF, 0xC0, 0x00, 0xFE, 0x1F, 0xC0,
  0x01, 0xF8, 0x1F, 0x80, 0x03, 0xE0, 0x1F, 0x80, 0x07, 0xC0, 0x3F, 0x80,
  0x0F, 0x80, 0x3F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7F, 0x00,
  0x7C, 0x00, 0x7F, 0x00, 0xF8, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x7E, 0x03,
  0xE0, 0x00, 0xFE, 0x07, 0xC0, 0x00, 0xFE, 0x0F, 0x80, 0x00, 0xFC, 0x1F,
  0x00, 0x00, 0xFC, 0x3E, 0x00, 0x01, 0xFC, 0x7C, 0x00, 0x01, 0xFC, 0xF8,
  0x00, 0x01, 0xF9, 0xF0, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x03, 0xF8, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xEF,
  0x80, 0x00, 0x00, 0xFF, 0xFD, 0xF0, 0x00, 0x00, 0x3E, 0xFF, 0xFF, 0x00,
  0x00, 0x07, 0xDF, 0xFB, 0xE0, 0x00, 0x01, 0xF7, 0xFF, 0x7C, 0x00, 0x00,
  0x3E, 0xFF, 0xE7, 0xC0, 0x00, 0x07, 0xDF, 0xFC, 0xF8, 0x00, 0x01, 0xF3,
  0xFF, 0x9F, 0x00, 0x00, 0x3E, 0x7F, 0xF1, 0xF0, 0x00, 0x07, 0x8F, 0xFE,
  0x3E, 0x00, 0x01, 0xF1, 0xFF, 0xC7, 0xE0, 0x00, 0x3E, 0x3F, 0xF8, 0x7C,
  0x00, 0x0F, 0x87, 0xFF, 0x0F, 0x80, 0x01, 0xF0, 0xFF, 0xE0, 0xF8, 0x00,
  0x3E, 0x1F, 0xFC, 0x1F, 0x00, 0x0F, 0x83, 0xFF, 0x83, 0xE0, 0x01, 0xF0,
  0x7F, 0xF0, 0x3E, 0x00, 0x7C, 0x0F, 0xFE, 0x07, 0xC0, 0x0F, 0x81, 0xFF,
  0xC0, 0xFC, 0x01, 0xF0, 0x3F, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xFF, 0x01,
  0xF0, 0x0F, 0x80, 0xFF, 0xE0, 0x1F, 0x01, 0xE0, 0x1F, 0xFC, 0x03, 0xE0,
  0x7C, 0x03, 0xFF, 0x80, 0x7C, 0x0F, 0x80, 0x7F, 0xF0, 0x07, 0xC3, 0xE0,
  0x0F, 0xFE, 0x00, 0xF8, 0x7C, 0x01, 0xFF, 0xC0, 0x1F, 0x8F, 0x80, 0x3F,
  0xF8, 0x01, 0xF3, 0xE0, 0x07, 0xFF, 0x00, 0x3E, 0x7C, 0x00, 0xFF, 0xE0,
  0x03, 0xEF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xE0,
  0x01, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xFF, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xDF, 0x80, 0x00, 0x1F, 0xF7, 0xE0,
  0x00, 0x07, 0xFC, 0xFC, 0x00, 0x01, 0xFF, 0x9F, 0x80, 0x00, 0x7F, 0xE7,
  0xE0, 0x00, 0x1F, 0xF8, 0xFC, 0x00, 0x07, 0xFE, 0x3F, 0x80, 0x01, 0xFF,
  0x87, 0xE0, 0x00, 0x7F, 0xE0, 0xFC, 0x00, 0x1F, 0xF8, 0x3F, 0x80, 0x07,
  0xFE, 0x07, 0xE0, 0x01, 0xFF, 0x80, 0xFC, 0x00, 0x7F, 0xE0, 0x3F, 0x80,
  0x1F, 0xF8, 0x07, 0xE0, 0x07, 0xFE, 0x00, 0xFC, 0x01, 0xFF, 0x80, 0x3F,
  0x00, 0x7F, 0xE0, 0x07, 0xE0, 0x1F, 0xF8, 0x00, 0xFC, 0x07, 0xFE, 0x00,
  0x3F, 0x01, 0xFF, 0x80, 0x07, 0xE0, 0x7F, 0xE0, 0x01, 0xFC, 0x1F, 0xF8,
  0x00, 0x3F, 0x07, 0xFE, 0x00, 0x07, 0xE1, 0xFF, 0x80, 0x01, 0xFC, 0x7F,
  0xE0, 0x00, 0x3F, 0x1F, 0xF8, 0x00, 0x07, 0xE7, 0xFE, 0x00, 0x01, 0xFD,
  0xFF, 0x80, 0x00, 0x3F, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x7F,
  0x00, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x00,
  0x0F, 0xC7, 0xE0, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x00, 0x1F, 0x9F,
  0x00, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x00, 0x3F, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0xFC, 0x00, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x00, 0x1F, 0x81, 0xFC,
  0x00, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x03, 0xFE, 0x00, 0x0F,
  0xF0, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF1,
  0xF0, 0x01, 0xFF, 0x3E, 0x00, 0x07, 0xF7, 0xC0, 0x00, 0x7E, 0xF8, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x3F, 0x7C,
  0x00, 0x0F, 0xEF, 0x80, 0x07, 0xF9, 0xF0, 0x0F, 0xFE, 0x3F, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xE0,
  0x3F, 0xF0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0xFC, 0x00,
  0x00, 0x07, 0xE1, 0xF8, 0x00, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x00, 0x0F,
  0xCF, 0xC0, 0x00, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0x00, 0x3F, 0x7E, 0x00,
  0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0x9F,
  0x00, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x07, 0xE1,
  0xFC, 0x00, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x00, 0x7F, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0x80, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0x83, 0xE0, 0x01, 0xFF, 0x0F, 0x80, 0x01, 0xFC, 0x3E,
  0x00, 0x03, 0xF0, 0xF8, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x1F, 0x8F, 0x80,
  0x00, 0x7E, 0x3E, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x03, 0xE3, 0xE0, 0x00,
  0x0F, 0x8F, 0x80, 0x00, 0x7E, 0x3E, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x07,
  0xE3, 0xE0, 0x00, 0x3F, 0x0F, 0x80, 0x01, 0xFC, 0x3E, 0x00, 0x0F, 0xE0,
  0xF8, 0x01, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xE0, 0x0F, 0xC0, 0x0F, 0x80,
  0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0xFC, 0x03, 0xE0, 0x03,
  0xF0, 0x0F, 0x80, 0x07, 0xE0, 0x3E, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x3F,
  0x03, 0xE0, 0x00, 0x7E, 0x0F, 0x80, 0x01, 0xF8, 0x3E, 0x00, 0x03, 0xF0,
  0xF8, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0x7F, 0x3E,
  0x00, 0x00, 0xFC, 0xF8, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xE3, 0xFF, 0x07, 0xF8, 0x7F, 0x00, 0x0F, 0x1F,
  0xC0, 0x00, 0x23, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F,
  0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFD, 0xC0, 0x00, 0x3F, 0xBF,
  0x80, 0x3F, 0xE7, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x5C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x1F,
  0x7C, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x0F,
  0xC7, 0xE0, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x0F,
  0xF0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x7C,
  0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0x7E, 0x3E, 0x00, 0x00, 0x07,
  0xC3, 0xF0, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x0F, 0xC1, 0xF0, 0x00,
  0x00, 0xF8, 0x1F, 0x80, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x01, 0xF8, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x01, 0xF8,
  0x00, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x3F, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0x3F, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x01, 0xF9,
  0xF8, 0x00, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00,
  0x0F, 0x9F, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0x9F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xF9, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0xF7, 0xC0, 0x00, 0xFC, 0x3E, 0x00,
  0x07, 0xDF, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF3, 0xE0, 0x01,
  0xF8, 0x1F, 0x80, 0x0F, 0x8F, 0x80, 0x07, 0xE0, 0x7E, 0x00, 0x3E, 0x3F,
  0x00, 0x1F, 0x00, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x03, 0xE0, 0x07,
  0xE1, 0xF0, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x07, 0xC0, 0x0F, 0xC0, 0x3F,
  0x00, 0x7C, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x3E, 0x00, 0xF8,
  0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x3E, 0x03, 0xF0,
  0x1F, 0x80, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x7C, 0x00, 0x3E, 0x07, 0xC0,
  0x1F, 0x01, 0xF0, 0x00, 0xF8, 0x1F, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF0,
  0x7C, 0x00, 0xF8, 0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x03, 0xE0, 0xF8, 0x00,
  0x1F, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x1F,
  0x80, 0x01, 0xF8, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x07, 0xE7, 0xC0, 0x01,
  0xF1, 0xF0, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x3E, 0x7C,
  0x00, 0x0F, 0x9F, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x01,
  0xF7, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xEF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xBE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC7,
  0xE0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0xFC, 0x00, 0x07, 0xE0, 0x0F, 0x80, 0x00, 0xF8, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x0F, 0x80, 0x00, 0x7E, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x0F, 0xC7, 0xE0,
  0x00, 0x00, 0xFC, 0xF8, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xF7, 0xE0,
  0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x07,
  0xC0, 0x1F, 0x80, 0x01, 0xF0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x0F, 0x80, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x1F, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0x00, 0xFC, 0x3E, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x01, 0xFB, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x07,
  0xE7, 0xE0, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x07, 0xE0, 0x3F, 0x00,
  0x03, 0xF0, 0x0F, 0xC0, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x01, 0xF0, 0x03, 0xE0, 0x00,
  0x7E, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x03, 0xF0, 0x3F, 0x00,
  0x00, 0x7E, 0x1F, 0x80, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x03, 0xF3, 0xF0,
  0x00, 0x00, 0xFC, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x03, 0xDE, 0x00, 0x00, 0x1F, 0x3C, 0x00, 0x00, 0x78, 0xF0, 0x00,
  0x03, 0xE1, 0xE0, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x01,
  0xE0, 0x3E, 0x00, 0x07, 0x80, 0x78, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0xF0,
  0x03, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x1E, 0x00, 0xF8, 0x00,
  0x7C, 0x03, 0xC0, 0x00, 0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x07,
  0x83, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x3C, 0x7C, 0x00, 0x00, 0xF9,
  0xF0, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3E, 0x00, 0xF0,
  0x07, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xE0, 0x0F, 0xE0, 0x40, 0x01, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x07,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xCF, 0xFF, 0x81, 0xF3,
  0xF8, 0x00, 0x7D, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00,
  0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0x7F, 0x00, 0xFF, 0xDF,
  0xFF, 0xFD, 0xF3, 0xFF, 0xFE, 0x7C, 0x7F, 0xFF, 0x0F, 0x07, 0xFF, 0x03,
  0xC0, 0x1C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x03, 0xE0, 0xFF, 0xE0, 0x1F, 0x1F,
  0xFF, 0xC0, 0xF9, 0xFF, 0xFF, 0x07, 0xDF, 0xFF, 0xFC, 0x3F, 0xF0, 0x0F,
  0xF1, 0xFE, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x7E, 0x7F, 0x00, 0x03, 0xF3,
  0xF0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x7E, 0xFC, 0x00, 0x01, 0xF7, 0xE0,
  0x00, 0x0F, 0xBF, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x03, 0xEF, 0x80, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x7D, 0xF8,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x3F, 0x7F, 0x00, 0x01, 0xFB, 0xF8, 0x00,
  0x1F, 0x9F, 0xE0, 0x00, 0xFC, 0xFF, 0x80, 0x0F, 0xC7, 0xFE, 0x01, 0xFE,
  0x3E, 0xFF, 0xFF, 0xE1, 0xF3, 0xFF, 0xFE, 0x0F, 0x0F, 0xFF, 0xE0, 0x78,
  0x1F, 0xFC, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x7F,
  0xFE, 0x01, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xE0,
  0x1E, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x02, 0x1F, 0xF0, 0x0E, 0x0F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x0F, 0x80, 0x7C, 0x03, 0xFF, 0x83, 0xE0, 0x7F, 0xFF, 0x1F, 0x07,
  0xFF, 0xFC, 0xF8, 0x7F, 0xFF, 0xF7, 0xC7, 0xF8, 0x07, 0xFE, 0x3F, 0x00,
  0x1F, 0xF3, 0xF0, 0x00, 0x7F, 0x9F, 0x80, 0x01, 0xFD, 0xF8, 0x00, 0x0F,
  0xEF, 0xC0, 0x00, 0x3F, 0x7C, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x03, 0xF7,
  0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x0F, 0xE7, 0xE0,
  0x00, 0xFF, 0x1F, 0x80, 0x0F, 0xF8, 0xFF, 0x00, 0xFF, 0xC3, 0xFF, 0xFF,
  0xBE, 0x0F, 0xFF, 0xF9, 0xF0, 0x3F, 0xFF, 0x8F, 0x80, 0x7F, 0xF0, 0x7C,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x01,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0xFC, 0x03,
  0xF8, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0xE7,
  0xE0, 0x00, 0x3E, 0x7E, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3F, 0x7C, 0x00,
  0x03, 0xF7, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x04, 0x0F, 0xF0, 0x03, 0xC0, 0x7F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xC0,
  0x3F, 0xFE, 0x01, 0xFF, 0x78, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x01, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0x80, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xFF, 0x07, 0xC0, 0xFF, 0xFE, 0x3E, 0x0F, 0xFF, 0xF9,
  0xF0, 0xFF, 0xFF, 0xEF, 0x8F, 0xF0, 0x0F, 0xFC, 0x7E, 0x00, 0x3F, 0xE7,
  0xE0, 0x00, 0xFF, 0x3F, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x1F, 0xDF, 0x80,
  0x00, 0x7E, 0xF8, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x0F, 0xBE, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x3F, 0x7E, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0xFE,
  0x3F, 0x00, 0x0F, 0xF1, 0xFE, 0x01, 0xFF, 0x87, 0xFF, 0xFF, 0x7C, 0x1F,
  0xFF, 0xF3, 0xE0, 0x7F, 0xFF, 0x1F, 0x00, 0xFF, 0xE0, 0xF8, 0x00, 0x38,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x20,
  0x00, 0x07, 0xF0, 0xC0, 0x00, 0x7F, 0x07, 0xE0, 0x0F, 0xF0, 0x3F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x0F, 0x80,
  0x3E, 0x0F, 0xFF, 0x07, 0xC7, 0xFF, 0xF8, 0xF9, 0xFF, 0xFF, 0x9F, 0x7F,
  0xFF, 0xF3, 0xFF, 0x00, 0x7F, 0x7F, 0xC0, 0x07, 0xEF, 0xF0, 0x00, 0x7F,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xC0, 0x7B, 0xFF, 0xFF, 0xFF, 0xE2, 0x00, 0x00, 0x00, 0x00, 0xFB, 0xEF,
  0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF,
  0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0x00, 0x78,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xFA, 0x0F, 0xEF, 0xFF, 0x3F, 0xF8,
  0xFF, 0xE3, 0xFE, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xBE, 0x00, 0x07, 0xE7, 0xC0, 0x01, 0xF8, 0xF8, 0x00,
  0x7E, 0x1F, 0x00, 0x1F, 0x83, 0xE0, 0x07, 0xE0, 0x7C, 0x01, 0xF8, 0x0F,
  0x80, 0x7E, 0x01, 0xF0, 0x1F, 0x80, 0x3E, 0x07, 0xE0, 0x07, 0xC1, 0xF8,
  0x00, 0xF8, 0x7F, 0x00, 0x1F, 0x1F, 0xC0, 0x03, 0xE3, 0xF0, 0x00, 0x7C,
  0xFC, 0x00, 0x0F, 0xBF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80,
  0x07, 0xFB, 0xF8, 0x00, 0xFE, 0x3F, 0x00, 0x1F, 0x83, 0xF0, 0x03, 0xE0,
  0x3F, 0x00, 0x7C, 0x07, 0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xE0,
  0x3E, 0x00, 0x7E, 0x07, 0xC0, 0x0F, 0xE0, 0xF8, 0x00, 0xFC, 0x1F, 0x00,
  0x0F, 0xC3, 0xE0, 0x00, 0xFC, 0x7C, 0x00, 0x1F, 0xCF, 0x80, 0x01, 0xF9,
  0xF0, 0x00, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0x7C, 0x03, 0xC1, 0xFF, 0xE0, 0x0F, 0xFE, 0x0F, 0x8F, 0xFF, 0xE0,
  0xFF, 0xFE, 0x3E, 0x7F, 0xFF, 0x87, 0xFF, 0xFC, 0xFB, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFB, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xEF, 0xF0, 0x01, 0xFF, 0x80,
  0x1F, 0xBF, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x07,
  0xFF, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x1E, 0x07,
  0xFF, 0x83, 0xE3, 0xFF, 0xFC, 0x7C, 0xFF, 0xFF, 0xCF, 0xBF, 0xFF, 0xF9,
  0xFF, 0x80, 0x3F, 0xBF, 0xC0, 0x03, 0xF7, 0xF8, 0x00, 0x3F, 0xFE, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0x80, 0x7F, 0x81, 0xF8, 0x00,
  0x7E, 0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x07,
  0xE7, 0xE0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x3F, 0x7C, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x03, 0xF7, 0xC0, 0x00,
  0x0F, 0x9F, 0x80, 0x00, 0x3E, 0x3E, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x07,
  0xC1, 0xF8, 0x00, 0x3F, 0x07, 0xF0, 0x01, 0xF8, 0x0F, 0xE0, 0x1F, 0xE0,
  0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x07, 0xC1,
  0xFF, 0xC0, 0x3E, 0x3F, 0xFF, 0x81, 0xF3, 0xFF, 0xFE, 0x0F, 0xBF, 0xFF,
  0xF8, 0x7F, 0xE0, 0x1F, 0xE3, 0xFC, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0xFC,
  0xFE, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0xFD, 0xF8,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0xFB, 0xE0, 0x00,
  0x07, 0xDF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x1F, 0x7E,
  0x00, 0x00, 0xFB, 0xF0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x7E, 0xFE, 0x00,
  0x03, 0xF7, 0xF0, 0x00, 0x3F, 0x3F, 0xC0, 0x03, 0xF9, 0xFF, 0x00, 0x3F,
  0x8F, 0xFC, 0x03, 0xFC, 0x7D, 0xFF, 0xFF, 0xC3, 0xE7, 0xFF, 0xFC, 0x1F,
  0x1F, 0xFF, 0xC0, 0xF8, 0x3F, 0xF8, 0x07, 0xC0, 0x18, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0xFF, 0x07, 0xC0, 0xFF, 0xFE, 0x3E, 0x0F, 0xFF, 0xF9,
  0xF0, 0xFF, 0xFF, 0xEF, 0x8F, 0xE0, 0x0F, 0xFC, 0x7E, 0x00, 0x3F, 0xE7,
  0xE0, 0x00, 0xFF, 0x3F, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x1F, 0xDF, 0x80,
  0x00, 0x7E, 0xF8, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x1F, 0xBE, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x3F, 0x7E, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x1F, 0xCF, 0xC0, 0x01, 0xFE,
  0x3F, 0x00, 0x1F, 0xF1, 0xFE, 0x01, 0xFF, 0x87, 0xFF, 0xFF, 0x7C, 0x1F,
  0xFF, 0xF3, 0xE0, 0x7F, 0xFF, 0x1F, 0x00, 0xFF, 0xE0, 0xF8, 0x00, 0x60,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xDE, 0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x7F, 0xEF, 0x9F,
  0xFD, 0xF7, 0xE0, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x0F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x8F, 0xC0,
  0x0F, 0x3F, 0x00, 0x02, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0,
  0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xEF, 0x80, 0x1F, 0xDF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x01, 0xD0, 0x00, 0x01, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x7E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0x7F, 0xF8, 0x03, 0xFF, 0x00, 0x06, 0x00,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF0,
  0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xFF, 0x80, 0x03, 0xFD, 0xF8, 0x00, 0xFF, 0xBF, 0x80, 0x3F, 0xF3, 0xFF,
  0xFF, 0xBE, 0x7F, 0xFF, 0xE7, 0xC7, 0xFF, 0xF8, 0xF8, 0x3F, 0xFC, 0x0F,
  0x00, 0x38, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x03, 0xF7,
  0xE0, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x3E, 0x3E, 0x00, 0x01, 0xF8, 0xFC,
  0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0xFC, 0x1F, 0x80,
  0x03, 0xE0, 0x3E, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x7C, 0x03, 0xF0, 0x01,
  0xF0, 0x07, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x3E, 0x00, 0xF8,
  0x00, 0xF8, 0x07, 0xE0, 0x03, 0xF0, 0x1F, 0x00, 0x07, 0xC0, 0xFC, 0x00,
  0x1F, 0x03, 0xE0, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0xF8, 0x7E, 0x00, 0x03,
  0xE1, 0xF0, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x7C,
  0xF8, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0x7F, 0x00, 0x03, 0xEF, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x9F, 0x00, 0x07,
  0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x3F, 0xE0, 0x01, 0xF1, 0xF8, 0x00, 0xF7,
  0x80, 0x07, 0xC7, 0xE0, 0x03, 0xDF, 0x00, 0x3F, 0x0F, 0x80, 0x1F, 0x7C,
  0x00, 0xF8, 0x3E, 0x00, 0x7D, 0xF0, 0x03, 0xE0, 0xFC, 0x01, 0xE3, 0xC0,
  0x0F, 0x81, 0xF0, 0x0F, 0x8F, 0x80, 0x7E, 0x07, 0xC0, 0x3E, 0x3E, 0x01,
  0xF0, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0xC0, 0x7E, 0x07, 0xC1, 0xF0, 0x3F,
  0x00, 0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0x7C, 0x1F, 0x03, 0xE0,
  0x0F, 0x83, 0xE0, 0x3E, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0xF8, 0x7E, 0x00,
  0x7C, 0x3E, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0xF0, 0x07, 0xC7, 0xC0, 0x07,
  0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x0F, 0x9F, 0x00, 0x7C, 0xF8, 0x00, 0x3E,
  0x7C, 0x01, 0xF3, 0xE0, 0x00, 0xF9, 0xE0, 0x03, 0xEF, 0x80, 0x03, 0xEF,
  0x80, 0x0F, 0xBE, 0x00, 0x07, 0xFE, 0x00, 0x3E, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0xFC, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x01, 0xF0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0xFC,
  0x0F, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x0F, 0xCF,
  0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0xFC, 0xF8, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFC,
  0x0F, 0xC0, 0x07, 0xE0, 0x1F, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x00,
  0xFC, 0x07, 0xE0, 0x01, 0xF0, 0x1F, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F,
  0xC7, 0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7E,
  0xF8, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x07, 0xC3,
  0xE0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0xFC, 0x0F,
  0xC0, 0x01, 0xF8, 0x0F, 0x80, 0x03, 0xE0, 0x1F, 0x00, 0x0F, 0xC0, 0x3F,
  0x00, 0x1F, 0x80, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x7C,
  0x01, 0xF0, 0x00, 0xF8, 0x03, 0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x01, 0xF0,
  0x1F, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x07, 0xC1,
  0xF0, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x1F, 0x1F,
  0x00, 0x00, 0x1E, 0x3E, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x7D, 0xF0,
  0x00, 0x00, 0x7B, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xE0, 0x01, 0xFC,
  0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFE, 0x01, 0xFC, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7F, 0x00, 0xFF, 0xC0, 0x1F, 0xE0, 0x03, 0xF0, 0x00, 0x7F,
  0xC0, 0x0F, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0x7F, 0x80, 0x03, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xF0, 0x00, 0x1F, 0xC0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0xE0, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x1F, 0xF0, 0x07, 0xFE, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x03,
  0xFC, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x13, 0xFF, 0xC0, 0x03,
  0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFE, 0x80, 0x01, 0xFF, 0xC8, 0x00, 0x01, 0xF0,
};

const GFXglyph NotoSans_Regular60pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 8, 44, 16, 4, -43 },
  { 45, 17, 16, 24, 4, -43 },
  { 79, 36, 43, 39, 1, -43 },
  { 273, 27, 49, 34, 4, -46 },
  { 439, 44, 44, 50, 3, -43 },
  { 681, 41, 45, 44, 3, -44 },
  { 912, 6, 16, 14, 4, -43 },
  { 924, 14, 52, 18, 2, -43 },
  { 1015, 14, 52, 18, 2, -43 },
  { 1106, 28, 27, 33, 2, -46 },
  { 1201, 28, 29, 34, 3, -36 },
  { 1303, 10, 15, 16, 2, -7 },
  { 1322, 15, 4, 19, 2, -18 },
  { 1330, 8, 8, 16, 4, -7 },
  { 1338, 21, 43, 22, 1, -43 },
  { 1451, 28, 45, 34, 3, -44 },
  { 1609, 16, 43, 34, 5, -43 },
  { 1695, 28, 43, 34, 3, -43 },
  { 1846, 28, 44, 34, 3, -43 },
  { 2000, 32, 43, 34, 1, -43 },
  { 2172, 27, 44, 34, 4, -43 },
  { 2321, 29, 44, 34, 3, -43 },
  { 2481, 28, 43, 34, 3, -43 },
  { 2632, 28, 44, 34, 3, -43 },
  { 2786, 28, 44, 34, 3, -43 },
  { 2940, 8, 34, 16, 4, -33 },
  { 2974, 10, 41, 16, 2, -33 },
  { 3026, 28, 29, 34, 3, -36 },
  { 3128, 28, 16, 34, 3, -29 },
  { 3184, 28, 29, 34, 3, -36 },
  { 3286, 23, 44, 26, 1, -43 },
  { 3413, 47, 48, 54, 3, -43 },
  { 3695, 38, 43, 38, 0, -43 },
  { 3900, 30, 43, 39, 6, -43 },
  { 4062, 32, 44, 38, 4, -43 },
  { 4238, 34, 43, 44, 6, -43 },
  { 4421, 24, 43, 33, 6, -43 },
  { 4550, 24, 43, 31, 6, -43 },
  { 4679, 35, 44, 44, 4, -43 },
  { 4872, 33, 43, 44, 6, -43 },
  { 5050, 16, 43, 20, 2, -43 },
  { 5136, 16, 54, 16, -5, -43 },
  { 5244, 31, 43, 37, 6, -43 },
  { 5411, 24, 43, 31, 6, -43 },
  { 5540, 43, 43, 54, 6, -43 },
  { 5772, 34, 43, 46, 6, -43 },
  { 5955, 39, 45, 47, 4, -44 },
  { 6175, 27, 43, 36, 6, -43 },
  { 6321, 39, 54, 47, 4, -44 },
  { 6585, 30, 43, 37, 6, -43 },
  { 6747, 27, 44, 33, 3, -43 },
  { 6896, 32, 43, 33, 1, -43 },
  { 7068, 33, 44, 44, 5, -43 },
  { 7250, 36, 43, 36, 0, -43 },
  { 7444, 54, 43, 56, 1, -43 },
  { 7735, 35, 43, 35, 0, -43 },
  { 7924, 34, 43, 34, 0, -43 },
  { 8107, 30, 43, 34, 2, -43 },
  { 8269, 13, 52, 20, 5, -43 },
  { 8354, 21, 43, 22, 1, -43 },
  { 8467, 14, 52, 20, 1, -43 },
  { 8558, 30, 27, 34, 2, -43 },
  { 8660, 27, 4, 27, 0, 5 },
  { 8674, 12, 10, 17, 2, -46 },
  { 8689, 26, 34, 34, 3, -33 },
  { 8800, 29, 47, 37, 5, -46 },
  { 8971, 24, 34, 29, 3, -33 },
  { 9073, 29, 47, 37, 3, -46 },
  { 9244, 28, 34, 34, 3, -33 },
  { 9363, 22, 46, 21, 1, -46 },
  { 9490, 29, 47, 37, 3, -33 },
  { 9661, 27, 46, 37, 5, -46 },
  { 9817, 6, 44, 15, 5, -44 },
  { 9850, 14, 58, 15, -3, -44 },
  { 9952, 27, 46, 32, 5, -46 },
  { 10108, 5, 46, 15, 5, -46 },
  { 10137, 46, 33, 56, 5, -33 },
  { 10327, 27, 33, 37, 5, -33 },
  { 10439, 30, 34, 36, 3, -33 },
  { 10567, 29, 47, 37, 5, -33 },
  { 10738, 29, 47, 37, 3, -33 },
  { 10909, 19, 33, 25, 5, -33 },
  { 10988, 23, 34, 29, 3, -33 },
  { 11086, 19, 41, 22, 1, -40 },
  { 11184, 27, 33, 37, 5, -32 },
  { 11296, 30, 32, 30, 0, -32 },
  { 11416, 46, 32, 47, 1, -32 },
  { 11600, 30, 32, 32, 1, -32 },
  { 11720, 31, 46, 31, 0, -32 },
  { 11899, 24, 32, 28, 2, -32 },
  { 11995, 19, 52, 23, 2, -43 },
  { 12119, 5, 60, 33, 14, -46 },
  { 12157, 19, 52, 23, 2, -43 },
  { 12281, 28, 8, 34, 3, -25 },
};

const GFXfont NotoSans_Regular60pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Regular60pt7bBitmaps,
  (GFXglyph *)NotoSans_Regular60pt7bGlyphs,
  0x20, 0x7E, 82
};

#endif // _NOTOSANS_REGULAR60PT7B_H_
