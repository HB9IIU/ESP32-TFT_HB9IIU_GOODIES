#ifndef _NOTOSANS_REGULAR67PT7B_H_
#define _NOTOSANS_REGULAR67PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Regular.ttf
// Size: 67pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Regular67pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x3E,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7E, 0x3C, 0xFE, 0x07, 0xFF, 0xC0, 0xFD, 0xF8, 0x1F, 0xBE, 0x03, 0xF7,
  0xC0, 0x7E, 0xF8, 0x0F, 0xDF, 0x01, 0xFB, 0xE0, 0x3E, 0x7C, 0x07, 0xCF,
  0x80, 0xF9, 0xF0, 0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0x3C, 0xF8, 0x07, 0x9F,
  0x00, 0xF1, 0xE0, 0x1E, 0x38, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x07, 0x80, 0x00, 0x03,
  0xE0, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x0F, 0x00, 0x00,
  0x07, 0xC0, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x1E, 0x00,
  0x00, 0x0F, 0x80, 0x1E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x78, 0x00, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x01, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF8, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x03, 0xC0, 0x00, 0x01, 0xF0,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x07, 0xC0,
  0x00, 0x01, 0xE0, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x07, 0x80, 0x00, 0x03,
  0xE0, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x0F,
  0x80, 0x00, 0x03, 0xC0, 0x0F, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xC1, 0xFF, 0x3C, 0x7F, 0x87, 0xF0, 0x78, 0x07, 0x0F, 0xC0, 0xF0,
  0x00, 0x3F, 0x01, 0xE0, 0x00, 0x7E, 0x03, 0xC0, 0x00, 0xFC, 0x07, 0x80,
  0x01, 0xF8, 0x0F, 0x00, 0x03, 0xF0, 0x1E, 0x00, 0x07, 0xF0, 0x3C, 0x00,
  0x07, 0xE0, 0x78, 0x00, 0x0F, 0xF0, 0xF0, 0x00, 0x0F, 0xF9, 0xE0, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xC3, 0xFE, 0x00,
  0x07, 0x81, 0xFC, 0x00, 0x0F, 0x01, 0xF8, 0x00, 0x1E, 0x03, 0xF0, 0x00,
  0x3C, 0x03, 0xF0, 0x00, 0x78, 0x07, 0xE0, 0x00, 0xF0, 0x0F, 0xC0, 0x01,
  0xE0, 0x3F, 0x00, 0x03, 0xC0, 0x7E, 0xC0, 0x07, 0x81, 0xFD, 0xF0, 0x0F,
  0x0F, 0xF3, 0xFF, 0xDF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xC0, 0x03,
  0xFF, 0xF0, 0x00, 0x07, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xE0, 0x01,
  0xF8, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x1F, 0x80, 0x01, 0xF0, 0x00,
  0xF8, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x03, 0xE0, 0x01, 0xF8, 0x00,
  0x3E, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xFC, 0x00,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x3E, 0x00,
  0x01, 0xF0, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0xF8, 0x01, 0xF0, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x7C, 0x0F, 0x80,
  0x00, 0x0F, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x07, 0x80, 0x1F, 0x07, 0xC1,
  0xFE, 0x03, 0xE0, 0x0F, 0x87, 0xC1, 0xFF, 0xC1, 0xF0, 0x0F, 0x83, 0xE1,
  0xFF, 0xF0, 0xF8, 0x07, 0xC3, 0xE1, 0xFF, 0xFC, 0x3E, 0x07, 0xE1, 0xF1,
  0xF8, 0x3E, 0x1F, 0x87, 0xE1, 0xF0, 0xF8, 0x0F, 0x87, 0xFF, 0xF1, 0xF8,
  0x7C, 0x07, 0xC3, 0xFF, 0xF0, 0xF8, 0x7C, 0x01, 0xF0, 0xFF, 0xF0, 0xFC,
  0x3E, 0x00, 0xF8, 0x1F, 0xF0, 0x7C, 0x1F, 0x00, 0x7C, 0x00, 0x80, 0x7C,
  0x0F, 0x80, 0x3E, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x3E,
  0x03, 0xE0, 0x0F, 0x80, 0x00, 0x1F, 0x01, 0xE0, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0xF0, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x78, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x3C, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x1F, 0x00, 0x03,
  0xE0, 0x03, 0xE0, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x03, 0xE0, 0x01,
  0xF8, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0xC1, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x00, 0x03,
  0xFB, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x7E, 0x03, 0xFE, 0xFF, 0x00, 0x03, 0xF0, 0x3F, 0xC3, 0xFC, 0x00,
  0x3F, 0x03, 0xFC, 0x0F, 0xF0, 0x01, 0xF8, 0x3F, 0xC0, 0x3F, 0xC0, 0x0F,
  0xC1, 0xFC, 0x00, 0xFF, 0x00, 0xFC, 0x1F, 0xC0, 0x03, 0xFC, 0x07, 0xE0,
  0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x07, 0xE0, 0x00, 0x3F, 0xC3, 0xF0, 0x3F,
  0x00, 0x00, 0xFF, 0x3F, 0x81, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x0F, 0xC0,
  0x00, 0x0F, 0xFF, 0x80, 0x7E, 0x00, 0x00, 0x3F, 0xFC, 0x03, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x1F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0xF0, 0x07, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0x7F,
  0xFF, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xCF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF,
  0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0xBE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFD, 0xFB, 0xE7, 0xCF, 0x9F,
  0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x1E, 0x38, 0x00, 0x7E, 0x01,
  0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0,
  0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8,
  0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x03,
  0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1F,
  0x80, 0x3F, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80,
  0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3E, 0x00, 0xFC,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x01, 0x00, 0x0F, 0x80, 0x0B, 0xE0, 0x1F, 0x00, 0xF7, 0xF8, 0x3C,
  0x1F, 0xEF, 0xFF, 0x79, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x07, 0xCF, 0xC0,
  0x00, 0x1F, 0x8F, 0x80, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x80,
  0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xE0, 0x3F, 0x80, 0x3F, 0xC0, 0x7F, 0x00,
  0x3F, 0x00, 0x7F, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x08, 0x00, 0x80, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0xC7, 0xF1, 0xF8, 0x7E, 0x3F, 0x8F, 0xE3, 0xF0, 0xFC, 0x3E, 0x1F,
  0x87, 0xE1, 0xF0, 0x7C, 0x1E, 0x0F, 0x83, 0xE0, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3C, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x3C, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFE, 0x7F,
  0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0xC0, 0x01,
  0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00,
  0xFC, 0x3F, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00,
  0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00,
  0x3F, 0x7C, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00,
  0x3F, 0x7E, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00,
  0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00,
  0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xFC, 0x1F, 0x80, 0x01,
  0xF8, 0x0F, 0xC0, 0x03, 0xF8, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xFC, 0x3F,
  0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x07, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F,
  0xFC, 0x7F, 0xBF, 0x3F, 0xCF, 0xDF, 0xE3, 0xFF, 0xF0, 0xFD, 0xF0, 0x3F,
  0x38, 0x0F, 0xC4, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xC0, 0x0F,
  0xF0, 0x3F, 0x00, 0x07, 0xF8, 0x1C, 0x00, 0x03, 0xF8, 0x18, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x01, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFC, 0xFF,
  0xF0, 0x7F, 0x80, 0x0F, 0xF8, 0x3E, 0x00, 0x03, 0xF8, 0x18, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0xC0, 0x00, 0x03, 0xFC, 0xF8, 0x00, 0x0F, 0xF8, 0xFF, 0xC0, 0x7F,
  0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x00, 0x7C,
  0xF8, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00,
  0x1F, 0x1F, 0x80, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x00, 0x7E, 0x1F, 0x80,
  0x00, 0x07, 0xC1, 0xF8, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x1F, 0x81,
  0xF8, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x1F, 0x80, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x1F, 0x80,
  0x01, 0xF8, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0xF8,
  0x00, 0x1F, 0x80, 0x1F, 0x80, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x3E, 0x00, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x08, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x80, 0x00, 0x03, 0xF9,
  0x80, 0x00, 0x0F, 0xE3, 0xE0, 0x00, 0x7F, 0xC7, 0xFF, 0x1F, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x1C, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0xC0,
  0x0F, 0xC1, 0xFF, 0xF0, 0x1F, 0x8F, 0xFF, 0xF8, 0x3F, 0x3F, 0xFF, 0xF8,
  0x7E, 0xFF, 0xFF, 0xF8, 0xFF, 0xF0, 0x0F, 0xF9, 0xFF, 0x80, 0x07, 0xF3,
  0xFE, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x03, 0xF7, 0xC0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x0F, 0xDF, 0x80,
  0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0xFC, 0x7F, 0x00,
  0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x3F, 0x80, 0xFF, 0xC3,
  0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0x80, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFC, 0x3F, 0xF0, 0x1F, 0xE0, 0x07,
  0xF8, 0x1F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x00,
  0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00,
  0x7C, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00,
  0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0xC0, 0x01, 0xF8, 0x0F, 0xE0, 0x07,
  0xF0, 0x07, 0xF8, 0x0F, 0xE0, 0x07, 0xFC, 0x3F, 0xC0, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xF8, 0x3F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x01,
  0xFC, 0x7F, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00,
  0xFE, 0x3F, 0xC0, 0x03, 0xFC, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFE, 0xFF, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x1F, 0xC0, 0x03,
  0xF0, 0x3F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x00,
  0xFC, 0x7E, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00,
  0x7E, 0xFC, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0x7E, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00,
  0xFF, 0x3F, 0x00, 0x01, 0xFF, 0x3F, 0x80, 0x03, 0xFF, 0x1F, 0xE0, 0x0F,
  0xFF, 0x1F, 0xFF, 0xFF, 0xBF, 0x0F, 0xFF, 0xFF, 0x3F, 0x07, 0xFF, 0xFE,
  0x3E, 0x01, 0xFF, 0xF8, 0x3E, 0x00, 0x7F, 0xE0, 0x7E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0xC0, 0x0C, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7E, 0x3C, 0x07, 0x81, 0xF8, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7,
  0xF8, 0xFE, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x87, 0xF0, 0xFE, 0x1F,
  0xC3, 0xF0, 0x7E, 0x1F, 0xC3, 0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x7E, 0x0F,
  0x81, 0xF0, 0x3C, 0x0F, 0x81, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xC7, 0xE0,
  0x07, 0xF9, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x07, 0xFF, 0xF8, 0x03, 0xE1,
  0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x3E, 0x3E, 0x00, 0x3F, 0xFF, 0xFC, 0x03,
  0xE3, 0xE0, 0x07, 0xFE, 0x7F, 0xC0, 0x1F, 0x3E, 0x00, 0xFE, 0x00, 0xFC,
  0x01, 0xF7, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x7C, 0x01, 0xF8, 0x00,
  0xF8, 0x01, 0xF7, 0xC0, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xF8, 0x03, 0xF0,
  0x00, 0xF8, 0x00, 0xFF, 0x80, 0x3E, 0x00, 0x0F, 0x80, 0x0F, 0xF8, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0xFF, 0x80, 0x7E, 0x00, 0x0F, 0x80, 0x0F, 0xF8,
  0x07, 0xE0, 0x00, 0xF8, 0x00, 0xFF, 0x80, 0x7E, 0x00, 0x0F, 0x80, 0x1F,
  0xF8, 0x07, 0xE0, 0x00, 0xF8, 0x01, 0xFF, 0x80, 0x7E, 0x00, 0x0F, 0x80,
  0x1F, 0xF8, 0x07, 0xE0, 0x01, 0xF8, 0x01, 0xFF, 0x80, 0x3E, 0x00, 0x1F,
  0x80, 0x3E, 0xF8, 0x03, 0xE0, 0x01, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0x00,
  0x3F, 0x80, 0x3C, 0xF8, 0x03, 0xF0, 0x03, 0xFC, 0x07, 0xCF, 0x80, 0x1F,
  0x80, 0x7B, 0xC0, 0xF8, 0x7C, 0x01, 0xFF, 0xFF, 0x3F, 0xFF, 0x87, 0xC0,
  0x0F, 0xFF, 0xF1, 0xFF, 0xF0, 0x7C, 0x00, 0x7F, 0xFE, 0x1F, 0xFE, 0x07,
  0xE0, 0x01, 0xFF, 0x80, 0x7F, 0x80, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xC0,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xFF, 0xF3, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x00, 0x01, 0xFB, 0xE0,
  0x00, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xC7, 0xC0, 0x00,
  0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0xC1, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x00, 0x3E,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x01,
  0xFC, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC7, 0xE0, 0x00,
  0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x00,
  0x03, 0xF7, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0x80, 0x1F, 0xFF, 0x8F, 0xE0, 0x00, 0x3F,
  0xE3, 0xF8, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00,
  0x1F, 0xCF, 0xE0, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x00, 0xFC, 0xFE, 0x00,
  0x00, 0x3F, 0x3F, 0x80, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x03, 0xF3, 0xF8,
  0x00, 0x00, 0xFC, 0xFE, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x1F, 0x8F,
  0xE0, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x0F, 0xE0, 0x00,
  0x3F, 0xE3, 0xF8, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x00, 0x3F, 0xBF, 0x80,
  0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00,
  0x7F, 0xBF, 0x80, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xC0, 0x07, 0xE0, 0x3F, 0xE0, 0x00, 0x0C, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x20, 0x3F, 0xF8, 0x00,
  0x1C, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0x01, 0xFA, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xC0, 0x0F, 0xFF, 0xE0, 0x3F, 0x80, 0x00,
  0xFF, 0xE0, 0x7F, 0x00, 0x00, 0x3F, 0xE0, 0xFE, 0x00, 0x00, 0x3F, 0xE1,
  0xFC, 0x00, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x00, 0x3F, 0xC7, 0xF0, 0x00,
  0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x00, 0x7F,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0xFE, 0x00,
  0x00, 0x00, 0xFD, 0xFC, 0x00, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x00, 0x03,
  0xF7, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x00, 0x3F, 0x7F,
  0x00, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00,
  0x03, 0xF3, 0xF8, 0x00, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x00, 0x1F, 0xCF,
  0xE0, 0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x3F, 0x80, 0x00,
  0x07, 0xF8, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x00, 0xFF, 0x81,
  0xFC, 0x00, 0x07, 0xFF, 0x03, 0xF8, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFB, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xEF, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x01, 0xFC, 0x03, 0xFF, 0x00,
  0x00, 0x38, 0x07, 0xFC, 0x00, 0x00, 0x08, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x00, 0x3F,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0x03, 0xFF, 0x80,
  0x00, 0x7F, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF,
  0x80, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03,
  0xF8, 0x03, 0xF8, 0x03, 0xFD, 0xFF, 0xFC, 0xFF, 0xFE, 0x7F, 0xFE, 0x3F,
  0xFE, 0x1F, 0xFC, 0x03, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x07, 0xFB, 0xF8, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x3F, 0x8F,
  0xE0, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0xFE,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x03,
  0xF8, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xE0,
  0x07, 0xF0, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x07,
  0xF0, 0x1F, 0xC0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x1F, 0xC1, 0xFC, 0x00,
  0x03, 0xF8, 0x7F, 0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x0F, 0xE7, 0xF0,
  0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0x3F, 0xBF, 0xE0, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFD, 0xFC, 0x00, 0x03,
  0xFF, 0x3F, 0xC0, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0x80,
  0x01, 0xFC, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x07, 0xF0, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xF8,
  0x00, 0xFF, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0xFE, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0xFE, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x1F, 0xC3, 0xF8, 0x00,
  0x03, 0xF8, 0x7F, 0x00, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x03, 0xF9, 0xFC,
  0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xDF,
  0xFF, 0xF0, 0x00, 0x00, 0x07, 0xDF, 0xFD, 0xF8, 0x00, 0x00, 0x0F, 0xDF,
  0xFD, 0xF8, 0x00, 0x00, 0x0F, 0x9F, 0xFC, 0xF8, 0x00, 0x00, 0x1F, 0xBF,
  0xFC, 0xFC, 0x00, 0x00, 0x1F, 0x3F, 0xFC, 0xFC, 0x00, 0x00, 0x1F, 0x3F,
  0xFC, 0x7C, 0x00, 0x00, 0x3F, 0x3F, 0xFC, 0x7E, 0x00, 0x00, 0x3E, 0x3F,
  0xFC, 0x7E, 0x00, 0x00, 0x3E, 0x3F, 0xFC, 0x3F, 0x00, 0x00, 0x7E, 0x3F,
  0xFC, 0x3F, 0x00, 0x00, 0x7C, 0x3F, 0xFC, 0x1F, 0x00, 0x00, 0xFC, 0x3F,
  0xFC, 0x1F, 0x80, 0x00, 0xF8, 0x3F, 0xFC, 0x1F, 0x80, 0x00, 0xF8, 0x3F,
  0xFC, 0x0F, 0x80, 0x01, 0xF8, 0x3F, 0xFC, 0x0F, 0xC0, 0x01, 0xF0, 0x3F,
  0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0xFC, 0x07, 0xE0, 0x03, 0xF0, 0x3F,
  0xFC, 0x07, 0xE0, 0x03, 0xE0, 0x3F, 0xFC, 0x03, 0xE0, 0x07, 0xE0, 0x3F,
  0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x3F, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x3F,
  0xFC, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0xFC, 0x01, 0xF8, 0x0F, 0x80, 0x3F,
  0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x3F, 0xFC, 0x00, 0xFC, 0x1F, 0x00, 0x3F,
  0xFC, 0x00, 0xFC, 0x1F, 0x00, 0x3F, 0xFC, 0x00, 0x7C, 0x3F, 0x00, 0x3F,
  0xFC, 0x00, 0x7E, 0x3E, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x3F,
  0xFC, 0x00, 0x3E, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x7C, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xF7, 0xF0, 0x00, 0x01, 0xFF, 0xDF, 0xC0, 0x00, 0x07, 0xFF, 0x3F,
  0x80, 0x00, 0x1F, 0xFC, 0x7E, 0x00, 0x00, 0x7F, 0xF1, 0xFC, 0x00, 0x01,
  0xFF, 0xC3, 0xF8, 0x00, 0x07, 0xFF, 0x0F, 0xE0, 0x00, 0x1F, 0xFC, 0x1F,
  0xC0, 0x00, 0x7F, 0xF0, 0x3F, 0x80, 0x01, 0xFF, 0xC0, 0xFE, 0x00, 0x07,
  0xFF, 0x01, 0xFC, 0x00, 0x1F, 0xFC, 0x03, 0xF8, 0x00, 0x7F, 0xF0, 0x0F,
  0xE0, 0x01, 0xFF, 0xC0, 0x1F, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0x80, 0x1F,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFC, 0x01, 0xFF, 0xC0, 0x03,
  0xF0, 0x07, 0xFF, 0x00, 0x0F, 0xE0, 0x1F, 0xFC, 0x00, 0x1F, 0xC0, 0x7F,
  0xF0, 0x00, 0x7F, 0x01, 0xFF, 0xC0, 0x00, 0xFE, 0x07, 0xFF, 0x00, 0x01,
  0xFC, 0x1F, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0xF0, 0x00, 0x0F, 0xE1, 0xFF,
  0xC0, 0x00, 0x1F, 0xC7, 0xFF, 0x00, 0x00, 0x7F, 0x1F, 0xFC, 0x00, 0x00,
  0xFE, 0x7F, 0xF0, 0x00, 0x01, 0xFD, 0xFF, 0xC0, 0x00, 0x07, 0xF7, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xE0, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x3F,
  0x00, 0x00, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x7F, 0x00,
  0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0x00,
  0x7E, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00, 0x00, 0xFE,
  0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x07, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF,
  0x1F, 0xC0, 0x1F, 0xFE, 0x3F, 0x80, 0x03, 0xFE, 0x7F, 0x00, 0x01, 0xFE,
  0xFE, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xEF, 0xE0,
  0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x7F, 0x3F, 0x80, 0x01, 0xFE, 0x7F, 0x00,
  0x1F, 0xF8, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x81,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC3, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE7, 0xF0, 0x00,
  0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00,
  0x00, 0x7E, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xF7, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x00, 0x07,
  0xE7, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xE3,
  0xF0, 0x00, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC3, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x81, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x01, 0xFC, 0x03, 0xFF, 0xF0, 0x3F, 0x80, 0x03, 0xFE, 0x07,
  0xF0, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x1F,
  0xC3, 0xF8, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0x3F, 0x0F, 0xE0, 0x00,
  0x07, 0xE1, 0xFC, 0x00, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0x1F, 0x87, 0xF0,
  0x00, 0x03, 0xF0, 0xFE, 0x00, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x1F, 0xC3,
  0xF8, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x1F,
  0x81, 0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x07, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x03, 0xF8, 0x03, 0xF8, 0x00,
  0x3F, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x7F, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x0F, 0xC0,
  0xFE, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x03,
  0xF8, 0x7F, 0x00, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x03, 0xF9, 0xFC, 0x00,
  0x00, 0x7F, 0x3F, 0x80, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x07, 0xFC,
  0x00, 0xFC, 0x1F, 0xE0, 0x00, 0x38, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xFB, 0x80, 0x00, 0x0F, 0xE7, 0xE0, 0x00,
  0x7F, 0xCF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xE7,
  0xE0, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x00,
  0x1F, 0xC7, 0xF0, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0xFF,
  0x00, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x7E, 0x00,
  0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x00,
  0xFE, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x1F,
  0x80, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00,
  0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x3F, 0x80, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x00, 0x7F,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00,
  0x1F, 0x81, 0xF8, 0x00, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x00, 0x07, 0xE3, 0xF0, 0x00,
  0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0x03,
  0xE7, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF7, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xE7, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFC,
  0x3F, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x0F, 0xBF,
  0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x1F, 0x9F, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF9, 0xF8, 0x00,
  0x1F, 0x81, 0xFC, 0x00, 0x1F, 0x9F, 0x80, 0x01, 0xF8, 0x0F, 0xC0, 0x01,
  0xF0, 0xF8, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0,
  0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x3E, 0x07,
  0xC0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7F, 0x00, 0x7E,
  0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00,
  0x7E, 0x00, 0x7F, 0x00, 0x7C, 0x03, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x03, 0xF0, 0x0F, 0x80, 0x1F, 0x00, 0xFC, 0x00, 0x1F, 0x81, 0xF8, 0x01,
  0xF8, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0x81, 0xF8, 0x00, 0x1F,
  0x81, 0xF8, 0x00, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x3F,
  0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x7C, 0x3F, 0x00,
  0x00, 0xFC, 0x7E, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x07, 0xC7, 0xE0, 0x00,
  0x7E, 0x3F, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x07,
  0xE7, 0xC0, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x03, 0xF7,
  0xE0, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3E, 0xF8,
  0x00, 0x01, 0xF7, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0x7C, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0x7E,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0xFE,
  0x00, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x00,
  0x0F, 0xCF, 0xC0, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x01, 0xF8,
  0xFC, 0x00, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x00, 0x0F, 0xC1, 0xFC, 0x00,
  0x00, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x01, 0xF8,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x07, 0xF0,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xF8,
  0x00, 0x0F, 0xE0, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x00, 0x3F, 0x83, 0xF8,
  0x00, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01, 0xFD, 0xF8,
  0x00, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0x00,
  0xFC, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x00, 0x1F, 0x81, 0xFC,
  0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x0F, 0xE0, 0x00, 0x1F,
  0x80, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x03, 0xF8,
  0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x00, 0x7E,
  0x01, 0xF8, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x3F, 0x00,
  0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x00, 0x3F,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x7B, 0xE0, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0x3C, 0x7C,
  0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x1F, 0x07,
  0xC0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x07, 0xC0,
  0x3E, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x03, 0xE0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x03, 0xE0, 0x3E,
  0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x3E, 0x1F,
  0x00, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x01, 0xF7,
  0xC0, 0x00, 0x00, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xF8, 0x1F, 0xC0,
  0x7F, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x03, 0xFC, 0x1F, 0xF8, 0x1E, 0x00,
  0x1F, 0xC0, 0x40, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x3F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFB,
  0xF3, 0xFF, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0xFD, 0xFC, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x3F, 0xEF, 0xE0, 0x03, 0xFF, 0x7F, 0xC0, 0xFE, 0xF9,
  0xFF, 0xFF, 0xE7, 0xC7, 0xFF, 0xFE, 0x3E, 0x1F, 0xFF, 0xE0, 0xF0, 0x3F,
  0xFC, 0x07, 0x80, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0xC0, 0x00, 0xFC, 0x1F, 0xFC, 0x00, 0xF8, 0x7F,
  0xFF, 0x00, 0xF8, 0xFF, 0xFF, 0xC0, 0xF9, 0xFF, 0xFF, 0xE0, 0xFB, 0xFE,
  0x7F, 0xF0, 0xFF, 0xC0, 0x07, 0xF0, 0xFF, 0x80, 0x03, 0xF8, 0xFF, 0x00,
  0x01, 0xFC, 0xFE, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0xFC, 0xFC, 0x00,
  0x00, 0xFE, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00,
  0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00,
  0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00,
  0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFE, 0x00,
  0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x01, 0xFC, 0xFF, 0x00,
  0x01, 0xFC, 0xFF, 0x80, 0x03, 0xF8, 0xFF, 0xC0, 0x07, 0xF8, 0xFB, 0xF8,
  0x3F, 0xF0, 0xFB, 0xFF, 0xFF, 0xE0, 0xF9, 0xFF, 0xFF, 0xC0, 0xF0, 0x7F,
  0xFF, 0x80, 0xF0, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE1, 0xFF, 0x00, 0x30, 0xFF, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x04, 0x7F, 0x80, 0x06, 0x0F, 0xFE, 0x3F, 0x81, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x03,
  0x00, 0x3F, 0x00, 0x7F, 0xF0, 0x3F, 0x01, 0xFF, 0xFC, 0x3F, 0x07, 0xFF,
  0xFF, 0x3F, 0x0F, 0xFF, 0xFF, 0xBF, 0x1F, 0xFC, 0x7F, 0xBF, 0x1F, 0xE0,
  0x07, 0xFF, 0x3F, 0x80, 0x03, 0xFF, 0x3F, 0x80, 0x01, 0xFF, 0x7F, 0x00,
  0x00, 0xFF, 0x7E, 0x00, 0x00, 0xFF, 0x7E, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0x7E, 0x00,
  0x00, 0x7F, 0x7F, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x01, 0xFF, 0x3F, 0x80,
  0x01, 0xFF, 0x1F, 0xC0, 0x07, 0xFF, 0x1F, 0xF8, 0x3F, 0xBF, 0x0F, 0xFF,
  0xFF, 0xBF, 0x07, 0xFF, 0xFF, 0x3F, 0x03, 0xFF, 0xFC, 0x3F, 0x00, 0xFF,
  0xF0, 0x1F, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xC0, 0x3F, 0xE0, 0xFF, 0x81, 0xFE, 0x00, 0xFF, 0x07, 0xE0, 0x00, 0xFC,
  0x3F, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x1F, 0xDF,
  0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x87, 0xFC, 0x00, 0x1E, 0x0F, 0xFE, 0x0F, 0xF8, 0x1F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xF0, 0x08,
  0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x1F, 0x01, 0xFF, 0xFC, 0x1F, 0x07, 0xFF, 0xFF,
  0x3F, 0x0F, 0xFF, 0xFF, 0xBF, 0x0F, 0xFC, 0xFF, 0xBF, 0x1F, 0xE0, 0x07,
  0xFF, 0x3F, 0x80, 0x03, 0xFF, 0x3F, 0x80, 0x01, 0xFF, 0x7F, 0x00, 0x00,
  0xFF, 0x7E, 0x00, 0x00, 0xFF, 0x7E, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00,
  0x7F, 0x7F, 0x00, 0x00, 0xFF, 0x3F, 0x00, 0x00, 0xFF, 0x3F, 0x80, 0x01,
  0xFF, 0x1F, 0xC0, 0x07, 0xFF, 0x1F, 0xF8, 0x1F, 0xBF, 0x0F, 0xFF, 0xFF,
  0xBF, 0x07, 0xFF, 0xFF, 0x3F, 0x01, 0xFF, 0xFC, 0x3F, 0x00, 0xFF, 0xF8,
  0x3F, 0x00, 0x07, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x20, 0x00, 0x01,
  0xFC, 0x38, 0x00, 0x03, 0xFC, 0x3F, 0x80, 0x0F, 0xF8, 0x3F, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x0C,
  0x00, 0x3F, 0x07, 0xFF, 0x80, 0xFC, 0x7F, 0xFF, 0x83, 0xF3, 0xFF, 0xFF,
  0x8F, 0x9F, 0xFF, 0xFE, 0x3E, 0xFF, 0x8F, 0xFC, 0xFF, 0xE0, 0x07, 0xFB,
  0xFE, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x0F, 0xC0, 0x7C, 0xFF, 0xFF, 0xFF, 0xEF, 0xCF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF,
  0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB,
  0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E,
  0x00, 0x3E, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE,
  0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0x7F, 0xC0, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0xFC, 0x00, 0x0F, 0xE7,
  0xE0, 0x00, 0xFE, 0x3F, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0xFE, 0x0F, 0xC0,
  0x0F, 0xE0, 0x7E, 0x00, 0xFE, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0xFE,
  0x00, 0xFC, 0x0F, 0xE0, 0x07, 0xE0, 0xFE, 0x00, 0x3F, 0x0F, 0xE0, 0x01,
  0xF8, 0x7E, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x7C, 0x7F, 0x00, 0x03, 0xE7,
  0xF0, 0x00, 0x1F, 0x7F, 0x80, 0x00, 0xFB, 0xFE, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x3F, 0xEF, 0xE0, 0x01, 0xFE, 0x3F, 0x00, 0x0F, 0xE1, 0xFC, 0x00,
  0x7E, 0x07, 0xF0, 0x03, 0xF0, 0x1F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xFC,
  0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xE0, 0x3F, 0x00, 0x3F, 0x81, 0xF8, 0x01,
  0xFE, 0x0F, 0xC0, 0x07, 0xF0, 0x7E, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x7F,
  0x1F, 0x80, 0x03, 0xFC, 0xFC, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x3F, 0xBF,
  0x00, 0x00, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x1F, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x03, 0xE1, 0xFF, 0xFC, 0x07, 0xFF,
  0xF8, 0x7C, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x8F, 0x9F, 0xFF, 0xFC, 0x7F,
  0xFF, 0xF9, 0xF7, 0xF9, 0xFF, 0xDF, 0xE1, 0xFF, 0xBF, 0xF0, 0x03, 0xFF,
  0xE0, 0x0F, 0xF7, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7E, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x7E, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F,
  0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xC0, 0x03, 0xE0, 0x7F, 0xF8, 0x0F, 0x87, 0xFF,
  0xF8, 0x3E, 0x3F, 0xFF, 0xF8, 0xF9, 0xFF, 0xFF, 0xF3, 0xEF, 0xF0, 0xFF,
  0xCF, 0xFC, 0x00, 0x7F, 0xBF, 0xE0, 0x00, 0xFE, 0xFF, 0x00, 0x01, 0xFB,
  0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xF3, 0xFF, 0xC0, 0x7F, 0x80,
  0x1F, 0xE0, 0x7F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0xFE, 0x3F, 0x80,
  0x00, 0x3F, 0x1F, 0x80, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x07, 0xEF, 0xE0,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x0F,
  0xCF, 0xC0, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x07,
  0xF0, 0x7F, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x07, 0xF0, 0x0F, 0xFC, 0x1F,
  0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0xF8, 0x1F, 0xFE, 0x00, 0xF8, 0x7F, 0xFF, 0x00, 0xF8, 0xFF,
  0xFF, 0xC0, 0xF9, 0xFF, 0xFF, 0xE0, 0xFB, 0xFE, 0x7F, 0xF0, 0xFF, 0xC0,
  0x0F, 0xF8, 0xFF, 0x80, 0x03, 0xF8, 0xFF, 0x00, 0x01, 0xFC, 0xFE, 0x00,
  0x01, 0xFC, 0xFE, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0xFE, 0xFC, 0x00,
  0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00,
  0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00,
  0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00,
  0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00,
  0x00, 0xFC, 0xFE, 0x00, 0x01, 0xFC, 0xFF, 0x00, 0x01, 0xFC, 0xFF, 0x80,
  0x03, 0xF8, 0xFF, 0xC0, 0x07, 0xF0, 0xFB, 0xF8, 0x3F, 0xF0, 0xFB, 0xFF,
  0xFF, 0xE0, 0xF9, 0xFF, 0xFF, 0xC0, 0xF8, 0x7F, 0xFF, 0x80, 0xFC, 0x1F,
  0xFE, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x1F, 0x01, 0xFF, 0xFC, 0x1F, 0x07, 0xFF, 0xFE, 0x3F, 0x0F, 0xFF,
  0xFF, 0x3F, 0x0F, 0xF8, 0x7F, 0xBF, 0x1F, 0xE0, 0x07, 0xFF, 0x3F, 0x80,
  0x03, 0xFF, 0x3F, 0x80, 0x01, 0xFF, 0x7F, 0x00, 0x00, 0xFF, 0x7E, 0x00,
  0x00, 0xFF, 0x7E, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x7F, 0x7F, 0x00,
  0x00, 0xFF, 0x7F, 0x00, 0x01, 0xFF, 0x3F, 0x80, 0x01, 0xFF, 0x1F, 0xE0,
  0x07, 0xFF, 0x1F, 0xF8, 0x3F, 0xBF, 0x0F, 0xFF, 0xFF, 0x3F, 0x07, 0xFF,
  0xFF, 0x3F, 0x01, 0xFF, 0xFC, 0x3F, 0x00, 0xFF, 0xF0, 0x3F, 0x00, 0x0F,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0xC7, 0xC0, 0x7F, 0xFE, 0x0F, 0xFD, 0xF0, 0xFF,
  0xEF, 0x8F, 0xFF, 0x7C, 0xFF, 0xFB, 0xEF, 0xC0, 0x1F, 0x7C, 0x00, 0xFF,
  0x80, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x8F, 0xF8, 0x3F, 0xC7,
  0xF0, 0x00, 0xF1, 0xF8, 0x00, 0x04, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFE,
  0xFF, 0x00, 0xFF, 0xBF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xFF, 0xF9, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF8, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x83, 0x01, 0xFF,
  0xFC, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x03, 0xC0,
  0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x0F,
  0xF7, 0xE0, 0x00, 0x3F, 0xEF, 0xE0, 0x00, 0x7F, 0xDF, 0xE0, 0x03, 0xFF,
  0x9F, 0xF8, 0x3F, 0xFF, 0x1F, 0xFF, 0xFF, 0x7E, 0x1F, 0xFF, 0xFC, 0xFC,
  0x1F, 0xFF, 0xF0, 0xF8, 0x0F, 0xFF, 0x81, 0xF0, 0x01, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x01,
  0xF9, 0xFC, 0x00, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00,
  0x0F, 0xC3, 0xF8, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x1F, 0x80,
  0x00, 0x7E, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x3F,
  0x00, 0x03, 0xF0, 0x07, 0xE0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x03, 0xF0, 0x03, 0xF0,
  0x00, 0x7E, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x07, 0xE0, 0x1F,
  0x80, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0xFC, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x0F,
  0x87, 0xC0, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00,
  0x1F, 0x3E, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0x3F, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0x0F,
  0xC0, 0x03, 0xFF, 0x80, 0x07, 0xE1, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0xFC,
  0x3F, 0x00, 0x1F, 0xBE, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xE7, 0xC0, 0x07,
  0xE0, 0x7E, 0x00, 0x7C, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0x8F, 0x80,
  0x1F, 0x81, 0xF8, 0x03, 0xF1, 0xF0, 0x03, 0xE0, 0x3F, 0x00, 0x7C, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0x80, 0x7E, 0x03, 0xF0,
  0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x7C, 0x0F, 0xC0, 0x7C, 0x00, 0xF8, 0x0F,
  0x81, 0xF8, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x1F, 0x03, 0xF0, 0x03, 0xF0,
  0x7E, 0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x0F, 0x80, 0x7E, 0x1F, 0x80, 0x07,
  0xC3, 0xF0, 0x07, 0xC3, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0xF8, 0x7E, 0x00,
  0x1F, 0x8F, 0x80, 0x1F, 0x8F, 0x80, 0x03, 0xF1, 0xF0, 0x01, 0xF1, 0xF0,
  0x00, 0x3E, 0x7E, 0x00, 0x3E, 0x7E, 0x00, 0x07, 0xEF, 0x80, 0x07, 0xEF,
  0xC0, 0x00, 0xFD, 0xF0, 0x00, 0xFD, 0xF0, 0x00, 0x0F, 0xBE, 0x00, 0x0F,
  0xBE, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x3F, 0x83,
  0xF8, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x1F, 0xC0,
  0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xF0, 0x0F, 0xC0, 0x01, 0xF8, 0x0F, 0xE0,
  0x00, 0xFE, 0x07, 0xE0, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x0F, 0xC7, 0xF0,
  0x00, 0x03, 0xF7, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x00, 0xFC,
  0x7E, 0x00, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x7E,
  0x03, 0xF0, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x3F,
  0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x07, 0xE0, 0x3F, 0x80, 0x03, 0xF8, 0x1F,
  0x80, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x1F, 0xDF,
  0xC0, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x07,
  0xF7, 0xE0, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00,
  0x3F, 0x8F, 0xC0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xF0, 0x7E, 0x00,
  0x01, 0xF8, 0x1F, 0xC0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0xFC,
  0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x03, 0xF0, 0x07, 0xE0, 0x01, 0xF8, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0,
  0x01, 0xF8, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x7E,
  0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x3F,
  0x1F, 0x80, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x00,
  0x7C, 0xFC, 0x00, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0x03, 0xEF, 0x80, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x78, 0x00, 0x1F, 0xC0,
  0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x3F, 0xE0, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0xC0, 0x07, 0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x7F, 0x00,
  0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x7F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x03,
  0xF8, 0x00, 0x0A, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x01, 0x1F, 0xFF,
  0x00, 0x03, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0xC0, 0x00,
  0x7F, 0xF8, 0x80, 0x00, 0x07, 0xC0,
};

const GFXglyph NotoSans_Regular67pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 8, 49, 18, 5, -48 },
  { 50, 19, 17, 27, 4, -48 },
  { 91, 40, 48, 43, 2, -48 },
  { 331, 31, 55, 38, 4, -51 },
  { 545, 49, 50, 56, 3, -49 },
  { 852, 45, 50, 49, 4, -49 },
  { 1134, 7, 17, 15, 4, -48 },
  { 1149, 15, 59, 20, 3, -48 },
  { 1260, 15, 59, 20, 2, -48 },
  { 1371, 31, 30, 37, 3, -51 },
  { 1488, 32, 33, 38, 3, -40 },
  { 1620, 10, 17, 18, 3, -8 },
  { 1642, 16, 6, 22, 3, -21 },
  { 1654, 8, 9, 18, 5, -8 },
  { 1663, 23, 48, 25, 1, -48 },
  { 1801, 32, 50, 38, 3, -49 },
  { 2001, 18, 48, 38, 6, -48 },
  { 2109, 32, 49, 38, 3, -49 },
  { 2305, 32, 50, 38, 3, -49 },
  { 2505, 36, 48, 38, 1, -48 },
  { 2721, 31, 49, 38, 4, -48 },
  { 2911, 31, 50, 38, 4, -49 },
  { 3105, 32, 48, 38, 3, -48 },
  { 3297, 32, 50, 38, 3, -49 },
  { 3497, 32, 50, 38, 3, -49 },
  { 3697, 8, 38, 18, 5, -37 },
  { 3735, 11, 46, 18, 2, -37 },
  { 3799, 32, 33, 38, 3, -41 },
  { 3931, 30, 18, 38, 4, -33 },
  { 3999, 32, 33, 38, 3, -41 },
  { 4131, 26, 50, 29, 1, -49 },
  { 4294, 52, 54, 60, 4, -48 },
  { 4645, 43, 48, 43, 0, -48 },
  { 4903, 34, 48, 44, 6, -48 },
  { 5107, 36, 50, 42, 4, -49 },
  { 5332, 39, 48, 49, 6, -48 },
  { 5566, 27, 48, 37, 6, -48 },
  { 5728, 27, 48, 35, 6, -48 },
  { 5890, 40, 50, 49, 4, -49 },
  { 6140, 37, 48, 50, 6, -48 },
  { 6362, 17, 48, 23, 3, -48 },
  { 6464, 17, 61, 18, -5, -48 },
  { 6594, 35, 48, 41, 6, -48 },
  { 6804, 27, 48, 35, 6, -48 },
  { 6966, 48, 48, 61, 6, -48 },
  { 7254, 38, 48, 51, 6, -48 },
  { 7482, 44, 50, 52, 4, -49 },
  { 7757, 31, 48, 41, 6, -48 },
  { 7943, 44, 60, 52, 4, -49 },
  { 8273, 35, 48, 42, 6, -48 },
  { 8483, 31, 50, 37, 3, -49 },
  { 8677, 36, 48, 37, 1, -48 },
  { 8893, 37, 49, 49, 6, -48 },
  { 9120, 40, 48, 40, 0, -48 },
  { 9360, 60, 48, 62, 1, -48 },
  { 9720, 39, 48, 39, 0, -48 },
  { 9954, 38, 48, 38, 0, -48 },
  { 10182, 33, 48, 38, 3, -48 },
  { 10380, 15, 59, 22, 5, -48 },
  { 10491, 23, 48, 25, 1, -48 },
  { 10629, 15, 59, 22, 2, -48 },
  { 10740, 33, 30, 38, 3, -48 },
  { 10864, 30, 4, 30, 0, 6 },
  { 10879, 13, 10, 19, 3, -51 },
  { 10896, 29, 38, 38, 3, -37 },
  { 11034, 32, 52, 41, 6, -51 },
  { 11242, 26, 38, 32, 4, -37 },
  { 11366, 32, 52, 41, 4, -51 },
  { 11574, 30, 38, 38, 4, -37 },
  { 11717, 25, 51, 23, 1, -51 },
  { 11877, 32, 53, 41, 4, -37 },
  { 12089, 30, 51, 41, 6, -51 },
  { 12281, 7, 49, 17, 5, -49 },
  { 12324, 16, 65, 17, -4, -49 },
  { 12454, 29, 51, 36, 6, -51 },
  { 12639, 6, 51, 17, 6, -51 },
  { 12678, 51, 37, 63, 6, -37 },
  { 12914, 30, 37, 41, 6, -37 },
  { 13053, 33, 38, 41, 4, -37 },
  { 13210, 32, 53, 41, 6, -37 },
  { 13422, 32, 53, 41, 4, -37 },
  { 13634, 21, 37, 28, 6, -37 },
  { 13732, 26, 38, 32, 3, -37 },
  { 13856, 22, 45, 24, 1, -44 },
  { 13980, 31, 37, 41, 5, -36 },
  { 14124, 34, 36, 34, 0, -36 },
  { 14277, 51, 36, 53, 1, -36 },
  { 14507, 33, 36, 35, 1, -36 },
  { 14656, 34, 52, 34, 0, -36 },
  { 14877, 26, 36, 31, 3, -36 },
  { 14994, 21, 59, 25, 2, -48 },
  { 15149, 5, 67, 37, 16, -51 },
  { 15191, 22, 59, 25, 2, -48 },
  { 15354, 32, 9, 38, 3, -28 },
};

const GFXfont NotoSans_Regular67pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Regular67pt7bBitmaps,
  (GFXglyph *)NotoSans_Regular67pt7bGlyphs,
  0x20, 0x7E, 91
};

#endif // _NOTOSANS_REGULAR67PT7B_H_
