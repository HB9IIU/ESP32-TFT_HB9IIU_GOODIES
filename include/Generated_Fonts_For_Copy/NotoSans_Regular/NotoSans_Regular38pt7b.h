#ifndef _NOTOSANS_REGULAR38PT7B_H_
#define _NOTOSANS_REGULAR38PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Regular.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Regular38pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0x77, 0x76, 0x66, 0x66, 0x60, 0x00,
  0x2F, 0xFF, 0xF2, 0xF1, 0xEE, 0x1D, 0xC3, 0xB8, 0x77, 0x0E, 0xE1, 0xDC,
  0x3B, 0x06, 0x60, 0xCC, 0x18, 0x00, 0xE0, 0xE0, 0x01, 0xC1, 0xC0, 0x03,
  0x83, 0x80, 0x06, 0x07, 0x00, 0x0C, 0x0C, 0x00, 0x38, 0x18, 0x00, 0x70,
  0x70, 0x00, 0xE0, 0xE0, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0x0E, 0x06,
  0x00, 0x1C, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x70, 0x70, 0x00, 0xC0, 0xC0,
  0x03, 0x81, 0x80, 0x07, 0x07, 0x01, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE0,
  0x30, 0x30, 0x00, 0xE0, 0x60, 0x01, 0xC1, 0xC0, 0x03, 0x83, 0x80, 0x07,
  0x07, 0x00, 0x0C, 0x0E, 0x00, 0x18, 0x18, 0x00, 0x70, 0x70, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x0F, 0xFF, 0x0F, 0xFF,
  0xE7, 0xED, 0xF1, 0xC3, 0x04, 0xF0, 0xC0, 0x3C, 0x30, 0x0F, 0x0C, 0x01,
  0xC3, 0x00, 0x7C, 0xC0, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0x37, 0xE0, 0x0C, 0x78, 0x03, 0x0F, 0x00, 0xC3, 0xC0, 0x30,
  0xF0, 0x0C, 0x3B, 0x83, 0x3E, 0xFF, 0xFF, 0x3F, 0xFF, 0x83, 0xFF, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x00,
  0x03, 0xF8, 0x01, 0xE0, 0x7F, 0xC0, 0x1C, 0x07, 0x1C, 0x03, 0x80, 0xE0,
  0xC0, 0x38, 0x0E, 0x0E, 0x07, 0x00, 0xE0, 0xE0, 0x70, 0x0E, 0x0E, 0x0E,
  0x00, 0xE0, 0xE0, 0xE0, 0x0E, 0x0E, 0x1C, 0x00, 0xE0, 0xE3, 0x80, 0x0E,
  0x0E, 0x38, 0x60, 0xE0, 0xE7, 0x1F, 0x8E, 0x0C, 0x73, 0xFC, 0x71, 0xCE,
  0x70, 0xE7, 0xFC, 0xE7, 0x0E, 0x3F, 0x9C, 0x70, 0x60, 0x41, 0xC6, 0x07,
  0x00, 0x38, 0xE0, 0x70, 0x03, 0x0E, 0x07, 0x00, 0x70, 0xE0, 0x70, 0x0E,
  0x06, 0x07, 0x00, 0xE0, 0x60, 0x70, 0x1C, 0x07, 0x06, 0x01, 0xC0, 0x70,
  0xE0, 0x38, 0x03, 0x9E, 0x03, 0x80, 0x3F, 0xC0, 0x70, 0x01, 0xF8, 0x00,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7C, 0x7C, 0x00,
  0x1C, 0x0F, 0x00, 0x07, 0x01, 0xC0, 0x01, 0xC0, 0x70, 0x00, 0x70, 0x1C,
  0x00, 0x1C, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x00, 0xF3, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x70,
  0xFB, 0xE0, 0x3C, 0x7C, 0x7C, 0x0E, 0x1E, 0x0F, 0x83, 0x8F, 0x01, 0xF1,
  0xE3, 0xC0, 0x3E, 0x70, 0xF0, 0x03, 0xFC, 0x3C, 0x00, 0x7E, 0x0F, 0x00,
  0x0F, 0x03, 0xC0, 0x07, 0xE0, 0x78, 0x07, 0xFC, 0x1F, 0xFF, 0xE7, 0x83,
  0xFF, 0xF0, 0xF0, 0x3F, 0xF0, 0x1F, 0xF7, 0x77, 0x77, 0x76, 0x66, 0x07,
  0x0E, 0x1E, 0x1C, 0x38, 0x38, 0x78, 0x70, 0x70, 0xF0, 0xF0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xF0, 0xF0, 0x70,
  0x70, 0x78, 0x38, 0x3C, 0x1C, 0x1E, 0x0E, 0x07, 0xF0, 0x3C, 0x0E, 0x07,
  0x81, 0xC0, 0xF0, 0x38, 0x1C, 0x0F, 0x03, 0x81, 0xC0, 0xE0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x38, 0x1C, 0x0E, 0x0F,
  0x07, 0x83, 0x83, 0xC1, 0xC1, 0xE0, 0xE0, 0xF0, 0xF0, 0x00, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x04, 0x0E, 0x07, 0xC7,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xE0, 0x00, 0xF8, 0x00, 0xEE, 0x00,
  0xF7, 0x80, 0xF1, 0xC0, 0x78, 0xF0, 0x78, 0x3C, 0x0C, 0x18, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x7B, 0xDE, 0xE7, 0x73, 0x9C, 0xC0,
  0xFF, 0xFF, 0xFF, 0xE0, 0x2F, 0xFF, 0xF2, 0x00, 0x3C, 0x00, 0xE0, 0x07,
  0x80, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07,
  0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x0F,
  0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x0E,
  0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x00, 0x00, 0x80, 0x03, 0xFE, 0x01,
  0xFF, 0xC0, 0xFC, 0xF8, 0x3C, 0x0F, 0x1E, 0x01, 0xC7, 0x00, 0x79, 0xC0,
  0x0E, 0xF0, 0x03, 0xBC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0x9C, 0x00, 0xE7, 0x00, 0x79, 0xE0,
  0x1C, 0x3C, 0x0F, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xE0, 0x01, 0xC0,
  0xF0, 0xFC, 0x7F, 0x3D, 0xFE, 0x77, 0x1C, 0x87, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x00, 0x80, 0x03, 0xFE,
  0x03, 0xFF, 0xE3, 0xF9, 0xF8, 0x70, 0x0F, 0x08, 0x01, 0xC0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00,
  0x0E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x80, 0x07, 0xFE, 0x07, 0xFF, 0xE3, 0xF8, 0xFC, 0x60, 0x0F, 0x10, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0xFC, 0x03, 0xFC, 0x00, 0xFF, 0xC0, 0x03, 0xFC, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x1E, 0x80, 0x0F, 0x3F, 0xBF, 0xCF, 0xFF, 0xE1,
  0xFF, 0xE0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0,
  0x00, 0x77, 0x00, 0x07, 0x70, 0x00, 0xE7, 0x00, 0x1C, 0x70, 0x03, 0xC7,
  0x00, 0x38, 0x70, 0x07, 0x07, 0x00, 0xF0, 0x70, 0x0E, 0x07, 0x01, 0xC0,
  0x70, 0x38, 0x07, 0x03, 0x80, 0x70, 0x70, 0x07, 0x0E, 0x00, 0x70, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x3F, 0xFF,
  0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x3C, 0x01, 0xFF,
  0xF0, 0x7F, 0xFE, 0x0C, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03,
  0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x7B, 0x00, 0x3C, 0xFE, 0xFE, 0x3F, 0xFF, 0x03, 0xFF, 0x00, 0x00,
  0x08, 0x00, 0x7F, 0xC0, 0x7F, 0xF0, 0x3F, 0x04, 0x1F, 0x00, 0x0F, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03,
  0xC7, 0xE0, 0xF7, 0xFE, 0x3B, 0xFF, 0xCF, 0xC0, 0x7B, 0xE0, 0x0E, 0xF0,
  0x03, 0xFC, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x01, 0xDC, 0x00,
  0xF7, 0x00, 0x3D, 0xE0, 0x0E, 0x3C, 0x07, 0x87, 0xEF, 0xC0, 0xFF, 0xE0,
  0x1F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07,
  0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03,
  0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0x00, 0xC0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xF8, 0x7C,
  0x78, 0x07, 0x9C, 0x01, 0xE7, 0x00, 0x39, 0xC0, 0x0E, 0x70, 0x07, 0x9E,
  0x01, 0xC3, 0xC0, 0xF0, 0xF8, 0x78, 0x0F, 0xFC, 0x01, 0xFC, 0x00, 0xFF,
  0x80, 0x7D, 0xF8, 0x3C, 0x1F, 0x1E, 0x01, 0xEF, 0x00, 0x3B, 0x80, 0x0F,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0xC0, 0x0E, 0x78, 0x07, 0x9F,
  0x8F, 0xC3, 0xFF, 0xE0, 0x3F, 0xF0, 0x00, 0x80, 0x03, 0xFE, 0x01, 0xFF,
  0xC0, 0xF8, 0xF8, 0x78, 0x0F, 0x1C, 0x01, 0xCF, 0x00, 0x7B, 0x80, 0x0E,
  0xE0, 0x03, 0xB8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x03, 0xDC,
  0x01, 0xF7, 0x80, 0xFC, 0xFF, 0xFF, 0x1F, 0xF3, 0xC1, 0xF0, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3E, 0x08, 0x7F, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x6F, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x2F, 0xFF, 0xF2, 0x18, 0xF3, 0xCF, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF3, 0xCE, 0x79,
  0xE7, 0x1C, 0xE3, 0x80, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x3C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xC0, 0x00, 0x70, 0x00, 0x04, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x80, 0x00, 0x38, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00,
  0xFC, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x00,
  0xF8, 0x00, 0x30, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x3F, 0xF0, 0xFF,
  0xFC, 0x7E, 0xFE, 0x60, 0x1E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0F, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x07, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x07, 0x80, 0x02, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x1F, 0xE7, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x07, 0x80, 0x01, 0xE0,
  0x38, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x07, 0x0E, 0x00, 0xF8, 0x0E, 0x38,
  0x1F, 0xFC, 0x39, 0xC0, 0xFF, 0xF0, 0x67, 0x07, 0x81, 0xC1, 0xDC, 0x1C,
  0x07, 0x07, 0x60, 0xE0, 0x18, 0x1F, 0x83, 0x80, 0x60, 0x7E, 0x0E, 0x03,
  0x81, 0xF8, 0x38, 0x0E, 0x07, 0xE0, 0xE0, 0x38, 0x1F, 0x83, 0x80, 0xE0,
  0x6E, 0x0E, 0x03, 0x83, 0xB8, 0x3C, 0x1F, 0x0E, 0x60, 0x7F, 0xEF, 0xF1,
  0xC0, 0xFF, 0x3F, 0x87, 0x00, 0xF0, 0x38, 0x0E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x20, 0x01, 0xF8,
  0x0F, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0xF7, 0x00, 0x00, 0xE7, 0x00, 0x00, 0xE7, 0x80, 0x01, 0xC3,
  0x80, 0x01, 0xC3, 0x80, 0x03, 0xC1, 0xC0, 0x03, 0x81, 0xC0, 0x03, 0x81,
  0xE0, 0x07, 0x80, 0xE0, 0x07, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1C, 0x00, 0x38, 0x1C, 0x00,
  0x3C, 0x3C, 0x00, 0x1C, 0x38, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x70, 0x00,
  0x0E, 0x70, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3,
  0xFF, 0xFC, 0x70, 0x07, 0xCE, 0x00, 0x79, 0xC0, 0x07, 0xB8, 0x00, 0xF7,
  0x00, 0x1E, 0xE0, 0x03, 0x9C, 0x00, 0x73, 0x80, 0x1C, 0x7F, 0xFF, 0x0F,
  0xFF, 0x81, 0xFF, 0xFC, 0x38, 0x07, 0xE7, 0x00, 0x3E, 0xE0, 0x03, 0xDC,
  0x00, 0x3B, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xB8,
  0x00, 0xF7, 0x00, 0x7E, 0xFF, 0xFF, 0x9F, 0xFF, 0xC3, 0xFF, 0xE0, 0x00,
  0x00, 0x04, 0x00, 0x07, 0xFF, 0x00, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xF8,
  0x03, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x1F, 0x80, 0x10, 0x7F, 0xFF, 0x80, 0xFF, 0xFC, 0x03,
  0xFF, 0xC0, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xE1, 0xC0, 0x1F,
  0x8E, 0x00, 0x3E, 0x70, 0x00, 0xFB, 0x80, 0x03, 0xDC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xEE, 0x00, 0x0F, 0x70, 0x00, 0xF3,
  0x80, 0x0F, 0x9C, 0x03, 0xF8, 0xFF, 0xFF, 0x87, 0xFF, 0xF0, 0x3F, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0xFF, 0xEF,
  0xFF, 0xDF, 0xFF, 0xB8, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0F, 0xFF, 0xDF, 0xFF, 0xBF, 0xFF, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x00, 0x02, 0x00, 0x01, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0xF8, 0x00, 0x83, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFE, 0xE0, 0x00, 0x3D, 0xC0,
  0x00, 0x7B, 0xC0, 0x00, 0xF7, 0x80, 0x01, 0xE7, 0x80, 0x03, 0xCF, 0x00,
  0x07, 0x8F, 0x00, 0x0F, 0x0F, 0x80, 0x1E, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF8, 0x07, 0xFF, 0xC0, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x70,
  0xFF, 0xFF, 0xCF, 0x83, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x3E, 0x7F, 0xFF, 0xE0, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x7B, 0xFE, 0xFF,
  0x3F, 0x00, 0xE0, 0x01, 0xEE, 0x00, 0x3C, 0xE0, 0x07, 0x8E, 0x00, 0xF0,
  0xE0, 0x1E, 0x0E, 0x03, 0xC0, 0xE0, 0x78, 0x0E, 0x0F, 0x00, 0xE1, 0xE0,
  0x0E, 0x3C, 0x00, 0xE3, 0x80, 0x0E, 0x78, 0x00, 0xEF, 0x80, 0x0F, 0xFC,
  0x00, 0xFB, 0xC0, 0x0F, 0x1E, 0x00, 0xE0, 0xF0, 0x0E, 0x0F, 0x80, 0xE0,
  0x78, 0x0E, 0x03, 0xC0, 0xE0, 0x1E, 0x0E, 0x01, 0xF0, 0xE0, 0x0F, 0x0E,
  0x00, 0x78, 0xE0, 0x03, 0xCE, 0x00, 0x3C, 0xE0, 0x01, 0xF0, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE,
  0x00, 0x07, 0x7F, 0xC0, 0x00, 0xEF, 0xDC, 0x00, 0x1D, 0xFB, 0x80, 0x07,
  0x7F, 0x78, 0x00, 0xEF, 0xE7, 0x00, 0x3D, 0xFC, 0xE0, 0x07, 0x3F, 0x9E,
  0x00, 0xE7, 0xF1, 0xC0, 0x38, 0xFE, 0x38, 0x07, 0x1F, 0xC3, 0x80, 0xE3,
  0xF8, 0x70, 0x38, 0x7F, 0x0F, 0x07, 0x0F, 0xE0, 0xE1, 0xC1, 0xFC, 0x1C,
  0x38, 0x3F, 0x83, 0xC7, 0x07, 0xF0, 0x39, 0xC0, 0xFE, 0x07, 0xB8, 0x1F,
  0xC0, 0x7F, 0x03, 0xF8, 0x0F, 0xC0, 0x7F, 0x01, 0xF8, 0x0F, 0xE0, 0x1E,
  0x01, 0xFC, 0x03, 0xC0, 0x3F, 0x80, 0x78, 0x07, 0x80, 0xF0, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00,
  0x1F, 0xBC, 0x00, 0xFC, 0xF0, 0x07, 0xE7, 0x80, 0x3F, 0x1E, 0x01, 0xF8,
  0x78, 0x0F, 0xC3, 0xC0, 0x7E, 0x0F, 0x03, 0xF0, 0x78, 0x1F, 0x81, 0xE0,
  0xFC, 0x07, 0x87, 0xE0, 0x3C, 0x3F, 0x00, 0xF1, 0xF8, 0x03, 0xCF, 0xC0,
  0x1E, 0x7E, 0x00, 0x7B, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1E, 0x00, 0x08, 0x00, 0x00,
  0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xF0, 0x07, 0xC1,
  0xF0, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x1E, 0x78, 0x00, 0x07,
  0x3C, 0x00, 0x03, 0xDC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xB8, 0x00, 0x03, 0xDC, 0x00, 0x01, 0xEF, 0x00, 0x00, 0xF7, 0x80,
  0x00, 0x71, 0xC0, 0x00, 0x78, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x1F,
  0x80, 0x7C, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xF0, 0x7F, 0xFE, 0x3F, 0xFF, 0x9C, 0x03, 0xEE, 0x00, 0xF7, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x01, 0xEE, 0x01, 0xF7, 0x1F, 0xF3, 0xFF, 0xF1, 0xFF, 0xE0, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xF0,
  0x07, 0xC1, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x1E, 0x78,
  0x00, 0x07, 0x3C, 0x00, 0x03, 0xDC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xB8, 0x00, 0x03, 0xDC, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0xF7, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x78, 0xF0, 0x00, 0x3C, 0x3C, 0x00,
  0x3C, 0x1F, 0x80, 0x7C, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0xFF, 0xF0, 0x1F,
  0xFF, 0x83, 0xFF, 0xF8, 0x70, 0x0F, 0x8E, 0x00, 0xF9, 0xC0, 0x0F, 0x38,
  0x01, 0xE7, 0x00, 0x1C, 0xE0, 0x07, 0x9C, 0x00, 0xF3, 0x80, 0x1E, 0x70,
  0x07, 0x8E, 0x03, 0xE1, 0xFF, 0xF8, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xE0,
  0x78, 0x1C, 0x0F, 0x03, 0x80, 0xF0, 0x70, 0x0E, 0x0E, 0x01, 0xE1, 0xC0,
  0x1E, 0x38, 0x03, 0xC7, 0x00, 0x3C, 0xE0, 0x03, 0xDC, 0x00, 0x7B, 0x80,
  0x07, 0x80, 0x00, 0xC0, 0x07, 0xFF, 0x0F, 0xFF, 0xC7, 0xFF, 0xE7, 0x80,
  0x33, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x0F, 0x80, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x3F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x1E, 0x00, 0x0F, 0xC0, 0x0F, 0x7F, 0xFF, 0x3F, 0xFF, 0x0F,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0E, 0xE0, 0x00, 0x77, 0x00, 0x07, 0xBC, 0x00, 0x3C, 0xF0,
  0x03, 0xC7, 0xC0, 0x3E, 0x1F, 0xFF, 0xE0, 0x7F, 0xFE, 0x00, 0xFF, 0xC0,
  0xF0, 0x00, 0x1E, 0xE0, 0x00, 0x39, 0xE0, 0x00, 0xF3, 0xC0, 0x01, 0xE3,
  0x80, 0x03, 0x87, 0x80, 0x0F, 0x0F, 0x00, 0x1C, 0x0E, 0x00, 0x38, 0x1E,
  0x00, 0xF0, 0x3C, 0x01, 0xC0, 0x38, 0x07, 0x80, 0x78, 0x0F, 0x00, 0x70,
  0x1C, 0x00, 0xE0, 0x78, 0x01, 0xE0, 0xF0, 0x01, 0xC1, 0xC0, 0x03, 0x87,
  0x80, 0x07, 0x8F, 0x00, 0x07, 0x1C, 0x00, 0x0E, 0x78, 0x00, 0x1E, 0xE0,
  0x00, 0x1D, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xEE, 0x00,
  0x3E, 0x00, 0x39, 0xE0, 0x07, 0xC0, 0x07, 0x3C, 0x00, 0xF8, 0x01, 0xE3,
  0x80, 0x3B, 0x80, 0x3C, 0x70, 0x07, 0x70, 0x07, 0x0F, 0x00, 0xEE, 0x00,
  0xE1, 0xE0, 0x1D, 0xE0, 0x3C, 0x1C, 0x07, 0x1C, 0x07, 0x83, 0x80, 0xE3,
  0x80, 0xE0, 0x78, 0x1C, 0x78, 0x1C, 0x07, 0x07, 0x87, 0x07, 0x80, 0xE0,
  0xE0, 0xE0, 0xE0, 0x1C, 0x1C, 0x1C, 0x1C, 0x03, 0xC7, 0x83, 0xC3, 0x80,
  0x38, 0xE0, 0x38, 0xF0, 0x07, 0x1C, 0x07, 0x1C, 0x00, 0xF3, 0x80, 0xF3,
  0x80, 0x1E, 0xF0, 0x0E, 0x70, 0x01, 0xDC, 0x01, 0xDE, 0x00, 0x3B, 0x80,
  0x3B, 0x80, 0x07, 0x70, 0x03, 0xF0, 0x00, 0xEC, 0x00, 0x7E, 0x00, 0x0F,
  0x80, 0x0F, 0xC0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x1E, 0x00,
  0x03, 0x80, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x78, 0xF0, 0x01, 0xC3, 0xC0,
  0x0F, 0x07, 0x80, 0x38, 0x0E, 0x01, 0xC0, 0x3C, 0x0F, 0x00, 0x78, 0x38,
  0x00, 0xE1, 0xE0, 0x03, 0xCF, 0x00, 0x07, 0xB8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F,
  0x80, 0x01, 0xCE, 0x00, 0x0F, 0x3C, 0x00, 0x38, 0x78, 0x01, 0xC0, 0xE0,
  0x0F, 0x03, 0xC0, 0x38, 0x07, 0x81, 0xE0, 0x0E, 0x0F, 0x00, 0x3C, 0x38,
  0x00, 0x79, 0xE0, 0x01, 0xEF, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x7D, 0xE0,
  0x01, 0xE7, 0x80, 0x0F, 0x0F, 0x00, 0x3C, 0x1C, 0x01, 0xE0, 0x78, 0x07,
  0x00, 0xE0, 0x3C, 0x03, 0xC0, 0xE0, 0x07, 0x07, 0x80, 0x1E, 0x1C, 0x00,
  0x38, 0xF0, 0x00, 0xF3, 0x80, 0x01, 0xDE, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x7F,
  0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xF0, 0x01, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0,
  0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0xFF, 0xFF, 0xFF, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0xC0, 0x00, 0xD8,
  0x00, 0x3B, 0x80, 0x06, 0x30, 0x01, 0xC7, 0x00, 0x38, 0x60, 0x0E, 0x0E,
  0x01, 0xC0, 0xC0, 0x70, 0x1C, 0x0E, 0x01, 0xC3, 0x80, 0x38, 0x70, 0x03,
  0x8C, 0x00, 0x73, 0x80, 0x07, 0xF0, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0xF1, 0xE1, 0xE1, 0xE1, 0xC1, 0xC0, 0x01, 0xE0, 0x1F,
  0xFC, 0x3F, 0xFE, 0x1C, 0x1F, 0x10, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x07, 0xFF, 0x3F, 0xFF, 0x7E, 0x07, 0xF8, 0x07, 0xF0,
  0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x1F, 0xFC, 0xFF, 0x7F,
  0xF7, 0x3F, 0xC3, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0xF0, 0x3D,
  0xFF, 0x0E, 0xFF, 0xF3, 0xF8, 0x3C, 0xF8, 0x07, 0xBC, 0x00, 0xEF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x03, 0xBF,
  0x01, 0xEE, 0xF3, 0xF3, 0x9F, 0xF8, 0xE3, 0xFC, 0x00, 0x01, 0xF0, 0x1F,
  0xFC, 0x7F, 0xF9, 0xF0, 0x63, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x04, 0xFF, 0xF8, 0xFF, 0xF0, 0x7F,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x03, 0xC1, 0xC3, 0xFE, 0x71,
  0xFF, 0xDC, 0xF8, 0x3F, 0x78, 0x07, 0xDE, 0x00, 0xF7, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1D, 0xC0, 0x0F, 0x78, 0x03, 0xDF, 0x01, 0xF3,
  0xF3, 0xFC, 0x7F, 0xF7, 0x07, 0xF1, 0xC0, 0x01, 0xE0, 0x03, 0xFF, 0x01,
  0xFF, 0xE0, 0xF8, 0x7C, 0x38, 0x07, 0x1E, 0x01, 0xE7, 0x00, 0x3B, 0xC0,
  0x0E, 0xF0, 0x03, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x21,
  0xFF, 0xF8, 0x3F, 0xFE, 0x07, 0xFE, 0x00, 0x01, 0xFC, 0x1F, 0xE0, 0xFF,
  0x83, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x03, 0xFF,
  0xCF, 0xFF, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x03, 0xE0,
  0x03, 0xFE, 0x71, 0xFF, 0xDC, 0xF8, 0x7F, 0x78, 0x07, 0xDE, 0x00, 0xF7,
  0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1D, 0xC0, 0x0F, 0x78, 0x03,
  0xCF, 0x01, 0xF3, 0xF3, 0xFC, 0x7F, 0xF7, 0x07, 0xF1, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE3, 0x00, 0xF8, 0xFF,
  0xFC, 0x3F, 0xFE, 0x03, 0xFE, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x70, 0x79, 0xFF, 0x3B, 0xFF, 0xDF, 0xC1, 0xFF, 0x80, 0x7F, 0xC0, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x38, 0x6F, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x03,
  0xC1, 0xE0, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x03,
  0xBF, 0xDF, 0xCF, 0xC0, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x07, 0xBC, 0x07, 0x9E, 0x07, 0x8F, 0x07, 0x87, 0x87, 0x83, 0xC7, 0x81,
  0xE7, 0x80, 0xE7, 0x80, 0x77, 0x80, 0x3B, 0xE0, 0x1F, 0xF8, 0x0F, 0x9E,
  0x07, 0x8F, 0x03, 0xC3, 0xC1, 0xE0, 0xF0, 0xF0, 0x3C, 0x78, 0x1E, 0x3C,
  0x07, 0x9E, 0x01, 0xEF, 0x00, 0x78, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x07,
  0x07, 0x3F, 0xE1, 0xFF, 0x3B, 0xFF, 0x9F, 0xFD, 0xFC, 0x3F, 0xC1, 0xFF,
  0x80, 0xFC, 0x07, 0xF8, 0x03, 0xC0, 0x1F, 0xC0, 0x1E, 0x00, 0xFE, 0x00,
  0xF0, 0x07, 0xF0, 0x07, 0x80, 0x3F, 0x80, 0x3C, 0x01, 0xFC, 0x01, 0xE0,
  0x0F, 0xE0, 0x0F, 0x00, 0x7F, 0x00, 0x78, 0x03, 0xF8, 0x03, 0xC0, 0x1F,
  0xC0, 0x1E, 0x00, 0xFE, 0x00, 0xF0, 0x07, 0xF0, 0x07, 0x80, 0x3F, 0x80,
  0x3C, 0x01, 0xFC, 0x01, 0xE0, 0x0F, 0xE0, 0x0F, 0x00, 0x7F, 0x00, 0x78,
  0x03, 0x80, 0x00, 0xF8, 0x71, 0xFF, 0x3B, 0xFF, 0xDF, 0xC1, 0xFF, 0x80,
  0x7F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x38, 0x01,
  0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xFC, 0x1F, 0x07, 0xC3, 0xC0, 0x78, 0xF0,
  0x07, 0x9C, 0x00, 0x77, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xDC, 0x00, 0x73, 0x80,
  0x0E, 0x78, 0x03, 0xC7, 0x80, 0xF0, 0x7E, 0xFC, 0x07, 0xFF, 0x00, 0x7F,
  0xC0, 0x00, 0xF0, 0x39, 0xFF, 0x0E, 0xFF, 0xF3, 0xF8, 0x7C, 0xF8, 0x07,
  0xBE, 0x00, 0xEF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xC0,
  0x0F, 0xF8, 0x07, 0xBF, 0x01, 0xEE, 0xF3, 0xF3, 0x9F, 0xF8, 0xF3, 0xFC,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x03,
  0xFE, 0x71, 0xFF, 0xDC, 0xF8, 0x3F, 0x78, 0x07, 0xDE, 0x00, 0xF7, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3D, 0xC0, 0x0F, 0x78, 0x03, 0xCF,
  0x01, 0xF3, 0xF3, 0xFC, 0x7F, 0xF7, 0x07, 0xF1, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0xFE, 0x3F, 0xE7, 0xFE, 0xF1, 0xFC,
  0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x00, 0x07, 0xC0, 0xFF, 0xF7, 0xFF, 0xFE, 0x06, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x3C, 0x00, 0x7C, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0xFC,
  0x00, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x7F, 0x0F, 0xFF, 0xFE,
  0x7F, 0xE0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x3C, 0x0F, 0xFF, 0xFF,
  0xF3, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x1F,
  0x10, 0xFF, 0x07, 0xF0, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x1F,
  0xE0, 0x0F, 0x78, 0x0F, 0xBF, 0x3F, 0xCF, 0xFE, 0xE3, 0xFC, 0x70, 0xF0,
  0x01, 0xEE, 0x00, 0x3D, 0xE0, 0x07, 0x3C, 0x01, 0xE3, 0x80, 0x38, 0x78,
  0x07, 0x07, 0x01, 0xE0, 0xE0, 0x38, 0x1E, 0x07, 0x01, 0xC1, 0xE0, 0x38,
  0x38, 0x03, 0x8F, 0x00, 0x71, 0xC0, 0x0F, 0x38, 0x00, 0xEF, 0x00, 0x1D,
  0xC0, 0x03, 0xB8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0xF0,
  0x07, 0x80, 0x3B, 0x80, 0x3C, 0x01, 0xDE, 0x03, 0xF0, 0x1E, 0xF0, 0x1F,
  0x80, 0xE3, 0x80, 0xFC, 0x07, 0x1C, 0x0E, 0x70, 0x78, 0xF0, 0x73, 0x83,
  0xC3, 0x83, 0x9C, 0x1C, 0x1C, 0x38, 0xF0, 0xE0, 0xE1, 0xC3, 0x8F, 0x07,
  0x8E, 0x1C, 0x70, 0x1C, 0xF0, 0xE3, 0x80, 0xE7, 0x03, 0x9C, 0x07, 0x38,
  0x1D, 0xE0, 0x3D, 0xC0, 0xEE, 0x00, 0xFC, 0x03, 0x70, 0x07, 0xE0, 0x1F,
  0x80, 0x3F, 0x00, 0xF8, 0x00, 0xF0, 0x07, 0xC0, 0x07, 0x80, 0x1E, 0x00,
  0xF0, 0x03, 0xDE, 0x01, 0xE3, 0xC0, 0xF0, 0x70, 0x38, 0x1E, 0x1E, 0x03,
  0xCF, 0x00, 0x7B, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0x78, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x07, 0xF8, 0x03, 0xCF, 0x00, 0xE1, 0xE0, 0x78, 0x38,
  0x3C, 0x0F, 0x1E, 0x01, 0xE7, 0x00, 0x3B, 0xC0, 0x0F, 0xF0, 0x01, 0xEE,
  0x00, 0x3D, 0xE0, 0x07, 0x1C, 0x01, 0xE3, 0x80, 0x3C, 0x78, 0x07, 0x07,
  0x01, 0xE0, 0xF0, 0x38, 0x0E, 0x07, 0x01, 0xC1, 0xE0, 0x3C, 0x38, 0x03,
  0x8F, 0x00, 0x71, 0xE0, 0x07, 0x38, 0x00, 0xE7, 0x00, 0x1D, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x03, 0xFE,
  0x00, 0x7F, 0x80, 0x0F, 0xC0, 0x00, 0x7F, 0xFE, 0xFF, 0xFC, 0x00, 0x78,
  0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x07,
  0x80, 0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00,
  0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x1F, 0x03,
  0xF0, 0x78, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0xF0, 0x1E, 0x0F, 0xC0, 0xF0, 0x0F, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x78, 0x03, 0xF0, 0x1F, 0x00, 0x70, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xF0, 0x0F, 0xC0, 0xFE, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x70, 0x07, 0xC0,
  0x3F, 0x00, 0x70, 0x3F, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xE0, 0xFE, 0x0F,
  0xC0, 0xF0, 0x00, 0x3E, 0x00, 0x5F, 0xF0, 0x3F, 0xFF, 0xFF, 0x07, 0xFE,
  0x80, 0x3F, 0x00,
};

const GFXglyph NotoSans_Regular38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 4, 28, 10, 3, -27 },
  { 15, 11, 10, 16, 2, -27 },
  { 29, 23, 27, 25, 1, -27 },
  { 107, 18, 31, 22, 2, -29 },
  { 177, 28, 28, 32, 2, -28 },
  { 275, 26, 28, 28, 2, -28 },
  { 366, 4, 10, 9, 2, -27 },
  { 371, 8, 33, 11, 2, -27 },
  { 404, 9, 33, 11, 1, -27 },
  { 442, 17, 17, 21, 2, -29 },
  { 479, 18, 19, 22, 2, -23 },
  { 522, 5, 9, 10, 2, -4 },
  { 528, 9, 3, 12, 2, -12 },
  { 532, 4, 6, 10, 3, -5 },
  { 535, 14, 27, 14, 0, -27 },
  { 583, 18, 28, 22, 2, -28 },
  { 646, 10, 27, 22, 3, -27 },
  { 680, 18, 28, 22, 2, -28 },
  { 743, 18, 28, 22, 2, -28 },
  { 806, 20, 27, 22, 1, -27 },
  { 874, 18, 27, 22, 2, -27 },
  { 935, 18, 28, 22, 2, -28 },
  { 998, 18, 27, 22, 2, -27 },
  { 1059, 18, 28, 22, 2, -28 },
  { 1122, 18, 28, 22, 2, -28 },
  { 1185, 4, 22, 10, 3, -21 },
  { 1196, 6, 26, 10, 1, -21 },
  { 1216, 18, 19, 22, 2, -23 },
  { 1259, 18, 11, 22, 2, -19 },
  { 1284, 18, 19, 22, 2, -23 },
  { 1327, 16, 29, 16, 0, -28 },
  { 1385, 30, 30, 34, 2, -27 },
  { 1498, 24, 27, 24, 0, -27 },
  { 1579, 19, 27, 25, 4, -27 },
  { 1644, 21, 28, 24, 2, -28 },
  { 1718, 21, 27, 28, 4, -27 },
  { 1789, 15, 27, 21, 4, -27 },
  { 1840, 15, 27, 20, 4, -27 },
  { 1891, 23, 28, 28, 2, -28 },
  { 1972, 20, 27, 28, 4, -27 },
  { 2040, 9, 27, 13, 2, -27 },
  { 2071, 10, 34, 10, -3, -27 },
  { 2114, 20, 27, 24, 4, -27 },
  { 2182, 15, 27, 20, 4, -27 },
  { 2233, 27, 27, 34, 4, -27 },
  { 2325, 21, 27, 29, 4, -27 },
  { 2396, 25, 28, 30, 2, -28 },
  { 2484, 17, 27, 23, 4, -27 },
  { 2542, 25, 34, 30, 2, -28 },
  { 2649, 19, 27, 24, 4, -27 },
  { 2714, 17, 28, 21, 2, -28 },
  { 2774, 21, 27, 21, 0, -27 },
  { 2845, 21, 27, 28, 3, -27 },
  { 2916, 23, 27, 23, 0, -27 },
  { 2994, 35, 27, 35, 0, -27 },
  { 3113, 22, 27, 22, 0, -27 },
  { 3188, 22, 27, 22, 0, -27 },
  { 3263, 19, 27, 22, 1, -27 },
  { 3328, 9, 33, 13, 3, -27 },
  { 3366, 14, 27, 14, 0, -27 },
  { 3414, 8, 33, 13, 1, -27 },
  { 3447, 19, 17, 22, 1, -27 },
  { 3488, 17, 3, 17, 0, 3 },
  { 3495, 7, 6, 11, 2, -29 },
  { 3501, 16, 21, 21, 2, -21 },
  { 3543, 18, 29, 23, 3, -29 },
  { 3609, 15, 21, 18, 2, -21 },
  { 3649, 18, 29, 23, 2, -29 },
  { 3715, 18, 21, 21, 2, -21 },
  { 3763, 14, 29, 13, 1, -29 },
  { 3814, 18, 30, 23, 2, -21 },
  { 3882, 17, 29, 23, 3, -29 },
  { 3944, 4, 28, 10, 3, -28 },
  { 3958, 9, 37, 10, -2, -28 },
  { 4000, 17, 29, 20, 3, -29 },
  { 4062, 4, 29, 10, 3, -29 },
  { 4077, 29, 21, 36, 3, -21 },
  { 4154, 17, 21, 23, 3, -21 },
  { 4199, 19, 21, 23, 2, -21 },
  { 4249, 18, 30, 23, 3, -21 },
  { 4317, 18, 30, 23, 2, -21 },
  { 4385, 12, 21, 16, 3, -21 },
  { 4417, 14, 21, 18, 2, -21 },
  { 4454, 12, 25, 14, 1, -25 },
  { 4492, 17, 20, 23, 3, -20 },
  { 4535, 19, 20, 19, 0, -20 },
  { 4583, 29, 20, 30, 0, -20 },
  { 4656, 18, 20, 20, 1, -20 },
  { 4701, 19, 29, 19, 0, -20 },
  { 4770, 15, 20, 18, 1, -20 },
  { 4808, 12, 33, 14, 1, -27 },
  { 4858, 3, 38, 21, 9, -29 },
  { 4873, 12, 33, 14, 1, -27 },
  { 4923, 18, 5, 22, 2, -16 },
};

const GFXfont NotoSans_Regular38pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Regular38pt7bBitmaps,
  (GFXglyph *)NotoSans_Regular38pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _NOTOSANS_REGULAR38PT7B_H_
