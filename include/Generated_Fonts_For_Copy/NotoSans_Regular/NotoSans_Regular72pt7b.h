#ifndef _NOTOSANS_REGULAR72PT7B_H_
#define _NOTOSANS_REGULAR72PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Regular.ttf
// Size: 72pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Regular72pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0xBF, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F,
  0x9F, 0xCF, 0xE7, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3,
  0xF1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3E, 0x1F, 0x07, 0x83, 0xC1, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x0F, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xDF, 0xC7, 0xC0,
  0xFE, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x07,
  0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x03, 0xEF, 0xC0,
  0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0x80, 0x3E, 0x78,
  0x03, 0xE7, 0x80, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x3C, 0x00, 0x00, 0xF8,
  0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x03,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF8, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xE0, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07,
  0xC0, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0x3E,
  0x3F, 0xC3, 0xFC, 0x1F, 0x01, 0xE1, 0xFC, 0x0F, 0x80, 0x10, 0xFC, 0x07,
  0xC0, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x7F, 0x01, 0xF0, 0x00, 0x3F, 0x80,
  0xF8, 0x00, 0x1F, 0xC0, 0x7C, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x03, 0xF8,
  0x1F, 0x00, 0x01, 0xFC, 0x0F, 0x80, 0x00, 0x7F, 0x87, 0xC0, 0x00, 0x3F,
  0xFB, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x01, 0xF3, 0xFF, 0x80, 0x00, 0xF8, 0x3F, 0xC0, 0x00, 0x7C, 0x0F,
  0xF0, 0x00, 0x3E, 0x03, 0xF8, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x0F, 0x80,
  0x7E, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x03, 0xE0, 0x1F, 0x80, 0x01, 0xF0,
  0x0F, 0xC0, 0x00, 0xF8, 0x0F, 0xF8, 0x00, 0x7C, 0x0F, 0xEF, 0x80, 0x3E,
  0x1F, 0xF7, 0xFC, 0x1F, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x20, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0xF8, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x7E, 0x00,
  0x01, 0xF0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x3F,
  0x00, 0x03, 0xE0, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80,
  0x1F, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0xF8, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x0F, 0x80, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0xF8, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0xFC, 0x00, 0x00, 0xF8, 0x01, 0xF8,
  0x1F, 0x80, 0x00, 0x0F, 0x80, 0x1F, 0x81, 0xF0, 0x00, 0x00, 0xF8, 0x01,
  0xF8, 0x3F, 0x00, 0x40, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x7F, 0xC0, 0xF8,
  0x01, 0xF0, 0x7E, 0x1F, 0xFF, 0x0F, 0xC0, 0x1F, 0x07, 0xC3, 0xFF, 0xF8,
  0x7C, 0x03, 0xF0, 0xFC, 0x3F, 0xFF, 0x87, 0xC0, 0x3E, 0x0F, 0x87, 0xE0,
  0xFC, 0x7E, 0x07, 0xE1, 0xF8, 0x7C, 0x07, 0xE3, 0xF9, 0xFC, 0x3F, 0x0F,
  0xC0, 0x7E, 0x1F, 0xFF, 0xC3, 0xE0, 0xF8, 0x03, 0xE1, 0xFF, 0xF8, 0x7E,
  0x0F, 0x80, 0x3F, 0x07, 0xFF, 0x07, 0xC1, 0xF8, 0x01, 0xF0, 0x3F, 0xC0,
  0xFC, 0x1F, 0x80, 0x1F, 0x00, 0x00, 0x0F, 0x81, 0xF0, 0x01, 0xF0, 0x00,
  0x01, 0xF8, 0x1F, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x01, 0xF0, 0x01, 0xF0,
  0x00, 0x03, 0xF0, 0x1F, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x01, 0xF0, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x01, 0xF0,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x01,
  0xF0, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0x03, 0xF0,
  0x01, 0xF8, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x3E, 0x00,
  0x0F, 0xC0, 0x00, 0x7C, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x1F, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xF0, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC7, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0x00, 0xFF, 0x8F, 0xF0, 0x00, 0x3F, 0x80, 0xFF, 0x83, 0xFC, 0x00, 0x1F,
  0x80, 0xFF, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x3F, 0xC0, 0x0F,
  0xE0, 0x7F, 0x00, 0x0F, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0x03, 0xFE, 0x03,
  0xF0, 0x3F, 0x80, 0x00, 0xFF, 0x83, 0xF8, 0x1F, 0xC0, 0x00, 0x3F, 0xE1,
  0xF8, 0x0F, 0xE0, 0x00, 0x0F, 0xF9, 0xFC, 0x07, 0xE0, 0x00, 0x03, 0xFF,
  0xFC, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x1F, 0xE0, 0x00, 0x01,
  0xFF, 0xE0, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x03, 0xFE, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xFE, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xFE, 0x3F, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xF8, 0x03, 0xFF, 0xFF,
  0xFC, 0x03, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xFF,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFB,
  0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xF9, 0xF3, 0xE7, 0xCF, 0x1E, 0x3C,
  0x78, 0xF0, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x80,
  0x3F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0,
  0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0,
  0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07,
  0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0,
  0x03, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F,
  0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x03, 0xF0, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x04, 0x00, 0x3E, 0x00, 0x09, 0xF0, 0x0F, 0x80, 0x3E, 0x7F, 0x83, 0xE0,
  0xFF, 0xBF, 0xFE, 0x79, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00,
  0x0F, 0xDF, 0x80, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x01, 0xF8, 0xFE, 0x00,
  0x00, 0xFE, 0x1F, 0x80, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0xFE,
  0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x07, 0xF8, 0x07, 0xF0, 0x01, 0xFC, 0x01,
  0xFE, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x20,
  0x02, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0xE3, 0xFC, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F,
  0x0F, 0xE1, 0xFC, 0x3F, 0x07, 0xE0, 0xF8, 0x3F, 0x07, 0xE0, 0xF8, 0x1F,
  0x07, 0xC0, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1C, 0x3F, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0x7F, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x7F, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0xFC, 0x0F,
  0xE0, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x01, 0xFC,
  0x7E, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x03,
  0xF3, 0xF8, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x7E, 0xFC, 0x00,
  0x00, 0x1F, 0xBF, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x7E, 0xFC, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x01, 0xFB, 0xF0, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x3F, 0x9F, 0x80,
  0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x00, 0xFC, 0x7F,
  0x00, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x07, 0xE0,
  0xFE, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0xFF,
  0x00, 0xFF, 0x80, 0x7F, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0xFF,
  0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x07, 0xFB,
  0xF0, 0xFF, 0x3F, 0x1F, 0xE3, 0xF3, 0xFC, 0x7F, 0xFF, 0x87, 0xF7, 0xF0,
  0x7F, 0x3C, 0x07, 0xF1, 0x80, 0x7F, 0x10, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0x07, 0xFF, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0xFC, 0x00, 0x07,
  0xF8, 0x1E, 0x00, 0x00, 0xFF, 0x02, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFE, 0x07, 0xFF, 0x07, 0xF8, 0x00,
  0x3F, 0xE0, 0xF8, 0x00, 0x03, 0xF8, 0x18, 0x00, 0x00, 0x7F, 0x04, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xFE, 0x80, 0x00, 0x00, 0x7F, 0x3C, 0x00, 0x00, 0x7F, 0xCF,
  0xE0, 0x00, 0x7F, 0xE3, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00,
  0x3F, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x0F, 0xE3, 0xF0,
  0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0xFC, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x02, 0x00, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1C, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x80, 0x00, 0x03, 0xFC, 0xE0, 0x00, 0x07,
  0xF8, 0xFC, 0x00, 0x1F, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x03, 0xFF, 0x00, 0x1F, 0x87,
  0xFF, 0xF0, 0x0F, 0xE3, 0xFF, 0xFF, 0x03, 0xF1, 0xFF, 0xFF, 0xE0, 0xFC,
  0xFF, 0xFF, 0xFC, 0x3F, 0x7E, 0x00, 0xFF, 0x8F, 0xFE, 0x00, 0x0F, 0xF3,
  0xFF, 0x00, 0x01, 0xFC, 0xFF, 0x80, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x0F,
  0xEF, 0xE0, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x07, 0xF7, 0xE0,
  0x00, 0x01, 0xFD, 0xF8, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x1F, 0x8F,
  0xC0, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x00, 0xFC,
  0x1F, 0xC0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0xFF, 0x80, 0x3F,
  0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFE, 0x03, 0xFF,
  0x01, 0xFE, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x00,
  0x7E, 0x1F, 0xC0, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x07, 0xF1, 0xF8, 0x00,
  0x00, 0xFC, 0x7E, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x0F, 0xC7, 0xF0,
  0x00, 0x07, 0xF0, 0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x7E, 0x0F,
  0xE0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x0F, 0xE0,
  0x0F, 0xF8, 0x0F, 0xF0, 0x01, 0xFF, 0x87, 0xF8, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFC,
  0x7F, 0xF0, 0x03, 0xFC, 0x03, 0xFE, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0xFE,
  0x00, 0x07, 0xF8, 0x7F, 0x00, 0x00, 0xFF, 0x1F, 0x80, 0x00, 0x1F, 0xCF,
  0xE0, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x1F,
  0xBF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x01, 0xFB, 0xF8, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x7F, 0x1F, 0xE0,
  0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0xF0, 0x7F, 0xF0, 0x1F,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x80,
  0x1F, 0xE0, 0x7F, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x00, 0xFC, 0x3F, 0x80,
  0x00, 0x7F, 0x1F, 0x80, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0x0F, 0xEF, 0xC0,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0x7F, 0x00, 0x00, 0xFF, 0xBF, 0xC0, 0x00, 0xFF, 0xCF, 0xF0, 0x00, 0xFF,
  0xE3, 0xFF, 0x03, 0xFB, 0xF1, 0xFF, 0xFF, 0xF9, 0xF8, 0x7F, 0xFF, 0xF8,
  0xFC, 0x0F, 0xFF, 0xF8, 0x7E, 0x01, 0xFF, 0xF0, 0x3F, 0x00, 0x0F, 0xC0,
  0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x3F,
  0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x08, 0x3F, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x7F, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFE, 0xFE, 0x3E, 0x00, 0x03,
  0x00, 0xFE, 0x0F, 0xE1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x0F,
  0xE0, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0xFE, 0x1F, 0xE1, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0x83, 0xF8, 0x3F,
  0x83, 0xF0, 0x3F, 0x03, 0xE0, 0x7E, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0x3F, 0xFE, 0x7E,
  0x00, 0x1F, 0xE3, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0x87, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x3F, 0x00, 0x03, 0xFF, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x7C, 0x1F, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x3E, 0x0F, 0x80, 0x0F,
  0xFF, 0xFF, 0xC0, 0x1F, 0x8F, 0xC0, 0x0F, 0xF8, 0x0F, 0xE0, 0x07, 0xC7,
  0xC0, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xE0, 0x01, 0xF8,
  0x01, 0xF3, 0xF0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0xF9, 0xF0, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x7C, 0xF8, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x3E, 0x7C,
  0x01, 0xF8, 0x00, 0x1F, 0x00, 0x1F, 0xFE, 0x00, 0xFC, 0x00, 0x0F, 0x80,
  0x0F, 0xFF, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x07, 0xFF, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x03, 0xEF, 0x80, 0x1F, 0x00, 0x01, 0xF0, 0x01, 0xF7, 0xC0,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0xFB, 0xE0, 0x07, 0xC0, 0x00, 0xFC, 0x00,
  0x7D, 0xF0, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x3E, 0xF8, 0x01, 0xF0, 0x00,
  0x3F, 0x00, 0x3F, 0x7C, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x1F, 0x3F, 0x00,
  0x7E, 0x00, 0x1F, 0xC0, 0x0F, 0x9F, 0x80, 0x3F, 0x00, 0x0F, 0xE0, 0x0F,
  0xC7, 0xC0, 0x0F, 0xC0, 0x0F, 0xF8, 0x07, 0xC3, 0xE0, 0x07, 0xF0, 0x0F,
  0xBC, 0x07, 0xC1, 0xF0, 0x01, 0xFE, 0x1F, 0x9F, 0xDF, 0xE0, 0xFC, 0x00,
  0x7F, 0xFF, 0x8F, 0xFF, 0xE0, 0x7E, 0x00, 0x3F, 0xFF, 0x83, 0xFF, 0xE0,
  0x1F, 0x00, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xC0, 0x00, 0xFF, 0x00,
  0x1F, 0xC0, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x3F, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00,
  0x01, 0xF3, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x00, 0x07,
  0xE1, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x00, 0x00, 0xFC,
  0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0xFE, 0x00, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0xE0, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0x00, 0x03,
  0xF9, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0xBF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xC0, 0x01, 0xFF, 0xF0, 0xFC, 0x00, 0x00,
  0xFF, 0x8F, 0xC0, 0x00, 0x07, 0xF8, 0xFC, 0x00, 0x00, 0x3F, 0xCF, 0xC0,
  0x00, 0x01, 0xFC, 0xFC, 0x00, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x01, 0xFC,
  0xFC, 0x00, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x00,
  0x1F, 0xCF, 0xC0, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x00, 0x1F, 0xCF, 0xC0,
  0x00, 0x03, 0xF8, 0xFC, 0x00, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0x07, 0xF0,
  0xFC, 0x00, 0x01, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xC0, 0x00, 0x3F, 0xF0,
  0xFC, 0x00, 0x00, 0x7F, 0x8F, 0xC0, 0x00, 0x03, 0xFC, 0xFC, 0x00, 0x00,
  0x1F, 0xEF, 0xC0, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0x0F, 0xEF, 0xC0,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xEF, 0xC0,
  0x00, 0x01, 0xFE, 0xFC, 0x00, 0x00, 0x1F, 0xEF, 0xC0, 0x00, 0x03, 0xFC,
  0xFC, 0x00, 0x00, 0xFF, 0xCF, 0xC0, 0x07, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x3F, 0x00, 0xFF, 0xC0, 0x00, 0x0C, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x01, 0x00, 0x7F, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xE0, 0x00, 0xFF, 0xFE, 0x03, 0xF0, 0x00,
  0x03, 0xFF, 0x81, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0xFC, 0x00, 0x00, 0x1F,
  0xF0, 0x7E, 0x00, 0x00, 0x03, 0xFC, 0x3F, 0x00, 0x00, 0x00, 0xFF, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0x00, 0x1F, 0xE7, 0xE0, 0x00,
  0x00, 0x07, 0xF3, 0xF0, 0x00, 0x00, 0x03, 0xFD, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0xBF,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0xBF, 0x00, 0x00,
  0x00, 0x1F, 0xDF, 0x80, 0x00, 0x00, 0x1F, 0xEF, 0xC0, 0x00, 0x00, 0x0F,
  0xE7, 0xE0, 0x00, 0x00, 0x0F, 0xF3, 0xF0, 0x00, 0x00, 0x07, 0xF1, 0xF8,
  0x00, 0x00, 0x07, 0xF8, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x7E, 0x00, 0x00,
  0x07, 0xFC, 0x3F, 0x00, 0x00, 0x0F, 0xFC, 0x1F, 0x80, 0x00, 0x1F, 0xFC,
  0x0F, 0xC0, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xF9, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFE, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xE0, 0x0F, 0xFC, 0x00, 0x00, 0x38, 0x03, 0xFF, 0x00, 0x00, 0x01, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0xDF, 0x80, 0x00, 0x1F, 0xFF, 0xFB, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x00,
  0x00, 0xFD, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xBF, 0xC0, 0x00, 0x00, 0x03,
  0xF3, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xCF,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xE1, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x3F, 0xE0, 0x00,
  0x00, 0x1F, 0x83, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x3F, 0xE0, 0x00, 0x00,
  0x7E, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x3F, 0xFE, 0x00, 0x0F, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x07, 0xFC, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x01, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xFA, 0x03, 0xFE, 0x7F, 0xFF, 0xCF, 0xFF,
  0xF1, 0xFF, 0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0x80, 0x1F, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xFB, 0xF0, 0x00, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0x01,
  0xFC, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x00, 0x7F, 0x03, 0xF0,
  0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0xE0, 0x3F, 0x00, 0x00, 0xFF,
  0x00, 0xFC, 0x00, 0x07, 0xF8, 0x03, 0xF0, 0x00, 0x3F, 0xC0, 0x0F, 0xC0,
  0x01, 0xFE, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80,
  0x03, 0xF0, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x0F, 0xE0, 0x00, 0x3F, 0x00,
  0x7F, 0x00, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x00,
  0x0F, 0xC0, 0xFF, 0x00, 0x00, 0x3F, 0x07, 0xF8, 0x00, 0x00, 0xFC, 0x3F,
  0xC0, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x00, 0x0F, 0xC7, 0xF8, 0x00, 0x00,
  0x3F, 0x3F, 0xF0, 0x00, 0x00, 0xFD, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFB, 0xFC, 0x00, 0x00,
  0xFF, 0x87, 0xF8, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x1F,
  0xE0, 0x00, 0x3F, 0x00, 0x7F, 0x80, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0x03,
  0xF0, 0x01, 0xFE, 0x00, 0x0F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xF0, 0x00, 0xFC, 0x00, 0x1F, 0xE0, 0x03, 0xF0, 0x00, 0x3F, 0xC0, 0x0F,
  0xC0, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x01, 0xFE, 0x00, 0xFC, 0x00, 0x03,
  0xFC, 0x03, 0xF0, 0x00, 0x07, 0xF8, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x3F,
  0x00, 0x00, 0x3F, 0xC0, 0xFC, 0x00, 0x00, 0x7F, 0x83, 0xF0, 0x00, 0x00,
  0xFF, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x00, 0x07, 0xF8, 0xFC,
  0x00, 0x00, 0x0F, 0xF3, 0xF0, 0x00, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFD, 0xF8,
  0x00, 0x00, 0x03, 0xF7, 0xFF, 0xBF, 0x00, 0x00, 0x00, 0x7E, 0xFF, 0xF7,
  0xF0, 0x00, 0x00, 0x0F, 0x9F, 0xFE, 0x7E, 0x00, 0x00, 0x03, 0xF3, 0xFF,
  0xCF, 0xC0, 0x00, 0x00, 0x7E, 0x7F, 0xF8, 0xFC, 0x00, 0x00, 0x1F, 0x8F,
  0xFF, 0x1F, 0x80, 0x00, 0x03, 0xF1, 0xFF, 0xE3, 0xF8, 0x00, 0x00, 0x7E,
  0x3F, 0xFC, 0x3F, 0x00, 0x00, 0x1F, 0x87, 0xFF, 0x87, 0xE0, 0x00, 0x03,
  0xF0, 0xFF, 0xF0, 0xFE, 0x00, 0x00, 0x7C, 0x1F, 0xFE, 0x0F, 0xC0, 0x00,
  0x1F, 0x83, 0xFF, 0xC1, 0xF8, 0x00, 0x03, 0xF0, 0x7F, 0xF8, 0x1F, 0x80,
  0x00, 0xFC, 0x0F, 0xFF, 0x03, 0xF0, 0x00, 0x1F, 0x81, 0xFF, 0xE0, 0x7F,
  0x00, 0x03, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x00, 0xFC, 0x07, 0xFF, 0x80,
  0xFC, 0x00, 0x1F, 0x80, 0xFF, 0xF0, 0x1F, 0xC0, 0x07, 0xE0, 0x1F, 0xFE,
  0x01, 0xF8, 0x00, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0x00, 0x1F, 0x80, 0x7F,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xFF, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xFF, 0xE0, 0x0F, 0xE0, 0x1F, 0x00, 0x3F, 0xFC, 0x00, 0xFC, 0x07, 0xE0,
  0x07, 0xFF, 0x80, 0x1F, 0x80, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xF8, 0x3F,
  0x00, 0x1F, 0xFE, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xE0,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xFF, 0x00, 0x0F,
  0xC7, 0xE0, 0x01, 0xFF, 0xE0, 0x01, 0xFC, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x1F, 0xBF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xF7, 0xE0, 0x00, 0xFF, 0xF0,
  0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFB, 0xF8, 0x00, 0x00, 0x1F, 0xFD, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0x7F, 0x00, 0x00, 0x07, 0xFF, 0x9F, 0xC0, 0x00, 0x03, 0xFF, 0xCF,
  0xF0, 0x00, 0x01, 0xFF, 0xE3, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0xFE, 0x00,
  0x00, 0x7F, 0xF8, 0x7F, 0x80, 0x00, 0x3F, 0xFC, 0x1F, 0xC0, 0x00, 0x1F,
  0xFE, 0x07, 0xF0, 0x00, 0x0F, 0xFF, 0x03, 0xFC, 0x00, 0x07, 0xFF, 0x80,
  0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x3F, 0x80, 0x01, 0xFF, 0xE0, 0x1F, 0xE0,
  0x00, 0xFF, 0xF0, 0x07, 0xF0, 0x00, 0x7F, 0xF8, 0x03, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0x00,
  0x1F, 0xE0, 0x07, 0xFF, 0x80, 0x07, 0xF0, 0x03, 0xFF, 0xC0, 0x01, 0xFC,
  0x01, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0x80, 0x7F,
  0xF8, 0x00, 0x0F, 0xE0, 0x3F, 0xFC, 0x00, 0x07, 0xF8, 0x1F, 0xFE, 0x00,
  0x01, 0xFC, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0x07, 0xFF, 0x80, 0x00, 0x3F,
  0xC3, 0xFF, 0xC0, 0x00, 0x0F, 0xE1, 0xFF, 0xE0, 0x00, 0x07, 0xF8, 0xFF,
  0xF0, 0x00, 0x01, 0xFE, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xDF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x00, 0x00, 0x03,
  0xF8, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x3F, 0x80, 0x00, 0x00, 0x01,
  0xFC, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0xFE, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x00, 0x01,
  0xFE, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x00, 0x01,
  0xFC, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0x00, 0x03,
  0xF8, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x07, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x87, 0xE0, 0x03,
  0xFF, 0xE3, 0xF0, 0x00, 0x1F, 0xF9, 0xF8, 0x00, 0x03, 0xFC, 0xFC, 0x00,
  0x00, 0xFF, 0x7E, 0x00, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0x1F, 0xDF, 0x80,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x0F, 0xEF,
  0xC0, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x07, 0xFB, 0xF0, 0x00, 0x07, 0xF9,
  0xF8, 0x00, 0x07, 0xFC, 0xFC, 0x00, 0x1F, 0xFC, 0x7F, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x00, 0x00,
  0x03, 0xF8, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x3F, 0x80, 0x00, 0x00,
  0x01, 0xFC, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0xFE, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x00,
  0x01, 0xFC, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x00,
  0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0x00,
  0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x07,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0xFF, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7E, 0x00, 0x1F, 0xFE, 0x03,
  0xF0, 0x00, 0x0F, 0xF8, 0x1F, 0x80, 0x00, 0x3F, 0xE0, 0xFC, 0x00, 0x00,
  0xFF, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x00, 0x0F, 0xE1, 0xF8,
  0x00, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x00, 0x1F,
  0xC3, 0xF0, 0x00, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0xFC, 0x00,
  0x00, 0x3F, 0x87, 0xE0, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x0F, 0xF0, 0x7E, 0x00, 0x00,
  0x7F, 0x03, 0xF0, 0x00, 0x0F, 0xF0, 0x1F, 0x80, 0x01, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x07,
  0xF8, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x7E,
  0x00, 0x03, 0xF8, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x00, 0x7F,
  0x80, 0xFC, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x3F, 0x00,
  0x00, 0x3F, 0xC1, 0xF8, 0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x07, 0xF8,
  0x7E, 0x00, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x00, 0xFF, 0x1F, 0x80, 0x00,
  0x03, 0xFC, 0xFC, 0x00, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x00, 0x7F, 0xBF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0xE0, 0x00, 0xFC, 0x7F, 0x80, 0x00, 0x18,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE,
  0x80, 0x00, 0x01, 0xFE, 0xF0, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x1F, 0xFC,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x7E, 0x00,
  0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x00,
  0x7F, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00,
  0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x00, 0x01, 0xFD, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0x00, 0xFE,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x7E, 0x00,
  0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x00, 0x01,
  0xFB, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xDF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xCF, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x07, 0xF3, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFE, 0x1F,
  0xC0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x0F, 0xDF,
  0x80, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x3F, 0x81,
  0xFC, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x03, 0xF1,
  0xF8, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x0F, 0xE0,
  0x1F, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0xFC,
  0x1F, 0x80, 0x03, 0xF8, 0x03, 0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xF8,
  0x01, 0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x0F,
  0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0xC0, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0xFC, 0x03,
  0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0xFC, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x0F, 0xC0,
  0xFE, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x1F, 0xC0,
  0xFC, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x01, 0xFC,
  0x1F, 0x80, 0x03, 0xF0, 0x7F, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x01, 0xF8,
  0x3F, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x1F,
  0x87, 0xE0, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x1F,
  0x8F, 0xC0, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x01,
  0xF9, 0xF8, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x01,
  0xF9, 0xF8, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x1F, 0x7E, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x87, 0xF0,
  0x00, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x3F,
  0x00, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x83, 0xF0, 0x00, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0x87, 0xE0, 0x00, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0x00,
  0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xBF, 0x80, 0x00, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x00, 0x3F,
  0x87, 0xF0, 0x00, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00,
  0x07, 0xE0, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x00, 0x03,
  0xF8, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00,
  0x00, 0x07, 0xF7, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x00,
  0xF8, 0x7C, 0x00, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0xF8, 0x00,
  0x00, 0xF8, 0x1F, 0x00, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x3F,
  0x00, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x0F,
  0x80, 0x01, 0xF8, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x0F, 0x80, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x00,
  0x7C, 0x1F, 0x80, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x00, 0xF8, 0xFC, 0x00,
  0x00, 0x1F, 0x9F, 0x00, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xF8, 0x07, 0xFC, 0x03, 0xC0, 0x01, 0xFE,
  0x02, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xC0, 0x7F, 0x1F, 0xF0, 0x00, 0x7F,
  0x3F, 0xC0, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F,
  0x7E, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0x7F, 0x00, 0x03, 0xFF, 0x7F, 0x00, 0x07, 0xFF, 0x7F, 0x80, 0x1F, 0xFF,
  0x3F, 0xF8, 0xFF, 0xBF, 0x3F, 0xFF, 0xFF, 0x3F, 0x1F, 0xFF, 0xFE, 0x3F,
  0x0F, 0xFF, 0xF8, 0x1F, 0x03, 0xFF, 0xF0, 0x1F, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x07, 0xFF, 0x00,
  0x3F, 0x07, 0xFF, 0xF0, 0x0F, 0xC7, 0xFF, 0xFE, 0x03, 0xF3, 0xFF, 0xFF,
  0xE0, 0xFD, 0xFF, 0xFF, 0xFC, 0x3F, 0xFE, 0x01, 0xFF, 0x8F, 0xFE, 0x00,
  0x1F, 0xE3, 0xFF, 0x00, 0x03, 0xFC, 0xFF, 0x80, 0x00, 0x7F, 0x3F, 0xC0,
  0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00, 0x7E, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7E, 0xFF, 0x00, 0x00, 0x3F, 0xBF,
  0xC0, 0x00, 0x0F, 0xEF, 0xF8, 0x00, 0x07, 0xF3, 0xFE, 0x00, 0x01, 0xFC,
  0xFF, 0xC0, 0x00, 0xFE, 0x3F, 0xFC, 0x00, 0xFF, 0x8F, 0xDF, 0xFF, 0xFF,
  0xC3, 0xF3, 0xFF, 0xFF, 0xE0, 0xF8, 0x7F, 0xFF, 0xF0, 0x3E, 0x0F, 0xFF,
  0xF8, 0x0F, 0x80, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xF0, 0x7E, 0x1F, 0xF0, 0x00, 0x41, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x30, 0xFF, 0x80, 0x1F, 0x0F, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x1F, 0xF8, 0x0F, 0xC0, 0x3F, 0xFF, 0xC3, 0xF0, 0x1F,
  0xFF, 0xF8, 0xFC, 0x0F, 0xFF, 0xFF, 0x3F, 0x07, 0xFF, 0xFF, 0xEF, 0xC3,
  0xFE, 0x01, 0xFF, 0xF1, 0xFE, 0x00, 0x1F, 0xFC, 0xFF, 0x00, 0x03, 0xFF,
  0x3F, 0x80, 0x00, 0x7F, 0xCF, 0xE0, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x03,
  0xFD, 0xFC, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00,
  0x7F, 0x7F, 0x00, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x0F, 0xF3, 0xF8, 0x00,
  0x03, 0xFC, 0xFF, 0x00, 0x01, 0xFF, 0x1F, 0xE0, 0x00, 0xFF, 0xC7, 0xFC,
  0x00, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0xFC, 0x1F, 0xFF, 0xFF, 0x3F, 0x03,
  0xFF, 0xFF, 0x87, 0xC0, 0x7F, 0xFF, 0xC1, 0xF0, 0x07, 0xFF, 0xC0, 0x7C,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0x80, 0x07, 0xF0, 0x3F, 0x80, 0x01,
  0xFC, 0x3F, 0x80, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x3F, 0x9F, 0xC0, 0x00,
  0x1F, 0xCF, 0xE0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x03, 0xFB, 0xF0, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x06, 0x07, 0xFE, 0x00, 0x1F,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00,
  0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0x03, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x07, 0xC0,
  0x3F, 0xFF, 0x81, 0xF0, 0x1F, 0xFF, 0xF8, 0x7C, 0x0F, 0xFF, 0xFF, 0x1F,
  0x07, 0xFF, 0xFF, 0xEF, 0xC3, 0xFE, 0x03, 0xFF, 0xF1, 0xFF, 0x00, 0x1F,
  0xFC, 0x7F, 0x00, 0x03, 0xFF, 0x3F, 0x80, 0x00, 0x7F, 0xCF, 0xE0, 0x00,
  0x0F, 0xF7, 0xF0, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0x00, 0x7F, 0x7E, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xF7, 0xE0, 0x00,
  0x01, 0xFD, 0xFC, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x1F, 0xDF, 0xC0,
  0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x01, 0xFF, 0x1F,
  0xE0, 0x00, 0xFF, 0xC7, 0xFC, 0x00, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0xFC,
  0x1F, 0xFF, 0xFF, 0xBF, 0x03, 0xFF, 0xFF, 0xCF, 0xC0, 0x3F, 0xFF, 0xC3,
  0xF0, 0x07, 0xFF, 0xC0, 0xFC, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x10, 0x00, 0x00, 0x7F, 0x07,
  0x80, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x03, 0xFF, 0x00, 0x7E, 0x0F, 0xFF, 0xF0, 0x3F, 0x0F, 0xFF, 0xFC, 0x1F,
  0x9F, 0xFF, 0xFF, 0x0F, 0xDF, 0xFF, 0xFF, 0xC7, 0xEF, 0xE0, 0x3F, 0xF3,
  0xFF, 0x80, 0x07, 0xF9, 0xFF, 0x80, 0x01, 0xFE, 0xFF, 0x80, 0x00, 0x7F,
  0x7F, 0x80, 0x00, 0x1F, 0xBF, 0xC0, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0xFE, 0x79, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF,
  0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF,
  0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB,
  0xF7, 0xEF, 0xC0, 0x00, 0x1E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x81, 0xFE, 0x7F, 0xFF, 0x3F,
  0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0x07, 0xFF, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xFE, 0xFC, 0x00, 0x03, 0xFC, 0xFC, 0x00, 0x07, 0xF8,
  0xFC, 0x00, 0x0F, 0xF0, 0xFC, 0x00, 0x1F, 0xE0, 0xFC, 0x00, 0x3F, 0xC0,
  0xFC, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0xFE, 0x00,
  0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0xFC, 0x07, 0xF0, 0x00,
  0xFC, 0x0F, 0xE0, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0xFC, 0x3F, 0x80, 0x00,
  0xFC, 0x7F, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x00, 0xFC, 0xFF, 0x00, 0x00,
  0xFD, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xDF, 0xE0, 0x00, 0xFF, 0x8F, 0xE0, 0x00, 0xFF, 0x07, 0xF0, 0x00,
  0xFE, 0x07, 0xF8, 0x00, 0xFC, 0x03, 0xFC, 0x00, 0xFC, 0x01, 0xFC, 0x00,
  0xFC, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0xFC, 0x00, 0x7F, 0x80,
  0xFC, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x1F, 0xE0,
  0xFC, 0x00, 0x0F, 0xF0, 0xFC, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x03, 0xF8,
  0xFC, 0x00, 0x03, 0xFC, 0xFC, 0x00, 0x01, 0xFE, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x07, 0xFF, 0x00, 0x07, 0xFF,
  0x01, 0xF0, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x83, 0xF1, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xC7, 0xE7, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xCF, 0xDF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0x9F, 0xBF, 0x01, 0xFF, 0x7F, 0x80, 0xFF, 0xBF,
  0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0xF8,
  0x07, 0xFF, 0x80, 0x7C, 0x0F, 0xFF, 0xF0, 0x3F, 0x1F, 0xFF, 0xFC, 0x1F,
  0x9F, 0xFF, 0xFF, 0x8F, 0xDF, 0xFF, 0xFF, 0xC7, 0xEF, 0xE0, 0x3F, 0xF3,
  0xFF, 0x80, 0x07, 0xF9, 0xFF, 0x80, 0x01, 0xFE, 0xFF, 0x80, 0x00, 0x7F,
  0x7F, 0x80, 0x00, 0x1F, 0xBF, 0xC0, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF0, 0x00, 0xFF, 0x01,
  0xFC, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x01,
  0xFC, 0x7F, 0x00, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x00, 0xFE, 0x7E, 0x00,
  0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x07, 0xEF,
  0xE0, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x00,
  0xFE, 0x7E, 0x00, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x00, 0xFE, 0x7F, 0x00,
  0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x3F, 0x81,
  0xFC, 0x00, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x1F,
  0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0xF8, 0x07, 0xFF, 0x00, 0x3E, 0x07, 0xFF, 0xF0,
  0x0F, 0xC7, 0xFF, 0xFF, 0x03, 0xF3, 0xFF, 0xFF, 0xE0, 0xFD, 0xFF, 0xFF,
  0xFC, 0x3F, 0x7E, 0x01, 0xFF, 0x8F, 0xFE, 0x00, 0x1F, 0xE3, 0xFF, 0x00,
  0x03, 0xFC, 0xFF, 0x80, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x1F, 0xEF, 0xF0,
  0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x7E, 0xFF, 0x00, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x0F, 0xEF,
  0xF8, 0x00, 0x07, 0xF3, 0xFE, 0x00, 0x03, 0xFC, 0xFF, 0xE0, 0x01, 0xFE,
  0x3F, 0xFC, 0x00, 0xFF, 0x8F, 0xDF, 0xFF, 0xFF, 0xC3, 0xF3, 0xFF, 0xFF,
  0xE0, 0xFC, 0x7F, 0xFF, 0xF0, 0x3F, 0x0F, 0xFF, 0xF8, 0x0F, 0xC0, 0xFF,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x07, 0xC0, 0x3F, 0xFF, 0x81, 0xF0, 0x1F,
  0xFF, 0xF8, 0x7C, 0x0F, 0xFF, 0xFF, 0x1F, 0x07, 0xFF, 0xFF, 0xEF, 0xC3,
  0xFE, 0x01, 0xFF, 0xF1, 0xFE, 0x00, 0x1F, 0xFC, 0x7F, 0x00, 0x03, 0xFF,
  0x3F, 0x80, 0x00, 0x7F, 0xCF, 0xE0, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x03,
  0xFD, 0xFC, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00,
  0x7F, 0x7F, 0x00, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x0F, 0xF3, 0xF8, 0x00,
  0x03, 0xFC, 0xFF, 0x00, 0x01, 0xFF, 0x1F, 0xE0, 0x00, 0xFF, 0xC7, 0xFC,
  0x00, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0xFC, 0x1F, 0xFF, 0xFF, 0x3F, 0x03,
  0xFF, 0xFF, 0x8F, 0xC0, 0x7F, 0xFF, 0xC3, 0xF0, 0x07, 0xFF, 0xC0, 0xFC,
  0x00, 0x1F, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x03, 0xFF, 0xF0, 0x1F, 0xFB, 0xF0, 0xFF, 0xF7, 0xE3, 0xFF, 0xEF,
  0xCF, 0xFF, 0xDF, 0x9F, 0xF7, 0xBF, 0x7E, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0xFF, 0x00,
  0x3F, 0x3F, 0x80, 0x00, 0xE7, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F,
  0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFB,
  0xFF, 0x9F, 0xFE, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0x80,
  0x01, 0xF0, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0x7F, 0x00,
  0x03, 0xFF, 0x7F, 0xC0, 0x0F, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0x9F, 0x1F, 0xFF, 0xFF, 0x1F, 0x07, 0xFF, 0xFC, 0x1F, 0x01, 0xFF,
  0xF0, 0x1F, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0xFE, 0x00,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0xFE, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFC,
  0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x7E, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x00,
  0x7E, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x0F, 0xCF, 0xE0,
  0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x0F,
  0xDF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xE7, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0x1F, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7E, 0x1F, 0x80, 0x01, 0xFF, 0xC0,
  0x01, 0xFC, 0x3F, 0x00, 0x07, 0xEF, 0x80, 0x03, 0xF8, 0x7F, 0x00, 0x0F,
  0xDF, 0x80, 0x07, 0xE0, 0x7E, 0x00, 0x1F, 0x3F, 0x00, 0x0F, 0xC0, 0xFC,
  0x00, 0x7E, 0x7E, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x7E,
  0x03, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE1, 0xF8,
  0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC1, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0x83, 0xF0, 0x0F, 0xC0, 0x1F, 0xC0, 0x3E, 0x07, 0xE0, 0x1F, 0x80, 0x1F,
  0x80, 0xFC, 0x0F, 0xC0, 0x3F, 0x00, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0xFC,
  0x00, 0x7F, 0x03, 0xE0, 0x1F, 0x81, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x3F,
  0x03, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x0F, 0xE0, 0x01, 0xF8, 0x3F,
  0x00, 0x7E, 0x1F, 0x80, 0x03, 0xF8, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x03,
  0xF1, 0xF8, 0x00, 0xF8, 0x7E, 0x00, 0x07, 0xE3, 0xF0, 0x01, 0xF9, 0xFC,
  0x00, 0x0F, 0xC7, 0xC0, 0x03, 0xF3, 0xF0, 0x00, 0x0F, 0x9F, 0x80, 0x07,
  0xE7, 0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x3F, 0x7C,
  0x00, 0x0F, 0xDF, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x01, 0xFC, 0x3F, 0xC0, 0x00,
  0x1F, 0xC1, 0xFC, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x01, 0xFC, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0xFE, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x03,
  0xF9, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0x9F, 0x80, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0x7F, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x3F, 0x80, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x1F, 0xE0, 0x00,
  0x3F, 0x81, 0xFC, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x1F, 0xC7, 0xF0,
  0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x00, 0x03,
  0xFB, 0xF0, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x01, 0xFC, 0xFE, 0x00,
  0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x7E, 0x00, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x7E, 0x00, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x0F,
  0xC0, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x01, 0xF8,
  0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x01, 0xF8, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x3F, 0x01,
  0xFC, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x00,
  0x3F, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x07, 0xE1, 0xF8,
  0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x07,
  0xE7, 0xE0, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x00, 0xFB, 0xF0, 0x00,
  0x00, 0x07, 0xDF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xE0, 0x07,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x80,
  0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x01,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x4F, 0xFF, 0xC0, 0x00, 0x37,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xEE, 0x00, 0x3F, 0xFF, 0xF3, 0x00, 0x03, 0xFF,
  0xF8, 0x80, 0x00, 0x1F, 0xF8, 0x00,
};

const GFXglyph NotoSans_Regular72pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 9, 52, 19, 5, -51 },
  { 60, 20, 18, 29, 5, -51 },
  { 105, 43, 51, 47, 2, -51 },
  { 380, 33, 59, 41, 4, -55 },
  { 624, 52, 53, 60, 4, -52 },
  { 969, 49, 53, 53, 4, -52 },
  { 1294, 7, 18, 16, 5, -51 },
  { 1310, 16, 62, 22, 3, -51 },
  { 1434, 17, 62, 22, 2, -51 },
  { 1566, 34, 33, 40, 3, -55 },
  { 1707, 33, 35, 41, 4, -43 },
  { 1852, 11, 17, 19, 3, -8 },
  { 1876, 17, 6, 23, 3, -22 },
  { 1889, 9, 10, 19, 5, -9 },
  { 1901, 25, 51, 27, 1, -51 },
  { 2061, 34, 53, 41, 4, -52 },
  { 2287, 20, 51, 41, 6, -51 },
  { 2415, 34, 52, 41, 3, -52 },
  { 2636, 34, 53, 41, 3, -52 },
  { 2862, 38, 52, 41, 2, -52 },
  { 3109, 32, 52, 41, 5, -51 },
  { 3317, 34, 53, 41, 4, -52 },
  { 3543, 35, 51, 41, 3, -51 },
  { 3767, 34, 53, 41, 4, -52 },
  { 3993, 33, 53, 41, 4, -52 },
  { 4212, 9, 41, 19, 5, -40 },
  { 4259, 12, 49, 19, 2, -40 },
  { 4333, 34, 36, 41, 4, -44 },
  { 4486, 33, 19, 41, 4, -35 },
  { 4565, 34, 36, 41, 4, -44 },
  { 4718, 28, 53, 31, 1, -52 },
  { 4904, 57, 57, 65, 4, -51 },
  { 5311, 46, 52, 46, 0, -52 },
  { 5610, 36, 51, 47, 7, -51 },
  { 5840, 39, 53, 46, 4, -52 },
  { 6099, 41, 51, 53, 7, -51 },
  { 6361, 29, 51, 40, 7, -51 },
  { 6546, 29, 51, 37, 7, -51 },
  { 6731, 43, 53, 52, 4, -52 },
  { 7016, 39, 51, 53, 7, -51 },
  { 7265, 18, 51, 24, 3, -51 },
  { 7380, 19, 65, 20, -6, -51 },
  { 7535, 38, 51, 45, 7, -51 },
  { 7778, 29, 51, 38, 7, -51 },
  { 7963, 51, 51, 65, 7, -51 },
  { 8289, 41, 51, 55, 7, -51 },
  { 8551, 48, 53, 56, 4, -52 },
  { 8869, 33, 51, 44, 7, -51 },
  { 9080, 48, 64, 56, 4, -52 },
  { 9464, 37, 51, 45, 7, -51 },
  { 9700, 32, 53, 40, 4, -52 },
  { 9912, 38, 51, 40, 1, -51 },
  { 10155, 40, 52, 53, 6, -51 },
  { 10415, 43, 51, 43, 0, -51 },
  { 10690, 65, 51, 67, 1, -51 },
  { 11105, 42, 51, 42, 0, -51 },
  { 11373, 41, 51, 41, 0, -51 },
  { 11635, 35, 51, 41, 3, -51 },
  { 11859, 16, 62, 24, 6, -51 },
  { 11983, 25, 51, 27, 1, -51 },
  { 12143, 16, 62, 24, 2, -51 },
  { 12267, 35, 33, 41, 3, -52 },
  { 12412, 32, 5, 32, 0, 6 },
  { 12432, 14, 11, 20, 3, -55 },
  { 12452, 32, 40, 40, 3, -39 },
  { 12612, 34, 56, 44, 6, -55 },
  { 12850, 28, 40, 35, 4, -39 },
  { 12990, 34, 56, 44, 4, -55 },
  { 13228, 33, 40, 41, 4, -39 },
  { 13393, 27, 55, 25, 1, -55 },
  { 13579, 34, 56, 44, 4, -39 },
  { 13817, 33, 55, 45, 6, -55 },
  { 14044, 7, 53, 19, 6, -53 },
  { 14091, 17, 70, 19, -4, -53 },
  { 14240, 32, 55, 38, 6, -55 },
  { 14460, 6, 55, 19, 6, -55 },
  { 14502, 55, 39, 67, 6, -39 },
  { 14771, 33, 39, 45, 6, -39 },
  { 14932, 36, 40, 44, 4, -39 },
  { 15112, 34, 56, 44, 6, -39 },
  { 15350, 34, 56, 44, 4, -39 },
  { 15588, 23, 39, 30, 6, -39 },
  { 15701, 27, 40, 34, 4, -39 },
  { 15836, 23, 48, 26, 1, -47 },
  { 15974, 32, 40, 45, 6, -39 },
  { 16134, 37, 39, 37, 0, -39 },
  { 16315, 55, 39, 57, 1, -39 },
  { 16584, 36, 39, 38, 1, -39 },
  { 16760, 37, 56, 37, 0, -39 },
  { 17019, 28, 39, 34, 3, -39 },
  { 17156, 23, 62, 27, 2, -51 },
  { 17335, 5, 72, 40, 17, -55 },
  { 17380, 23, 62, 27, 2, -51 },
  { 17559, 34, 9, 41, 4, -30 },
};

const GFXfont NotoSans_Regular72pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Regular72pt7bBitmaps,
  (GFXglyph *)NotoSans_Regular72pt7bGlyphs,
  0x20, 0x7E, 98
};

#endif // _NOTOSANS_REGULAR72PT7B_H_
