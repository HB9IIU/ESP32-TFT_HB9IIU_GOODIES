#ifndef _NOTOSANS_REGULAR57PT7B_H_
#define _NOTOSANS_REGULAR57PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Regular.ttf
// Size: 57pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Regular57pt7bBitmaps[] PROGMEM = {
  0x00, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF8, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78,
  0xE1, 0xC3, 0x87, 0x00, 0x00, 0x00, 0x00, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7C, 0x70, 0xF8, 0x3F, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E,
  0xF8, 0x1E, 0xF8, 0x1E, 0xF8, 0x1E, 0xF8, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E,
  0x70, 0x1E, 0x70, 0x1E, 0x70, 0x1E, 0x70, 0x1C, 0x00, 0x07, 0x80, 0x78,
  0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x1E, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0xF0,
  0x0F, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x07,
  0xC0, 0x3C, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x00, 0x78, 0x07, 0x80, 0x1F,
  0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x3C, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x78, 0x07,
  0xC0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x01, 0xE0,
  0x1E, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x3C, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x78, 0x00,
  0x01, 0xE0, 0x1E, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x1E, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0xF0, 0x0F,
  0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x07, 0xC0,
  0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x3F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x3F, 0x9E, 0x3F, 0x3F, 0x0F,
  0x01, 0x9F, 0x07, 0x80, 0x0F, 0x83, 0xC0, 0x07, 0x81, 0xE0, 0x03, 0xC0,
  0xF0, 0x01, 0xF0, 0x78, 0x00, 0xF8, 0x3C, 0x00, 0x7E, 0x1E, 0x00, 0x1F,
  0xCF, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00,
  0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x0F, 0x1F, 0xE0, 0x07, 0x83, 0xF0, 0x03, 0xC0, 0xF8, 0x01, 0xE0,
  0x7C, 0x00, 0xF0, 0x1E, 0x00, 0x78, 0x1F, 0x00, 0x3C, 0x0F, 0xC0, 0x1E,
  0x0F, 0xF0, 0x0F, 0x0F, 0xDF, 0xC7, 0xFF, 0xEF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xC0, 0x07, 0xFE, 0x00, 0x01,
  0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x78, 0x00, 0xF9, 0xF8, 0x00, 0x3C, 0x00,
  0x7C, 0x1E, 0x00, 0x1F, 0x00, 0x1E, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80,
  0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x3C, 0x00, 0xF0, 0x00, 0xF0, 0x0F, 0x00,
  0x7C, 0x00, 0x3C, 0x03, 0xE0, 0x1E, 0x00, 0x0F, 0x00, 0xF8, 0x0F, 0x80,
  0x03, 0xC0, 0x3E, 0x03, 0xC0, 0x00, 0xF0, 0x0F, 0x81, 0xE0, 0x00, 0x3C,
  0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x00, 0xF8, 0x3C, 0x00, 0x03, 0xC0, 0x3E,
  0x1F, 0x00, 0x00, 0xF0, 0x0F, 0x07, 0x83, 0xF0, 0x3C, 0x03, 0xC3, 0xE3,
  0xFF, 0x0F, 0x80, 0xF0, 0xF1, 0xFF, 0xE1, 0xE0, 0x7C, 0x7C, 0x7F, 0xF8,
  0x7C, 0x1E, 0x1E, 0x3E, 0x1F, 0x0F, 0x9F, 0x8F, 0x0F, 0x03, 0xC3, 0xFF,
  0xC7, 0xC7, 0xC0, 0x78, 0x7F, 0xE1, 0xE1, 0xE0, 0x1E, 0x07, 0xF0, 0xF8,
  0x78, 0x07, 0x80, 0x00, 0x3C, 0x1E, 0x01, 0xE0, 0x00, 0x1F, 0x07, 0x80,
  0x78, 0x00, 0x07, 0x81, 0xE0, 0x1F, 0x00, 0x03, 0xE0, 0x78, 0x07, 0xC0,
  0x00, 0xF0, 0x1E, 0x01, 0xF0, 0x00, 0x78, 0x07, 0x80, 0x7C, 0x00, 0x3E,
  0x01, 0xE0, 0x1E, 0x00, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x07, 0xC0, 0x1E,
  0x01, 0xE0, 0x01, 0xE0, 0x07, 0x80, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x3E,
  0x00, 0x3C, 0x00, 0x3C, 0x0F, 0x00, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x07,
  0x80, 0x01, 0xFF, 0xE0, 0x03, 0xC0, 0x00, 0x3F, 0xF0, 0x01, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x07, 0xE0,
  0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x00,
  0xFC, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0x01, 0xF9, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x3E, 0x07, 0xF1, 0xFC, 0x00, 0x7C,
  0x1F, 0xC1, 0xFC, 0x01, 0xF0, 0x3F, 0x01, 0xFC, 0x03, 0xE0, 0xFC, 0x01,
  0xFC, 0x0F, 0xC1, 0xF0, 0x01, 0xFC, 0x1F, 0x07, 0xE0, 0x01, 0xFC, 0x3E,
  0x0F, 0x80, 0x01, 0xFC, 0xF8, 0x1F, 0x00, 0x01, 0xFF, 0xF0, 0x3E, 0x00,
  0x01, 0xFF, 0xC0, 0x7C, 0x00, 0x01, 0xFF, 0x00, 0xFC, 0x00, 0x01, 0xFE,
  0x01, 0xF8, 0x00, 0x03, 0xFC, 0x01, 0xF8, 0x00, 0x0F, 0xFC, 0x03, 0xF8,
  0x00, 0x7F, 0xFC, 0x03, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF1,
  0xFC, 0x07, 0xFF, 0xFF, 0xC1, 0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xFC, 0x03,
  0xFF, 0xF0, 0x01, 0xFE, 0x00, 0x18, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xBC, 0xE7, 0x39, 0xC0, 0x00, 0xF8, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x07,
  0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x03, 0xE0,
  0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x01, 0xF0, 0x07, 0xC0, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x03,
  0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0,
  0x3E, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x7C,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x78, 0x0E, 0x01, 0xCF, 0xE1, 0xC3,
  0xF9, 0xFF, 0xFB, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x7B, 0xE0,
  0x00, 0x1F, 0x3C, 0x00, 0x07, 0xC7, 0xC0, 0x01, 0xF8, 0x7C, 0x00, 0x3E,
  0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x1E, 0x03, 0xE0,
  0x00, 0x80, 0x30, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x1F, 0x8F, 0xC7, 0xE3, 0xE3, 0xF1, 0xF8, 0xF8, 0x7C,
  0x3C, 0x3E, 0x1F, 0x0F, 0x07, 0x87, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x1C, 0x00,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x01, 0xFC, 0x0F, 0xE0, 0x3F,
  0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xC1, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x0F,
  0x8F, 0x80, 0x01, 0xF1, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x03, 0xEF, 0x80,
  0x00, 0x7D, 0xF0, 0x00, 0x0F, 0xBE, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xFC, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7C, 0xF8, 0x00, 0x0F, 0x9F,
  0x00, 0x01, 0xF3, 0xE0, 0x00, 0x7E, 0x7C, 0x00, 0x0F, 0x87, 0xC0, 0x01,
  0xF0, 0xFC, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x81, 0xFC, 0x07, 0xE0, 0x1F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xE0,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x7C, 0x03, 0xF8, 0x0F, 0xF0,
  0x3F, 0xE1, 0xFF, 0xC7, 0xFF, 0x9F, 0x9F, 0xFE, 0x3E, 0xF8, 0x7D, 0xE0,
  0xF9, 0x81, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x0F, 0xF8,
  0x0F, 0xE0, 0xFC, 0x00, 0x7E, 0x0E, 0x00, 0x07, 0xC1, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0xFF, 0x00, 0xFF, 0x1F, 0x00, 0x0F, 0xC3,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFA, 0x00, 0x00,
  0xFE, 0xF8, 0x00, 0xFF, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1E, 0xF8, 0x00,
  0x00, 0xFB, 0xE0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x1F, 0x3E, 0x00, 0x00,
  0xF8, 0xF8, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0xF8,
  0x3E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0xF8, 0x0F,
  0x80, 0x07, 0xC0, 0x3E, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0xF8, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0xF8, 0x07,
  0xC0, 0x03, 0xE0, 0x3E, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x3E, 0x07, 0xC0,
  0x00, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7B, 0xFF, 0x00,
  0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xE0, 0x7F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xD0, 0x00, 0x0F, 0xCF,
  0x00, 0x1F, 0xE7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0x80, 0x00, 0x30, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x07,
  0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xC0, 0x10,
  0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x3F, 0xF0, 0x1F, 0x1F, 0xFF, 0x83, 0xE7, 0xFF, 0xF8, 0x7D,
  0xFE, 0xFF, 0x8F, 0xFC, 0x03, 0xF9, 0xFE, 0x00, 0x1F, 0xBF, 0x80, 0x01,
  0xF7, 0xE0, 0x00, 0x3E, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3E, 0xF0, 0x00, 0x07,
  0xDF, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0x7E, 0x00, 0x07, 0xC7, 0xC0,
  0x00, 0xF8, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC0, 0xFC, 0x03, 0xF8,
  0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x03, 0xF8, 0x07, 0xF0, 0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x03, 0xE3,
  0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF1, 0xF0, 0x00,
  0x3E, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x3F, 0x0F,
  0xC0, 0x0F, 0xC0, 0xFE, 0x03, 0xF0, 0x0F, 0xE0, 0xFC, 0x00, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x0F,
  0xFF, 0xF0, 0x03, 0xF8, 0xFF, 0x80, 0xFC, 0x07, 0xF8, 0x3F, 0x00, 0x3F,
  0x8F, 0xC0, 0x03, 0xF1, 0xF0, 0x00, 0x3F, 0x7C, 0x00, 0x03, 0xEF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x1F, 0x3F, 0x00,
  0x07, 0xE7, 0xF0, 0x03, 0xF8, 0x7F, 0xE7, 0xFE, 0x07, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x03,
  0xFC, 0x0F, 0xE0, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x07, 0xC3, 0xE0, 0x00,
  0xFC, 0xFC, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x1F, 0x7C,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0x7D, 0xF0, 0x00, 0x07, 0xBE, 0x00, 0x00,
  0xF7, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFD, 0xF0,
  0x00, 0x3F, 0xBF, 0x00, 0x0F, 0xF7, 0xF0, 0x03, 0xFE, 0x7F, 0x83, 0xF7,
  0x87, 0xFF, 0xFD, 0xF0, 0x7F, 0xFF, 0x3E, 0x03, 0xFF, 0x87, 0xC0, 0x0F,
  0x80, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x80, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFC,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x30, 0x00, 0x00, 0x7D, 0xFF, 0xFF, 0xFF,
  0xFF, 0xDF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x1C,
  0x1F, 0x1F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x1F, 0x8F, 0xC7, 0xE3, 0xE1, 0xF0, 0xF8, 0xF8,
  0x7C, 0x3E, 0x1E, 0x1F, 0x0F, 0x07, 0x80, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x7E, 0x07, 0xF9, 0xC0,
  0x03, 0xE4, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xF0, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x00,
  0x3E, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x03, 0x40, 0x03,
  0xC1, 0xF0, 0x03, 0xFF, 0xF8, 0x1F, 0x0F, 0x00, 0x3F, 0xFF, 0x80, 0x78,
  0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xC7, 0x80, 0x3F, 0x01, 0xE0, 0x1E, 0x7C,
  0x03, 0xE0, 0x0F, 0x00, 0x7B, 0xC0, 0x3E, 0x00, 0x78, 0x03, 0xDE, 0x01,
  0xF0, 0x03, 0xC0, 0x1E, 0xF0, 0x1F, 0x00, 0x1E, 0x00, 0xF7, 0x80, 0xF8,
  0x00, 0xF0, 0x07, 0xFC, 0x07, 0x80, 0x07, 0x80, 0x3F, 0xE0, 0x3C, 0x00,
  0x3C, 0x01, 0xFE, 0x01, 0xE0, 0x01, 0xE0, 0x0F, 0xF0, 0x0F, 0x00, 0x0F,
  0x00, 0x7F, 0x80, 0x78, 0x00, 0xF8, 0x07, 0xBC, 0x03, 0xC0, 0x07, 0xC0,
  0x3D, 0xF0, 0x1F, 0x00, 0x3E, 0x01, 0xEF, 0x80, 0xF8, 0x03, 0xF0, 0x1E,
  0x3C, 0x03, 0xE0, 0x1F, 0x80, 0xF1, 0xE0, 0x1F, 0x83, 0xDE, 0x0F, 0x0F,
  0x00, 0x7F, 0xFE, 0x7F, 0xF8, 0x7C, 0x01, 0xFF, 0xE3, 0xFF, 0x81, 0xE0,
  0x07, 0xFE, 0x0F, 0xF8, 0x0F, 0x00, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7D, 0xE0, 0x00,
  0x00, 0x07, 0x9F, 0x00, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00, 0x0F, 0x8F,
  0x80, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x7C, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x3C, 0x00,
  0x00, 0x3E, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x7C, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x0F, 0xC0,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0xFC,
  0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x01, 0xF8,
  0x1F, 0x00, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x8F, 0x80,
  0x07, 0xFC, 0xF8, 0x00, 0x1F, 0xCF, 0x80, 0x00, 0xFC, 0xF8, 0x00, 0x07,
  0xCF, 0x80, 0x00, 0x7E, 0xF8, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x7E, 0xF8,
  0x00, 0x07, 0xCF, 0x80, 0x00, 0x7C, 0xF8, 0x00, 0x07, 0xCF, 0x80, 0x00,
  0xF8, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x3F, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0xF8, 0x00,
  0x7F, 0x8F, 0x80, 0x00, 0xFC, 0xF8, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x3E,
  0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x7E, 0xF8, 0x00, 0x0F, 0xEF, 0x80, 0x01, 0xFC, 0xF8,
  0x00, 0xFF, 0xCF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xF8, 0x1F,
  0xC0, 0x7F, 0x80, 0x03, 0x81, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x20, 0x3F, 0xE0, 0x03, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x60, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x00, 0x7F, 0xE0,
  0xF8, 0x00, 0x0F, 0xF0, 0xF8, 0x00, 0x03, 0xF8, 0xF8, 0x00, 0x01, 0xF8,
  0xF8, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x00, 0x7E,
  0xF8, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0x7E,
  0xF8, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x01, 0xFC, 0xF8, 0x00, 0x01, 0xF8,
  0xF8, 0x00, 0x07, 0xF8, 0xF8, 0x00, 0x0F, 0xF0, 0xF8, 0x00, 0x3F, 0xE0,
  0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xC0, 0x7F, 0x80, 0xFF, 0x00, 0x01, 0xC0, 0x7F, 0x00, 0x00, 0x10,
  0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xF7, 0xC0, 0x00, 0xFF, 0xFD, 0xF0, 0x00, 0x3F, 0xFF,
  0x7C, 0x00, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x00,
  0x7D, 0xF8, 0x00, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x07, 0xCF, 0xC0, 0x00,
  0x01, 0xF3, 0xF0, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0x1F, 0x1F, 0x80,
  0x00, 0x07, 0xC3, 0xF0, 0x00, 0x01, 0xF0, 0xFF, 0x00, 0x00, 0x7C, 0x1F,
  0xE0, 0x00, 0x1F, 0x03, 0xFF, 0x00, 0x0F, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x00, 0x07, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3E, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xE0, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x03, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x1F, 0xBF,
  0xFE, 0xFF, 0xF3, 0xFF, 0x8F, 0xFC, 0x1F, 0x80, 0xF8, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x1F, 0xBE, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x1F, 0x8F, 0x80,
  0x01, 0xF8, 0x7C, 0x00, 0x1F, 0x83, 0xE0, 0x01, 0xF8, 0x1F, 0x00, 0x1F,
  0x80, 0xF8, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xF8, 0x01,
  0xF0, 0x0F, 0x80, 0x0F, 0x80, 0xFC, 0x00, 0x7C, 0x0F, 0xC0, 0x03, 0xE0,
  0xFC, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0xF8, 0xFC, 0x00, 0x07, 0xCF, 0xC0,
  0x00, 0x3E, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0xF8,
  0x1F, 0x80, 0x07, 0xC0, 0x7E, 0x00, 0x3E, 0x03, 0xF8, 0x01, 0xF0, 0x0F,
  0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xFC, 0x03, 0xE0, 0x07, 0xF0,
  0x1F, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x7E, 0x07, 0xC0, 0x01, 0xF8, 0x3E,
  0x00, 0x0F, 0xE1, 0xF0, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0xFC, 0x7C, 0x00,
  0x03, 0xF3, 0xE0, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x01,
  0xF8, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xF7, 0x80, 0x00, 0x03, 0xFF, 0xF7, 0xC0, 0x00, 0x03, 0xDF, 0xF7, 0xC0,
  0x00, 0x07, 0xDF, 0xF3, 0xE0, 0x00, 0x07, 0xDF, 0xF3, 0xE0, 0x00, 0x07,
  0x9F, 0xF3, 0xE0, 0x00, 0x0F, 0x9F, 0xF1, 0xF0, 0x00, 0x0F, 0x9F, 0xF1,
  0xF0, 0x00, 0x0F, 0x1F, 0xF0, 0xF0, 0x00, 0x1F, 0x1F, 0xF0, 0xF8, 0x00,
  0x1E, 0x1F, 0xF0, 0xF8, 0x00, 0x3E, 0x1F, 0xF0, 0x7C, 0x00, 0x3E, 0x1F,
  0xF0, 0x7C, 0x00, 0x3C, 0x1F, 0xF0, 0x7C, 0x00, 0x7C, 0x1F, 0xF0, 0x3E,
  0x00, 0x7C, 0x1F, 0xF0, 0x3E, 0x00, 0x78, 0x1F, 0xF0, 0x1E, 0x00, 0xF8,
  0x1F, 0xF0, 0x1F, 0x00, 0xF0, 0x1F, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0xF0,
  0x0F, 0x81, 0xF0, 0x1F, 0xF0, 0x0F, 0x81, 0xE0, 0x1F, 0xF0, 0x0F, 0x83,
  0xE0, 0x1F, 0xF0, 0x07, 0xC3, 0xC0, 0x1F, 0xF0, 0x07, 0xC7, 0xC0, 0x1F,
  0xF0, 0x03, 0xC7, 0xC0, 0x1F, 0xF0, 0x03, 0xE7, 0x80, 0x1F, 0xF0, 0x03,
  0xEF, 0x80, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFF, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x1F, 0xF7, 0xE0, 0x00, 0x1F, 0xF3, 0xE0, 0x00, 0x1F, 0xF3,
  0xF0, 0x00, 0x1F, 0xF1, 0xF8, 0x00, 0x1F, 0xF1, 0xF8, 0x00, 0x1F, 0xF0,
  0xFC, 0x00, 0x1F, 0xF0, 0x7E, 0x00, 0x1F, 0xF0, 0x7E, 0x00, 0x1F, 0xF0,
  0x3F, 0x00, 0x1F, 0xF0, 0x1F, 0x80, 0x1F, 0xF0, 0x1F, 0x80, 0x1F, 0xF0,
  0x0F, 0xC0, 0x1F, 0xF0, 0x07, 0xC0, 0x1F, 0xF0, 0x07, 0xE0, 0x1F, 0xF0,
  0x03, 0xF0, 0x1F, 0xF0, 0x01, 0xF0, 0x1F, 0xF0, 0x01, 0xF8, 0x1F, 0xF0,
  0x00, 0xFC, 0x1F, 0xF0, 0x00, 0xFC, 0x1F, 0xF0, 0x00, 0x7E, 0x1F, 0xF0,
  0x00, 0x3F, 0x1F, 0xF0, 0x00, 0x3F, 0x1F, 0xF0, 0x00, 0x1F, 0x9F, 0xF0,
  0x00, 0x0F, 0xDF, 0xF0, 0x00, 0x0F, 0xDF, 0xF0, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0x81, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x7C, 0x00,
  0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x00, 0x7E,
  0x7E, 0x00, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x03, 0xE7, 0xC0, 0x00,
  0x00, 0x0F, 0x9F, 0x00, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x00, 0xFD,
  0xF0, 0x00, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xF7,
  0xC0, 0x00, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00,
  0x00, 0xFD, 0xF0, 0x00, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x00, 0x0F, 0xDF,
  0x80, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00,
  0x07, 0xE3, 0xF0, 0x00, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x1F,
  0x80, 0x00, 0x03, 0xE0, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x00,
  0xFC, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFE, 0x3E, 0x00, 0x3F, 0xCF, 0x80, 0x03, 0xF3, 0xE0, 0x00,
  0x7E, 0xF8, 0x00, 0x1F, 0xBE, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFB, 0xE0,
  0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFB,
  0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0xBE, 0x00, 0x07, 0xEF, 0x80, 0x03,
  0xF3, 0xE0, 0x03, 0xF8, 0xF8, 0x07, 0xFE, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0x81, 0xFF,
  0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x7E, 0x00,
  0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x00, 0x0F,
  0x9F, 0x00, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x00, 0xFD, 0xF0, 0x00,
  0x00, 0x03, 0xF7, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xF7, 0xC0, 0x00,
  0x00, 0x07, 0xDF, 0x00, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x00, 0xFD,
  0xF0, 0x00, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x00, 0x0F, 0x9F, 0x80, 0x00,
  0x00, 0x3E, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00, 0x07, 0xE3,
  0xF0, 0x00, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00,
  0x03, 0xE0, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x00, 0xFC, 0x01,
  0xFC, 0x00, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x7C, 0x00,
  0x7F, 0x83, 0xE0, 0x00, 0xFE, 0x1F, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x0F,
  0x87, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x1F, 0x8F,
  0x80, 0x00, 0xFC, 0x7C, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x3E, 0x1F, 0x00,
  0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x87, 0xC0, 0x01, 0xF8, 0x3E, 0x00, 0x1F,
  0xC1, 0xF0, 0x07, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xF8, 0x07, 0xC0, 0x07, 0xC0,
  0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1F,
  0x80, 0x7C, 0x00, 0x7E, 0x03, 0xE0, 0x03, 0xF0, 0x1F, 0x00, 0x0F, 0xC0,
  0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF8, 0x3E, 0x00, 0x07, 0xE1, 0xF0,
  0x00, 0x3F, 0x0F, 0x80, 0x00, 0xFC, 0x7C, 0x00, 0x03, 0xE3, 0xE0, 0x00,
  0x1F, 0x9F, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x3F, 0xE0,
  0x7F, 0x1F, 0xC0, 0x01, 0x87, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F,
  0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xFB, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0xFF, 0x3F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x00, 0x2C,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F,
  0xBE, 0x00, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x01, 0xF8,
  0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0xFF, 0x01,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x03, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00, 0x3E,
  0x7E, 0x00, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x01,
  0xF0, 0x7C, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0x3E, 0x07, 0xE0, 0x00,
  0x0F, 0x80, 0xF8, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x01, 0xF0, 0x0F, 0xC0,
  0x00, 0xFC, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x1F,
  0x80, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x01, 0xF0, 0x03, 0xE0,
  0x00, 0x3E, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x03, 0xF0, 0x1F,
  0x00, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x07, 0xE0,
  0xF8, 0x00, 0x00, 0xF8, 0x7E, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x0F,
  0xC7, 0xC0, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00,
  0x0F, 0x3E, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xBE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7C, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0x9F, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xF1, 0xF0,
  0x00, 0x3D, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0xBC, 0x00, 0x0F, 0x87,
  0xC0, 0x01, 0xF7, 0xC0, 0x01, 0xF0, 0xFC, 0x00, 0x3C, 0xF8, 0x00, 0x7E,
  0x0F, 0x80, 0x0F, 0x8F, 0x00, 0x0F, 0x81, 0xF0, 0x01, 0xF1, 0xF0, 0x01,
  0xF0, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x07, 0xE0, 0x0F, 0x87, 0xC0,
  0x0F, 0xC0, 0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x0F,
  0x80, 0x3E, 0x01, 0xF0, 0x07, 0x81, 0xF0, 0x07, 0xC0, 0x3F, 0x01, 0xF0,
  0x1E, 0x01, 0xF0, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x00, 0x7C, 0x07,
  0xC0, 0x7C, 0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x0F, 0x80, 0xF8, 0x00, 0xF8,
  0x3E, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x03,
  0xE0, 0xF0, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x1F, 0x00,
  0x07, 0xC7, 0xC0, 0x07, 0xC7, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8,
  0x00, 0x1F, 0x3E, 0x00, 0x0F, 0x1F, 0x00, 0x03, 0xE7, 0xC0, 0x01, 0xF3,
  0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xDE, 0x00, 0x07,
  0xDF, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x7B, 0xE0, 0x00, 0x1F, 0x78, 0x00,
  0x0F, 0x78, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x1F,
  0x83, 0xF0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x07,
  0xC0, 0x1F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03,
  0xE0, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x1F, 0x81,
  0xF0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x00, 0xFC,
  0xF8, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x3E, 0xF8, 0x00, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00,
  0x1F, 0x87, 0xC0, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0x07, 0xC0, 0x7E, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x07, 0xE0, 0x07, 0xC0,
  0x03, 0xE0, 0x03, 0xF0, 0x03, 0xE0, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0x7E,
  0x01, 0xF0, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x03,
  0xF0, 0xF8, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0xFC, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x3F, 0x7E, 0x00,
  0x00, 0x3E, 0x3E, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x00,
  0x00, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x0F, 0x80, 0x01, 0xF0, 0x0F, 0xC0,
  0x03, 0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0,
  0x07, 0xC0, 0x01, 0xF0, 0x0F, 0xC0, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0xF8,
  0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x7E,
  0x3E, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0xF1,
  0xE0, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x1E, 0x07, 0x80,
  0x03, 0xE0, 0x7C, 0x00, 0x3C, 0x03, 0xC0, 0x07, 0xC0, 0x3E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0xF0, 0x00, 0xF0, 0x0F, 0x00, 0x0F,
  0x81, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3C, 0x3C,
  0x00, 0x03, 0xE7, 0xC0, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFC, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0x80, 0xFE, 0x0C, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0x3F, 0xF0, 0x1F, 0x7F, 0x00, 0x1F, 0xFE, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFE, 0x01,
  0xFF, 0x7F, 0xDF, 0xEF, 0x7F, 0xFF, 0xCF, 0x3F, 0xFF, 0x8F, 0x0F, 0xFE,
  0x07, 0x00, 0x40, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x83, 0xFC, 0x01,
  0xF1, 0xFF, 0xF0, 0x3E, 0x7F, 0xFF, 0x07, 0xDF, 0xFF, 0xF0, 0xFF, 0xC0,
  0xFF, 0x1F, 0xE0, 0x07, 0xF3, 0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x7D, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x01, 0xF7, 0xC0, 0x00,
  0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFB, 0xF0,
  0x00, 0x1F, 0x7E, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0xF9, 0xFE, 0x00, 0x3F,
  0x3F, 0xE0, 0x1F, 0xC7, 0xBF, 0xFF, 0xF8, 0xF3, 0xFF, 0xFE, 0x1E, 0x3F,
  0xFF, 0x03, 0xC1, 0xFF, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC3, 0xFF, 0xFF, 0x1F, 0xF0, 0xF8, 0x7E,
  0x00, 0x23, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x11, 0xFC, 0x01, 0xC3,
  0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x00,
  0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x07, 0xF8, 0x3E, 0x07, 0xFF, 0xC7,
  0xC1, 0xFF, 0xFC, 0xF8, 0x7F, 0xFF, 0xDF, 0x1F, 0xE0, 0x7F, 0xE7, 0xF0,
  0x03, 0xFC, 0xFC, 0x00, 0x3F, 0xBF, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x7E,
  0xF8, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x1F, 0xFC, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7D, 0xF0, 0x00, 0x1F, 0xBF,
  0x00, 0x03, 0xF3, 0xE0, 0x00, 0xFE, 0x7E, 0x00, 0x1F, 0xC7, 0xF0, 0x0F,
  0xF8, 0xFF, 0xFF, 0xEF, 0x0F, 0xFF, 0xF9, 0xE0, 0x7F, 0xFE, 0x3C, 0x07,
  0xFF, 0x07, 0x80, 0x06, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xFC,
  0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x0F, 0xE0, 0x7F, 0x07, 0xE0,
  0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0xDF,
  0x00, 0x01, 0xF7, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x21, 0xFE, 0x00, 0x78, 0x3F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x01, 0xFF, 0xC0, 0x3F, 0xFE, 0x03, 0xFF,
  0xE0, 0x1F, 0xFF, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07,
  0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xFF, 0xE1, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC0, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7F,
  0x81, 0xE0, 0x7F, 0xFC, 0x3C, 0x1F, 0xFF, 0xC7, 0x87, 0xFF, 0xFC, 0xF1,
  0xFE, 0x0F, 0xFE, 0x3F, 0x00, 0x3F, 0xCF, 0xC0, 0x03, 0xF9, 0xF0, 0x00,
  0x3F, 0x7E, 0x00, 0x07, 0xEF, 0x80, 0x00, 0xFD, 0xF0, 0x00, 0x0F, 0xFE,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFE, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x07,
  0xDF, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x3F, 0x3E, 0x00, 0x07, 0xE7, 0xE0,
  0x01, 0xFC, 0x7F, 0x00, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xBE,
  0x07, 0xFF, 0xE7, 0xC0, 0x7F, 0xF0, 0xF8, 0x00, 0x40, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x88, 0x00, 0x03, 0xF0, 0xE0, 0x01,
  0xFC, 0x1F, 0xFB, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFC, 0x00, 0x05, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x1F, 0xE0,
  0x3E, 0x3F, 0xFE, 0x0F, 0x9F, 0xFF, 0xE3, 0xEF, 0xFF, 0xFC, 0xFF, 0xE0,
  0xFF, 0x3F, 0xC0, 0x07, 0xEF, 0xE0, 0x01, 0xFB, 0xF0, 0x00, 0x3E, 0xFC,
  0x00, 0x0F, 0xBF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7C, 0x39, 0xFF, 0xFF, 0x7D, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x7D,
  0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D,
  0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF0, 0x00, 0x70,
  0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7D, 0xDF, 0xEF, 0xFE,
  0x7F, 0xF3, 0xFE, 0x07, 0x80, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x03, 0xF7, 0xC0, 0x03,
  0xF3, 0xE0, 0x03, 0xF1, 0xF0, 0x03, 0xF0, 0xF8, 0x03, 0xF0, 0x7C, 0x03,
  0xF0, 0x3E, 0x03, 0xF0, 0x1F, 0x01, 0xF0, 0x0F, 0x81, 0xF0, 0x07, 0xC1,
  0xF8, 0x03, 0xE1, 0xF8, 0x01, 0xF1, 0xF8, 0x00, 0xF9, 0xF8, 0x00, 0x7D,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x07,
  0xF3, 0xF0, 0x03, 0xF0, 0xF8, 0x01, 0xF0, 0x7E, 0x00, 0xF8, 0x1F, 0x80,
  0x7C, 0x07, 0xE0, 0x3E, 0x01, 0xF8, 0x1F, 0x00, 0xFC, 0x0F, 0x80, 0x3F,
  0x07, 0xC0, 0x0F, 0xC3, 0xE0, 0x03, 0xF1, 0xF0, 0x01, 0xF8, 0xF8, 0x00,
  0x7E, 0x7C, 0x00, 0x1F, 0xBE, 0x00, 0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF0,
  0x3F, 0xC0, 0x07, 0xFC, 0x0F, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0xF1, 0xFF,
  0xFC, 0x3F, 0xFF, 0x8F, 0x3F, 0xFF, 0xC7, 0xFF, 0xFC, 0xFF, 0xC0, 0xFE,
  0xFC, 0x1F, 0xCF, 0xF0, 0x07, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x3F, 0xC0,
  0x03, 0xEF, 0xC0, 0x01, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFF,
  0x80, 0x01, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0x80,
  0x01, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0x80, 0x01,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0x00, 0x01, 0xFF, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0xF0, 0x3F, 0xE0, 0x3C, 0x3F, 0xFE, 0x0F, 0x1F, 0xFF, 0xE3,
  0xCF, 0xFF, 0xFC, 0xFF, 0xC0, 0xFF, 0x3F, 0xC0, 0x07, 0xEF, 0xE0, 0x01,
  0xFB, 0xF0, 0x00, 0x3E, 0xFC, 0x00, 0x0F, 0xBF, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xE0, 0x7F,
  0x81, 0xF8, 0x01, 0xFC, 0x3F, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x7E, 0x7E,
  0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3F, 0x7C, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3F,
  0x7C, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x3E, 0x3F, 0x00, 0x07, 0xE1, 0xF8,
  0x00, 0xFC, 0x1F, 0xC0, 0x3F, 0x80, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x60, 0x00, 0xF0,
  0x3F, 0xC0, 0x1E, 0x1F, 0xFF, 0x03, 0xC7, 0xFF, 0xF0, 0x79, 0xFF, 0xFF,
  0x0F, 0xFC, 0x0F, 0xF1, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x07, 0xE7, 0xE0,
  0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x1F,
  0x7C, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00,
  0x0F, 0xBF, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x7E, 0xFE, 0x00, 0x1F, 0x9F,
  0xE0, 0x03, 0xF3, 0xFE, 0x01, 0xFC, 0x7F, 0xFF, 0xFF, 0x8F, 0xBF, 0xFF,
  0xE1, 0xF3, 0xFF, 0xF0, 0x3E, 0x1F, 0xFC, 0x07, 0xC0, 0x30, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x81, 0xE0, 0x7F,
  0xFC, 0x3C, 0x1F, 0xFF, 0xC7, 0x87, 0xFF, 0xFC, 0xF1, 0xFE, 0x07, 0xFE,
  0x7F, 0x00, 0x3F, 0xCF, 0xC0, 0x03, 0xF9, 0xF0, 0x00, 0x3F, 0x7E, 0x00,
  0x07, 0xEF, 0x80, 0x00, 0xFD, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xDF, 0x00, 0x01,
  0xFB, 0xF0, 0x00, 0x3F, 0x3E, 0x00, 0x0F, 0xE7, 0xE0, 0x01, 0xFC, 0x7F,
  0x00, 0xFF, 0x8F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xBE, 0x07, 0xFF, 0xE7,
  0xC0, 0x7F, 0xF0, 0xF8, 0x00, 0x40, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0xF0, 0x1F, 0xFC, 0x1F, 0xFF, 0x0F, 0xFB, 0xC7, 0xFE,
  0xF3, 0xF9, 0xBD, 0xF0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0xC3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC,
  0x7E, 0x01, 0xF3, 0xF0, 0x00, 0xCF, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x03,
  0xEF, 0x00, 0x1F, 0xBF, 0xEF, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x03,
  0xFF, 0xF0, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x7F, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0xFC,
  0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0xE0, 0xFC, 0x00, 0x07,
  0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00,
  0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC,
  0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F,
  0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00,
  0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0x1F, 0xFC, 0x00, 0x07, 0xDF, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0xFD,
  0xF0, 0x00, 0x3F, 0x7C, 0x00, 0x1F, 0xDF, 0x80, 0x07, 0xF3, 0xF0, 0x07,
  0xFC, 0xFF, 0xFF, 0xEF, 0x1F, 0xFF, 0xF3, 0xC3, 0xFF, 0xF8, 0xF0, 0x3F,
  0xF8, 0x3C, 0x00, 0x40, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F,
  0xDF, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x3E, 0x1F,
  0x00, 0x01, 0xF0, 0xFC, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0xF8, 0x1F, 0x00,
  0x07, 0xC0, 0xFC, 0x00, 0x7E, 0x03, 0xE0, 0x03, 0xE0, 0x1F, 0x00, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00,
  0x7C, 0x07, 0xC0, 0x03, 0xE0, 0x3E, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x7C,
  0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x7C, 0x7C,
  0x00, 0x03, 0xE3, 0xE0, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x7D, 0xF0, 0x00,
  0x03, 0xEF, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFE,
  0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xE7, 0xC0, 0x07, 0xF8, 0x00,
  0x7C, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0x9F, 0x00, 0x1E, 0xF0, 0x03, 0xE1,
  0xF0, 0x07, 0xDE, 0x00, 0x7C, 0x3E, 0x00, 0xFB, 0xE0, 0x0F, 0x87, 0xC0,
  0x1E, 0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xC7, 0x80, 0x7C, 0x0F, 0x80, 0xF8,
  0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xC3, 0xE0,
  0x3E, 0x07, 0xC0, 0xF8, 0x3C, 0x0F, 0x80, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x0F, 0x83, 0xC0, 0xF8, 0x3E, 0x01, 0xF0, 0xF8, 0x0F, 0x07, 0x80, 0x1F,
  0x1F, 0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xC0, 0x3E, 0x3E, 0x00, 0x7C, 0xF8,
  0x03, 0xC7, 0xC0, 0x0F, 0x9F, 0x00, 0x7C, 0xF0, 0x00, 0xF3, 0xC0, 0x0F,
  0xBE, 0x00, 0x1F, 0x78, 0x00, 0xF7, 0xC0, 0x03, 0xEF, 0x00, 0x1E, 0xF0,
  0x00, 0x3F, 0xC0, 0x03, 0xDE, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x01, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x03,
  0xF7, 0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0xF8, 0x1F,
  0x80, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0x7E, 0x07,
  0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0xF9, 0xF0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xDF, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x1F,
  0x0F, 0x80, 0x03, 0xF0, 0x7C, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xC0, 0x3F,
  0x00, 0xF8, 0x01, 0xF0, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x3E,
  0x00, 0x07, 0xC7, 0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xF0, 0xF8, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x03,
  0xE3, 0xE0, 0x00, 0x3F, 0x1F, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x1F, 0x83,
  0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x7E, 0x03, 0xE0,
  0x03, 0xE0, 0x1F, 0x80, 0x1F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x0F, 0x80, 0x7C, 0x00, 0x7C, 0x07, 0xC0, 0x03, 0xF0, 0x3E, 0x00,
  0x0F, 0x81, 0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F,
  0x87, 0x80, 0x00, 0x3C, 0x7C, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x0F, 0x9E,
  0x00, 0x00, 0x3D, 0xF0, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x67,
  0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x01, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x7F, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01,
  0xF8, 0x01, 0xFC, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xF8,
  0x00, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x0F, 0xFC, 0x01, 0xFF,
  0x00, 0x1F, 0xC0, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x00,
  0x3F, 0x00, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x03, 0xF0, 0x07, 0xFC, 0x03,
  0xF8, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x0F, 0xF0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFE, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x27, 0xFF, 0x00, 0x0D, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xA0,
  0x00, 0xFF, 0xC4, 0x00, 0x00, 0xC0,
};

const GFXglyph NotoSans_Regular57pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 7, 42, 15, 4, -41 },
  { 38, 16, 15, 23, 4, -41 },
  { 68, 34, 41, 37, 1, -41 },
  { 243, 25, 46, 33, 4, -43 },
  { 387, 42, 42, 47, 3, -41 },
  { 608, 39, 42, 42, 3, -41 },
  { 813, 5, 15, 13, 4, -41 },
  { 823, 13, 50, 17, 2, -41 },
  { 905, 13, 50, 17, 2, -41 },
  { 987, 27, 25, 31, 2, -43 },
  { 1072, 27, 28, 33, 3, -34 },
  { 1167, 9, 14, 15, 2, -7 },
  { 1183, 14, 5, 18, 2, -18 },
  { 1192, 7, 8, 15, 4, -7 },
  { 1199, 20, 41, 21, 1, -41 },
  { 1302, 27, 42, 33, 3, -41 },
  { 1444, 15, 41, 33, 5, -41 },
  { 1521, 27, 41, 33, 3, -41 },
  { 1660, 26, 42, 33, 3, -41 },
  { 1797, 30, 41, 33, 1, -41 },
  { 1951, 25, 42, 33, 4, -41 },
  { 2083, 27, 42, 33, 3, -41 },
  { 2225, 27, 41, 33, 3, -41 },
  { 2364, 27, 42, 33, 3, -41 },
  { 2506, 27, 42, 33, 3, -41 },
  { 2648, 7, 32, 15, 4, -31 },
  { 2676, 9, 38, 15, 2, -31 },
  { 2719, 27, 28, 33, 3, -35 },
  { 2814, 26, 16, 33, 3, -28 },
  { 2866, 27, 28, 33, 3, -35 },
  { 2961, 22, 42, 25, 1, -41 },
  { 3077, 45, 46, 51, 3, -41 },
  { 3336, 36, 41, 36, 0, -41 },
  { 3521, 28, 41, 37, 6, -41 },
  { 3665, 31, 42, 36, 3, -41 },
  { 3828, 32, 41, 42, 6, -41 },
  { 3992, 22, 41, 32, 6, -41 },
  { 4105, 22, 41, 30, 6, -41 },
  { 4218, 34, 42, 42, 3, -41 },
  { 4397, 31, 41, 42, 6, -41 },
  { 4556, 15, 41, 19, 2, -41 },
  { 4633, 14, 52, 16, -4, -41 },
  { 4724, 29, 41, 35, 6, -41 },
  { 4873, 22, 41, 30, 6, -41 },
  { 4986, 40, 41, 52, 6, -41 },
  { 5191, 32, 41, 43, 6, -41 },
  { 5355, 38, 42, 45, 3, -41 },
  { 5555, 26, 41, 34, 6, -41 },
  { 5689, 38, 51, 45, 3, -41 },
  { 5932, 29, 41, 35, 6, -41 },
  { 6081, 26, 42, 31, 3, -41 },
  { 6218, 30, 41, 32, 1, -41 },
  { 6372, 31, 42, 42, 5, -41 },
  { 6535, 34, 41, 34, 0, -41 },
  { 6710, 51, 41, 53, 1, -41 },
  { 6972, 33, 41, 33, 0, -41 },
  { 7142, 32, 41, 32, 0, -41 },
  { 7306, 28, 41, 33, 2, -41 },
  { 7450, 12, 50, 19, 5, -41 },
  { 7525, 20, 41, 21, 1, -41 },
  { 7628, 13, 50, 19, 1, -41 },
  { 7710, 28, 26, 33, 2, -41 },
  { 7801, 25, 4, 25, 0, 5 },
  { 7814, 12, 9, 16, 2, -44 },
  { 7828, 24, 32, 32, 3, -31 },
  { 7924, 27, 44, 35, 5, -43 },
  { 8073, 22, 32, 27, 3, -31 },
  { 8161, 27, 44, 35, 3, -43 },
  { 8310, 26, 32, 32, 3, -31 },
  { 8414, 21, 44, 20, 1, -44 },
  { 8530, 27, 45, 35, 3, -31 },
  { 8682, 26, 43, 35, 5, -43 },
  { 8822, 6, 42, 15, 4, -42 },
  { 8854, 13, 56, 15, -3, -42 },
  { 8945, 25, 43, 30, 5, -43 },
  { 9080, 5, 43, 15, 5, -43 },
  { 9107, 44, 31, 53, 5, -31 },
  { 9278, 26, 31, 35, 5, -31 },
  { 9379, 28, 32, 34, 3, -31 },
  { 9491, 27, 45, 35, 5, -31 },
  { 9643, 27, 45, 35, 3, -31 },
  { 9795, 18, 31, 24, 5, -31 },
  { 9865, 22, 32, 27, 3, -31 },
  { 9953, 18, 39, 21, 1, -38 },
  { 10041, 26, 32, 35, 4, -31 },
  { 10145, 29, 31, 29, 0, -31 },
  { 10258, 43, 31, 45, 1, -31 },
  { 10425, 28, 31, 30, 1, -31 },
  { 10534, 29, 45, 29, 0, -31 },
  { 10698, 23, 31, 27, 2, -31 },
  { 10788, 18, 50, 22, 2, -41 },
  { 10901, 4, 57, 31, 14, -43 },
  { 10930, 18, 50, 22, 2, -41 },
  { 11043, 27, 8, 33, 3, -24 },
};

const GFXfont NotoSans_Regular57pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Regular57pt7bBitmaps,
  (GFXglyph *)NotoSans_Regular57pt7bGlyphs,
  0x20, 0x7E, 78
};

#endif // _NOTOSANS_REGULAR57PT7B_H_
