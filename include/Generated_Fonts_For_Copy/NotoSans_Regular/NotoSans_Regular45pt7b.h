#ifndef _NOTOSANS_REGULAR45PT7B_H_
#define _NOTOSANS_REGULAR45PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Regular.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Regular45pt7bBitmaps[] PROGMEM = {
  0x00, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE3, 0x8E, 0x30, 0xC3, 0x00, 0x00, 0x00, 0x1E, 0xFF, 0xFF,
  0xDE, 0x30, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0x7F, 0x07, 0xF0,
  0x77, 0x07, 0x70, 0x76, 0x07, 0x60, 0x70, 0x00, 0x38, 0x0E, 0x00, 0x07,
  0x01, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x3C, 0x0E, 0x00, 0x07, 0x81, 0xC0,
  0x00, 0xE0, 0x38, 0x00, 0x1C, 0x07, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x70,
  0x38, 0x07, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF0,
  0x0E, 0x07, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0x78, 0x1C, 0x00, 0x0E, 0x03,
  0x80, 0x01, 0xC0, 0x70, 0x00, 0x38, 0x1E, 0x00, 0x07, 0x03, 0x80, 0x01,
  0xE0, 0x70, 0x0F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xE0, 0x1C, 0x0E, 0x00, 0x07, 0x81, 0xC0, 0x00, 0xE0, 0x38, 0x00, 0x1C,
  0x07, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x0E, 0x07, 0x00,
  0x03, 0xC0, 0xE0, 0x00, 0x70, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x07, 0xFF, 0x01, 0xFF, 0xFE, 0x3F, 0xFF,
  0xE7, 0xEE, 0x3C, 0xF8, 0xE0, 0x4F, 0x0E, 0x00, 0xF0, 0xE0, 0x0F, 0x0E,
  0x00, 0xF0, 0xE0, 0x0F, 0x8E, 0x00, 0x7C, 0xE0, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xEF, 0xE0,
  0x0E, 0x1F, 0x00, 0xE0, 0xF0, 0x0E, 0x0F, 0x00, 0xE0, 0xF0, 0x0E, 0x0F,
  0x80, 0xE0, 0xFE, 0x0E, 0x3E, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF,
  0x00, 0x7F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x70,
  0x0F, 0xF8, 0x00, 0x70, 0x07, 0x9E, 0x00, 0x78, 0x07, 0x87, 0x80, 0x38,
  0x03, 0x81, 0xC0, 0x3C, 0x01, 0xC0, 0xE0, 0x1C, 0x01, 0xE0, 0x70, 0x1E,
  0x00, 0xF0, 0x38, 0x0E, 0x00, 0x78, 0x1E, 0x0F, 0x00, 0x38, 0x0F, 0x07,
  0x00, 0x1C, 0x07, 0x87, 0x00, 0x0F, 0x03, 0x87, 0x80, 0x07, 0x81, 0xC3,
  0x83, 0x81, 0xC0, 0xE3, 0xC7, 0xF0, 0xE0, 0x71, 0xC7, 0xFC, 0x78, 0x79,
  0xE7, 0x8F, 0x1E, 0x78, 0xE3, 0x83, 0x8F, 0xF8, 0xF3, 0xC1, 0xE3, 0xF8,
  0x71, 0xC0, 0x70, 0x30, 0x70, 0xE0, 0x38, 0x00, 0x78, 0x70, 0x1C, 0x00,
  0x38, 0x38, 0x0E, 0x00, 0x3C, 0x1C, 0x07, 0x00, 0x1C, 0x0E, 0x03, 0x80,
  0x1E, 0x07, 0x01, 0xC0, 0x0E, 0x03, 0x80, 0xE0, 0x0F, 0x01, 0xE0, 0xF0,
  0x07, 0x00, 0x70, 0x78, 0x07, 0x00, 0x38, 0x38, 0x07, 0x80, 0x1F, 0x7C,
  0x03, 0x80, 0x07, 0xFC, 0x03, 0xC0, 0x01, 0xFC, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0xF8, 0x3E, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x07, 0x80, 0x78, 0x00,
  0x0F, 0x00, 0x70, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00,
  0x3C, 0x0F, 0x80, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0xF0, 0x7C, 0x7C, 0x03, 0xC1, 0xF0,
  0x7C, 0x07, 0x87, 0xC0, 0x7C, 0x0F, 0x0F, 0x00, 0x7C, 0x3C, 0x1E, 0x00,
  0x7C, 0x78, 0x7C, 0x00, 0x7D, 0xF0, 0xF8, 0x00, 0x7F, 0xC1, 0xF0, 0x00,
  0x7F, 0x01, 0xE0, 0x00, 0x7C, 0x03, 0xC0, 0x01, 0xFC, 0x07, 0xC0, 0x07,
  0xFC, 0x07, 0xE0, 0x7F, 0x7C, 0x0F, 0xFF, 0xFC, 0x7C, 0x0F, 0xFF, 0xE0,
  0x7C, 0x07, 0xFF, 0x00, 0x7E, 0xFF, 0xFF, 0xFF, 0xF7, 0x76, 0x60, 0x03,
  0xC1, 0xE0, 0xF0, 0x3C, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x3C, 0x1E, 0x07,
  0x81, 0xE0, 0xF8, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x81, 0xE0, 0x78, 0x1E,
  0x07, 0xC0, 0xF0, 0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x3C,
  0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x7C, 0x07,
  0x80, 0xF0, 0x1F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x78,
  0x0F, 0x03, 0xC0, 0xF0, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x03, 0x01, 0xC0,
  0xDF, 0x8E, 0x3E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xE0, 0x01,
  0xF0, 0x00, 0x1F, 0xC0, 0x01, 0xEF, 0x00, 0x1E, 0x78, 0x00, 0xF1, 0xE0,
  0x0F, 0x0F, 0x80, 0xF8, 0x3E, 0x03, 0x81, 0xE0, 0x04, 0x04, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x3E, 0x78, 0xF3,
  0xE7, 0x8F, 0x1E, 0x38, 0xF1, 0xC3, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x7B, 0xFF, 0xFF, 0x78, 0xC0, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78,
  0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0x00, 0x70,
  0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x1F, 0x03, 0xE0,
  0xF8, 0x07, 0x83, 0xC0, 0x0F, 0x1E, 0x00, 0x3C, 0x78, 0x00, 0x79, 0xE0,
  0x01, 0xE7, 0x80, 0x07, 0x9C, 0x00, 0x1E, 0xF0, 0x00, 0x7B, 0xC0, 0x01,
  0xEF, 0x00, 0x07, 0xBC, 0x00, 0x1E, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x1E, 0xF0, 0x00, 0x7B, 0xC0, 0x01, 0xE7, 0x00,
  0x07, 0x9E, 0x00, 0x1E, 0x78, 0x00, 0x79, 0xE0, 0x03, 0xE3, 0xC0, 0x0F,
  0x0F, 0x00, 0x3C, 0x3E, 0x01, 0xE0, 0x7C, 0x1F, 0x80, 0xFF, 0xFC, 0x01,
  0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x00, 0xF0, 0x1F, 0x07, 0xF0, 0xFF, 0x1F,
  0xF7, 0xEF, 0xF8, 0xF7, 0x0F, 0x60, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x60, 0x00, 0x3F, 0xF8, 0x07, 0xFF,
  0xE0, 0xFF, 0xFF, 0x87, 0xE0, 0x7E, 0x1C, 0x00, 0xF0, 0x80, 0x07, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x70, 0x00, 0x7F,
  0xF8, 0x0F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xC0, 0x3E, 0x38, 0x00, 0xF8,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00,
  0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF8, 0x00, 0x1F,
  0x78, 0x03, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0E, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3D, 0xE0, 0x00, 0x39, 0xE0, 0x00,
  0x79, 0xE0, 0x00, 0xF1, 0xE0, 0x01, 0xE1, 0xE0, 0x01, 0xE1, 0xE0, 0x03,
  0xC1, 0xE0, 0x07, 0x81, 0xE0, 0x07, 0x01, 0xE0, 0x0F, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1C, 0x01, 0xE0, 0x3C, 0x01, 0xE0, 0x78, 0x01, 0xE0, 0x70,
  0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x3F,
  0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x73, 0xF0, 0x07, 0xFF, 0xE0, 0x7F, 0xFF,
  0x87, 0xFF, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE8, 0x00, 0x3E, 0xF0, 0x0F, 0xCF,
  0xFF, 0xF8, 0xFF, 0xFF, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0x80, 0x01, 0xFF,
  0x80, 0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE1, 0xFC, 0x07, 0x9F, 0xFC,
  0x1E, 0xFF, 0xF8, 0x77, 0x83, 0xF3, 0xF8, 0x03, 0xEF, 0xC0, 0x07, 0xBE,
  0x00, 0x1E, 0xF8, 0x00, 0x79, 0xE0, 0x00, 0xF7, 0x00, 0x03, 0xDE, 0x00,
  0x0F, 0x78, 0x00, 0x3D, 0xE0, 0x01, 0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x1E,
  0x1E, 0x00, 0xF0, 0x7E, 0x0F, 0xC0, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x01,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x1F, 0xF8, 0x03,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC3, 0xE0, 0x3F, 0x1E, 0x00, 0x79, 0xE0, 0x03,
  0xCF, 0x00, 0x1E, 0x78, 0x00, 0x73, 0xC0, 0x07, 0x8F, 0x00, 0x3C, 0x78,
  0x03, 0xE1, 0xE0, 0x3E, 0x0F, 0xC3, 0xE0, 0x3F, 0xFE, 0x00, 0x7F, 0xC0,
  0x03, 0xFE, 0x00, 0x3F, 0xFC, 0x07, 0xE3, 0xF0, 0x7C, 0x07, 0xC7, 0xC0,
  0x1F, 0x3C, 0x00, 0x7F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x1E, 0xF0, 0x00, 0xF7, 0x80, 0x0F, 0xBF, 0x00,
  0xF8, 0xFF, 0xFF, 0x83, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x00, 0x20, 0x00,
  0x1F, 0xF0, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xE0, 0x3E, 0x3E, 0x00,
  0xF1, 0xE0, 0x03, 0xCF, 0x00, 0x1E, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3D, 0xE0, 0x01,
  0xEF, 0x00, 0x1F, 0x7C, 0x01, 0xF9, 0xF8, 0x3F, 0xC7, 0xFF, 0xDE, 0x1F,
  0xFC, 0xF0, 0x3F, 0x87, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x0F, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xF8, 0x00,
  0x31, 0xEF, 0xFF, 0xFD, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7B, 0xFF, 0xFF, 0x78, 0xC0, 0x0C, 0x3E, 0x3F, 0x3F,
  0x3F, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1E, 0x3E, 0x3E, 0x3C, 0x3C, 0x3C, 0x78, 0x78,
  0x70, 0x70, 0xF0, 0x00, 0x00, 0x08, 0x00, 0x01, 0xC0, 0x00, 0x3E, 0x00,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x03, 0x80, 0x00,
  0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x01, 0xF0, 0x00, 0x0E,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0xC0, 0x1F, 0xFC, 0x3F, 0xFF, 0x9F,
  0xFF, 0xEF, 0x01, 0xFA, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x07, 0x80, 0x01, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x0F, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x03, 0x87, 0x00, 0x7F,
  0xE0, 0x79, 0xE0, 0x3F, 0xFE, 0x07, 0x38, 0x0F, 0xEF, 0xC0, 0xE7, 0x03,
  0xE0, 0x78, 0x1F, 0xE0, 0x78, 0x0F, 0x01, 0xF8, 0x1E, 0x01, 0xE0, 0x3F,
  0x03, 0xC0, 0x3C, 0x07, 0xE0, 0x70, 0x07, 0x80, 0xFC, 0x0E, 0x00, 0xF0,
  0x1F, 0x81, 0xC0, 0x1E, 0x07, 0xF0, 0x38, 0x03, 0xC0, 0xEE, 0x07, 0x00,
  0x78, 0x1D, 0xC0, 0xE0, 0x1F, 0x03, 0xB8, 0x1E, 0x03, 0xE0, 0xE7, 0x01,
  0xE0, 0xFC, 0x3C, 0xF0, 0x3F, 0xF9, 0xFF, 0x1E, 0x03, 0xFE, 0x3F, 0xC1,
  0xC0, 0x1F, 0x81, 0xF0, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x02, 0x00, 0x07, 0xF0, 0x07, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x07, 0x3C,
  0x00, 0x00, 0x78, 0xF0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x3C, 0x3C, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0x1E, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0x78, 0x07, 0x80, 0x03, 0xC0, 0x1E, 0x00, 0x1E, 0x00,
  0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xC0, 0x3C, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0xF0, 0x1E,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0xF8, 0x78, 0x00,
  0x03, 0xC7, 0x80, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x03,
  0xDE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xC7, 0x80, 0x7F, 0xCF, 0x00, 0x0F, 0x9E, 0x00, 0x0F, 0x3C, 0x00, 0x1F,
  0x78, 0x00, 0x1E, 0xF0, 0x00, 0x3D, 0xE0, 0x00, 0xFB, 0xC0, 0x01, 0xE7,
  0x80, 0x03, 0xCF, 0x00, 0x0F, 0x1E, 0x03, 0xFC, 0x3F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF1, 0xE0, 0x03, 0xF3, 0xC0, 0x01, 0xF7, 0x80,
  0x01, 0xEF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7B, 0xC0, 0x01, 0xF7, 0x80, 0x07,
  0xEF, 0x00, 0xFF, 0x9F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xFF, 0x07, 0xFF, 0xFE,
  0x0F, 0xF0, 0x1E, 0x1F, 0x80, 0x02, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xF0, 0x1E, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFE,
  0x00, 0xFF, 0xFC, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x03, 0xC0, 0x7F, 0xE0, 0xF0, 0x00, 0xFC, 0x3C, 0x00, 0x0F, 0x8F, 0x00,
  0x01, 0xF3, 0xC0, 0x00, 0x3C, 0xF0, 0x00, 0x0F, 0xBC, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x3E, 0xF0, 0x00, 0x1F,
  0x3C, 0x00, 0x0F, 0xCF, 0x00, 0x07, 0xE3, 0xC0, 0x07, 0xF0, 0xF0, 0x7F,
  0xF8, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xFF, 0xFE, 0xFF,
  0xFF, 0xBF, 0xFF, 0xEF, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE,
  0x07, 0xF0, 0x0F, 0x83, 0xF0, 0x00, 0x21, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F,
  0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3D, 0xE0, 0x00, 0x0F, 0x7C, 0x00, 0x03, 0xDF, 0x00, 0x00, 0xF3,
  0xE0, 0x00, 0x3C, 0x7C, 0x00, 0x0F, 0x1F, 0x80, 0x03, 0xC3, 0xFC, 0x01,
  0xF0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFD, 0xFF, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x03, 0xEF, 0xFE, 0xFF, 0xCF, 0xF0, 0x10,
  0x00, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0xF8, 0xF0, 0x01,
  0xF0, 0xF0, 0x03, 0xE0, 0xF0, 0x03, 0xC0, 0xF0, 0x07, 0x80, 0xF0, 0x0F,
  0x00, 0xF0, 0x1F, 0x00, 0xF0, 0x3E, 0x00, 0xF0, 0x7C, 0x00, 0xF0, 0xF8,
  0x00, 0xF1, 0xF0, 0x00, 0xF3, 0xE0, 0x00, 0xF7, 0xE0, 0x00, 0xF7, 0xF0,
  0x00, 0xFF, 0xF8, 0x00, 0xFE, 0xF8, 0x00, 0xFC, 0x7C, 0x00, 0xF0, 0x3E,
  0x00, 0xF0, 0x1E, 0x00, 0xF0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0xF0, 0x07,
  0xC0, 0xF0, 0x03, 0xC0, 0xF0, 0x03, 0xE0, 0xF0, 0x01, 0xF0, 0xF0, 0x00,
  0xF8, 0xF0, 0x00, 0xF8, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x3E, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x77, 0xF7, 0x00, 0x00,
  0xF7, 0xF7, 0x80, 0x00, 0xF7, 0xF7, 0x80, 0x00, 0xE7, 0xF3, 0xC0, 0x01,
  0xEF, 0xF3, 0xC0, 0x01, 0xCF, 0xF3, 0xC0, 0x03, 0xCF, 0xF1, 0xE0, 0x03,
  0xCF, 0xF1, 0xE0, 0x03, 0x8F, 0xF0, 0xE0, 0x07, 0x8F, 0xF0, 0xF0, 0x07,
  0x8F, 0xF0, 0xF0, 0x07, 0x0F, 0xF0, 0x78, 0x0F, 0x0F, 0xF0, 0x78, 0x0E,
  0x0F, 0xF0, 0x78, 0x1E, 0x0F, 0xF0, 0x3C, 0x1E, 0x0F, 0xF0, 0x3C, 0x1C,
  0x0F, 0xF0, 0x1C, 0x3C, 0x0F, 0xF0, 0x1E, 0x3C, 0x0F, 0xF0, 0x1E, 0x78,
  0x0F, 0xF0, 0x0F, 0x78, 0x0F, 0xF0, 0x0F, 0x70, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x07, 0xE0, 0x0F, 0xF0, 0x03, 0xE0,
  0x0F, 0xF0, 0x03, 0xC0, 0x0F, 0xF0, 0x03, 0xC0, 0x0F, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0xFF, 0x78, 0x00, 0x3F, 0xDF, 0x00, 0x0F, 0xF3,
  0xE0, 0x03, 0xFC, 0x78, 0x00, 0xFF, 0x1F, 0x00, 0x3F, 0xC3, 0xE0, 0x0F,
  0xF0, 0x78, 0x03, 0xFC, 0x1F, 0x00, 0xFF, 0x03, 0xC0, 0x3F, 0xC0, 0xF8,
  0x0F, 0xF0, 0x1F, 0x03, 0xFC, 0x03, 0xC0, 0xFF, 0x00, 0xF8, 0x3F, 0xC0,
  0x1F, 0x0F, 0xF0, 0x03, 0xC3, 0xFC, 0x00, 0xF8, 0xFF, 0x00, 0x1F, 0x3F,
  0xC0, 0x03, 0xCF, 0xF0, 0x00, 0xFB, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFE, 0x03, 0xF8, 0x0F,
  0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x3C, 0x7C, 0x00,
  0x01, 0xF3, 0xC0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0xF3,
  0xE0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x78, 0x7E, 0x00, 0x07, 0xC1, 0xF8,
  0x00, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF1, 0xE0, 0x7F, 0xCF, 0x00, 0x3F, 0x78, 0x00, 0xFB, 0xC0, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x0F, 0x78, 0x00, 0x7B, 0xC0, 0x07, 0xDE, 0x01, 0xFC, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0x81, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFE, 0x03, 0xF8, 0x0F,
  0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x3C, 0x7C, 0x00,
  0x01, 0xF3, 0xC0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0xF3,
  0xE0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x78, 0x7E, 0x00, 0x07, 0xC1, 0xF8,
  0x00, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0x80, 0xFF, 0x0F, 0x00, 0x3F,
  0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x3E, 0x78, 0x00, 0x3C, 0xF0, 0x00, 0x79,
  0xE0, 0x00, 0xF3, 0xC0, 0x01, 0xE7, 0x80, 0x07, 0xCF, 0x00, 0x0F, 0x1E,
  0x00, 0x3E, 0x3C, 0x00, 0xF8, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x81, 0xFF,
  0xFC, 0x03, 0xFF, 0xF8, 0x07, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x1E, 0x01,
  0xF0, 0x3C, 0x01, 0xE0, 0x78, 0x01, 0xE0, 0xF0, 0x03, 0xE1, 0xE0, 0x03,
  0xC3, 0xC0, 0x07, 0xC7, 0x80, 0x07, 0xCF, 0x00, 0x07, 0x9E, 0x00, 0x0F,
  0xBC, 0x00, 0x0F, 0x78, 0x00, 0x1F, 0x00, 0x38, 0x00, 0x3F, 0xFE, 0x03,
  0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xF0, 0x1E, 0x3E, 0x00, 0x11, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78,
  0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE8, 0x00, 0x1F, 0x7C, 0x03,
  0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0x78, 0x00, 0x0F, 0x3C, 0x00, 0x07, 0x9F, 0x00,
  0x07, 0xC7, 0xC0, 0x07, 0xC1, 0xF8, 0x0F, 0xC0, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xC0, 0x03, 0xFF, 0x80, 0xF0, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x79,
  0xE0, 0x00, 0x0F, 0x3E, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x78, 0x78, 0x00,
  0x0F, 0x0F, 0x80, 0x03, 0xE0, 0xF0, 0x00, 0x78, 0x1E, 0x00, 0x0F, 0x03,
  0xE0, 0x03, 0xE0, 0x3C, 0x00, 0x78, 0x07, 0x80, 0x0F, 0x00, 0x78, 0x03,
  0xE0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x1E, 0x03, 0xC0, 0x03,
  0xC0, 0x78, 0x00, 0x78, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0x78,
  0x00, 0x1E, 0x1F, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x3C, 0x78, 0x00, 0x07,
  0x8F, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x0F, 0x78, 0x00, 0x00, 0xEF, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0xF0, 0x00,
  0x7C, 0x00, 0x0F, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x78, 0x00, 0x7E, 0x00,
  0x1E, 0x78, 0x00, 0xFE, 0x00, 0x1E, 0x78, 0x00, 0xFF, 0x00, 0x1E, 0x78,
  0x00, 0xEF, 0x00, 0x3E, 0x3C, 0x01, 0xEF, 0x00, 0x3C, 0x3C, 0x01, 0xE7,
  0x00, 0x3C, 0x3C, 0x01, 0xE7, 0x80, 0x3C, 0x3C, 0x01, 0xC7, 0x80, 0x78,
  0x1E, 0x03, 0xC3, 0x80, 0x78, 0x1E, 0x03, 0xC3, 0xC0, 0x78, 0x1E, 0x03,
  0xC3, 0xC0, 0x78, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x0F, 0x07, 0x81, 0xE0,
  0xF0, 0x0F, 0x07, 0x81, 0xE0, 0xF0, 0x0F, 0x0F, 0x01, 0xE0, 0xF0, 0x0F,
  0x8F, 0x00, 0xE1, 0xE0, 0x07, 0x8F, 0x00, 0xF1, 0xE0, 0x07, 0x8E, 0x00,
  0xF1, 0xE0, 0x07, 0x9E, 0x00, 0xF1, 0xE0, 0x03, 0x9E, 0x00, 0x7B, 0xC0,
  0x03, 0xDE, 0x00, 0x7B, 0xC0, 0x03, 0xDC, 0x00, 0x7B, 0xC0, 0x03, 0xDC,
  0x00, 0x3B, 0x80, 0x01, 0xFC, 0x00, 0x3B, 0x80, 0x01, 0xF8, 0x00, 0x3F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x07,
  0x8F, 0x00, 0x03, 0xC1, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x78, 0x0F, 0x00,
  0x3C, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x07, 0x80, 0x0F, 0x03, 0xC0, 0x03,
  0xE0, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x0F, 0x3E, 0x00, 0x03, 0xEF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xCF, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x78, 0x7C, 0x00, 0x3C, 0x0F, 0x00,
  0x0F, 0x03, 0xE0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0xF0, 0x03,
  0xE0, 0x78, 0x00, 0x78, 0x3E, 0x00, 0x1F, 0x0F, 0x00, 0x03, 0xE7, 0x80,
  0x00, 0x7B, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xBC, 0x00, 0x07, 0xDF,
  0x00, 0x03, 0xC7, 0x80, 0x03, 0xE3, 0xE0, 0x01, 0xE0, 0xF0, 0x01, 0xE0,
  0x3C, 0x00, 0xF0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x78,
  0x00, 0xF0, 0x7C, 0x00, 0x7C, 0x3C, 0x00, 0x1E, 0x3E, 0x00, 0x0F, 0x9E,
  0x00, 0x03, 0xDF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xFF, 0xFF,
  0xFF, 0xFC, 0xF8, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x1C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x70, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xDC, 0x00, 0x0F, 0x78, 0x00,
  0x38, 0xE0, 0x00, 0xE3, 0xC0, 0x07, 0x07, 0x00, 0x1C, 0x1E, 0x00, 0xE0,
  0x38, 0x03, 0x80, 0xF0, 0x1E, 0x01, 0xC0, 0x70, 0x07, 0x83, 0xC0, 0x0E,
  0x0E, 0x00, 0x3C, 0x78, 0x00, 0x71, 0xC0, 0x01, 0xEF, 0x00, 0x03, 0xB8,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x3E,
  0x0F, 0x03, 0xC0, 0xF0, 0x38, 0x0E, 0x00, 0x20, 0x00, 0x7F, 0xF0, 0x1F,
  0xFF, 0xC1, 0xFF, 0xFC, 0x0C, 0x03, 0xE1, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x3F, 0xFF,
  0x1F, 0xFF, 0xF3, 0xFE, 0x0F, 0x7C, 0x00, 0xF7, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x03, 0xF7, 0xC0,
  0xFF, 0x7F, 0xFE, 0xF3, 0xFF, 0xCF, 0x1F, 0xF8, 0x70, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x80, 0x3C,
  0x7F, 0xC1, 0xEF, 0xFF, 0x0F, 0xFF, 0xFC, 0x7F, 0x01, 0xF3, 0xF0, 0x07,
  0xDF, 0x00, 0x1E, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x01, 0xEF, 0x80,
  0x0F, 0x7E, 0x00, 0xFB, 0xF8, 0x0F, 0x9D, 0xFF, 0xF8, 0xE7, 0xFF, 0x87,
  0x0F, 0xF8, 0x00, 0x00, 0x10, 0x00, 0x7F, 0xF0, 0x7F, 0xFC, 0x3F, 0xFE,
  0x1F, 0x81, 0x8F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xE0, 0x70, 0xFF, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x01, 0x80, 0xF0, 0x3F, 0xE3, 0xC3, 0xFF, 0xEF, 0x1F, 0xFF, 0xFC,
  0xFC, 0x07, 0xF3, 0xE0, 0x0F, 0xDF, 0x00, 0x1F, 0x7C, 0x00, 0x7D, 0xE0,
  0x01, 0xF7, 0x80, 0x03, 0xDE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0x78, 0x00, 0x3D, 0xE0, 0x00, 0xF7,
  0x80, 0x03, 0xDE, 0x00, 0x1F, 0x7C, 0x00, 0x7C, 0xF8, 0x03, 0xF1, 0xF0,
  0x1F, 0xC7, 0xFF, 0xEF, 0x0F, 0xFF, 0x3C, 0x0F, 0xF8, 0x70, 0x00, 0x10,
  0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0xC1, 0xF0, 0x3E, 0x1F,
  0x00, 0xF8, 0xF0, 0x03, 0xCF, 0x00, 0x1F, 0x78, 0x00, 0x7B, 0xC0, 0x03,
  0xDE, 0x00, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xE0, 0x01, 0x0F, 0xC0, 0x38, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFE, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x07, 0xC0,
  0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x3F, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x00, 0x20, 0x00, 0x0F, 0xF8, 0x70, 0xFF, 0xF3, 0xC7, 0xFF, 0xEF, 0x1F,
  0x03, 0xFC, 0xF8, 0x03, 0xF3, 0xC0, 0x07, 0xDF, 0x00, 0x1F, 0x78, 0x00,
  0x7D, 0xE0, 0x00, 0xF7, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0xF7, 0x80, 0x03, 0xDE, 0x00, 0x0F, 0x78, 0x00, 0x3D, 0xE0,
  0x00, 0xF7, 0x80, 0x07, 0xCF, 0x00, 0x1F, 0x3E, 0x00, 0xFC, 0x7C, 0x07,
  0xF1, 0xFF, 0xFB, 0xC3, 0xFF, 0xCF, 0x03, 0xFE, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x8C, 0x00, 0x7C, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x81, 0xFF, 0xF8,
  0x00, 0x7F, 0x80, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x01, 0x00, 0xF1, 0xFF, 0x0F, 0x7F, 0xFC, 0xFF, 0xFF, 0xEF,
  0xE0, 0x3E, 0xFC, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x1E, 0xDF,
  0xBF, 0xCF, 0xF3, 0xE0, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x03, 0xEF, 0x00, 0x78, 0xF0, 0x0F,
  0x0F, 0x01, 0xF0, 0xF0, 0x3E, 0x0F, 0x07, 0xC0, 0xF0, 0xF8, 0x0F, 0x1F,
  0x00, 0xF3, 0xE0, 0x0F, 0x7C, 0x00, 0xF7, 0x80, 0x0F, 0xFC, 0x00, 0xFF,
  0xE0, 0x0F, 0xDF, 0x00, 0xF0, 0xF0, 0x0F, 0x07, 0x80, 0xF0, 0x7C, 0x0F,
  0x03, 0xE0, 0xF0, 0x1E, 0x0F, 0x01, 0xF0, 0xF0, 0x0F, 0x8F, 0x00, 0x7C,
  0xF0, 0x03, 0xEF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x30,
  0x00, 0x30, 0x38, 0x7F, 0xC0, 0xFF, 0x8E, 0x7F, 0xF8, 0xFF, 0xF3, 0xBF,
  0xFF, 0x7F, 0xFE, 0xFE, 0x07, 0xFC, 0x0F, 0xFF, 0x00, 0xFE, 0x00, 0xFF,
  0x80, 0x1F, 0x00, 0x3F, 0xC0, 0x07, 0xC0, 0x0F, 0xF0, 0x01, 0xE0, 0x03,
  0xFC, 0x00, 0x78, 0x00, 0x7F, 0x00, 0x1E, 0x00, 0x1F, 0xC0, 0x07, 0x80,
  0x07, 0xF0, 0x01, 0xE0, 0x01, 0xFC, 0x00, 0x78, 0x00, 0x7F, 0x00, 0x1E,
  0x00, 0x1F, 0xC0, 0x07, 0x80, 0x07, 0xF0, 0x01, 0xE0, 0x01, 0xFC, 0x00,
  0x78, 0x00, 0x7F, 0x00, 0x1E, 0x00, 0x1F, 0xC0, 0x07, 0x80, 0x07, 0xF0,
  0x01, 0xE0, 0x01, 0xFC, 0x00, 0x78, 0x00, 0x7F, 0x00, 0x1E, 0x00, 0x1F,
  0xC0, 0x07, 0x80, 0x07, 0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x00, 0x30, 0x0E,
  0x1F, 0xF0, 0xE7, 0xFF, 0xCE, 0xFF, 0xFE, 0xFE, 0x03, 0xEF, 0xC0, 0x1F,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xF0,
  0x00, 0x30, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x01,
  0xF0, 0x1F, 0x07, 0xC0, 0x1F, 0x0F, 0x00, 0x1F, 0x3E, 0x00, 0x1E, 0x78,
  0x00, 0x3C, 0xF0, 0x00, 0x79, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x03, 0xDE, 0x00, 0x07, 0xBC, 0x00, 0x0F, 0x78, 0x00,
  0x3C, 0xF0, 0x00, 0x79, 0xF0, 0x00, 0xF1, 0xE0, 0x03, 0xC3, 0xE0, 0x0F,
  0x83, 0xE0, 0x3E, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0x80,
  0x00, 0x30, 0x07, 0x0F, 0xF8, 0x39, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0xE0,
  0x3E, 0x7E, 0x00, 0xFB, 0xE0, 0x03, 0xDE, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xFE,
  0x00, 0x3D, 0xF0, 0x01, 0xEF, 0xC0, 0x1F, 0x7F, 0x01, 0xF3, 0xFF, 0xFF,
  0x1E, 0xFF, 0xF0, 0xF1, 0xFF, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x0F, 0xF8, 0x70, 0xFF, 0xF3, 0xC7, 0xFF, 0xEF, 0x1F, 0x01,
  0xFC, 0xF8, 0x03, 0xF3, 0xC0, 0x07, 0xDF, 0x00, 0x1F, 0x78, 0x00, 0x7D,
  0xE0, 0x00, 0xF7, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x80, 0x03, 0xDE, 0x00, 0x0F, 0x78, 0x00, 0x3D, 0xE0, 0x01,
  0xF7, 0x80, 0x07, 0xDF, 0x00, 0x1F, 0x3E, 0x00, 0xFC, 0x7C, 0x07, 0xF1,
  0xFF, 0xFB, 0xC3, 0xFF, 0xCF, 0x03, 0xFE, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x3B, 0x87, 0xFE, 0x3F, 0xF9, 0xFF, 0xEF, 0x83, 0xF8,
  0x0F, 0xC0, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x00, 0x40,
  0x03, 0xFF, 0xC3, 0xFF, 0xF9, 0xFF, 0xFC, 0x78, 0x03, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF8, 0x00, 0x7F,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0E, 0x80, 0x07, 0xB8, 0x03, 0xEF,
  0xFF, 0xF3, 0xFF, 0xF8, 0x3F, 0xF8, 0x00, 0x06, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x1E, 0x00, 0x78, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xFF, 0x07, 0xFC, 0x0F, 0xF0,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x80, 0x3F, 0xFC, 0x0F, 0xF7, 0xFF, 0xFF, 0x3F, 0xFE, 0xF1, 0xFF, 0x87,
  0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x79, 0xE0, 0x00, 0xF3, 0xE0, 0x03, 0xE3,
  0xC0, 0x07, 0x87, 0x80, 0x0F, 0x07, 0x80, 0x3C, 0x0F, 0x00, 0x78, 0x1E,
  0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x1E, 0x00, 0x78,
  0x3C, 0x00, 0xF0, 0x78, 0x00, 0xF1, 0xE0, 0x01, 0xE3, 0xC0, 0x03, 0xC7,
  0x80, 0x03, 0xDE, 0x00, 0x07, 0xBC, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0,
  0x01, 0xEF, 0x00, 0x3E, 0x00, 0x79, 0xE0, 0x07, 0xE0, 0x0F, 0x1E, 0x01,
  0xFC, 0x01, 0xE3, 0xC0, 0x3B, 0x80, 0x3C, 0x78, 0x07, 0x78, 0x0F, 0x0F,
  0x01, 0xEF, 0x01, 0xE0, 0xF0, 0x3C, 0xE0, 0x3C, 0x1E, 0x07, 0x9E, 0x07,
  0x03, 0xC0, 0xE3, 0xC1, 0xE0, 0x78, 0x3C, 0x78, 0x3C, 0x07, 0x87, 0x87,
  0x07, 0x80, 0xF0, 0xE0, 0xF1, 0xE0, 0x1E, 0x3C, 0x1E, 0x3C, 0x01, 0xC7,
  0x81, 0xC7, 0x80, 0x3C, 0xE0, 0x3C, 0xF0, 0x07, 0xBC, 0x07, 0xBC, 0x00,
  0xF7, 0x80, 0x77, 0x80, 0x0E, 0xE0, 0x0E, 0xF0, 0x01, 0xDC, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x3F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x7C, 0x00,
  0x7E, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0xF8, 0x00, 0x7D, 0xF0, 0x03, 0xC3,
  0xE0, 0x1F, 0x07, 0x80, 0x78, 0x1F, 0x03, 0xC0, 0x3E, 0x1F, 0x00, 0x78,
  0x78, 0x00, 0xF3, 0xC0, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0xF3, 0xC0, 0x07, 0x8F, 0x80, 0x3E, 0x1E, 0x00, 0xF0, 0x3C, 0x07, 0x80,
  0xF8, 0x3E, 0x01, 0xF0, 0xF0, 0x03, 0xC7, 0x80, 0x0F, 0xBE, 0x00, 0x1F,
  0xF8, 0x00, 0x3E, 0xF0, 0x00, 0x79, 0xE0, 0x00, 0xF1, 0xE0, 0x03, 0xE3,
  0xC0, 0x07, 0x87, 0x80, 0x0F, 0x07, 0x80, 0x3C, 0x0F, 0x00, 0x78, 0x1F,
  0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x3C, 0x1F, 0x00, 0x78,
  0x3C, 0x00, 0x70, 0x78, 0x00, 0xF1, 0xE0, 0x01, 0xE3, 0xC0, 0x01, 0xC7,
  0x80, 0x03, 0xDE, 0x00, 0x03, 0xBC, 0x00, 0x07, 0x78, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x67, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFE,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xE0,
  0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x01, 0xFC,
  0x07, 0xF8, 0x0F, 0x80, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x03, 0xC0, 0x07, 0x80, 0x7E, 0x03, 0xF8, 0x07, 0xC0, 0x0F, 0xE0, 0x03,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x1F, 0xE0, 0x1F, 0xC0, 0x07, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xF8, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0xFC, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03,
  0xF0, 0x03, 0xF8, 0x01, 0xF0, 0x0F, 0xE0, 0x3E, 0x00, 0xF0, 0x01, 0xE0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0xFC, 0x0F, 0xF0,
  0x1F, 0xC0, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x0B, 0xFF, 0x00, 0x7F, 0xFF,
  0x0F, 0xF7, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x07, 0xF0,
};

const GFXglyph NotoSans_Regular45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 6, 33, 12, 3, -32 },
  { 26, 12, 11, 18, 3, -32 },
  { 43, 27, 32, 29, 1, -32 },
  { 151, 20, 37, 26, 3, -34 },
  { 244, 33, 33, 37, 2, -33 },
  { 381, 31, 33, 33, 2, -33 },
  { 509, 4, 11, 10, 3, -32 },
  { 515, 10, 39, 14, 2, -32 },
  { 564, 11, 39, 14, 1, -32 },
  { 618, 21, 20, 25, 2, -34 },
  { 671, 21, 22, 26, 2, -27 },
  { 729, 7, 11, 12, 2, -5 },
  { 739, 11, 4, 14, 2, -14 },
  { 745, 6, 6, 12, 3, -5 },
  { 750, 16, 32, 17, 0, -32 },
  { 814, 22, 33, 26, 2, -33 },
  { 905, 12, 32, 26, 4, -32 },
  { 953, 21, 33, 26, 2, -33 },
  { 1040, 21, 33, 26, 2, -33 },
  { 1127, 24, 32, 26, 1, -32 },
  { 1223, 20, 32, 26, 3, -32 },
  { 1303, 22, 33, 26, 2, -33 },
  { 1394, 22, 32, 26, 2, -32 },
  { 1482, 21, 33, 26, 2, -33 },
  { 1569, 21, 33, 26, 2, -33 },
  { 1656, 6, 26, 12, 3, -25 },
  { 1676, 8, 31, 12, 1, -25 },
  { 1707, 21, 22, 26, 2, -27 },
  { 1765, 20, 12, 26, 3, -22 },
  { 1795, 21, 22, 26, 2, -27 },
  { 1853, 17, 34, 20, 1, -33 },
  { 1926, 35, 36, 40, 3, -32 },
  { 2084, 29, 32, 29, 0, -32 },
  { 2200, 23, 32, 29, 4, -32 },
  { 2292, 24, 33, 28, 3, -33 },
  { 2391, 26, 32, 33, 4, -32 },
  { 2495, 18, 32, 25, 4, -32 },
  { 2567, 18, 32, 23, 4, -32 },
  { 2639, 26, 33, 33, 3, -33 },
  { 2747, 25, 32, 33, 4, -32 },
  { 2847, 11, 32, 15, 2, -32 },
  { 2891, 12, 41, 12, -4, -32 },
  { 2953, 24, 32, 28, 4, -32 },
  { 3049, 18, 32, 24, 4, -32 },
  { 3121, 32, 32, 41, 4, -32 },
  { 3249, 26, 32, 34, 4, -32 },
  { 3353, 29, 33, 35, 3, -33 },
  { 3473, 21, 32, 27, 4, -32 },
  { 3557, 29, 41, 35, 3, -33 },
  { 3706, 23, 32, 28, 4, -32 },
  { 3798, 21, 33, 25, 2, -33 },
  { 3885, 25, 32, 25, 0, -32 },
  { 3985, 25, 32, 33, 4, -32 },
  { 4085, 27, 32, 27, 0, -32 },
  { 4193, 40, 32, 42, 1, -32 },
  { 4353, 26, 32, 26, 0, -32 },
  { 4457, 25, 32, 25, 0, -32 },
  { 4557, 22, 32, 26, 2, -32 },
  { 4645, 10, 39, 15, 4, -32 },
  { 4694, 16, 32, 17, 0, -32 },
  { 4758, 10, 39, 15, 1, -32 },
  { 4807, 22, 20, 26, 2, -32 },
  { 4862, 20, 3, 20, 0, 4 },
  { 4870, 9, 7, 13, 2, -34 },
  { 4878, 20, 25, 25, 2, -25 },
  { 4941, 21, 34, 28, 4, -34 },
  { 5031, 18, 25, 22, 2, -25 },
  { 5088, 22, 34, 28, 2, -34 },
  { 5182, 21, 25, 25, 2, -25 },
  { 5248, 16, 34, 15, 1, -34 },
  { 5316, 22, 36, 28, 2, -25 },
  { 5415, 20, 34, 28, 4, -34 },
  { 5500, 4, 33, 12, 4, -33 },
  { 5517, 10, 44, 12, -2, -33 },
  { 5572, 20, 34, 24, 4, -34 },
  { 5657, 4, 34, 12, 4, -34 },
  { 5674, 34, 25, 42, 4, -25 },
  { 5781, 20, 25, 28, 4, -25 },
  { 5844, 23, 25, 27, 2, -25 },
  { 5916, 21, 36, 28, 4, -25 },
  { 6011, 22, 36, 28, 2, -25 },
  { 6110, 14, 25, 19, 4, -25 },
  { 6154, 18, 25, 22, 2, -25 },
  { 6211, 14, 30, 16, 1, -30 },
  { 6264, 20, 24, 28, 4, -24 },
  { 6324, 23, 24, 23, 0, -24 },
  { 6393, 35, 24, 35, 0, -24 },
  { 6498, 22, 24, 24, 1, -24 },
  { 6564, 23, 35, 23, 0, -24 },
  { 6665, 17, 24, 21, 2, -24 },
  { 6716, 15, 39, 17, 1, -32 },
  { 6790, 3, 45, 25, 11, -34 },
  { 6807, 15, 39, 17, 1, -32 },
  { 6881, 21, 6, 26, 2, -19 },
};

const GFXfont NotoSans_Regular45pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Regular45pt7bBitmaps,
  (GFXglyph *)NotoSans_Regular45pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _NOTOSANS_REGULAR45PT7B_H_
