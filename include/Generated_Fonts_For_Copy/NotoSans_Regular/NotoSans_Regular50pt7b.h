#ifndef _NOTOSANS_REGULAR50PT7B_H_
#define _NOTOSANS_REGULAR50PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Regular.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Regular50pt7bBitmaps[] PROGMEM = {
  0x00, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xF9, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x9C, 0x71, 0xC7, 0x1C, 0x71, 0xC0, 0x00, 0x00, 0x07,
  0xBE, 0xFF, 0xFF, 0xFE, 0x70, 0xF8, 0x7F, 0xE1, 0xFF, 0x83, 0xDE, 0x0F,
  0x78, 0x3D, 0xE0, 0xF7, 0x83, 0xDC, 0x0F, 0x70, 0x3D, 0xC0, 0xE7, 0x03,
  0x9C, 0x0E, 0x70, 0x38, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x78, 0x0E, 0x00,
  0x01, 0xE0, 0x38, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x1C, 0x07, 0x80, 0x00,
  0xF0, 0x1E, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x38,
  0x07, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x07, 0x80, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x01, 0xE0,
  0x00, 0x1C, 0x07, 0x80, 0x00, 0xF0, 0x1E, 0x00, 0x03, 0xC0, 0x70, 0x00,
  0x0E, 0x01, 0xC0, 0x00, 0x38, 0x0F, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x07,
  0x80, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xC0, 0x3C, 0x07, 0x80, 0x00, 0xF0, 0x1C,
  0x00, 0x03, 0xC0, 0x70, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x38, 0x0F, 0x00,
  0x01, 0xE0, 0x3C, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x1E, 0x03, 0x80, 0x00,
  0x70, 0x1E, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x7F, 0x39, 0xF8, 0xF8, 0x70, 0x23,
  0xE0, 0xE0, 0x07, 0x81, 0xC0, 0x0F, 0x03, 0x80, 0x1F, 0x07, 0x00, 0x3E,
  0x0E, 0x00, 0x3E, 0x1C, 0x00, 0x7F, 0x38, 0x00, 0x7F, 0xF0, 0x00, 0x7F,
  0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F,
  0xFE, 0x00, 0x1C, 0x7E, 0x00, 0x38, 0x7C, 0x00, 0x70, 0x7C, 0x00, 0xE0,
  0xF8, 0x01, 0xC1, 0xF0, 0x03, 0x83, 0xE0, 0x07, 0x07, 0xB0, 0x0E, 0x3F,
  0x7F, 0x1F, 0xFC, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xC0, 0xFF, 0xFE, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x07, 0xE0, 0x00, 0x1E, 0x00, 0xFF, 0x80,
  0x01, 0xE0, 0x0F, 0xFE, 0x00, 0x0E, 0x00, 0x78, 0x78, 0x00, 0xF0, 0x07,
  0x83, 0xC0, 0x0F, 0x00, 0x3C, 0x0F, 0x00, 0x78, 0x01, 0xC0, 0x78, 0x07,
  0x80, 0x0E, 0x03, 0xC0, 0x3C, 0x00, 0x70, 0x1E, 0x03, 0xC0, 0x07, 0x80,
  0x70, 0x1E, 0x00, 0x3C, 0x03, 0x81, 0xE0, 0x01, 0xE0, 0x1C, 0x0E, 0x00,
  0x0F, 0x00, 0xE0, 0xF0, 0x00, 0x38, 0x0F, 0x0F, 0x00, 0x01, 0xC0, 0x78,
  0x78, 0x7C, 0x0F, 0x03, 0xC7, 0x8F, 0xF8, 0x78, 0x1E, 0x3C, 0xFF, 0xE3,
  0xC1, 0xE3, 0xC7, 0x8F, 0x0F, 0x1F, 0x1E, 0x78, 0x3C, 0x7F, 0xF1, 0xE3,
  0xC0, 0xE1, 0xFF, 0x0E, 0x1C, 0x07, 0x83, 0xF0, 0xF0, 0xE0, 0x3C, 0x00,
  0x0F, 0x0F, 0x01, 0xE0, 0x00, 0x78, 0x78, 0x0F, 0x00, 0x07, 0x83, 0xC0,
  0x78, 0x00, 0x3C, 0x1E, 0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x1E, 0x00, 0x1E,
  0x07, 0x80, 0xF0, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0x0E, 0x00, 0xE0, 0x3C,
  0x00, 0xF0, 0x07, 0x81, 0xC0, 0x0F, 0x00, 0x3C, 0x1E, 0x00, 0x78, 0x00,
  0xF0, 0xF0, 0x07, 0x80, 0x07, 0xFF, 0x00, 0x3C, 0x00, 0x1F, 0xF8, 0x03,
  0xC0, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0x9F,
  0xC0, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x01, 0xE0,
  0x0F, 0x80, 0x00, 0x78, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x3E, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x01, 0xE0, 0x7E, 0x7E, 0x00, 0xF8, 0x3F, 0x0F,
  0xC0, 0x3E, 0x1F, 0x01, 0xF8, 0x0F, 0x0F, 0xC0, 0x3F, 0x07, 0xC3, 0xE0,
  0x07, 0xE1, 0xF0, 0xF8, 0x00, 0xFC, 0xF8, 0x3C, 0x00, 0x1F, 0xBE, 0x0F,
  0x00, 0x03, 0xFF, 0x03, 0xC0, 0x00, 0x7F, 0x80, 0xF8, 0x00, 0x0F, 0xE0,
  0x3E, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x03, 0xFF, 0x01, 0xF8, 0x01, 0xFF,
  0xE0, 0x7F, 0xCF, 0xFC, 0xFC, 0x0F, 0xFF, 0xFE, 0x1F, 0x81, 0xFF, 0xFE,
  0x03, 0xF0, 0x1F, 0xFE, 0x00, 0x7F, 0x00, 0x30, 0x00, 0x00, 0x00, 0xFF,
  0xFE, 0xF7, 0xBD, 0xEE, 0x73, 0x9C, 0xE7, 0x00, 0x01, 0xF0, 0x3E, 0x03,
  0xC0, 0x78, 0x0F, 0x80, 0xF0, 0x1F, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3C,
  0x07, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x07, 0x80, 0x78, 0x07, 0xC0, 0x7C, 0x03, 0xC0, 0x3E,
  0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x03,
  0xC0, 0x1E, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x0F,
  0x80, 0x78, 0x07, 0xC0, 0x7C, 0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x0F, 0x00,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x01,
  0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0xF8, 0x0F,
  0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x7C, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0E, 0x00, 0x30, 0x1C, 0x03, 0xFC, 0x38, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x7B, 0xC0, 0x00, 0xF7, 0xC0, 0x03, 0xC7, 0x80, 0x0F, 0x8F, 0x80,
  0x1F, 0x0F, 0x80, 0x7C, 0x1F, 0x81, 0xF8, 0x1F, 0x00, 0x60, 0x38, 0x00,
  0x40, 0x40, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x3F, 0x3E, 0x3E, 0x3E, 0x3C, 0x3C, 0x7C, 0x78, 0x78,
  0x78, 0x70, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7B, 0xEF, 0xFF,
  0xFF, 0xE7, 0x00, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F,
  0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03,
  0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0,
  0x1F, 0x80, 0xF8, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0x3C, 0x3C, 0x00, 0x3E,
  0x3C, 0x00, 0x1E, 0x7C, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1F,
  0x78, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0x78, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x1F,
  0x78, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0x7C, 0x00, 0x1E, 0x3C, 0x00, 0x1E,
  0x3C, 0x00, 0x3E, 0x3E, 0x00, 0x3C, 0x1E, 0x00, 0x7C, 0x1F, 0x00, 0xF8,
  0x0F, 0xE3, 0xF8, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x3C, 0x01, 0xF0, 0x1F, 0xC0, 0xFF, 0x07, 0xFC,
  0x7E, 0xF3, 0xF3, 0xFF, 0x9F, 0x7C, 0x7C, 0xC1, 0xF2, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x7E, 0x01, 0xF8, 0x38, 0x00, 0x7C,
  0x10, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x7C, 0x00, 0xFC, 0x30, 0x00, 0x7C,
  0x20, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E,
  0x80, 0x00, 0x7E, 0xE0, 0x00, 0xFC, 0xFE, 0x07, 0xFC, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x00, 0x60, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x7B, 0xC0,
  0x00, 0x1E, 0x78, 0x00, 0x07, 0x8F, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x3C,
  0x3C, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xE0, 0xF0, 0x00, 0x78, 0x1E, 0x00,
  0x1E, 0x03, 0xC0, 0x07, 0xC0, 0x78, 0x00, 0xF0, 0x0F, 0x00, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x78, 0x00, 0xF0, 0x1E,
  0x00, 0x1E, 0x07, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x3F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xE0, 0x40, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0xA0, 0x00, 0x3E, 0x60, 0x00, 0xFC, 0xFE, 0x0F, 0xF1, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0x01, 0xFF, 0xF8, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x3F, 0xF1, 0xC0, 0xFE, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3C, 0x3F, 0xE0, 0x78, 0xFF, 0xF0, 0xF7, 0xFF, 0xF1, 0xEF,
  0x03, 0xF3, 0xF8, 0x01, 0xF7, 0xE0, 0x03, 0xEF, 0x80, 0x03, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xE0, 0x00, 0x7B, 0xC0, 0x00, 0xF7, 0x80, 0x03, 0xEF, 0x80, 0x07,
  0x8F, 0x80, 0x1F, 0x1F, 0x80, 0x7E, 0x1F, 0xC3, 0xF8, 0x1F, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x01, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x1F, 0xE7, 0xF8, 0x3F, 0x00, 0x7C,
  0x3E, 0x00, 0x3E, 0x3C, 0x00, 0x3E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x1E,
  0x3C, 0x00, 0x3E, 0x3C, 0x00, 0x3E, 0x3E, 0x00, 0x3C, 0x1F, 0x00, 0x7C,
  0x1F, 0x80, 0xF8, 0x0F, 0xE3, 0xF0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x0F, 0xEF, 0xF0, 0x1F, 0x81, 0xF8,
  0x3E, 0x00, 0xFC, 0x3C, 0x00, 0x3E, 0x7C, 0x00, 0x1E, 0x78, 0x00, 0x1F,
  0x78, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0x78, 0x00, 0x0F,
  0x78, 0x00, 0x1F, 0x7C, 0x00, 0x1E, 0x7E, 0x00, 0x3E, 0x3F, 0x80, 0xFC,
  0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x18, 0x00,
  0x00, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0,
  0x3F, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0x3C, 0x7C, 0x00, 0x3E,
  0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0x78, 0x00, 0x0F, 0x78, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0x78, 0x00, 0x1F,
  0x7C, 0x00, 0x3F, 0x3E, 0x00, 0x7F, 0x3F, 0x01, 0xFF, 0x1F, 0xFF, 0xDF,
  0x0F, 0xFF, 0x9F, 0x03, 0xFF, 0x1F, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0,
  0x10, 0x1F, 0xE0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x1F, 0xFC, 0x00,
  0x01, 0x00, 0x00, 0x23, 0xEF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xBE, 0xFF, 0xFF, 0xFE,
  0x70, 0x08, 0x3E, 0x3F, 0x7F, 0x3F, 0x3E, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x3E, 0x3E, 0x3C, 0x7C, 0x7C, 0x78, 0x78, 0xF8, 0xF0, 0xF0, 0xE0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0F, 0xFC, 0x0F, 0xFF, 0xE3, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0x00,
  0x7E, 0x80, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xE0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x00,
  0xF8, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x78, 0x01, 0xFF, 0x00, 0xF1, 0xE0,
  0x0F, 0xFF, 0x81, 0xE3, 0x80, 0x7F, 0xFF, 0x01, 0xCF, 0x01, 0xF8, 0x3E,
  0x03, 0xDE, 0x03, 0xC0, 0x3C, 0x07, 0xB8, 0x0F, 0x00, 0x78, 0x0F, 0xF0,
  0x1E, 0x00, 0xF0, 0x1F, 0xE0, 0x78, 0x01, 0xE0, 0x1F, 0xC0, 0xF0, 0x03,
  0xC0, 0x3F, 0x81, 0xE0, 0x07, 0x80, 0xFF, 0x03, 0xC0, 0x0F, 0x01, 0xFE,
  0x07, 0x80, 0x1E, 0x03, 0xFC, 0x0F, 0x00, 0x3C, 0x07, 0xF8, 0x1E, 0x00,
  0xF8, 0x0E, 0xF0, 0x3C, 0x01, 0xF0, 0x3D, 0xE0, 0x3C, 0x07, 0xE0, 0x7B,
  0xC0, 0x7C, 0x0F, 0xC1, 0xE7, 0x80, 0x7F, 0xF9, 0xFF, 0x87, 0x80, 0xFF,
  0xE3, 0xFE, 0x0F, 0x00, 0x7F, 0x83, 0xF8, 0x1E, 0x00, 0x10, 0x00, 0x80,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x40,
  0x00, 0x3F, 0x80, 0x0F, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00,
  0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x3E, 0x7C, 0x00,
  0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x78, 0x3E, 0x00,
  0x00, 0x78, 0x1E, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xF0, 0x0F, 0x00,
  0x00, 0xF0, 0x0F, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x01, 0xE0, 0x07, 0x80,
  0x03, 0xE0, 0x07, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x03, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x0F, 0x80, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x1F, 0x00, 0x00, 0xF8,
  0x1E, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0x78, 0x3E, 0x00, 0x00, 0x7C,
  0x3C, 0x00, 0x00, 0x3C, 0x7C, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E,
  0x78, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x8F, 0x00, 0x3F, 0xC7,
  0x80, 0x03, 0xF3, 0xC0, 0x00, 0xF9, 0xE0, 0x00, 0x3C, 0xF0, 0x00, 0x1F,
  0x78, 0x00, 0x0F, 0xBC, 0x00, 0x07, 0xDE, 0x00, 0x03, 0xCF, 0x00, 0x03,
  0xE7, 0x80, 0x01, 0xE3, 0xC0, 0x01, 0xF1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x1E, 0x00, 0x7F, 0x8F, 0x00,
  0x07, 0xE7, 0x80, 0x00, 0xFB, 0xC0, 0x00, 0x7D, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0xFB, 0xC0, 0x00, 0xFD, 0xE0, 0x01, 0xFC,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xE0, 0x7F, 0x80, 0x3C, 0x1F, 0xC0, 0x00, 0x87, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x06, 0x07, 0xFF, 0xBF, 0xC0, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0xF0, 0x03, 0xFE, 0x0F,
  0x00, 0x07, 0xF0, 0xF0, 0x00, 0x1F, 0x8F, 0x00, 0x00, 0xFC, 0xF0, 0x00,
  0x07, 0xCF, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3E, 0xF0, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x0F, 0xCF,
  0x00, 0x01, 0xF8, 0xF0, 0x00, 0x7F, 0x0F, 0x00, 0x1F, 0xE0, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFE, 0x07, 0xF8, 0x00, 0xF0, 0x3F, 0x80, 0x00, 0x41, 0xFC,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x07, 0xDE, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x7D, 0xF0, 0x00,
  0x01, 0xF7, 0xE0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x1F, 0x3F, 0x00, 0x00,
  0x7C, 0x7E, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x07, 0xC3, 0xFC, 0x00, 0x1F,
  0x07, 0xFF, 0x8F, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x7F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x87, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x01, 0xF7, 0x7F, 0xBF, 0xF9, 0xFF, 0x8F, 0xF8, 0x08, 0x00, 0xF0,
  0x00, 0x0F, 0xBC, 0x00, 0x07, 0xCF, 0x00, 0x03, 0xE3, 0xC0, 0x01, 0xF8,
  0xF0, 0x00, 0xFC, 0x3C, 0x00, 0x7E, 0x0F, 0x00, 0x1F, 0x03, 0xC0, 0x0F,
  0x80, 0xF0, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x0F, 0x01, 0xF0, 0x03, 0xC0,
  0xF8, 0x00, 0xF0, 0x7C, 0x00, 0x3C, 0x3E, 0x00, 0x0F, 0x1F, 0x00, 0x03,
  0xCF, 0xC0, 0x00, 0xF3, 0xF0, 0x00, 0x3D, 0xFC, 0x00, 0x0F, 0xFF, 0x80,
  0x03, 0xFB, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x01,
  0xF0, 0x03, 0xC0, 0x7E, 0x00, 0xF0, 0x0F, 0xC0, 0x3C, 0x01, 0xF0, 0x0F,
  0x00, 0x3E, 0x03, 0xC0, 0x0F, 0xC0, 0xF0, 0x01, 0xF0, 0x3C, 0x00, 0x3E,
  0x0F, 0x00, 0x07, 0xC3, 0xC0, 0x01, 0xF8, 0xF0, 0x00, 0x3E, 0x3C, 0x00,
  0x07, 0xCF, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF7, 0x80, 0x00, 0x1F, 0xFF, 0x78, 0x00,
  0x03, 0xDF, 0xF7, 0xC0, 0x00, 0x3D, 0xFF, 0x3C, 0x00, 0x07, 0x9F, 0xF3,
  0xC0, 0x00, 0x79, 0xFF, 0x3E, 0x00, 0x07, 0x9F, 0xF1, 0xE0, 0x00, 0xF1,
  0xFF, 0x1E, 0x00, 0x0F, 0x1F, 0xF0, 0xF0, 0x01, 0xF1, 0xFF, 0x0F, 0x00,
  0x1E, 0x1F, 0xF0, 0xF8, 0x01, 0xE1, 0xFF, 0x07, 0x80, 0x3C, 0x1F, 0xF0,
  0x78, 0x03, 0xC1, 0xFF, 0x07, 0xC0, 0x3C, 0x1F, 0xF0, 0x3C, 0x07, 0x81,
  0xFF, 0x03, 0xC0, 0x78, 0x1F, 0xF0, 0x1E, 0x0F, 0x01, 0xFF, 0x01, 0xE0,
  0xF0, 0x1F, 0xF0, 0x1F, 0x0F, 0x01, 0xFF, 0x00, 0xF1, 0xE0, 0x1F, 0xF0,
  0x0F, 0x1E, 0x01, 0xFF, 0x00, 0xFB, 0xE0, 0x1F, 0xF0, 0x07, 0xBC, 0x01,
  0xFF, 0x00, 0x7B, 0xC0, 0x1F, 0xF0, 0x03, 0xF8, 0x01, 0xFF, 0x00, 0x3F,
  0x80, 0x1F, 0xF0, 0x03, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0x00, 0x1F, 0xF0,
  0x01, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0x7C, 0x00, 0x0F,
  0xF7, 0xC0, 0x00, 0xFF, 0x3E, 0x00, 0x0F, 0xF3, 0xF0, 0x00, 0xFF, 0x1F,
  0x00, 0x0F, 0xF0, 0xF8, 0x00, 0xFF, 0x0F, 0xC0, 0x0F, 0xF0, 0x7C, 0x00,
  0xFF, 0x03, 0xE0, 0x0F, 0xF0, 0x3F, 0x00, 0xFF, 0x01, 0xF0, 0x0F, 0xF0,
  0x0F, 0x80, 0xFF, 0x00, 0xF8, 0x0F, 0xF0, 0x07, 0xC0, 0xFF, 0x00, 0x3E,
  0x0F, 0xF0, 0x03, 0xE0, 0xFF, 0x00, 0x1F, 0x0F, 0xF0, 0x01, 0xF8, 0xFF,
  0x00, 0x0F, 0x8F, 0xF0, 0x00, 0x7C, 0xFF, 0x00, 0x07, 0xEF, 0xF0, 0x00,
  0x3E, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7E,
  0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x3E,
  0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x07, 0xCF,
  0x80, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x3E, 0xF0, 0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00,
  0x0F, 0x9F, 0x00, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x07, 0xC3, 0xE0, 0x00,
  0x03, 0xE0, 0xF8, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x03, 0xF0, 0x1F, 0xC0,
  0x07, 0xF0, 0x07, 0xFF, 0x7F, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x8F, 0x00,
  0xFF, 0x9E, 0x00, 0x3F, 0x3C, 0x00, 0x1F, 0x78, 0x00, 0x3E, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xBC, 0x00, 0x1F, 0x78, 0x00, 0x3E, 0xF0, 0x00, 0xF9,
  0xE0, 0x07, 0xF3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x1F,
  0xFF, 0x80, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x7E, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x01, 0xF0,
  0x7E, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x0F,
  0x9F, 0x00, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x00,
  0xF7, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0x1E, 0x7C, 0x00,
  0x00, 0x1F, 0x3E, 0x00, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x07, 0xC7, 0xC0,
  0x00, 0x07, 0xC3, 0xE0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x03, 0xE0, 0x7E,
  0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x07, 0xF0, 0x07, 0xFF, 0x7F, 0xF0, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x0B, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07,
  0xE0, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFE, 0x0F, 0x00, 0x7F, 0x87, 0x80, 0x07, 0xE3, 0xC0, 0x01, 0xF1, 0xE0,
  0x00, 0xF8, 0xF0, 0x00, 0x3E, 0x78, 0x00, 0x1F, 0x3C, 0x00, 0x0F, 0x9E,
  0x00, 0x07, 0xCF, 0x00, 0x03, 0xE7, 0x80, 0x01, 0xE3, 0xC0, 0x01, 0xF1,
  0xE0, 0x01, 0xF0, 0xF0, 0x01, 0xF8, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x3E,
  0x01, 0xE0, 0x0F, 0x80, 0xF0, 0x07, 0xC0, 0x78, 0x01, 0xF0, 0x3C, 0x00,
  0x7C, 0x1E, 0x00, 0x3E, 0x0F, 0x00, 0x0F, 0x87, 0x80, 0x07, 0xC3, 0xC0,
  0x01, 0xF1, 0xE0, 0x00, 0xFC, 0xF0, 0x00, 0x3E, 0x78, 0x00, 0x0F, 0xBC,
  0x00, 0x07, 0xDE, 0x00, 0x01, 0xF0, 0x01, 0xFF, 0x80, 0x3F, 0xFF, 0xE1,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x7E, 0x00, 0xF1, 0xF0, 0x00, 0x4F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xB0, 0x00, 0x7E, 0xFF, 0x1F,
  0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0x00, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0x78, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x1F, 0x78, 0x00, 0x01,
  0xF7, 0xC0, 0x00, 0x1E, 0x7C, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x3E, 0x3F,
  0x00, 0x07, 0xC1, 0xF8, 0x01, 0xFC, 0x0F, 0xF9, 0xFF, 0x80, 0x7F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x0F, 0x9F,
  0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x07, 0xC3, 0xE0,
  0x00, 0x1F, 0x07, 0x80, 0x00, 0x78, 0x1F, 0x00, 0x03, 0xE0, 0x7C, 0x00,
  0x0F, 0x80, 0xF0, 0x00, 0x3C, 0x03, 0xE0, 0x01, 0xF0, 0x0F, 0x80, 0x07,
  0xC0, 0x1E, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x03, 0xC0, 0x0F, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x3E, 0x01, 0xF0, 0x00,
  0x78, 0x0F, 0x80, 0x01, 0xF0, 0x3E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F,
  0x87, 0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x78, 0x78, 0x00, 0x01, 0xF3,
  0xE0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x3C, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3D, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xE7, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0xE0, 0x00,
  0xF1, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0x8F, 0x80, 0x07, 0xFC, 0x00, 0x7C,
  0x3C, 0x00, 0x79, 0xE0, 0x03, 0xE1, 0xF0, 0x03, 0xCF, 0x00, 0x1E, 0x0F,
  0x80, 0x1E, 0x78, 0x00, 0xF0, 0x3C, 0x01, 0xF1, 0xE0, 0x0F, 0x81, 0xE0,
  0x0F, 0x0F, 0x00, 0x7C, 0x0F, 0x80, 0x78, 0x78, 0x03, 0xC0, 0x7C, 0x03,
  0xC3, 0xE0, 0x1E, 0x01, 0xE0, 0x3E, 0x0F, 0x01, 0xF0, 0x0F, 0x01, 0xE0,
  0x78, 0x0F, 0x80, 0x7C, 0x0F, 0x03, 0xE0, 0x78, 0x03, 0xE0, 0xF8, 0x0F,
  0x03, 0xC0, 0x0F, 0x07, 0x80, 0x78, 0x3E, 0x00, 0x78, 0x3C, 0x03, 0xE1,
  0xE0, 0x03, 0xE1, 0xE0, 0x1F, 0x0F, 0x00, 0x1F, 0x1F, 0x00, 0x78, 0x78,
  0x00, 0x78, 0xF0, 0x03, 0xC7, 0xC0, 0x03, 0xC7, 0x80, 0x1F, 0x3C, 0x00,
  0x1F, 0x7C, 0x00, 0x79, 0xE0, 0x00, 0x7B, 0xC0, 0x03, 0xCF, 0x00, 0x03,
  0xDE, 0x00, 0x1E, 0xF8, 0x00, 0x1E, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0xF7,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xC0, 0x00, 0x7C, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x0F, 0x0F, 0x80, 0x00,
  0xF8, 0x3E, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x7C, 0x07, 0xC0, 0x07, 0xC0,
  0x1F, 0x00, 0x3C, 0x00, 0x78, 0x03, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x0F,
  0x81, 0xE0, 0x00, 0x3C, 0x1F, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x07, 0xCF,
  0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x01, 0xE3,
  0xE0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x0F, 0x01, 0xE0,
  0x00, 0xF8, 0x0F, 0x80, 0x07, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x07, 0xC0, 0x3C, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0xF8, 0x3E, 0x00,
  0x03, 0xE1, 0xF0, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x01,
  0xF0, 0xF8, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x03, 0xE3,
  0xE0, 0x00, 0x3E, 0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x78, 0x1F, 0x00,
  0x0F, 0x80, 0xF8, 0x00, 0xF0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x01, 0xE0,
  0x03, 0xC0, 0x3E, 0x00, 0x3E, 0x03, 0xC0, 0x01, 0xE0, 0x7C, 0x00, 0x1F,
  0x0F, 0x80, 0x00, 0xF0, 0xF8, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x79, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0x78, 0x00, 0x07, 0x9C, 0x00, 0x03, 0xCF, 0x00,
  0x01, 0xC3, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0xF0, 0x3C,
  0x00, 0x70, 0x0E, 0x00, 0x78, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x3C, 0x00,
  0xF0, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x8F, 0x00,
  0x03, 0xC7, 0x80, 0x00, 0xF7, 0x80, 0x00, 0x7B, 0xC0, 0x00, 0x1E, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F,
  0x03, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x01, 0xFF, 0x80, 0x3F,
  0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xF0, 0xFE, 0x0E, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x3F, 0xFF, 0x07, 0xFF, 0xFC, 0x7F, 0xFF, 0xF3, 0xFC,
  0x03, 0xDF, 0x80, 0x0F, 0x7C, 0x00, 0x3D, 0xE0, 0x00, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xF7, 0xC0, 0x1F, 0xDF,
  0x81, 0xFF, 0x3F, 0xFF, 0xBC, 0x7F, 0xFC, 0xF0, 0xFF, 0xC1, 0xC0, 0x30,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x7F,
  0x80, 0xF9, 0xFF, 0xE0, 0xFB, 0xFF, 0xF0, 0xF7, 0xE7, 0xF8, 0xFF, 0x00,
  0xFC, 0xFE, 0x00, 0x7C, 0xFC, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00,
  0x1E, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1E, 0xFC, 0x00,
  0x3E, 0xFC, 0x00, 0x7E, 0xFE, 0x00, 0xFC, 0xFF, 0xC1, 0xF8, 0xF7, 0xFF,
  0xF8, 0xF3, 0xFF, 0xE0, 0xF0, 0xFF, 0xC0, 0x00, 0x08, 0x00, 0x01, 0xFF,
  0xC0, 0xFF, 0xFC, 0x3F, 0xFF, 0x8F, 0xFF, 0xE3, 0xF0, 0x04, 0xFC, 0x00,
  0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x08, 0xFE, 0x1F, 0x1F, 0xFF, 0xE0, 0xFF, 0xFC,
  0x07, 0xFF, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x01, 0xFE, 0x1F, 0x07, 0xFF, 0x9F, 0x1F, 0xFF, 0xDF, 0x1F,
  0xC7, 0xFF, 0x3F, 0x00, 0xFF, 0x7E, 0x00, 0x7F, 0x7C, 0x00, 0x3F, 0x78,
  0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x7F, 0x3E, 0x00, 0xFF, 0x3F,
  0x83, 0xFF, 0x1F, 0xFF, 0xDF, 0x0F, 0xFF, 0x8F, 0x03, 0xFE, 0x0F, 0x00,
  0x20, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFE,
  0x3F, 0x83, 0xE0, 0x1F, 0x87, 0x80, 0x0F, 0x1F, 0x00, 0x1F, 0x3C, 0x00,
  0x1E, 0xF8, 0x00, 0x3D, 0xF0, 0x00, 0x7B, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x02, 0x0F, 0xF0, 0xFC, 0x0F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x00, 0x60, 0x00, 0x00,
  0x7F, 0xC0, 0x7F, 0xF0, 0x3F, 0xFC, 0x0F, 0xC6, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x7F, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xF0, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0x03, 0xFE, 0x0F, 0x07, 0xFF, 0x8F, 0x0F, 0xFF, 0xCF, 0x1F, 0xEF,
  0xFF, 0x3F, 0x00, 0xFF, 0x7E, 0x00, 0x7F, 0x7C, 0x00, 0x3F, 0x78, 0x00,
  0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x7F, 0x3E, 0x00, 0x7F, 0x3F, 0x83,
  0xFF, 0x1F, 0xFF, 0xDF, 0x0F, 0xFF, 0x9F, 0x03, 0xFF, 0x1F, 0x00, 0x20,
  0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x20, 0x00, 0x7C, 0x38, 0x00, 0xFC, 0x3F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC3, 0xFE, 0x0F, 0x9F, 0xFF, 0x1F,
  0x7F, 0xFF, 0x3D, 0xFD, 0xFE, 0x7F, 0x80, 0x7E, 0xFE, 0x00, 0x7D, 0xF8,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xC0,
  0x77, 0xFF, 0xFF, 0xB8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x03, 0xEF, 0xFE, 0xFF, 0xCF, 0xF8,
  0xFE, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x3F, 0xF8,
  0x01, 0xF3, 0xE0, 0x0F, 0x8F, 0x80, 0x7C, 0x3E, 0x03, 0xE0, 0xF8, 0x1F,
  0x83, 0xE0, 0xFC, 0x0F, 0x87, 0xE0, 0x3E, 0x3F, 0x00, 0xF8, 0xF8, 0x03,
  0xE7, 0xC0, 0x0F, 0xBE, 0x00, 0x3D, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xE0, 0x0F, 0xEF, 0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0x3E, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF8, 0x3E, 0x03, 0xE0, 0xF8, 0x07, 0xC3, 0xE0, 0x0F, 0x8F,
  0x80, 0x3F, 0x3E, 0x00, 0x7C, 0xF8, 0x00, 0xFB, 0xE0, 0x01, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0,
  0x7F, 0x80, 0x7F, 0xC1, 0xE3, 0xFF, 0xC1, 0xFF, 0xE3, 0xCF, 0xFF, 0xCF,
  0xFF, 0xE7, 0xBF, 0x3F, 0xBF, 0xBF, 0xEF, 0xF0, 0x1F, 0xF8, 0x0F, 0xDF,
  0xC0, 0x1F, 0xC0, 0x0F, 0xBF, 0x00, 0x1F, 0x80, 0x0F, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0xF0, 0x00, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xC0, 0x03, 0xFF, 0x00, 0x0F, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0x00, 0x0F,
  0xFC, 0x00, 0x3E, 0x00, 0x1F, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0xF0, 0x00,
  0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xE0, 0x01,
  0xFF, 0x80, 0x07, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0x80, 0x07, 0xFE, 0x00,
  0x1F, 0x00, 0x0F, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0xF8, 0x00, 0x7C, 0x00,
  0x3F, 0xF0, 0x00, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0xF0,
  0x7F, 0xC1, 0xE3, 0xFF, 0xE3, 0xCF, 0xFF, 0xE7, 0xBF, 0x3F, 0xEF, 0xF0,
  0x0F, 0xDF, 0xC0, 0x0F, 0xBF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0xF8, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x03,
  0xFF, 0xFC, 0x03, 0xFC, 0xFF, 0x03, 0xF0, 0x0F, 0xC1, 0xF0, 0x01, 0xF1,
  0xF0, 0x00, 0xF8, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x07,
  0xBE, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xEF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1E, 0xF8, 0x00, 0x0F, 0x7C, 0x00,
  0x07, 0xBE, 0x00, 0x07, 0xCF, 0x00, 0x03, 0xE7, 0xC0, 0x03, 0xE1, 0xF0,
  0x01, 0xF0, 0xFC, 0x01, 0xF0, 0x3F, 0x83, 0xF0, 0x0F, 0xFF, 0xF8, 0x03,
  0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0x00, 0x00, 0xF0, 0x7F, 0x80,
  0xF1, 0xFF, 0xE0, 0xF3, 0xFF, 0xF0, 0xF7, 0xE7, 0xF8, 0xFF, 0x00, 0xFC,
  0xFE, 0x00, 0x7C, 0xFC, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x1E,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x3E, 0xFC, 0x00, 0x3E,
  0xFE, 0x00, 0x7C, 0xFF, 0x00, 0xFC, 0xFF, 0xC1, 0xF8, 0xF7, 0xFF, 0xF0,
  0xF9, 0xFF, 0xE0, 0xF8, 0xFF, 0xC0, 0xF8, 0x08, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x0F, 0x07, 0xFF, 0x8F,
  0x1F, 0xFF, 0xCF, 0x1F, 0xC7, 0xFF, 0x3F, 0x00, 0xFF, 0x7E, 0x00, 0x7F,
  0x7C, 0x00, 0x3F, 0x78, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x7F,
  0x3E, 0x00, 0xFF, 0x3F, 0x83, 0xFF, 0x1F, 0xFF, 0xDF, 0x0F, 0xFF, 0x9F,
  0x03, 0xFE, 0x1F, 0x00, 0x20, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0xF0, 0x7F, 0xF0, 0xFF, 0xF3, 0xFF, 0xF3, 0xFE, 0xF7,
  0x80, 0xFF, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x0F, 0xFE, 0x07,
  0xFF, 0xF9, 0xFF, 0xFF, 0x7F, 0x07, 0xCF, 0x80, 0x19, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x1F,
  0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x01, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xA0, 0x01, 0xF7, 0x80, 0x7E, 0xFF, 0xFF, 0x9F, 0xFF, 0xE1, 0xFF,
  0xF0, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x80, 0x0F, 0xC1, 0x07, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x10,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07,
  0xFF, 0x00, 0x1F, 0xDF, 0x00, 0x7F, 0xBF, 0x83, 0xFF, 0x3F, 0xFF, 0x9E,
  0x3F, 0xFE, 0x3C, 0x3F, 0xF8, 0x78, 0x02, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xEF, 0x80, 0x01, 0xE3, 0xC0, 0x01,
  0xF1, 0xF0, 0x00, 0xF0, 0xF8, 0x00, 0xF8, 0x3C, 0x00, 0x7C, 0x1F, 0x00,
  0x3C, 0x07, 0x80, 0x3E, 0x03, 0xC0, 0x1F, 0x01, 0xF0, 0x0F, 0x00, 0x78,
  0x0F, 0x80, 0x3E, 0x07, 0x80, 0x1F, 0x03, 0xC0, 0x07, 0x83, 0xE0, 0x03,
  0xE1, 0xE0, 0x00, 0xF1, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x3E, 0x78, 0x00,
  0x0F, 0x7C, 0x00, 0x07, 0xBC, 0x00, 0x03, 0xDE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00,
  0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xF0, 0x01, 0xEF, 0x80, 0x0F, 0xC0, 0x07,
  0xBE, 0x00, 0x7F, 0x00, 0x3E, 0x78, 0x01, 0xFC, 0x00, 0xF9, 0xE0, 0x07,
  0x78, 0x03, 0xC7, 0xC0, 0x3D, 0xE0, 0x0F, 0x0F, 0x00, 0xF7, 0x80, 0x7C,
  0x3C, 0x03, 0xCF, 0x01, 0xE0, 0xF8, 0x1E, 0x3C, 0x07, 0x83, 0xE0, 0x78,
  0xF0, 0x1E, 0x07, 0x81, 0xE3, 0xE0, 0xF8, 0x1E, 0x0F, 0x87, 0x83, 0xC0,
  0x7C, 0x3C, 0x1E, 0x0F, 0x01, 0xF0, 0xF0, 0x78, 0x7C, 0x03, 0xC7, 0xC0,
  0xF1, 0xE0, 0x0F, 0x1E, 0x03, 0xC7, 0x80, 0x3E, 0x78, 0x0F, 0x1E, 0x00,
  0x79, 0xE0, 0x1E, 0xF8, 0x01, 0xEF, 0x00, 0x7B, 0xC0, 0x07, 0xBC, 0x01,
  0xEF, 0x00, 0x1E, 0xF0, 0x07, 0xBC, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x07, 0xC0, 0x01,
  0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x3E, 0x00,
  0x1F, 0x0F, 0x80, 0x0F, 0x03, 0xE0, 0x0F, 0x81, 0xF0, 0x0F, 0x80, 0x7C,
  0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x87, 0xC0, 0x03, 0xE7, 0xC0, 0x00,
  0xFB, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xF3, 0xE0, 0x00, 0xF8, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x1F,
  0x00, 0x7C, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x3E, 0x00,
  0x3E, 0x3E, 0x00, 0x0F, 0x3E, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x07, 0xDE,
  0x00, 0x03, 0xE7, 0xC0, 0x00, 0xF9, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x1F,
  0x0F, 0x80, 0x07, 0xC1, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x1F, 0x00,
  0x3C, 0x03, 0xC0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x1E, 0x01, 0xE0, 0x07,
  0x80, 0xF8, 0x01, 0xF0, 0x3C, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x87, 0xC0,
  0x01, 0xE1, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x1F, 0x3E, 0x00, 0x03, 0xCF,
  0x00, 0x00, 0xF3, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF,
  0xFE, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x03, 0x00, 0x1F, 0x00, 0x7F, 0x00, 0xFF, 0x01, 0xF8, 0x01, 0xF0, 0x01,
  0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xC0, 0x0F, 0xC0, 0xFF, 0x80, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0x0F,
  0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFF, 0x00, 0x7F, 0x00,
  0x3F, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x00,
  0x1F, 0x80, 0x0F, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xF0, 0x01, 0xFF, 0x00, 0x7F,
  0x00, 0x3F, 0x01, 0xFF, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x1F, 0x80,
  0xFF, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xE0, 0x00, 0x0F, 0xC0, 0x01, 0x3F,
  0xF8, 0x03, 0x7F, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFE, 0xC0,
  0x0F, 0xFC, 0x80, 0x00, 0x60,
};

const GFXglyph NotoSans_Regular50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 6, 37, 13, 4, -36 },
  { 29, 14, 13, 20, 3, -36 },
  { 52, 30, 36, 32, 1, -36 },
  { 187, 23, 41, 29, 3, -38 },
  { 305, 37, 37, 42, 2, -36 },
  { 477, 34, 37, 37, 3, -36 },
  { 635, 5, 13, 11, 3, -36 },
  { 644, 12, 44, 15, 2, -36 },
  { 710, 12, 44, 15, 1, -36 },
  { 776, 23, 23, 28, 2, -38 },
  { 843, 24, 24, 29, 2, -30 },
  { 915, 8, 12, 13, 2, -6 },
  { 927, 12, 4, 16, 2, -15 },
  { 933, 6, 7, 13, 4, -6 },
  { 939, 18, 36, 19, 0, -36 },
  { 1020, 24, 37, 29, 2, -36 },
  { 1131, 14, 36, 29, 4, -36 },
  { 1194, 24, 36, 29, 2, -36 },
  { 1302, 24, 37, 29, 2, -36 },
  { 1413, 27, 36, 29, 1, -36 },
  { 1535, 23, 37, 29, 3, -36 },
  { 1642, 23, 37, 29, 3, -36 },
  { 1749, 24, 36, 29, 2, -36 },
  { 1857, 24, 37, 29, 2, -36 },
  { 1968, 24, 37, 29, 2, -36 },
  { 2079, 6, 29, 13, 4, -28 },
  { 2101, 8, 34, 13, 2, -28 },
  { 2135, 24, 24, 29, 2, -30 },
  { 2207, 23, 13, 29, 3, -24 },
  { 2245, 24, 24, 29, 2, -30 },
  { 2317, 19, 37, 22, 1, -36 },
  { 2405, 39, 40, 45, 3, -36 },
  { 2600, 32, 36, 32, 0, -36 },
  { 2744, 25, 36, 33, 5, -36 },
  { 2857, 27, 37, 32, 3, -36 },
  { 2982, 28, 36, 37, 5, -36 },
  { 3108, 20, 36, 28, 5, -36 },
  { 3198, 20, 36, 26, 5, -36 },
  { 3288, 30, 37, 36, 3, -36 },
  { 3427, 27, 36, 37, 5, -36 },
  { 3549, 13, 36, 17, 2, -36 },
  { 3608, 13, 46, 14, -4, -36 },
  { 3683, 26, 36, 31, 5, -36 },
  { 3800, 20, 36, 26, 5, -36 },
  { 3890, 36, 36, 45, 5, -36 },
  { 4052, 28, 36, 38, 5, -36 },
  { 4178, 33, 37, 39, 3, -36 },
  { 4331, 23, 36, 30, 5, -36 },
  { 4435, 33, 45, 39, 3, -36 },
  { 4621, 25, 36, 31, 5, -36 },
  { 4734, 22, 37, 27, 3, -36 },
  { 4836, 27, 36, 28, 0, -36 },
  { 4958, 28, 37, 37, 4, -36 },
  { 5088, 30, 36, 30, 0, -36 },
  { 5223, 45, 36, 47, 1, -36 },
  { 5426, 29, 36, 29, 0, -36 },
  { 5557, 28, 36, 28, 0, -36 },
  { 5683, 25, 36, 29, 2, -36 },
  { 5796, 11, 44, 16, 4, -36 },
  { 5857, 18, 36, 19, 0, -36 },
  { 5938, 11, 44, 16, 1, -36 },
  { 5999, 25, 23, 29, 2, -36 },
  { 6071, 22, 4, 22, 0, 4 },
  { 6082, 10, 8, 14, 2, -38 },
  { 6092, 22, 28, 28, 2, -27 },
  { 6169, 24, 39, 31, 4, -38 },
  { 6286, 19, 28, 24, 3, -27 },
  { 6353, 24, 39, 31, 3, -38 },
  { 6470, 23, 28, 28, 3, -27 },
  { 6551, 18, 38, 17, 1, -38 },
  { 6637, 24, 39, 31, 3, -27 },
  { 6754, 23, 38, 31, 4, -38 },
  { 6864, 5, 37, 13, 4, -37 },
  { 6888, 12, 49, 13, -3, -37 },
  { 6962, 22, 38, 27, 4, -38 },
  { 7067, 5, 38, 13, 4, -38 },
  { 7091, 39, 27, 47, 4, -27 },
  { 7223, 23, 27, 31, 4, -27 },
  { 7301, 25, 28, 30, 3, -27 },
  { 7389, 24, 39, 31, 4, -27 },
  { 7506, 24, 39, 31, 3, -27 },
  { 7623, 16, 27, 21, 4, -27 },
  { 7677, 19, 28, 24, 3, -27 },
  { 7744, 16, 34, 18, 1, -33 },
  { 7812, 23, 28, 31, 4, -27 },
  { 7893, 25, 27, 25, 0, -27 },
  { 7978, 38, 27, 39, 1, -27 },
  { 8107, 25, 27, 26, 1, -27 },
  { 8192, 26, 39, 26, 0, -27 },
  { 8319, 20, 27, 24, 2, -27 },
  { 8387, 16, 44, 19, 1, -36 },
  { 8475, 4, 50, 28, 12, -38 },
  { 8500, 16, 44, 19, 2, -36 },
  { 8588, 24, 7, 29, 2, -21 },
};

const GFXfont NotoSans_Regular50pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Regular50pt7bBitmaps,
  (GFXglyph *)NotoSans_Regular50pt7bGlyphs,
  0x20, 0x7E, 68
};

#endif // _NOTOSANS_REGULAR50PT7B_H_
