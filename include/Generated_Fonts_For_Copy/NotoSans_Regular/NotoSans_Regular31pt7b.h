#ifndef _NOTOSANS_REGULAR31PT7B_H_
#define _NOTOSANS_REGULAR31PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Regular.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Regular31pt7bBitmaps[] PROGMEM = {
  0x00, 0x77, 0x77, 0x77, 0x76, 0x66, 0x66, 0x66, 0x66, 0x00, 0x6F, 0xFF,
  0xE3, 0xF1, 0xF8, 0xDC, 0x6E, 0x37, 0x19, 0x0C, 0x86, 0x01, 0x87, 0x00,
  0xE1, 0x80, 0x30, 0x60, 0x0C, 0x18, 0x03, 0x0E, 0x00, 0xC3, 0x07, 0xFF,
  0xFD, 0xFF, 0xFF, 0x06, 0x0C, 0x01, 0x87, 0x00, 0x61, 0xC0, 0x38, 0x60,
  0x0C, 0x18, 0x3F, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0x1C, 0x30, 0x07,
  0x0C, 0x01, 0x83, 0x00, 0x60, 0xC0, 0x18, 0x70, 0x0E, 0x18, 0x00, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x03, 0xF8, 0x3F, 0xF9, 0xFF, 0xEE, 0x30, 0xB8,
  0xC0, 0xE3, 0x03, 0x8C, 0x0F, 0x30, 0x1F, 0xC0, 0x3F, 0xC0, 0x1F, 0xC0,
  0x3F, 0x80, 0xCF, 0x03, 0x1C, 0x0C, 0x70, 0x31, 0xF0, 0xCE, 0xFF, 0xFB,
  0xFF, 0x80, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x7E, 0x01, 0xC1,
  0xFC, 0x06, 0x0C, 0x30, 0x38, 0x30, 0xC0, 0xC0, 0xC3, 0x87, 0x03, 0x0E,
  0x18, 0x0C, 0x38, 0xE0, 0x30, 0xE3, 0x00, 0xC3, 0x98, 0x43, 0x0C, 0xE7,
  0xCC, 0x33, 0x3B, 0x9F, 0xDC, 0xC7, 0x7E, 0x67, 0x0C, 0x03, 0x98, 0x30,
  0x0C, 0x60, 0xC0, 0x71, 0x83, 0x01, 0x86, 0x0C, 0x0C, 0x18, 0x30, 0x70,
  0x70, 0xC1, 0x80, 0xC7, 0x0E, 0x03, 0xF8, 0x30, 0x07, 0xC0, 0x0F, 0xE0,
  0x00, 0xFF, 0x80, 0x0E, 0x1C, 0x00, 0x70, 0x70, 0x03, 0x03, 0x80, 0x1C,
  0x1C, 0x00, 0xE1, 0xC0, 0x03, 0x9E, 0x00, 0x1F, 0xE0, 0x00, 0x7C, 0x00,
  0x07, 0xE0, 0x00, 0x7F, 0x81, 0xC7, 0x1E, 0x0E, 0x70, 0x78, 0x63, 0x81,
  0xE7, 0x1C, 0x07, 0xB8, 0xE0, 0x1F, 0x87, 0x00, 0x78, 0x38, 0x07, 0xE1,
  0xF0, 0xFF, 0x87, 0xFF, 0x9E, 0x0F, 0xF0, 0x7C, 0xFF, 0xFF, 0xD2, 0x0E,
  0x18, 0x71, 0xC3, 0x86, 0x1C, 0x38, 0x70, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0xE0, 0xC1, 0xC3, 0x87, 0x06, 0x0E, 0x1C, 0x1C, 0x18, 0x38, 0xE0,
  0xE0, 0xC1, 0xC1, 0x83, 0x87, 0x06, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3,
  0x87, 0x0E, 0x1C, 0x38, 0xE1, 0xC3, 0x8E, 0x1C, 0x70, 0xE3, 0x80, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x0E, 0x61, 0xBF, 0xFF,
  0xFF, 0xFF, 0x03, 0x80, 0x0D, 0x80, 0x3B, 0x80, 0xE3, 0x83, 0xC7, 0x83,
  0x06, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x39, 0xDC, 0xE7, 0x31, 0x9C, 0xFF, 0xFF,
  0xFF, 0x6F, 0xFF, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0xE0, 0x1C, 0x07, 0x00,
  0xE0, 0x18, 0x07, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x00,
  0xC0, 0x38, 0x07, 0x00, 0xC0, 0x38, 0x07, 0x01, 0xC0, 0x00, 0x1F, 0xC0,
  0xFF, 0xC7, 0x87, 0x1C, 0x0E, 0xE0, 0x1B, 0x80, 0x7E, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xE7, 0x03, 0x9E, 0x1C, 0x3F, 0xF0, 0x7F,
  0x00, 0x07, 0x0F, 0x3F, 0x7F, 0xE7, 0x47, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x1F,
  0xE0, 0x7F, 0xF1, 0xE0, 0xF1, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xF0, 0xFF, 0xF1, 0xC0, 0xF2, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x1F, 0xE0,
  0x3F, 0x00, 0x7F, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x77, 0x01, 0xEF, 0xFF, 0x8F, 0xFC, 0x00, 0x00,
  0x38, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xB8, 0x03, 0xB8, 0x07,
  0x38, 0x06, 0x38, 0x0E, 0x38, 0x1C, 0x38, 0x18, 0x38, 0x30, 0x38, 0x70,
  0x38, 0xE0, 0x38, 0xC0, 0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x7F, 0xF1, 0xFF, 0xC7, 0x00,
  0x1C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x66, 0x01, 0xFF,
  0x8F, 0xFF, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x03, 0xB0, 0x1E, 0xFF, 0xF1, 0xFF, 0x00, 0x07, 0xF8,
  0x3F, 0xE3, 0xC0, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x00,
  0xE7, 0xC3, 0xBF, 0xCD, 0xC7, 0xBC, 0x0F, 0xE0, 0x1F, 0x80, 0x7C, 0x00,
  0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x77, 0x01, 0xCE, 0x1E, 0x3F, 0xF0, 0x3F,
  0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03,
  0x80, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x1F, 0xE1, 0xFF, 0xC7, 0x03,
  0xB8, 0x0E, 0xE0, 0x1B, 0x80, 0x6E, 0x03, 0x9C, 0x0E, 0x38, 0xF0, 0x7F,
  0x80, 0xFC, 0x0F, 0xF8, 0x78, 0x7B, 0x80, 0xEE, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7E, 0x01, 0xFC, 0x0E, 0x7F, 0xF0, 0x7F, 0x80, 0x1F, 0xC0,
  0xFF, 0x87, 0x07, 0x38, 0x0E, 0xE0, 0x1B, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x80, 0x7E, 0x03, 0xDF, 0x7F, 0x3F, 0xDC, 0x38, 0x70, 0x01,
  0xC0, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x7F, 0xC1, 0xFC,
  0x00, 0x7F, 0xF7, 0x00, 0x00, 0x00, 0x00, 0x06, 0xFF, 0xF0, 0x3B, 0xDE,
  0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1D, 0xCE, 0x73, 0x19, 0xCC, 0x00,
  0x00, 0x04, 0x00, 0x70, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0x3C, 0x00, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00,
  0xF0, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0x00, 0x0F, 0x00, 0x1F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x3C, 0x03, 0xE0, 0x3E,
  0x07, 0xC0, 0x7C, 0x03, 0xC0, 0x0C, 0x00, 0x00, 0x3F, 0xC7, 0xFF, 0x18,
  0x1C, 0x00, 0x60, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0xF0, 0x0F,
  0x00, 0xE0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x00, 0xFF, 0x80, 0x03,
  0xFF, 0xE0, 0x07, 0x80, 0xF8, 0x1E, 0x00, 0x3C, 0x18, 0x00, 0x0C, 0x30,
  0x00, 0x0E, 0x70, 0x3F, 0x86, 0x60, 0xFF, 0x87, 0xE1, 0xC1, 0x83, 0xC1,
  0x81, 0x83, 0xC3, 0x81, 0x83, 0xC3, 0x81, 0x83, 0xC3, 0x01, 0x83, 0xC3,
  0x03, 0x83, 0xC3, 0x83, 0x87, 0xC3, 0x83, 0x86, 0xC1, 0xCE, 0xCE, 0xE0,
  0xFC, 0xFC, 0x60, 0x30, 0x30, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x40, 0x0F, 0x87, 0xC0, 0x07, 0xFF, 0xC0, 0x00, 0x7C, 0x00, 0x00,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xB8, 0x00,
  0x39, 0x80, 0x03, 0x9C, 0x00, 0x31, 0xC0, 0x07, 0x0E, 0x00, 0x70, 0xE0,
  0x0E, 0x06, 0x00, 0xE0, 0x70, 0x0C, 0x07, 0x01, 0xFF, 0xF0, 0x1F, 0xFF,
  0x81, 0x80, 0x38, 0x38, 0x01, 0xC3, 0x80, 0x1C, 0x70, 0x00, 0xC7, 0x00,
  0x0E, 0x60, 0x00, 0xEE, 0x00, 0x07, 0xFF, 0xE1, 0xFF, 0xF3, 0x81, 0xF7,
  0x00, 0xEE, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x0E, 0xE0, 0x1D, 0xFF,
  0xF3, 0xFF, 0x87, 0xFF, 0xEE, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0x07, 0xEF, 0xFF, 0x9F, 0xFC, 0x00,
  0x03, 0xFF, 0x87, 0xFF, 0x87, 0xC0, 0xC7, 0x80, 0x07, 0x80, 0x03, 0x80,
  0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x60, 0xFF, 0xF0, 0x3F, 0xF8, 0xFF,
  0xE0, 0x3F, 0xFE, 0x0E, 0x07, 0xE3, 0x80, 0x3C, 0xE0, 0x07, 0x38, 0x00,
  0xEE, 0x00, 0x3B, 0x80, 0x0E, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3B, 0x80, 0x0E, 0xE0,
  0x07, 0xB8, 0x03, 0xCE, 0x01, 0xE3, 0x83, 0xF0, 0xFF, 0xF8, 0x3F, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x03, 0xFF, 0x83, 0xFF, 0xF1,
  0xF0, 0x18, 0xF0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x00, 0x7E, 0x00, 0x1D, 0xC0, 0x07, 0x70, 0x01, 0xDE, 0x00, 0x73,
  0xC0, 0x1C, 0x7C, 0x07, 0x0F, 0xFF, 0xC0, 0xFF, 0xE0, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1C, 0xFF, 0xFF, 0x1C, 0x1C,
  0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C,
  0x1C, 0x1C, 0x1C, 0x1C, 0xFF, 0xFF, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x06, 0x0E, 0xFE, 0xFC, 0xF0, 0xE0, 0x0F,
  0xE0, 0x1C, 0xE0, 0x38, 0xE0, 0x78, 0xE0, 0xF0, 0xE0, 0xE0, 0xE1, 0xC0,
  0xE3, 0x80, 0xE7, 0x00, 0xEE, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0xF3, 0x80,
  0xE1, 0xC0, 0xE1, 0xE0, 0xE0, 0xE0, 0xE0, 0x70, 0xE0, 0x38, 0xE0, 0x3C,
  0xE0, 0x1C, 0xE0, 0x0E, 0xE0, 0x07, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xF6,
  0x00, 0x1F, 0xDC, 0x00, 0xFF, 0xB0, 0x03, 0x7E, 0xE0, 0x1D, 0xFB, 0x80,
  0x77, 0xE6, 0x01, 0x9F, 0x9C, 0x0E, 0x7E, 0x70, 0x31, 0xF8, 0xC0, 0xC7,
  0xE3, 0x87, 0x1F, 0x86, 0x18, 0x7E, 0x1C, 0xE1, 0xF8, 0x73, 0x87, 0xE0,
  0xCC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0x81, 0xF8, 0x1E, 0x07, 0xE0, 0x78,
  0x1F, 0x80, 0xC0, 0x70, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF0,
  0x07, 0xDC, 0x01, 0xF3, 0x80, 0x7C, 0xF0, 0x1F, 0x9C, 0x07, 0xE3, 0x81,
  0xF8, 0xE0, 0x7E, 0x1C, 0x1F, 0x83, 0x87, 0xE0, 0xE1, 0xF8, 0x1C, 0x7E,
  0x07, 0x9F, 0x80, 0xE7, 0xE0, 0x1D, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x80,
  0x1F, 0xE0, 0x07, 0xF8, 0x00, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xF8, 0x1E,
  0x07, 0xC3, 0x80, 0x1C, 0x78, 0x00, 0xE7, 0x00, 0x0E, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0x70, 0x00,
  0xE7, 0x80, 0x0E, 0x3C, 0x01, 0xC1, 0xF0, 0x78, 0x0F, 0xFF, 0x00, 0x3F,
  0xE0, 0xFF, 0xC3, 0xFF, 0xCE, 0x0F, 0xB8, 0x0F, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xFE, 0x07, 0xBF, 0xFC, 0xFF, 0xC3,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xF8, 0x1E, 0x07, 0xC3,
  0x80, 0x1C, 0x78, 0x00, 0xE7, 0x00, 0x0E, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0x70, 0x00, 0xE7, 0x80,
  0x0E, 0x3C, 0x01, 0xC1, 0xF0, 0x78, 0x0F, 0xFF, 0x00, 0x3F, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xE0,
  0xFF, 0xE0, 0xFF, 0xF0, 0xE0, 0xF8, 0xE0, 0x3C, 0xE0, 0x1C, 0xE0, 0x1C,
  0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x38, 0xFF, 0xF0, 0xFF, 0xE0,
  0xFF, 0xC0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x70, 0xE0, 0x70, 0xE0, 0x38,
  0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x0E, 0xE0, 0x0F, 0x1F, 0xF1, 0xFF, 0xE7,
  0x03, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x78, 0x00,
  0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07,
  0x00, 0x1C, 0x00, 0x60, 0x03, 0xB0, 0x3E, 0xFF, 0xF3, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03,
  0x9C, 0x01, 0xCF, 0x83, 0xC3, 0xFF, 0xC0, 0x7F, 0xC0, 0xE0, 0x01, 0xEC,
  0x00, 0x39, 0xC0, 0x07, 0x38, 0x01, 0xC3, 0x80, 0x38, 0x70, 0x07, 0x0E,
  0x01, 0xC0, 0xE0, 0x38, 0x1C, 0x07, 0x03, 0x81, 0xC0, 0x38, 0x38, 0x07,
  0x06, 0x00, 0x61, 0xC0, 0x0E, 0x38, 0x01, 0xC6, 0x00, 0x19, 0xC0, 0x03,
  0xB8, 0x00, 0x76, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x01,
  0xC0, 0x00, 0xE0, 0x07, 0x00, 0x77, 0x00, 0xF0, 0x07, 0x70, 0x0F, 0x80,
  0x77, 0x00, 0xF8, 0x06, 0x30, 0x1D, 0x80, 0xE3, 0x81, 0xD8, 0x0E, 0x38,
  0x1D, 0xC0, 0xE3, 0x81, 0x9C, 0x0C, 0x18, 0x38, 0xC1, 0xC1, 0xC3, 0x8E,
  0x1C, 0x1C, 0x30, 0xE1, 0xC1, 0xC7, 0x06, 0x18, 0x0E, 0x70, 0x73, 0x80,
  0xE7, 0x07, 0x38, 0x0E, 0x60, 0x73, 0x80, 0x6E, 0x03, 0x30, 0x06, 0xE0,
  0x3F, 0x00, 0x7C, 0x03, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x3C, 0x01, 0xE0,
  0x03, 0xC0, 0x1E, 0x00, 0x38, 0x00, 0xE0, 0x70, 0x03, 0xCE, 0x00, 0xC3,
  0x80, 0x70, 0x70, 0x38, 0x0E, 0x0E, 0x03, 0x87, 0x00, 0x73, 0x80, 0x0C,
  0xE0, 0x03, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xF0,
  0x00, 0xCE, 0x00, 0x73, 0x80, 0x38, 0x70, 0x0C, 0x0E, 0x07, 0x03, 0x83,
  0x80, 0x70, 0xE0, 0x1C, 0x70, 0x03, 0xB8, 0x00, 0x70, 0xE0, 0x03, 0xDC,
  0x00, 0xE7, 0x00, 0x70, 0xE0, 0x1C, 0x38, 0x0E, 0x07, 0x03, 0x00, 0xE1,
  0xC0, 0x38, 0xE0, 0x07, 0x38, 0x01, 0xDC, 0x00, 0x3F, 0x00, 0x0F, 0x80,
  0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x7F,
  0xFE, 0x7F, 0xFE, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87,
  0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xFF, 0xF8, 0xE0, 0x0E, 0x01, 0xC0, 0x18,
  0x03, 0x80, 0x70, 0x06, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x38, 0x03, 0x00,
  0x70, 0x0E, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x07, 0x00, 0x60, 0x0E,
  0x01, 0xC0, 0xFF, 0xFC, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0F,
  0xFF, 0xF8, 0x03, 0x80, 0x03, 0x80, 0x07, 0xC0, 0x06, 0xC0, 0x0E, 0x60,
  0x0C, 0x60, 0x0C, 0x30, 0x18, 0x30, 0x18, 0x18, 0x30, 0x18, 0x30, 0x0C,
  0x70, 0x0C, 0x60, 0x06, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0xF1, 0xC3,
  0x86, 0x0C, 0x07, 0xE0, 0xFF, 0xC1, 0xE7, 0x84, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC1, 0xFF, 0x3F, 0xFD, 0xE0, 0x77, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0xF7, 0x07, 0xDF, 0xFB, 0x3F, 0x8C, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x31, 0xF0, 0xDF, 0xF3,
  0xF3, 0xEF, 0x03, 0xB8, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x03,
  0xC0, 0x1F, 0x00, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3B, 0xE1, 0xED, 0xFF,
  0x33, 0xF8, 0x07, 0xE1, 0xFF, 0x3E, 0xE7, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x78,
  0x33, 0xFF, 0x0F, 0xE0, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC3, 0xE3, 0x3F, 0xED, 0xF3, 0xF7, 0x03, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x01, 0xF8, 0x07, 0x70, 0x1D, 0xE0, 0xF3, 0xFE, 0xC7, 0xF3, 0x0F, 0xC0,
  0x7F, 0x83, 0xCF, 0x1C, 0x0E, 0xE0, 0x1B, 0x80, 0x7E, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x81,
  0x8F, 0xFE, 0x0F, 0xF0, 0x01, 0xE0, 0x7F, 0x0F, 0xE0, 0xE0, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0xFC, 0xFF, 0xC1, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x0F, 0x8C, 0xFF, 0xB7, 0xCF, 0xDC, 0x0F, 0xE0,
  0x1F, 0x80, 0x7E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x1D, 0xC0, 0x77, 0x83, 0xCF, 0xFB, 0x1F, 0xCC, 0x00, 0x30,
  0x00, 0xC0, 0x07, 0x00, 0x1D, 0x80, 0xE7, 0xFF, 0x9F, 0xF8, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x31, 0xF0,
  0xDF, 0xF3, 0xF3, 0xEF, 0x03, 0xB8, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0x6F, 0xF2, 0x00, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x60, 0x06, 0x0F, 0x0F, 0x02, 0x00, 0x00, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x0E, 0xFE, 0xFC, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x0F, 0xC0,
  0x76, 0x07, 0x30, 0x71, 0x87, 0x0C, 0x70, 0x67, 0x03, 0x70, 0x1F, 0xC0,
  0xFF, 0x07, 0x38, 0x30, 0xE1, 0x83, 0x8C, 0x1E, 0x60, 0x73, 0x01, 0xD8,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xC1, 0xF9, 0xBF, 0xC7,
  0xFB, 0xF7, 0xDE, 0xFF, 0x83, 0xE0, 0x7E, 0x03, 0xC0, 0x7C, 0x07, 0x00,
  0xF0, 0x0E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x0F,
  0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x00, 0xF0,
  0x0E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x06, 0xC7, 0xC3, 0x7F, 0xCF,
  0xCF, 0xBC, 0x0E, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1C, 0x07, 0xC0, 0x3F, 0xE0, 0xFB, 0xE3, 0x80, 0xEE, 0x01, 0xDC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xCE, 0x03, 0x9E, 0x0E, 0x1F, 0xFC, 0x0F, 0xE0, 0xC7, 0xC3,
  0x7F, 0xCF, 0xCF, 0xBC, 0x0E, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xEF, 0x87,
  0xB7, 0xFC, 0xCF, 0xE3, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x0F, 0x8C, 0xFF, 0xB7, 0xCF, 0xDC, 0x0F, 0xE0,
  0x1F, 0x80, 0x7E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x07, 0xE0, 0x1D, 0xC0, 0x77, 0x83, 0xCF, 0xFB, 0x1F, 0xCC, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0xC7, 0xE7,
  0xF7, 0xFE, 0x0E, 0x07, 0x03, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x00, 0x1F, 0x8F, 0xFF, 0xC7, 0xE0, 0x0C,
  0x01, 0xC0, 0x3C, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0x80, 0x70, 0x06,
  0x00, 0xE0, 0x3F, 0xFE, 0xFF, 0x80, 0x0C, 0x03, 0x80, 0x70, 0x1F, 0xEF,
  0xFC, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x3F, 0x83, 0xF0, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x76, 0x01, 0xEE, 0x03,
  0xDE, 0x0F, 0x9F, 0xF7, 0x1F, 0xCE, 0xE0, 0x07, 0xE0, 0x0E, 0x70, 0x0E,
  0x70, 0x0E, 0x30, 0x1C, 0x38, 0x1C, 0x38, 0x18, 0x18, 0x38, 0x1C, 0x38,
  0x1C, 0x30, 0x0E, 0x70, 0x0E, 0x70, 0x06, 0xE0, 0x07, 0xE0, 0x07, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0xE0, 0x1C, 0x07, 0x60, 0x3C, 0x07, 0x70, 0x3C,
  0x06, 0x70, 0x3E, 0x0E, 0x70, 0x76, 0x0E, 0x30, 0x76, 0x0E, 0x38, 0x67,
  0x0C, 0x38, 0xE7, 0x1C, 0x18, 0xE3, 0x1C, 0x1C, 0xC3, 0x18, 0x1C, 0xC3,
  0x98, 0x1D, 0xC1, 0xB8, 0x0D, 0x81, 0xB8, 0x0D, 0x81, 0xF0, 0x0F, 0x81,
  0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0xF0, 0xE0, 0x1E, 0xE0, 0x39, 0xC0,
  0xE1, 0xC3, 0x81, 0xC7, 0x03, 0x9C, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0x80,
  0x0F, 0x80, 0x3F, 0x00, 0xE7, 0x01, 0xC7, 0x07, 0x0E, 0x1C, 0x0E, 0x38,
  0x0E, 0xE0, 0x1E, 0xE0, 0x07, 0xE0, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x38,
  0x1C, 0x38, 0x1C, 0x38, 0x1C, 0x1C, 0x38, 0x1C, 0x38, 0x0C, 0x30, 0x0E,
  0x70, 0x06, 0x70, 0x06, 0x60, 0x07, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x01,
  0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x0F, 0x00, 0xFE,
  0x00, 0xFC, 0x00, 0x7F, 0xF7, 0xFF, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0x70, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xC1, 0xF0, 0xF0, 0x38, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x01, 0xC0, 0x70, 0xF8, 0x38, 0x0F, 0x80,
  0x70, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x38, 0x0F,
  0x81, 0xF0, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xE0, 0x3E, 0x03, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x00, 0xC0, 0x38, 0x07, 0xC0, 0x70, 0x7C, 0x38, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x78, 0x3E, 0x0E,
  0x00, 0x7C, 0x07, 0xFE, 0x3C, 0x7F, 0xE0, 0x7E,
};

const GFXglyph NotoSans_Regular31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 4, 22, 8, 2, -22 },
  { 12, 9, 8, 13, 2, -22 },
  { 21, 18, 22, 20, 1, -22 },
  { 71, 14, 26, 18, 2, -24 },
  { 117, 22, 22, 26, 2, -22 },
  { 178, 21, 22, 23, 2, -22 },
  { 236, 3, 8, 7, 2, -22 },
  { 239, 7, 27, 9, 1, -22 },
  { 263, 7, 27, 9, 1, -22 },
  { 287, 15, 14, 17, 1, -24 },
  { 314, 14, 15, 18, 2, -18 },
  { 341, 5, 8, 8, 1, -4 },
  { 346, 8, 3, 10, 1, -10 },
  { 349, 4, 4, 8, 2, -4 },
  { 351, 11, 22, 12, 0, -22 },
  { 382, 14, 22, 18, 2, -22 },
  { 421, 8, 22, 18, 3, -22 },
  { 443, 15, 22, 18, 1, -22 },
  { 485, 15, 22, 18, 1, -22 },
  { 527, 16, 22, 18, 1, -22 },
  { 571, 14, 22, 18, 2, -22 },
  { 610, 14, 22, 18, 2, -22 },
  { 649, 15, 22, 18, 1, -22 },
  { 691, 14, 22, 18, 2, -22 },
  { 730, 14, 22, 18, 2, -22 },
  { 769, 4, 17, 8, 2, -17 },
  { 778, 5, 21, 8, 1, -17 },
  { 792, 14, 15, 18, 2, -19 },
  { 819, 14, 8, 18, 2, -15 },
  { 833, 14, 15, 18, 2, -19 },
  { 860, 13, 22, 13, 0, -22 },
  { 896, 24, 25, 28, 2, -22 },
  { 971, 20, 22, 20, 0, -22 },
  { 1026, 15, 22, 20, 3, -22 },
  { 1068, 17, 22, 20, 2, -22 },
  { 1115, 18, 22, 23, 3, -22 },
  { 1165, 12, 22, 17, 3, -22 },
  { 1198, 12, 22, 16, 3, -22 },
  { 1231, 18, 22, 23, 2, -22 },
  { 1281, 17, 22, 23, 3, -22 },
  { 1328, 8, 22, 11, 1, -22 },
  { 1350, 8, 28, 8, -2, -22 },
  { 1378, 16, 22, 19, 3, -22 },
  { 1422, 12, 22, 16, 3, -22 },
  { 1455, 22, 22, 28, 3, -22 },
  { 1516, 18, 22, 24, 3, -22 },
  { 1566, 20, 22, 24, 2, -22 },
  { 1621, 14, 22, 19, 3, -22 },
  { 1660, 20, 27, 24, 2, -22 },
  { 1728, 16, 22, 19, 3, -22 },
  { 1772, 14, 22, 17, 2, -22 },
  { 1811, 17, 22, 17, 0, -22 },
  { 1858, 17, 22, 23, 3, -22 },
  { 1905, 19, 22, 19, 0, -22 },
  { 1958, 28, 22, 29, 0, -22 },
  { 2035, 18, 22, 18, 0, -22 },
  { 2085, 18, 22, 18, 0, -22 },
  { 2135, 16, 22, 18, 1, -22 },
  { 2179, 7, 27, 10, 2, -22 },
  { 2203, 11, 22, 12, 0, -22 },
  { 2234, 7, 27, 10, 1, -22 },
  { 2258, 16, 14, 18, 1, -22 },
  { 2286, 14, 2, 14, 0, 3 },
  { 2290, 6, 5, 9, 1, -24 },
  { 2294, 14, 17, 17, 1, -17 },
  { 2324, 14, 24, 19, 3, -24 },
  { 2366, 12, 17, 15, 2, -17 },
  { 2392, 14, 24, 19, 2, -24 },
  { 2434, 14, 17, 17, 2, -17 },
  { 2464, 12, 24, 11, 0, -24 },
  { 2500, 14, 24, 19, 2, -17 },
  { 2542, 14, 24, 19, 3, -24 },
  { 2584, 4, 23, 8, 2, -23 },
  { 2596, 8, 30, 8, -2, -23 },
  { 2626, 13, 24, 17, 3, -24 },
  { 2665, 2, 24, 8, 3, -24 },
  { 2671, 23, 17, 29, 3, -17 },
  { 2720, 14, 17, 19, 3, -17 },
  { 2750, 15, 17, 19, 2, -17 },
  { 2782, 14, 24, 19, 3, -17 },
  { 2824, 14, 24, 19, 2, -17 },
  { 2866, 9, 17, 13, 3, -17 },
  { 2886, 11, 17, 15, 2, -17 },
  { 2910, 11, 20, 11, 0, -20 },
  { 2938, 15, 17, 19, 2, -17 },
  { 2970, 16, 17, 16, 0, -17 },
  { 3004, 24, 17, 24, 0, -17 },
  { 3055, 15, 17, 16, 1, -17 },
  { 3087, 16, 24, 16, 0, -17 },
  { 3135, 12, 17, 15, 1, -17 },
  { 3161, 10, 27, 12, 1, -22 },
  { 3195, 3, 31, 17, 7, -24 },
  { 3207, 10, 27, 12, 1, -22 },
  { 3241, 14, 4, 18, 2, -13 },
};

const GFXfont NotoSans_Regular31pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Regular31pt7bBitmaps,
  (GFXglyph *)NotoSans_Regular31pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _NOTOSANS_REGULAR31PT7B_H_
