#ifndef _NOTOSANS_REGULAR14PT7B_H_
#define _NOTOSANS_REGULAR14PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Regular.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Regular14pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0xA8, 0xB0, 0xB9, 0x99, 0x12, 0x09, 0x04, 0x8F, 0xF1, 0x21,
  0x23, 0xFC, 0x48, 0x24, 0x12, 0x00, 0x20, 0x8F, 0xE8, 0xA1, 0xC1, 0xC9,
  0x27, 0xF2, 0x08, 0xE1, 0x24, 0x89, 0x22, 0x50, 0x97, 0xBA, 0x91, 0xA4,
  0x49, 0x22, 0x58, 0xE0, 0x78, 0x26, 0x13, 0x0D, 0x03, 0x06, 0xCE, 0x35,
  0x0E, 0x87, 0x3C, 0xC0, 0xF0, 0x6A, 0x49, 0x24, 0x91, 0x30, 0xC6, 0x22,
  0x33, 0x33, 0x22, 0x6C, 0x30, 0x8A, 0x7F, 0x31, 0x6C, 0x80, 0x30, 0xC3,
  0x3F, 0x30, 0xC0, 0xEA, 0xE0, 0xB0, 0x08, 0xC4, 0x22, 0x11, 0x88, 0x46,
  0x00, 0x7B, 0x38, 0x61, 0x86, 0x18, 0x61, 0xCD, 0xE0, 0x37, 0x91, 0x11,
  0x11, 0x11, 0x7A, 0x30, 0x43, 0x08, 0x63, 0x18, 0xC3, 0xF0, 0xFA, 0x30,
  0x43, 0x78, 0x70, 0x41, 0x8F, 0xE0, 0x04, 0x0C, 0x14, 0x14, 0x24, 0x44,
  0xC4, 0xFF, 0x04, 0x04, 0xFF, 0x08, 0x20, 0xF8, 0x30, 0x41, 0x8F, 0xE0,
  0x3D, 0x0C, 0x20, 0xFE, 0x18, 0x61, 0xC5, 0xE0, 0xFC, 0x10, 0xC2, 0x18,
  0x41, 0x08, 0x21, 0x00, 0x7A, 0x18, 0x73, 0x71, 0x68, 0x61, 0x85, 0xE0,
  0x7A, 0x38, 0x61, 0x85, 0xF0, 0x41, 0x0B, 0xC0, 0xB0, 0x0B, 0x4C, 0x00,
  0x1A, 0x50, 0x04, 0x33, 0x30, 0xC0, 0xC0, 0xC0, 0xFC, 0x00, 0x3F, 0x83,
  0x03, 0x03, 0x0C, 0xCC, 0x00, 0xFA, 0x30, 0x42, 0x18, 0xC2, 0x00, 0x20,
  0x80, 0x1F, 0x04, 0x19, 0x01, 0x47, 0x99, 0x13, 0x22, 0x64, 0xCC, 0xFA,
  0x80, 0x88, 0x00, 0xFC, 0x00, 0x08, 0x0A, 0x05, 0x02, 0x82, 0x21, 0x11,
  0xFC, 0x82, 0x41, 0x40, 0xC0, 0xFD, 0x8F, 0x0E, 0x1F, 0xD8, 0xF0, 0xE1,
  0xC7, 0xF8, 0x3E, 0xC7, 0x04, 0x08, 0x10, 0x20, 0x60, 0x60, 0x7C, 0xFC,
  0xC6, 0xC3, 0xC1, 0xC1, 0xC1, 0xC1, 0xC3, 0xC6, 0xFC, 0xFF, 0x0C, 0x30,
  0xFF, 0x0C, 0x30, 0xC3, 0xF0, 0xFF, 0x0C, 0x30, 0xC3, 0xFC, 0x30, 0xC3,
  0x00, 0x3F, 0x61, 0xC0, 0x80, 0x80, 0x87, 0x81, 0xC1, 0x61, 0x3F, 0xC1,
  0xC1, 0xC1, 0xC1, 0xFF, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xE9, 0x24, 0x92,
  0x5C, 0x33, 0x33, 0x33, 0x33, 0x33, 0x3E, 0xC0, 0xC3, 0xC4, 0xC8, 0xD0,
  0xF0, 0xD0, 0xC8, 0xCC, 0xC6, 0xC3, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0xF0, 0xC0, 0xE8, 0x3A, 0x0F, 0xC5, 0xD1, 0x74, 0xDD, 0xA7, 0x29,
  0xCC, 0x71, 0x10, 0xC1, 0xE1, 0xA1, 0xD1, 0xD9, 0xC9, 0xC5, 0xC7, 0xC3,
  0xC3, 0x3E, 0x31, 0xB0, 0x70, 0x18, 0x0C, 0x06, 0x03, 0x83, 0x63, 0x1F,
  0x00, 0xF9, 0x8B, 0x1E, 0x3C, 0x5F, 0x30, 0x60, 0xC1, 0x80, 0x3E, 0x31,
  0xB0, 0x70, 0x18, 0x0C, 0x06, 0x03, 0x83, 0x63, 0x1F, 0x01, 0x80, 0x70,
  0xFC, 0xC4, 0xC6, 0xC6, 0xC4, 0xF8, 0xC8, 0xC4, 0xC6, 0xC3, 0x7E, 0x18,
  0x30, 0x60, 0x60, 0xC1, 0x8F, 0xE0, 0xFF, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1,
  0x42, 0x3E, 0x81, 0x41, 0x43, 0x62, 0x26, 0x24, 0x34, 0x1C, 0x18, 0x18,
  0xC2, 0x1A, 0x38, 0x91, 0x44, 0x8A, 0x26, 0xD3, 0x14, 0x50, 0xA2, 0x85,
  0x14, 0x38, 0xE0, 0x82, 0x00, 0xC3, 0x62, 0x24, 0x1C, 0x18, 0x18, 0x34,
  0x26, 0x42, 0xC3, 0xC3, 0x42, 0x66, 0x24, 0x38, 0x18, 0x18, 0x18, 0x18,
  0x18, 0xFC, 0x10, 0x86, 0x10, 0x86, 0x10, 0x83, 0xF0, 0xF2, 0x49, 0x24,
  0x92, 0x70, 0xC2, 0x10, 0xC2, 0x10, 0x42, 0x18, 0x40, 0xE4, 0x92, 0x49,
  0x24, 0xF0, 0x20, 0xC5, 0x92, 0x86, 0x10, 0xFC, 0xB4, 0x33, 0x20, 0xC7,
  0xEE, 0x38, 0xFD, 0x81, 0x02, 0x04, 0xCE, 0xD8, 0xE0, 0xC1, 0xC7, 0x8A,
  0xF0, 0x33, 0x61, 0x08, 0x43, 0x0F, 0x04, 0x10, 0x4D, 0xCE, 0x18, 0x61,
  0x87, 0x17, 0xC0, 0x31, 0x38, 0x7F, 0x82, 0x0C, 0x1F, 0x19, 0x48, 0xFA,
  0x10, 0x84, 0x21, 0x08, 0x35, 0x38, 0x61, 0x86, 0x1C, 0x5F, 0x04, 0x1F,
  0xC0, 0x81, 0x02, 0x04, 0xCE, 0xD8, 0xA1, 0xC3, 0x87, 0x0E, 0x18, 0xCA,
  0xAA, 0xA0, 0x30, 0x22, 0x22, 0x22, 0x22, 0x22, 0xE0, 0x82, 0x08, 0x21,
  0x8A, 0x4A, 0x3C, 0x92, 0x28, 0xC0, 0xFF, 0xE0, 0x99, 0x9D, 0xCF, 0x10,
  0xC2, 0x18, 0x43, 0x08, 0x61, 0x0C, 0x21, 0x99, 0xDB, 0x14, 0x38, 0x70,
  0xE1, 0xC3, 0x30, 0x9A, 0x14, 0x38, 0x70, 0xF1, 0x3C, 0x99, 0xDB, 0x1C,
  0x18, 0x38, 0xF1, 0x5E, 0x81, 0x02, 0x00, 0x35, 0x38, 0x61, 0x86, 0x1C,
  0x5F, 0x04, 0x10, 0x40, 0x9D, 0x71, 0x08, 0x42, 0x10, 0x76, 0x61, 0x83,
  0x04, 0x3E, 0x23, 0xF8, 0xC6, 0x31, 0x8C, 0x38, 0x86, 0x18, 0x61, 0x86,
  0x1C, 0x5F, 0x83, 0x8D, 0x12, 0x22, 0xC5, 0x0A, 0x08, 0x84, 0x38, 0x8D,
  0x29, 0x25, 0x24, 0xA4, 0x63, 0x0C, 0x61, 0x8C, 0xC2, 0x88, 0xB0, 0xC1,
  0x85, 0x19, 0x63, 0x83, 0x8D, 0x12, 0x22, 0xC5, 0x0E, 0x08, 0x10, 0x63,
  0x80, 0xF8, 0x44, 0x46, 0x22, 0x1F, 0x19, 0x88, 0x42, 0x33, 0x84, 0x21,
  0x08, 0x30, 0xFF, 0xFC, 0xC1, 0x08, 0x42, 0x18, 0x64, 0x21, 0x09, 0xC0,
  0xE6, 0x70,
};

const GFXglyph NotoSans_Regular14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 2, 10, 4, 1, -10 },
  { 4, 4, 4, 6, 1, -10 },
  { 6, 9, 10, 9, 0, -10 },
  { 18, 6, 12, 8, 1, -11 },
  { 27, 10, 10, 12, 1, -10 },
  { 40, 9, 10, 10, 1, -10 },
  { 52, 1, 4, 3, 1, -10 },
  { 53, 3, 12, 4, 1, -10 },
  { 58, 4, 12, 4, 0, -10 },
  { 64, 6, 7, 8, 1, -11 },
  { 70, 6, 6, 8, 1, -8 },
  { 75, 2, 4, 4, 1, -2 },
  { 76, 3, 1, 5, 1, -4 },
  { 77, 2, 2, 4, 1, -2 },
  { 78, 5, 10, 5, 0, -10 },
  { 85, 6, 10, 8, 1, -10 },
  { 93, 4, 10, 8, 1, -10 },
  { 98, 6, 10, 8, 1, -10 },
  { 106, 6, 10, 8, 1, -10 },
  { 114, 8, 10, 8, 0, -10 },
  { 124, 6, 10, 8, 1, -10 },
  { 132, 6, 10, 8, 1, -10 },
  { 140, 6, 10, 8, 1, -10 },
  { 148, 6, 10, 8, 1, -10 },
  { 156, 6, 10, 8, 1, -10 },
  { 164, 2, 8, 4, 1, -8 },
  { 166, 3, 10, 4, 0, -8 },
  { 170, 6, 7, 8, 1, -9 },
  { 176, 6, 4, 8, 1, -7 },
  { 179, 6, 7, 8, 1, -9 },
  { 185, 6, 10, 6, 0, -10 },
  { 193, 11, 11, 13, 1, -10 },
  { 209, 9, 10, 9, 0, -10 },
  { 221, 7, 10, 9, 1, -10 },
  { 230, 7, 10, 9, 1, -10 },
  { 239, 8, 10, 10, 1, -10 },
  { 249, 6, 10, 8, 1, -10 },
  { 257, 6, 10, 7, 1, -10 },
  { 265, 8, 10, 10, 1, -10 },
  { 275, 8, 10, 10, 1, -10 },
  { 285, 3, 10, 5, 1, -10 },
  { 289, 4, 13, 4, -1, -10 },
  { 296, 8, 10, 9, 1, -10 },
  { 306, 6, 10, 7, 1, -10 },
  { 314, 10, 10, 13, 1, -10 },
  { 327, 8, 10, 11, 1, -10 },
  { 337, 9, 10, 11, 1, -10 },
  { 349, 7, 10, 8, 1, -10 },
  { 358, 9, 12, 11, 1, -10 },
  { 372, 8, 10, 9, 1, -10 },
  { 382, 6, 10, 8, 1, -10 },
  { 390, 8, 10, 8, 0, -10 },
  { 400, 8, 10, 10, 1, -10 },
  { 410, 8, 10, 8, 0, -10 },
  { 420, 13, 10, 13, 0, -10 },
  { 437, 8, 10, 8, 0, -10 },
  { 447, 8, 10, 8, 0, -10 },
  { 457, 6, 10, 8, 1, -10 },
  { 465, 3, 12, 5, 1, -10 },
  { 470, 5, 10, 5, 0, -10 },
  { 477, 3, 12, 5, 0, -10 },
  { 482, 6, 6, 8, 1, -10 },
  { 487, 6, 1, 6, 0, 1 },
  { 488, 2, 3, 4, 1, -11 },
  { 489, 6, 8, 8, 1, -8 },
  { 495, 7, 11, 9, 1, -11 },
  { 505, 5, 8, 7, 1, -8 },
  { 510, 6, 11, 9, 1, -11 },
  { 519, 6, 8, 8, 1, -8 },
  { 525, 5, 11, 5, 0, -11 },
  { 532, 6, 11, 9, 1, -8 },
  { 541, 7, 11, 9, 1, -11 },
  { 551, 2, 10, 4, 1, -10 },
  { 554, 4, 13, 4, -1, -10 },
  { 561, 6, 11, 7, 1, -11 },
  { 570, 1, 11, 4, 1, -11 },
  { 572, 11, 8, 13, 1, -8 },
  { 583, 7, 8, 9, 1, -8 },
  { 590, 7, 8, 8, 1, -8 },
  { 597, 7, 11, 9, 1, -8 },
  { 607, 6, 11, 9, 1, -8 },
  { 616, 5, 8, 6, 1, -8 },
  { 621, 5, 8, 7, 1, -8 },
  { 626, 5, 9, 5, 0, -9 },
  { 632, 6, 8, 9, 1, -8 },
  { 638, 7, 8, 7, 0, -8 },
  { 645, 11, 8, 11, 0, -8 },
  { 656, 7, 8, 7, 0, -8 },
  { 663, 7, 11, 7, 0, -8 },
  { 673, 5, 8, 7, 1, -8 },
  { 678, 5, 12, 5, 0, -10 },
  { 686, 1, 14, 8, 3, -11 },
  { 688, 5, 12, 5, 0, -10 },
  { 696, 6, 2, 8, 1, -6 },
};

const GFXfont NotoSans_Regular14pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Regular14pt7bBitmaps,
  (GFXglyph *)NotoSans_Regular14pt7bGlyphs,
  0x20, 0x7E, 19
};

#endif // _NOTOSANS_REGULAR14PT7B_H_
