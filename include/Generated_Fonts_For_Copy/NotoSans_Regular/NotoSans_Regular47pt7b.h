#ifndef _NOTOSANS_REGULAR47PT7B_H_
#define _NOTOSANS_REGULAR47PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Regular.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Regular47pt7bBitmaps[] PROGMEM = {
  0x00, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0x00, 0x00, 0x31, 0xFF,
  0xFF, 0xFD, 0xF3, 0x00, 0xF8, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07,
  0xF8, 0x3D, 0xC1, 0xEE, 0x0F, 0x70, 0x7B, 0x83, 0x9C, 0x1C, 0xE0, 0x67,
  0x03, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x3C, 0x0F,
  0x00, 0x03, 0x80, 0xE0, 0x00, 0x38, 0x0E, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x38, 0x0E, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x07, 0x01,
  0xC0, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0x00, 0xE0, 0x38, 0x00, 0x0E, 0x03, 0x80, 0x00, 0xE0,
  0x38, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x1C, 0x07, 0x00,
  0x01, 0xC0, 0x70, 0x0F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFE, 0x03, 0x80, 0xE0, 0x00, 0x38, 0x0E, 0x00, 0x03, 0x80, 0xE0,
  0x00, 0x78, 0x1E, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x70, 0x1C, 0x00, 0x07,
  0x01, 0xC0, 0x00, 0x70, 0x1C, 0x00, 0x07, 0x01, 0xC0, 0x00, 0xF0, 0x3C,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x80, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0xC7, 0xFF, 0xFE, 0x7E, 0x71,
  0xE7, 0xC3, 0x81, 0x3C, 0x1C, 0x01, 0xE0, 0xE0, 0x0F, 0x07, 0x00, 0x78,
  0x38, 0x03, 0xE1, 0xC0, 0x0F, 0x8E, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x01,
  0xC7, 0xE0, 0x0E, 0x1F, 0x00, 0x70, 0x78, 0x03, 0x83, 0xC0, 0x1C, 0x1E,
  0x00, 0xE0, 0xF8, 0x07, 0x0F, 0xF8, 0x39, 0xFB, 0xFF, 0xFF, 0x9F, 0xFF,
  0xF8, 0x7F, 0xFF, 0x00, 0x2F, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x78,
  0x03, 0xFC, 0x00, 0x1E, 0x00, 0xFF, 0xC0, 0x03, 0xC0, 0x3C, 0x3C, 0x00,
  0xF0, 0x07, 0x83, 0x80, 0x1C, 0x00, 0xE0, 0x78, 0x07, 0x80, 0x1C, 0x0F,
  0x00, 0xE0, 0x07, 0x80, 0xE0, 0x3C, 0x00, 0xF0, 0x1C, 0x07, 0x00, 0x1E,
  0x03, 0x81, 0xE0, 0x03, 0xC0, 0x70, 0x78, 0x00, 0x78, 0x0E, 0x0F, 0x00,
  0x0F, 0x01, 0xC3, 0xC0, 0x01, 0xE0, 0x38, 0x70, 0x30, 0x1C, 0x0F, 0x1E,
  0x3F, 0x83, 0x81, 0xE3, 0x8F, 0xF8, 0x78, 0x38, 0xF3, 0xEF, 0x87, 0x8F,
  0x1C, 0x78, 0x78, 0xFF, 0xC7, 0x9E, 0x07, 0x0F, 0xF9, 0xE3, 0xC0, 0xE0,
  0x7C, 0x3C, 0x70, 0x1C, 0x00, 0x0F, 0x0E, 0x03, 0xC0, 0x01, 0xC1, 0xC0,
  0x78, 0x00, 0x78, 0x38, 0x0F, 0x00, 0x0E, 0x07, 0x01, 0xE0, 0x03, 0xC0,
  0xE0, 0x3C, 0x00, 0x70, 0x1C, 0x07, 0x80, 0x1E, 0x03, 0xC0, 0xE0, 0x07,
  0x80, 0x78, 0x1C, 0x00, 0xF0, 0x07, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0xF0,
  0x07, 0x00, 0x1F, 0xFC, 0x01, 0xE0, 0x01, 0xFF, 0x00, 0x78, 0x00, 0x1F,
  0xC0, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x07, 0xE7, 0xF0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x0F, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0xF0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x07, 0x83, 0xE0,
  0x00, 0x07, 0xC7, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x3C, 0x1F, 0x9F, 0x00, 0x3C, 0x3F, 0x0F, 0x80, 0x7C, 0x3E, 0x07, 0xC0,
  0x78, 0x7C, 0x03, 0xE0, 0x78, 0x78, 0x01, 0xF8, 0xF8, 0x78, 0x00, 0xFC,
  0xF0, 0xF8, 0x00, 0x7F, 0xF0, 0xF8, 0x00, 0x3F, 0xE0, 0x78, 0x00, 0x1F,
  0xC0, 0x78, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x1F, 0xE0, 0x7E, 0x00, 0x7F,
  0xF0, 0x3F, 0x83, 0xFD, 0xF8, 0x1F, 0xFF, 0xF8, 0xFC, 0x0F, 0xFF, 0xE0,
  0x7E, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0xBD, 0xEF, 0x79, 0xCE, 0x73, 0x9C,
  0xE7, 0x00, 0x01, 0xE0, 0x78, 0x1E, 0x03, 0xC0, 0xF0, 0x3E, 0x07, 0x81,
  0xF0, 0x3C, 0x07, 0x81, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xE0, 0x3C, 0x07,
  0x80, 0xF8, 0x0F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xE0, 0xF0,
  0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x7C, 0x07, 0x80,
  0xF0, 0x1F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF8, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x81, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x3E, 0x07,
  0x81, 0xF0, 0x3C, 0x0F, 0x81, 0xE0, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x38, 0x1C, 0x06, 0xFE, 0x71, 0xFB, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC1, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x3D,
  0xE0, 0x00, 0xF3, 0xC0, 0x07, 0x8F, 0x80, 0x3E, 0x1F, 0x00, 0xF0, 0x7C,
  0x07, 0xC0, 0xF8, 0x07, 0x03, 0x80, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x3E, 0x7C,
  0xF1, 0xE7, 0xCF, 0x1E, 0x3C, 0x71, 0xE3, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x31, 0xFF, 0xFF, 0xFD, 0xF3, 0x00, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07,
  0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x07,
  0xFF, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0x7F, 0x01, 0xF0, 0x1F, 0x07, 0xC0,
  0x1E, 0x0F, 0x00, 0x1E, 0x3E, 0x00, 0x3C, 0x78, 0x00, 0x7C, 0xF0, 0x00,
  0x79, 0xE0, 0x00, 0xF3, 0xC0, 0x01, 0xEF, 0x80, 0x03, 0xDF, 0x00, 0x07,
  0xBC, 0x00, 0x0F, 0x78, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xCF, 0x00, 0x07, 0x9E,
  0x00, 0x0F, 0x3C, 0x00, 0x1E, 0x78, 0x00, 0x3C, 0xF0, 0x00, 0x78, 0xF0,
  0x01, 0xE1, 0xE0, 0x03, 0xC3, 0xE0, 0x0F, 0x83, 0xC0, 0x3E, 0x07, 0xE0,
  0xFC, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x00, 0x78,
  0x07, 0xC0, 0x7E, 0x0F, 0xF0, 0xFF, 0x8F, 0xBD, 0xF9, 0xFF, 0x8F, 0x78,
  0x79, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x01, 0xFE, 0x00, 0x3F, 0xFE, 0x01,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x7C, 0x01, 0xF0, 0xE0, 0x03, 0xC2, 0x00,
  0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xFF, 0x03, 0xFF, 0xFE,
  0x3F, 0xF7, 0xFC, 0x7C, 0x01, 0xF0, 0xC0, 0x03, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x01, 0xFF, 0xE0,
  0x07, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7B,
  0x00, 0x03, 0xEF, 0x80, 0x7F, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7B, 0xC0,
  0x00, 0x3D, 0xE0, 0x00, 0x3C, 0xF0, 0x00, 0x3C, 0x78, 0x00, 0x1E, 0x3C,
  0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x0E, 0x07, 0x80, 0x0F, 0x03,
  0xC0, 0x0F, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x07, 0x80,
  0x3C, 0x07, 0x80, 0x1E, 0x03, 0xC0, 0x0F, 0x03, 0xC0, 0x07, 0x83, 0xC0,
  0x03, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3,
  0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x30, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x80, 0x3F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x40, 0x01, 0xFB, 0xE0, 0x3F, 0x9F, 0xFF,
  0xF8, 0xFF, 0xFF, 0x81, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x03, 0xFF,
  0x80, 0x3F, 0xFE, 0x01, 0xFE, 0x18, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC3, 0xF8, 0x0F, 0x3F, 0xFC,
  0x3D, 0xFF, 0xF8, 0xFF, 0x87, 0xF3, 0xF8, 0x07, 0xCF, 0x80, 0x0F, 0xBE,
  0x00, 0x1E, 0xF0, 0x00, 0x7B, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xF7, 0x80, 0x07, 0x9E, 0x00, 0x1E,
  0x7C, 0x00, 0xF8, 0xF8, 0x07, 0xC1, 0xF0, 0x3F, 0x07, 0xFF, 0xF8, 0x07,
  0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFF,
  0x80, 0x3F, 0xFF, 0x80, 0xFE, 0x3F, 0x83, 0xE0, 0x0F, 0x87, 0x80, 0x0F,
  0x1F, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x78, 0xF8, 0x00, 0xF0,
  0xF0, 0x01, 0xE1, 0xF0, 0x07, 0xC1, 0xF0, 0x1F, 0x03, 0xF0, 0x7C, 0x03,
  0xFB, 0xF0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x3F,
  0x3F, 0x80, 0xF8, 0x1F, 0x83, 0xE0, 0x0F, 0x8F, 0x80, 0x0F, 0x9E, 0x00,
  0x0F, 0x7C, 0x00, 0x1E, 0xF0, 0x00, 0x3D, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0xF7, 0xC0, 0x01, 0xE7, 0x80, 0x03, 0xCF, 0x80, 0x0F, 0x8F, 0xC0, 0x7E,
  0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3E, 0x01, 0xF0, 0xF0,
  0x03, 0xC7, 0x80, 0x07, 0x9E, 0x00, 0x1E, 0x78, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xF7,
  0x80, 0x03, 0xDE, 0x00, 0x1F, 0x7C, 0x00, 0xFC, 0xF8, 0x0F, 0xF1, 0xFF,
  0xFB, 0xC3, 0xFF, 0xCF, 0x07, 0xFE, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x82, 0x01, 0xFC, 0x07, 0xFF,
  0xE0, 0x1F, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x39, 0xFF, 0xFF, 0xFD, 0xF1,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x31, 0xFF,
  0xFF, 0xFD, 0xF3, 0x00, 0x0E, 0x1F, 0x3F, 0x3F, 0x3F, 0x1F, 0x04, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x1E, 0x3E, 0x3E, 0x3C, 0x3C, 0x38, 0x78, 0x78, 0x70, 0xF0,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0x00,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x80, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x3C, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x00,
  0xFE, 0x00, 0x03, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0F,
  0xF8, 0x1F, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFE, 0x70, 0x0F, 0x90, 0x01,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x1E, 0x00,
  0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x7F, 0xF0, 0x38, 0x70, 0x0F, 0xFF,
  0x81, 0xE7, 0x80, 0xFF, 0xFC, 0x07, 0x38, 0x0F, 0x80, 0xE0, 0x3B, 0xC0,
  0xF8, 0x07, 0x01, 0xDE, 0x07, 0x80, 0x78, 0x0E, 0xE0, 0x38, 0x03, 0xC0,
  0x7F, 0x03, 0xC0, 0x1E, 0x03, 0xF8, 0x1E, 0x00, 0xF0, 0x1D, 0xC0, 0xF0,
  0x07, 0x80, 0xEE, 0x07, 0x80, 0x3C, 0x07, 0x70, 0x3C, 0x01, 0xE0, 0x3B,
  0x81, 0xE0, 0x0F, 0x03, 0xDC, 0x07, 0x00, 0xF8, 0x1C, 0xE0, 0x3C, 0x07,
  0xC1, 0xE7, 0x81, 0xF0, 0xF7, 0x1E, 0x3C, 0x07, 0xFF, 0x3F, 0xF0, 0xE0,
  0x1F, 0xF0, 0xFF, 0x07, 0x80, 0x3E, 0x03, 0xE0, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x01, 0x00, 0x01, 0xFC, 0x00, 0x78, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xDE, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x3C, 0xF0, 0x00,
  0x00, 0xF3, 0xC0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x1E, 0x1E, 0x00, 0x00,
  0xF0, 0x3C, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x78,
  0x07, 0x80, 0x01, 0xE0, 0x1E, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x3C, 0x00,
  0xF0, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x03, 0xC0,
  0x7C, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x78, 0x3C,
  0x00, 0x01, 0xF0, 0xF0, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x0F, 0x9E, 0x00,
  0x00, 0x1E, 0x78, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x01, 0xF0, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x8F, 0x00, 0x7F,
  0x9E, 0x00, 0x1F, 0x3C, 0x00, 0x1F, 0x78, 0x00, 0x3E, 0xF0, 0x00, 0x7D,
  0xE0, 0x00, 0xFB, 0xC0, 0x01, 0xF7, 0x80, 0x03, 0xCF, 0x00, 0x07, 0x9E,
  0x00, 0x1E, 0x3C, 0x03, 0xF8, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xC3, 0xC0, 0x1F, 0xE7, 0x80, 0x07, 0xEF, 0x00, 0x07, 0xDE, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xDE, 0x00, 0x1F,
  0xBF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC1, 0xFF, 0xFE, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF0, 0xFE, 0x00, 0x70, 0xFC, 0x00, 0x08, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x08, 0x3F, 0xF0,
  0x7C, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0,
  0xF0, 0x07, 0xFC, 0x3C, 0x00, 0x3F, 0x8F, 0x00, 0x03, 0xF3, 0xC0, 0x00,
  0x7C, 0xF0, 0x00, 0x0F, 0xBC, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xBC, 0x00, 0x03, 0xEF,
  0x00, 0x01, 0xF3, 0xC0, 0x00, 0xFC, 0xF0, 0x00, 0x7E, 0x3C, 0x00, 0xFF,
  0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF,
  0xFF, 0xFB, 0xFF, 0xFE, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFE, 0x07, 0xF0, 0x03, 0xC0, 0xFC, 0x00, 0x04, 0x1F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F,
  0x7C, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x0F, 0x3E, 0x00, 0x00, 0xF3, 0xF0,
  0x00, 0x0F, 0x1F, 0x80, 0x00, 0xF0, 0xFC, 0x00, 0x0F, 0x07, 0xFC, 0x07,
  0xF0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF3, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xE0,
  0x0F, 0x00, 0xF8, 0x0F, 0xDF, 0xFC, 0xFF, 0xC7, 0xFC, 0x1F, 0x80, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0xF8, 0xF0,
  0x01, 0xF0, 0xF0, 0x03, 0xE0, 0xF0, 0x07, 0xC0, 0xF0, 0x0F, 0x80, 0xF0,
  0x1F, 0x00, 0xF0, 0x1E, 0x00, 0xF0, 0x3C, 0x00, 0xF0, 0x7C, 0x00, 0xF0,
  0xF8, 0x00, 0xF1, 0xF0, 0x00, 0xF3, 0xE0, 0x00, 0xF7, 0xE0, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xF0, 0x00, 0xFE, 0xF8, 0x00, 0xF8, 0xFC, 0x00, 0xF0,
  0x7C, 0x00, 0xF0, 0x3E, 0x00, 0xF0, 0x1F, 0x00, 0xF0, 0x1F, 0x00, 0xF0,
  0x0F, 0x80, 0xF0, 0x07, 0xC0, 0xF0, 0x03, 0xE0, 0xF0, 0x03, 0xE0, 0xF0,
  0x01, 0xF0, 0xF0, 0x00, 0xF8, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x7C, 0xF0,
  0x00, 0x3E, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x78, 0x00, 0x03, 0xFF, 0xBC,
  0x00, 0x01, 0xDF, 0xDE, 0x00, 0x01, 0xEF, 0xE7, 0x80, 0x00, 0xF7, 0xF3,
  0xC0, 0x00, 0xF3, 0xF8, 0xF0, 0x00, 0x79, 0xFC, 0x78, 0x00, 0x38, 0xFE,
  0x3C, 0x00, 0x3C, 0x7F, 0x0F, 0x00, 0x1E, 0x3F, 0x87, 0x80, 0x1E, 0x1F,
  0xC3, 0xC0, 0x0F, 0x0F, 0xE0, 0xF0, 0x07, 0x87, 0xF0, 0x78, 0x07, 0x83,
  0xF8, 0x1E, 0x03, 0xC1, 0xFC, 0x0F, 0x01, 0xC0, 0xFE, 0x07, 0x81, 0xE0,
  0x7F, 0x01, 0xE0, 0xF0, 0x3F, 0x80, 0xF0, 0xF0, 0x1F, 0xC0, 0x78, 0x78,
  0x0F, 0xE0, 0x1E, 0x38, 0x07, 0xF0, 0x0F, 0x3C, 0x03, 0xF8, 0x03, 0xDE,
  0x01, 0xFC, 0x01, 0xEE, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x03,
  0xC0, 0x07, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xBE, 0x00, 0x0F, 0xE7, 0xC0, 0x03,
  0xF9, 0xF0, 0x00, 0xFE, 0x3E, 0x00, 0x3F, 0x87, 0xC0, 0x0F, 0xE1, 0xF0,
  0x03, 0xF8, 0x3E, 0x00, 0xFE, 0x07, 0xC0, 0x3F, 0x81, 0xF0, 0x0F, 0xE0,
  0x3E, 0x03, 0xF8, 0x07, 0x80, 0xFE, 0x01, 0xF0, 0x3F, 0x80, 0x3E, 0x0F,
  0xE0, 0x07, 0x83, 0xF8, 0x01, 0xF0, 0xFE, 0x00, 0x3E, 0x3F, 0x80, 0x0F,
  0x8F, 0xE0, 0x01, 0xF3, 0xF8, 0x00, 0x3E, 0xFE, 0x00, 0x0F, 0xBF, 0x80,
  0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x3F,
  0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x00,
  0x7C, 0x1F, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x78, 0xF8, 0x00, 0x00,
  0xF9, 0xE0, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x03,
  0xDF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0x7C, 0xF8,
  0x00, 0x00, 0xF0, 0xF8, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x0F, 0x81, 0xF0,
  0x00, 0x3F, 0x03, 0xF8, 0x00, 0xFC, 0x03, 0xFE, 0x0F, 0xF0, 0x01, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xC0,
  0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0xCF, 0x00, 0xFE, 0x78,
  0x01, 0xFB, 0xC0, 0x07, 0xDE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0,
  0x03, 0xDE, 0x00, 0x3E, 0xF0, 0x07, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF, 0xE1,
  0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x03,
  0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x7C, 0x7C,
  0x00, 0x00, 0x78, 0xF8, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x01, 0xF7, 0xC0,
  0x00, 0x01, 0xEF, 0x80, 0x00, 0x03, 0xDF, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x07, 0xBE, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00,
  0x1E, 0x7C, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x03,
  0xE1, 0xF0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0xFC,
  0x03, 0xFE, 0x0F, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xF0,
  0x0F, 0xF0, 0xF0, 0x01, 0xF0, 0xF0, 0x00, 0xF8, 0xF0, 0x00, 0xF8, 0xF0,
  0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0,
  0x00, 0xF8, 0xF0, 0x00, 0xF0, 0xF0, 0x01, 0xF0, 0xF0, 0x03, 0xE0, 0xF0,
  0x7F, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xF0,
  0x1E, 0x00, 0xF0, 0x1F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x80, 0xF0,
  0x07, 0xC0, 0xF0, 0x03, 0xC0, 0xF0, 0x03, 0xE0, 0xF0, 0x01, 0xF0, 0xF0,
  0x01, 0xF0, 0xF0, 0x00, 0xF8, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x7C, 0xF0,
  0x00, 0x3E, 0xF0, 0x00, 0x3F, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0x00, 0x71, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xFB, 0x00, 0x07, 0xEF, 0xC0, 0x7F, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x79, 0xF0, 0x00,
  0x1E, 0x3E, 0x00, 0x0F, 0x8F, 0xC0, 0x07, 0xC1, 0xFE, 0x0F, 0xE0, 0x3F,
  0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0x78, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x1E, 0x7C,
  0x00, 0x03, 0xE3, 0xC0, 0x00, 0x3C, 0x3E, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x7C, 0x1E, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x78, 0x0F, 0x00, 0x0F, 0x80,
  0xF0, 0x00, 0xF0, 0x0F, 0x80, 0x1F, 0x00, 0x78, 0x01, 0xF0, 0x07, 0x80,
  0x1E, 0x00, 0x7C, 0x03, 0xE0, 0x03, 0xC0, 0x3C, 0x00, 0x3C, 0x03, 0xC0,
  0x03, 0xE0, 0x7C, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x0F,
  0x0F, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0x79, 0xF0,
  0x00, 0x07, 0x9E, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x3E, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xE0, 0x00, 0x7F,
  0xE0, 0x00, 0xFC, 0x00, 0x1E, 0x78, 0x00, 0x7F, 0x00, 0x07, 0x9E, 0x00,
  0x1F, 0xC0, 0x03, 0xE7, 0xC0, 0x07, 0x78, 0x00, 0xF1, 0xF0, 0x03, 0xDE,
  0x00, 0x3C, 0x3C, 0x00, 0xF7, 0x80, 0x0F, 0x0F, 0x00, 0x3C, 0xF0, 0x07,
  0xC3, 0xE0, 0x0F, 0x3C, 0x01, 0xE0, 0x78, 0x07, 0x8F, 0x00, 0x78, 0x1E,
  0x01, 0xE3, 0xE0, 0x1E, 0x07, 0x80, 0x78, 0x78, 0x0F, 0x81, 0xF0, 0x3C,
  0x1E, 0x03, 0xC0, 0x3C, 0x0F, 0x07, 0x80, 0xF0, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x03, 0xC0, 0xF0, 0x3C, 0x1F, 0x00, 0xF8, 0x78, 0x0F, 0x07, 0x80,
  0x1E, 0x1E, 0x01, 0xE1, 0xE0, 0x07, 0x87, 0x80, 0x78, 0x78, 0x01, 0xE3,
  0xC0, 0x1E, 0x3E, 0x00, 0x7C, 0xF0, 0x07, 0xCF, 0x00, 0x0F, 0x3C, 0x00,
  0xF3, 0xC0, 0x03, 0xCE, 0x00, 0x3C, 0xF0, 0x00, 0xF7, 0x80, 0x0F, 0x78,
  0x00, 0x3D, 0xE0, 0x01, 0xDE, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x01,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x03, 0xE7, 0x80,
  0x00, 0xF8, 0xF8, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0xF0,
  0x1F, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xE0, 0x03, 0xE0,
  0x78, 0x00, 0x3C, 0x1F, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x7C, 0xF0, 0x00,
  0x07, 0xBE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xBE, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x7C, 0x3C,
  0x00, 0x0F, 0x07, 0xC0, 0x03, 0xE0, 0x78, 0x00, 0x78, 0x0F, 0x80, 0x1E,
  0x00, 0xF8, 0x07, 0xC0, 0x0F, 0x00, 0xF0, 0x01, 0xF0, 0x3C, 0x00, 0x1F,
  0x0F, 0x80, 0x03, 0xE1, 0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xDF, 0x00,
  0x00, 0x7C, 0xF8, 0x00, 0x03, 0xEF, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x1F,
  0x1E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x3E, 0x07, 0xC0,
  0x07, 0x80, 0x78, 0x01, 0xF0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x0F, 0x80,
  0x1F, 0x01, 0xE0, 0x01, 0xE0, 0x7C, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC3,
  0xE0, 0x00, 0x3C, 0x78, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x7B, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC0, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x80, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x30, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x73, 0x80, 0x01, 0xE7, 0x80,
  0x03, 0x87, 0x00, 0x0F, 0x0F, 0x00, 0x1C, 0x0E, 0x00, 0x78, 0x1E, 0x00,
  0xE0, 0x1C, 0x01, 0xC0, 0x3C, 0x07, 0x80, 0x3C, 0x0E, 0x00, 0x78, 0x3C,
  0x00, 0x78, 0x70, 0x00, 0xF1, 0xE0, 0x00, 0xF3, 0x80, 0x01, 0xEF, 0x00,
  0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF8, 0x3E,
  0x1F, 0x07, 0xC1, 0xF0, 0x78, 0x1E, 0x03, 0x00, 0x38, 0x00, 0x3F, 0xFC,
  0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xE0, 0x1F, 0x04, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x03, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xFC, 0x03, 0xEF, 0x80,
  0x1F, 0x78, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x80, 0x1F, 0xFC, 0x01, 0xFD, 0xF0, 0x3F, 0xEF, 0xFF, 0xEF, 0x3F, 0xFE,
  0x78, 0x7F, 0xC3, 0xC0, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x01, 0xC0, 0x3C, 0x7F,
  0xE0, 0xF3, 0xFF, 0xC3, 0xDF, 0xFF, 0x8F, 0xF0, 0x3F, 0x3F, 0x00, 0x3E,
  0xF8, 0x00, 0x7B, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xEF, 0xC0, 0x0F, 0xBF, 0x00, 0x3E, 0xFF, 0x03, 0xF3, 0xDF,
  0xFF, 0x8E, 0x3F, 0xFC, 0x38, 0x7F, 0xC0, 0x00, 0x38, 0x00, 0xFF, 0xF0,
  0xFF, 0xFC, 0x7F, 0xFE, 0x3F, 0x01, 0x9F, 0x00, 0x07, 0xC0, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x13, 0xF8, 0x3C, 0x7F,
  0xFF, 0x0F, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x0F, 0x03,
  0xC1, 0xFF, 0x8F, 0x0F, 0xFF, 0x3C, 0x7F, 0xFE, 0xF3, 0xE0, 0x3F, 0xDF,
  0x00, 0x3F, 0x78, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xF7, 0xC0, 0x0F, 0xDF, 0x00, 0x3F, 0x3F, 0x03,
  0xFC, 0x7F, 0xFE, 0xF0, 0xFF, 0xF3, 0xC1, 0xFF, 0x8F, 0x00, 0x30, 0x00,
  0x1F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xE0, 0x3E, 0x3E, 0x00,
  0xF9, 0xE0, 0x03, 0xCF, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x08, 0xFE, 0x03, 0xC3, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0xFF, 0xC0, 0xFF,
  0xE0, 0xFE, 0xE0, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x07, 0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0xF0,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x1F, 0xF8, 0xF0, 0xFF, 0xF3, 0xC7, 0xFF, 0xEF, 0x3F, 0x03,
  0xFD, 0xF0, 0x03, 0xF7, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0x7C, 0x00, 0x7D, 0xF0, 0x03, 0xF3,
  0xF0, 0x3F, 0xC7, 0xFF, 0xEF, 0x0F, 0xFF, 0x3C, 0x1F, 0xF8, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3E, 0x20, 0x01, 0xF8, 0xF8, 0x1F, 0xC3, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x06, 0x01, 0xE3, 0xFF,
  0x0F, 0x3F, 0xFE, 0x7B, 0xFF, 0xFB, 0xFC, 0x07, 0xDF, 0x80, 0x1F, 0xFC,
  0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xF0, 0x67, 0xBD, 0xFF, 0x30, 0x00, 0x00, 0x3D, 0xEF,
  0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE,
  0xF7, 0xBC, 0x00, 0xC0, 0x1E, 0x01, 0xE0, 0x1F, 0x01, 0xE0, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x3E, 0x87, 0xEF, 0xFC, 0xFF, 0x8F, 0xF0, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x07, 0xEF, 0x00, 0x3C, 0x78, 0x03, 0xC3,
  0xC0, 0x3C, 0x1E, 0x03, 0xE0, 0xF0, 0x3E, 0x07, 0x83, 0xE0, 0x3C, 0x3E,
  0x01, 0xE3, 0xE0, 0x0F, 0x3E, 0x00, 0x7B, 0xE0, 0x03, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xE7, 0xC0, 0x3C, 0x1F, 0x01, 0xE0, 0xF8,
  0x0F, 0x03, 0xE0, 0x78, 0x0F, 0x83, 0xC0, 0x3E, 0x1E, 0x01, 0xF0, 0xF0,
  0x07, 0xC7, 0x80, 0x1F, 0x3C, 0x00, 0x7D, 0xE0, 0x03, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x18, 0x00, 0x3C, 0x0E, 0x1F, 0xF8, 0x1F,
  0xF8, 0xF3, 0xFF, 0xC7, 0xFF, 0xCF, 0x7F, 0xFE, 0xFF, 0xFE, 0xFF, 0x03,
  0xEE, 0x03, 0xEF, 0xC0, 0x1F, 0xC0, 0x1F, 0xF8, 0x01, 0xF8, 0x01, 0xFF,
  0x80, 0x0F, 0x80, 0x0F, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0x00,
  0x0F, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0x00, 0x0F, 0xF0, 0x00,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0x00, 0x0F, 0xF0, 0x00, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0x00, 0x0F, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0x00,
  0x0F, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0x00, 0x0F, 0xF0, 0x00,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0x00, 0x0F, 0xF0, 0x00, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0x00, 0x0F, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x1C, 0x07, 0x0F, 0xFE, 0x3C, 0xFF, 0xF9, 0xEF, 0xFF, 0xEF,
  0xF0, 0x1F, 0x7E, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0x03, 0xF0, 0x1F,
  0x0F, 0x80, 0x1F, 0x1F, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x3D,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x7B, 0xE0, 0x00, 0xF3, 0xC0, 0x03, 0xE7, 0xC0, 0x07, 0x87, 0xC0,
  0x1F, 0x0F, 0xC0, 0xFC, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x00, 0x3C, 0x03, 0x87, 0xFE, 0x0F, 0x3F, 0xFC, 0x3D, 0xFF, 0xF8,
  0xFF, 0x03, 0xF3, 0xF0, 0x03, 0xEF, 0x80, 0x0F, 0xBE, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1E, 0xFC, 0x00, 0xFB, 0xF8,
  0x07, 0xEF, 0xF0, 0x3F, 0x3D, 0xFF, 0xF8, 0xF3, 0xFF, 0xC3, 0xC7, 0xFC,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x1F, 0xF8,
  0xF0, 0xFF, 0xF3, 0xC7, 0xFF, 0xEF, 0x3E, 0x03, 0xFD, 0xF0, 0x03, 0xF7,
  0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x1F, 0x7C, 0x00, 0xFD, 0xF0, 0x03, 0xF3, 0xF0, 0x3F, 0xC7, 0xFF,
  0xEF, 0x0F, 0xFF, 0x3C, 0x1F, 0xF0, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x3D, 0xC1, 0xFF, 0xCF, 0xF7, 0xBF, 0xEF, 0x78, 0x1F, 0xC0,
  0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x00, 0x00, 0xE0, 0x03, 0xFF, 0xE3, 0xFF, 0xFD, 0xFF, 0xFE, 0x7C,
  0x03, 0x9E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00,
  0x07, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xE0, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0x0F, 0xFF,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0x80,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xFC,
  0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xBF, 0x03, 0xFD, 0xFF, 0xFD,
  0xE7, 0xFF, 0xCF, 0x0F, 0xFC, 0x38, 0xF8, 0x00, 0x1F, 0x78, 0x00, 0x1E,
  0x78, 0x00, 0x3E, 0x7C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x7C,
  0x1E, 0x00, 0x78, 0x1E, 0x00, 0x78, 0x1F, 0x00, 0xF8, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x81, 0xE0, 0x07, 0x81, 0xE0, 0x07, 0x81, 0xE0,
  0x03, 0xC3, 0xC0, 0x03, 0xC3, 0xC0, 0x03, 0xC7, 0xC0, 0x01, 0xE7, 0x80,
  0x01, 0xE7, 0x80, 0x01, 0xEF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xF0,
  0x01, 0xFE, 0x00, 0x3E, 0x00, 0x3F, 0xE0, 0x0F, 0xE0, 0x0F, 0xBC, 0x01,
  0xFC, 0x01, 0xE7, 0x80, 0x3B, 0x80, 0x3C, 0xF0, 0x0F, 0x78, 0x07, 0x9F,
  0x01, 0xEF, 0x01, 0xF1, 0xE0, 0x3D, 0xE0, 0x3C, 0x3C, 0x0F, 0x1C, 0x07,
  0x87, 0x81, 0xE3, 0xC0, 0xF0, 0xF8, 0x3C, 0x78, 0x3C, 0x0F, 0x07, 0x0F,
  0x07, 0x81, 0xE1, 0xE0, 0xF0, 0xF0, 0x3C, 0x3C, 0x1E, 0x1E, 0x03, 0xC7,
  0x03, 0xC7, 0x80, 0x79, 0xE0, 0x3C, 0xF0, 0x0F, 0x3C, 0x07, 0x9E, 0x01,
  0xE7, 0x80, 0xF3, 0xC0, 0x1E, 0xE0, 0x0E, 0xF0, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xF8,
  0x00, 0x7E, 0xF8, 0x00, 0xF0, 0xF8, 0x03, 0xE0, 0xF0, 0x0F, 0x80, 0xF0,
  0x1E, 0x01, 0xF0, 0x7C, 0x01, 0xF1, 0xF0, 0x01, 0xE3, 0xC0, 0x03, 0xEF,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xF7, 0x80, 0x03, 0xC7, 0x80,
  0x0F, 0x8F, 0x80, 0x3E, 0x0F, 0x00, 0x78, 0x0F, 0x01, 0xF0, 0x1F, 0x07,
  0xC0, 0x1F, 0x0F, 0x00, 0x1E, 0x3E, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8,
  0x00, 0x1F, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x3E, 0x3C,
  0x00, 0x3C, 0x3E, 0x00, 0x7C, 0x1E, 0x00, 0x78, 0x1E, 0x00, 0x78, 0x0F,
  0x00, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x80, 0xF0, 0x07, 0x81, 0xF0, 0x07,
  0x81, 0xE0, 0x03, 0xC1, 0xE0, 0x03, 0xC3, 0xC0, 0x03, 0xC3, 0xC0, 0x01,
  0xE3, 0xC0, 0x01, 0xE7, 0x80, 0x00, 0xE7, 0x80, 0x00, 0xF7, 0x80, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFC, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x02, 0x00, 0x7C,
  0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x3E, 0x07, 0xF8, 0x0F, 0xC0, 0x1F,
  0xC0, 0x3F, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7F, 0x80, 0x7F, 0x00,
  0x3E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x80, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x0F, 0x80, 0x07,
  0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x7F, 0x01, 0xFF, 0x01,
  0xF0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07,
  0xC0, 0x07, 0x80, 0x1F, 0x80, 0xFF, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x06,
  0x00, 0x04, 0xFF, 0x80, 0x17, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFE, 0x00, 0x3F, 0xE8, 0x00, 0x08, 0x00,
};

const GFXglyph NotoSans_Regular47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 6, 35, 13, 3, -34 },
  { 28, 13, 13, 19, 3, -34 },
  { 50, 28, 34, 30, 1, -34 },
  { 169, 21, 39, 27, 3, -36 },
  { 272, 35, 34, 39, 2, -34 },
  { 421, 32, 34, 34, 2, -34 },
  { 557, 5, 13, 11, 3, -34 },
  { 566, 11, 41, 14, 2, -34 },
  { 623, 11, 41, 14, 1, -34 },
  { 680, 22, 21, 26, 2, -36 },
  { 738, 22, 23, 27, 2, -28 },
  { 802, 7, 11, 13, 2, -5 },
  { 812, 11, 3, 15, 2, -14 },
  { 817, 6, 7, 13, 3, -6 },
  { 823, 17, 34, 17, 0, -34 },
  { 896, 23, 34, 27, 2, -34 },
  { 994, 13, 34, 27, 4, -34 },
  { 1050, 22, 34, 27, 2, -34 },
  { 1144, 22, 34, 27, 2, -34 },
  { 1238, 25, 34, 27, 1, -34 },
  { 1345, 21, 34, 27, 3, -34 },
  { 1435, 22, 34, 27, 3, -34 },
  { 1529, 23, 34, 27, 2, -34 },
  { 1627, 23, 34, 27, 2, -34 },
  { 1725, 22, 34, 27, 2, -34 },
  { 1819, 6, 27, 13, 3, -26 },
  { 1840, 8, 32, 13, 1, -26 },
  { 1872, 22, 24, 27, 2, -29 },
  { 1938, 21, 13, 27, 3, -23 },
  { 1973, 22, 24, 27, 2, -29 },
  { 2039, 18, 35, 20, 1, -34 },
  { 2118, 37, 38, 42, 3, -34 },
  { 2294, 30, 34, 30, 0, -34 },
  { 2422, 23, 34, 31, 5, -34 },
  { 2520, 25, 34, 30, 3, -34 },
  { 2627, 26, 34, 34, 5, -34 },
  { 2738, 18, 34, 26, 5, -34 },
  { 2815, 18, 34, 24, 5, -34 },
  { 2892, 28, 34, 34, 3, -34 },
  { 3011, 25, 34, 35, 5, -34 },
  { 3118, 12, 34, 16, 2, -34 },
  { 3169, 13, 43, 13, -4, -34 },
  { 3239, 24, 34, 29, 5, -34 },
  { 3341, 18, 34, 25, 5, -34 },
  { 3418, 33, 34, 43, 5, -34 },
  { 3559, 26, 34, 36, 5, -34 },
  { 3670, 31, 34, 37, 3, -34 },
  { 3802, 21, 34, 28, 5, -34 },
  { 3892, 31, 42, 37, 3, -34 },
  { 4055, 24, 34, 29, 5, -34 },
  { 4157, 22, 34, 26, 2, -34 },
  { 4251, 26, 34, 26, 0, -34 },
  { 4362, 26, 34, 34, 4, -34 },
  { 4473, 28, 34, 28, 0, -34 },
  { 4592, 42, 34, 44, 1, -34 },
  { 4771, 27, 34, 28, 0, -34 },
  { 4886, 27, 34, 27, 0, -34 },
  { 5001, 23, 34, 27, 2, -34 },
  { 5099, 10, 41, 15, 4, -34 },
  { 5151, 17, 34, 17, 0, -34 },
  { 5224, 11, 41, 15, 1, -34 },
  { 5281, 23, 21, 27, 2, -34 },
  { 5342, 21, 3, 21, 0, 4 },
  { 5350, 9, 8, 13, 2, -36 },
  { 5359, 21, 26, 26, 2, -26 },
  { 5428, 22, 36, 29, 4, -36 },
  { 5527, 18, 26, 23, 3, -26 },
  { 5586, 22, 36, 29, 3, -36 },
  { 5685, 21, 26, 27, 3, -26 },
  { 5754, 17, 36, 16, 1, -36 },
  { 5831, 22, 37, 29, 3, -26 },
  { 5933, 21, 36, 29, 4, -36 },
  { 6028, 5, 35, 12, 4, -35 },
  { 6050, 12, 46, 12, -3, -35 },
  { 6119, 21, 36, 25, 4, -36 },
  { 6214, 4, 36, 12, 4, -36 },
  { 6232, 36, 26, 44, 4, -26 },
  { 6349, 21, 26, 29, 4, -26 },
  { 6418, 23, 26, 28, 3, -26 },
  { 6493, 22, 37, 29, 4, -26 },
  { 6595, 22, 37, 29, 3, -26 },
  { 6697, 15, 26, 19, 4, -26 },
  { 6746, 18, 26, 23, 2, -26 },
  { 6805, 15, 31, 17, 1, -31 },
  { 6864, 21, 25, 29, 4, -25 },
  { 6930, 24, 25, 24, 0, -25 },
  { 7005, 35, 25, 37, 1, -25 },
  { 7115, 23, 25, 25, 1, -25 },
  { 7187, 24, 36, 24, 0, -25 },
  { 7295, 18, 25, 22, 2, -25 },
  { 7352, 15, 41, 18, 1, -34 },
  { 7429, 4, 47, 26, 11, -36 },
  { 7453, 16, 41, 18, 1, -34 },
  { 7535, 22, 7, 27, 2, -20 },
};

const GFXfont NotoSans_Regular47pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Regular47pt7bBitmaps,
  (GFXglyph *)NotoSans_Regular47pt7bGlyphs,
  0x20, 0x7E, 64
};

#endif // _NOTOSANS_REGULAR47PT7B_H_
