#ifndef _NOTOSANS_REGULAR44PT7B_H_
#define _NOTOSANS_REGULAR44PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Regular.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Regular44pt7bBitmaps[] PROGMEM = {
  0x00, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x71, 0xC7, 0x0C, 0x30, 0xC0, 0x00, 0x00, 0x07, 0xBE, 0xFF, 0xF7,
  0x8C, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFE,
  0x06, 0x60, 0x66, 0x06, 0x60, 0x60, 0x00, 0x38, 0x1C, 0x00, 0x0E, 0x07,
  0x00, 0x07, 0x81, 0xC0, 0x01, 0xC0, 0x70, 0x00, 0x70, 0x3C, 0x00, 0x1C,
  0x0E, 0x00, 0x07, 0x03, 0x80, 0x03, 0xC0, 0xE0, 0x00, 0xE0, 0x38, 0x0F,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x70,
  0x00, 0x70, 0x1C, 0x00, 0x1C, 0x0F, 0x00, 0x07, 0x03, 0x80, 0x01, 0xC0,
  0xE0, 0x00, 0xF0, 0x38, 0x00, 0x38, 0x0E, 0x03, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xE0, 0x38, 0x1C, 0x00, 0x1C, 0x07, 0x00,
  0x07, 0x01, 0xC0, 0x01, 0xC0, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x1C, 0x0E,
  0x00, 0x0F, 0x03, 0x80, 0x03, 0x80, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x0F, 0xFF, 0x83,
  0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0x8E, 0x1C, 0xF0, 0xE0, 0x0F, 0x0E, 0x00,
  0xF0, 0xE0, 0x0F, 0x0E, 0x00, 0xF0, 0xE0, 0x0F, 0x8E, 0x00, 0x7F, 0xE0,
  0x03, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0xE3, 0xE0, 0x0E, 0x1E, 0x00, 0xE0, 0xF0, 0x0E, 0x0F, 0x00,
  0xE0, 0xF0, 0x0E, 0x1E, 0xC0, 0xE3, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F,
  0xFF, 0xF0, 0x0F, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x0F, 0x80, 0x00, 0x20, 0x1F, 0xC0, 0x01,
  0xC0, 0x3F, 0xE0, 0x03, 0xC0, 0x78, 0xF0, 0x03, 0x80, 0x70, 0x70, 0x07,
  0x80, 0x70, 0x78, 0x07, 0x00, 0xF0, 0x38, 0x0E, 0x00, 0xE0, 0x38, 0x1E,
  0x00, 0xE0, 0x38, 0x1C, 0x00, 0xE0, 0x38, 0x3C, 0x00, 0xE0, 0x38, 0x38,
  0x00, 0xE0, 0x38, 0x78, 0x00, 0xE0, 0x38, 0x70, 0x00, 0xF0, 0x38, 0xF1,
  0xF8, 0x70, 0x78, 0xE7, 0xFC, 0x70, 0x71, 0xC7, 0xFE, 0x78, 0xF3, 0xCF,
  0x0E, 0x3F, 0xE3, 0x8E, 0x0F, 0x1F, 0xE7, 0x8E, 0x07, 0x07, 0x87, 0x0E,
  0x07, 0x00, 0x0F, 0x1E, 0x07, 0x00, 0x0E, 0x1E, 0x07, 0x00, 0x1E, 0x1E,
  0x07, 0x00, 0x1C, 0x1E, 0x07, 0x00, 0x38, 0x1E, 0x07, 0x00, 0x78, 0x0E,
  0x07, 0x00, 0x70, 0x0E, 0x07, 0x00, 0xF0, 0x0E, 0x07, 0x00, 0xE0, 0x0F,
  0x0E, 0x01, 0xE0, 0x07, 0xBE, 0x01, 0xC0, 0x07, 0xFC, 0x03, 0xC0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x03, 0xF1, 0xF0, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x78, 0x07, 0x80, 0x01,
  0xE0, 0x1E, 0x00, 0x07, 0x80, 0x78, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x3C,
  0x0F, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x07, 0xDF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0xF0, 0x7E, 0xF8, 0x03, 0xC3, 0xE1, 0xF0, 0x0F,
  0x1F, 0x03, 0xE0, 0x78, 0x78, 0x07, 0xC1, 0xE1, 0xE0, 0x0F, 0x8F, 0x0F,
  0x80, 0x1F, 0x3C, 0x3C, 0x00, 0x3F, 0xE0, 0xF0, 0x00, 0x7F, 0x83, 0xE0,
  0x00, 0xFC, 0x07, 0x80, 0x03, 0xF0, 0x1F, 0x00, 0x3F, 0xF0, 0x3F, 0x03,
  0xFF, 0xE0, 0xFF, 0xFF, 0xCF, 0xC1, 0xFF, 0xFC, 0x1F, 0x81, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFE, 0x66, 0x60, 0x07, 0xC1, 0xE0, 0xF0, 0x38,
  0x1E, 0x0F, 0x03, 0xC0, 0xF0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x03, 0xC0, 0xF0, 0x1E,
  0x07, 0x80, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0xF8, 0x0E, 0x03, 0xC0, 0x78,
  0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x1C, 0x07, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x1E, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x0F,
  0x07, 0x81, 0xC0, 0xF0, 0x78, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0xE0, 0x60,
  0x7F, 0xE6, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x00, 0x1F,
  0x80, 0x03, 0xFC, 0x00, 0x79, 0xE0, 0x07, 0x9E, 0x00, 0xF0, 0xF0, 0x1F,
  0x0F, 0x81, 0xE0, 0x78, 0x06, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x3C, 0xF3, 0xDF, 0x79, 0xE7, 0x1C, 0xF3, 0x8E, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7B, 0xEF, 0xFF, 0x78, 0x80, 0x00, 0x0F,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38,
  0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xBF, 0x83, 0xE0,
  0x3E, 0x1E, 0x00, 0xF0, 0xF0, 0x03, 0x8F, 0x00, 0x1E, 0x78, 0x00, 0xF3,
  0xC0, 0x03, 0x9C, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3D, 0xC0, 0x01,
  0xEF, 0x00, 0x1E, 0x78, 0x00, 0xF3, 0xC0, 0x07, 0x8F, 0x00, 0x78, 0x7C,
  0x03, 0xC1, 0xF0, 0x7C, 0x07, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x7F, 0xC0,
  0x01, 0xF0, 0x3F, 0x07, 0xF1, 0xFF, 0x3E, 0xF7, 0xCF, 0xF8, 0xF7, 0x0F,
  0x20, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x01,
  0xF8, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0xE1, 0xFF, 0x7F, 0x87, 0xC0, 0x3E,
  0x18, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03,
  0xF8, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xE1, 0xFF, 0x3F, 0x87, 0x80, 0x3E,
  0x10, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0,
  0x1F, 0xFC, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3D, 0x00, 0x03,
  0xEF, 0x00, 0x7E, 0x7F, 0xFF, 0xE3, 0xFF, 0xFE, 0x07, 0xFF, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0x78, 0x00, 0x1C, 0xF0, 0x00, 0x79,
  0xE0, 0x01, 0xE3, 0xC0, 0x03, 0x87, 0x80, 0x0F, 0x0F, 0x00, 0x3C, 0x1E,
  0x00, 0x70, 0x3C, 0x01, 0xE0, 0x78, 0x07, 0x80, 0xF0, 0x1E, 0x01, 0xE0,
  0x38, 0x03, 0xC0, 0xF0, 0x07, 0x83, 0xC0, 0x0F, 0x07, 0x00, 0x1E, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x3F, 0xFF, 0x83, 0xFF, 0xF8,
  0x7F, 0xFF, 0x87, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x82, 0x00, 0xFC, 0x00,
  0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E,
  0x80, 0x03, 0xCE, 0x00, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xE0, 0x7F, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x07, 0xFF, 0x00, 0xFF, 0xF8, 0x0F, 0xF0, 0xC0,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x81, 0xC0, 0x3C,
  0xFF, 0xC1, 0xCF, 0xFF, 0x0E, 0xF9, 0xFC, 0xFE, 0x01, 0xF7, 0xE0, 0x07,
  0xBE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xB8, 0x00, 0x3D, 0xC0,
  0x01, 0xEF, 0x00, 0x0F, 0x78, 0x00, 0x7B, 0xC0, 0x03, 0xCF, 0x00, 0x3C,
  0x7C, 0x03, 0xE1, 0xF0, 0x3E, 0x07, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x3F,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xF0, 0x7F, 0x1F, 0xC3, 0xC0, 0x1E,
  0x3E, 0x00, 0x79, 0xE0, 0x03, 0xCF, 0x00, 0x1E, 0x78, 0x00, 0xF3, 0xC0,
  0x07, 0x8F, 0x00, 0x78, 0x7C, 0x03, 0xC1, 0xF0, 0x7C, 0x07, 0xE7, 0xC0,
  0x1F, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0x00, 0xFC, 0xFE, 0x0F, 0x81,
  0xF8, 0x78, 0x03, 0xE7, 0x80, 0x0F, 0x78, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x1E, 0xF0, 0x01,
  0xE7, 0xC0, 0x1F, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x00, 0xFF, 0xE0, 0x01,
  0xF8, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0xE0, 0x7F, 0xBF, 0x83, 0xE0, 0x3C,
  0x3E, 0x00, 0xF1, 0xE0, 0x03, 0xCE, 0x00, 0x1E, 0xF0, 0x00, 0x77, 0x80,
  0x03, 0xBC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7D,
  0xE0, 0x03, 0xEF, 0x80, 0x3F, 0x3E, 0x07, 0xF9, 0xFF, 0xFB, 0xC7, 0xFF,
  0x9E, 0x0F, 0xF0, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x01, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x7B,
  0xEF, 0xFF, 0x78, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0xFB, 0xFF, 0xDE, 0x20, 0x1E, 0x3E, 0x3F, 0x3E, 0x3E, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x3E, 0x3C, 0x3C, 0x3C, 0x38, 0x78, 0x78, 0x70, 0x70, 0xE0,
  0x00, 0x00, 0x08, 0x00, 0x01, 0xC0, 0x00, 0x3E, 0x00, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x01, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x04, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x80, 0x00, 0x07, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF0, 0x00,
  0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x00, 0x0E, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x07, 0xE0, 0x3F, 0xFE, 0x3F, 0xFF, 0x9F, 0xFF, 0xEE, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xE0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x3C, 0x03, 0xC0, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x00, 0x1C, 0x3C, 0x01,
  0xFC, 0x07, 0x9E, 0x01, 0xFF, 0xC0, 0xE7, 0x01, 0xFF, 0xF0, 0x39, 0xC0,
  0xF8, 0x1C, 0x07, 0xF0, 0x3C, 0x07, 0x01, 0xF8, 0x1E, 0x01, 0xC0, 0x7E,
  0x07, 0x00, 0x70, 0x1F, 0x81, 0xC0, 0x1C, 0x07, 0xE0, 0xF0, 0x07, 0x01,
  0xF8, 0x3C, 0x01, 0xC0, 0x7E, 0x0F, 0x00, 0x70, 0x1F, 0x83, 0xC0, 0x3C,
  0x0E, 0xE0, 0x70, 0x0F, 0x03, 0xB8, 0x1C, 0x03, 0xC0, 0xEE, 0x07, 0x81,
  0xB8, 0x73, 0x80, 0xFF, 0xEF, 0xFC, 0xF0, 0x1F, 0xF1, 0xFE, 0x1C, 0x03,
  0xF8, 0x3E, 0x07, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x0C, 0x00,
  0x1F, 0xC0, 0x1F, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x79, 0xE0,
  0x00, 0x07, 0x8E, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x00,
  0xE0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x3C, 0x03,
  0xC0, 0x03, 0xC0, 0x3C, 0x00, 0x3C, 0x01, 0xC0, 0x07, 0x80, 0x1E, 0x00,
  0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x7C,
  0x3C, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x3C, 0x78, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x1E, 0x78, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x3C, 0x00, 0xFC, 0xF0, 0x00, 0xFB, 0xC0,
  0x01, 0xEF, 0x00, 0x07, 0xBC, 0x00, 0x1E, 0xF0, 0x00, 0x7B, 0xC0, 0x01,
  0xEF, 0x00, 0x0F, 0xBC, 0x00, 0x3C, 0xF0, 0x03, 0xE3, 0xFF, 0xFF, 0x0F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0xF0, 0x07, 0xF3, 0xC0, 0x03, 0xEF, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xBC,
  0x03, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFC,
  0x00, 0xC3, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x01, 0xC0, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0x00, 0x7F, 0xFC, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFC, 0x1E, 0x00, 0x7F, 0x0F, 0x00, 0x0F, 0xC7, 0x80,
  0x01, 0xF3, 0xC0, 0x00, 0x7D, 0xE0, 0x00, 0x3E, 0xF0, 0x00, 0x0F, 0x78,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7B, 0xC0, 0x00, 0x3D, 0xE0, 0x00, 0x3E, 0xF0, 0x00,
  0x3E, 0x78, 0x00, 0x3E, 0x3C, 0x00, 0x7F, 0x1E, 0x07, 0xFF, 0x0F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3F, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xE0, 0x07, 0x07, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3D, 0xE0, 0x00, 0x0F, 0x7C, 0x00,
  0x03, 0xCF, 0x80, 0x00, 0xF3, 0xF0, 0x00, 0x3C, 0x7E, 0x00, 0x0F, 0x0F,
  0xE0, 0x07, 0xC1, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xF8,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFC,
  0xFC, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x07,
  0xFD, 0xFF, 0xFF, 0xF8, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x0F, 0x43, 0xEF, 0xF9, 0xFF, 0x3F, 0x80, 0xF0, 0x00,
  0x7F, 0xE0, 0x01, 0xF3, 0xC0, 0x03, 0xC7, 0x80, 0x0F, 0x0F, 0x00, 0x3C,
  0x1E, 0x00, 0xF0, 0x3C, 0x03, 0xC0, 0x78, 0x0F, 0x80, 0xF0, 0x3E, 0x01,
  0xE0, 0xF8, 0x03, 0xC3, 0xE0, 0x07, 0x8F, 0x80, 0x0F, 0x1E, 0x00, 0x1E,
  0x78, 0x00, 0x3D, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0xFE, 0xF8, 0x01, 0xF8,
  0xF0, 0x03, 0xE1, 0xF0, 0x07, 0x81, 0xF0, 0x0F, 0x01, 0xF0, 0x1E, 0x01,
  0xE0, 0x3C, 0x03, 0xE0, 0x78, 0x03, 0xE0, 0xF0, 0x03, 0xE1, 0xE0, 0x07,
  0xC3, 0xC0, 0x07, 0xC7, 0x80, 0x07, 0xCF, 0x00, 0x07, 0x9E, 0x00, 0x0F,
  0xBC, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xEF, 0xF7, 0x00,
  0x00, 0xEF, 0xF7, 0x80, 0x01, 0xEF, 0xF7, 0x80, 0x01, 0xCF, 0xF3, 0x80,
  0x03, 0xCF, 0xF3, 0xC0, 0x03, 0xCF, 0xF3, 0xC0, 0x03, 0x8F, 0xF1, 0xE0,
  0x07, 0x8F, 0xF1, 0xE0, 0x07, 0x0F, 0xF0, 0xE0, 0x0F, 0x0F, 0xF0, 0xF0,
  0x0F, 0x0F, 0xF0, 0xF0, 0x0E, 0x0F, 0xF0, 0x70, 0x1E, 0x0F, 0xF0, 0x78,
  0x1E, 0x0F, 0xF0, 0x78, 0x1C, 0x0F, 0xF0, 0x3C, 0x3C, 0x0F, 0xF0, 0x3C,
  0x38, 0x0F, 0xF0, 0x1C, 0x78, 0x0F, 0xF0, 0x1E, 0x78, 0x0F, 0xF0, 0x1E,
  0x70, 0x0F, 0xF0, 0x0E, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F,
  0xE0, 0x0F, 0xF0, 0x07, 0xE0, 0x0F, 0xF0, 0x07, 0xC0, 0x0F, 0xF0, 0x03,
  0xC0, 0x0F, 0xF0, 0x03, 0xC0, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00,
  0x3F, 0xDE, 0x00, 0x1F, 0xEF, 0x80, 0x0F, 0xF3, 0xE0, 0x07, 0xF8, 0xF0,
  0x03, 0xFC, 0x7C, 0x01, 0xFE, 0x1F, 0x00, 0xFF, 0x07, 0x80, 0x7F, 0x83,
  0xE0, 0x3F, 0xC0, 0xF0, 0x1F, 0xE0, 0x3C, 0x0F, 0xF0, 0x1F, 0x07, 0xF8,
  0x07, 0x83, 0xFC, 0x03, 0xE1, 0xFE, 0x00, 0xF8, 0xFF, 0x00, 0x3C, 0x3F,
  0x80, 0x1F, 0x1F, 0xC0, 0x07, 0xCF, 0xE0, 0x01, 0xE7, 0xF0, 0x00, 0xFB,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3E, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x01, 0xF8, 0x01,
  0xF8, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x7C,
  0x78, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x3D, 0xE0,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x0F, 0x78,
  0x00, 0x00, 0x7B, 0xE0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x3E, 0x7C, 0x00,
  0x01, 0xE1, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0, 0x3E, 0x00, 0x1F,
  0x00, 0xFE, 0x03, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFE, 0x00, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xCF, 0x00,
  0xFE, 0xF0, 0x03, 0xEF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFF,
  0x00, 0x1E, 0xF0, 0x07, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xE0,
  0xFF, 0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x01,
  0xF8, 0x01, 0xF8, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x0F, 0x80,
  0x00, 0x7C, 0x78, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x0F, 0xBE, 0x00, 0x00,
  0x3D, 0xE0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0x0F, 0x78, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x3E,
  0x7C, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0, 0x3E,
  0x00, 0x1F, 0x00, 0xFE, 0x03, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x07, 0x80, 0x3F, 0x0F, 0x00, 0x1F, 0x1E, 0x00, 0x1E,
  0x3C, 0x00, 0x3C, 0x78, 0x00, 0x78, 0xF0, 0x00, 0xF1, 0xE0, 0x01, 0xE3,
  0xC0, 0x03, 0xC7, 0x80, 0x07, 0x8F, 0x00, 0x1F, 0x1E, 0x00, 0x7C, 0x3C,
  0x0F, 0xF0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x03, 0xC0,
  0x78, 0x07, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x1E, 0x00, 0xF0, 0x3C, 0x01,
  0xF0, 0x78, 0x01, 0xE0, 0xF0, 0x03, 0xE1, 0xE0, 0x03, 0xC3, 0xC0, 0x07,
  0xC7, 0x80, 0x07, 0xCF, 0x00, 0x07, 0x9E, 0x00, 0x0F, 0xBC, 0x00, 0x0F,
  0x80, 0x01, 0xFC, 0x00, 0x7F, 0xFC, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x7E,
  0x00, 0xC7, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF8, 0x00, 0x1E, 0xF8,
  0x07, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x78, 0x00, 0x1E, 0x7C, 0x00, 0x1E,
  0x3E, 0x00, 0x3C, 0x3F, 0x80, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0xF0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0xF7, 0x80, 0x00,
  0x79, 0xF0, 0x00, 0x1E, 0x3C, 0x00, 0x0F, 0x8F, 0x00, 0x03, 0xC3, 0xE0,
  0x00, 0xF0, 0x78, 0x00, 0x7C, 0x1E, 0x00, 0x1E, 0x03, 0xC0, 0x07, 0x80,
  0xF0, 0x03, 0xE0, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1E,
  0x00, 0x78, 0x07, 0x80, 0x0F, 0x01, 0xE0, 0x03, 0xC0, 0xF0, 0x00, 0xF0,
  0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x01, 0xE1, 0xE0, 0x00,
  0x3C, 0x78, 0x00, 0x0F, 0x3C, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x7B, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xF0, 0x00, 0xFB, 0xC0,
  0x07, 0xF0, 0x01, 0xE7, 0x80, 0x0F, 0xE0, 0x03, 0xCF, 0x00, 0x1D, 0xC0,
  0x07, 0x9E, 0x00, 0x7B, 0x80, 0x1F, 0x1E, 0x00, 0xF7, 0x80, 0x3C, 0x3C,
  0x01, 0xCF, 0x00, 0x78, 0x78, 0x07, 0x8E, 0x00, 0xF0, 0xF0, 0x0F, 0x1E,
  0x03, 0xC0, 0xF0, 0x1E, 0x3C, 0x07, 0x81, 0xE0, 0x78, 0x38, 0x0F, 0x03,
  0xC0, 0xF0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0xF0, 0x78, 0x07, 0x83, 0x81,
  0xE0, 0xF0, 0x0F, 0x0F, 0x01, 0xC1, 0xE0, 0x1E, 0x1E, 0x03, 0xC3, 0xC0,
  0x1C, 0x38, 0x07, 0x8F, 0x00, 0x3C, 0xF0, 0x07, 0x1E, 0x00, 0x79, 0xE0,
  0x0F, 0x3C, 0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x00, 0xE7, 0x00, 0x3D, 0xE0,
  0x01, 0xFE, 0x00, 0x3B, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x0F, 0x8F, 0x00, 0x07, 0xC1, 0xE0,
  0x01, 0xE0, 0x7C, 0x00, 0xF0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x1E, 0x00,
  0x7C, 0x0F, 0x00, 0x0F, 0x03, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0x78, 0xF0,
  0x00, 0x0F, 0x3C, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0x7C, 0x00, 0x07, 0x8F, 0x00, 0x01, 0xE1, 0xE0,
  0x00, 0xF0, 0x7C, 0x00, 0x3C, 0x0F, 0x00, 0x1E, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x0F, 0x01, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0x78, 0x3C,
  0x00, 0x0F, 0x1E, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7C, 0xF8, 0x00, 0x0F,
  0xBC, 0x00, 0x07, 0x8F, 0x00, 0x07, 0x87, 0x80, 0x03, 0xC1, 0xE0, 0x03,
  0xC0, 0xF0, 0x03, 0xE0, 0x3C, 0x01, 0xE0, 0x1E, 0x01, 0xF0, 0x07, 0x80,
  0xF0, 0x03, 0xE0, 0xF8, 0x00, 0xF0, 0x78, 0x00, 0x7C, 0x78, 0x00, 0x1E,
  0x3C, 0x00, 0x07, 0xBC, 0x00, 0x03, 0xDE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1F,
  0xFF, 0xFF, 0xFC, 0xF8, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x1C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x0E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x60, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0x70, 0x00, 0x39, 0xC0,
  0x00, 0xE3, 0x80, 0x07, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0xE0, 0x70, 0x03,
  0x80, 0xE0, 0x1E, 0x03, 0x80, 0x70, 0x07, 0x03, 0xC0, 0x1E, 0x0E, 0x00,
  0x38, 0x78, 0x00, 0xF1, 0xC0, 0x01, 0xCF, 0x00, 0x07, 0xB8, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x7C, 0x1F, 0x07,
  0x81, 0xE0, 0x78, 0x1E, 0x01, 0xFC, 0x01, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F,
  0x83, 0xE0, 0x80, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x0F, 0xFF, 0x87, 0xFF, 0xF3, 0xFF, 0xFE, 0xFC,
  0x03, 0xDE, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x0F, 0xFC, 0x03, 0xF7, 0x80, 0xFE, 0xFF, 0xFD, 0xCF, 0xFF, 0x38, 0xFF,
  0x87, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x87, 0xE0, 0x3C, 0xFF, 0xC1, 0xDF, 0xFF, 0x0E, 0xF0, 0xFC, 0x7E,
  0x01, 0xF3, 0xE0, 0x07, 0x9E, 0x00, 0x1E, 0xF0, 0x00, 0xF7, 0x80, 0x07,
  0xBC, 0x00, 0x3D, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xF7, 0x80, 0x07, 0xBC, 0x00, 0x3D,
  0xF0, 0x03, 0xEF, 0x80, 0x1E, 0x7F, 0x03, 0xF3, 0xBF, 0xFF, 0x1C, 0xFF,
  0xF0, 0xE3, 0xFE, 0x00, 0x00, 0xFF, 0x01, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F,
  0x3E, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x01, 0x87, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFE, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x0F, 0xE3,
  0xC1, 0xFF, 0x8E, 0x1F, 0xFF, 0x71, 0xF8, 0x7F, 0x9F, 0x00, 0xFC, 0xF0,
  0x03, 0xEF, 0x80, 0x1F, 0x78, 0x00, 0x7B, 0xC0, 0x03, 0xDE, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xEF, 0x00,
  0x0F, 0x78, 0x00, 0x7B, 0xC0, 0x03, 0xDE, 0x00, 0x1E, 0xF8, 0x01, 0xF3,
  0xC0, 0x0F, 0x9F, 0x81, 0xFC, 0x7F, 0xFE, 0xE1, 0xFF, 0xE7, 0x03, 0xFC,
  0x38, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xF0, 0x3F, 0x0F, 0x83,
  0xE0, 0x1E, 0x1E, 0x00, 0xF9, 0xE0, 0x03, 0xCF, 0x00, 0x1E, 0x78, 0x00,
  0xF3, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x07, 0x07, 0xFF, 0xF8, 0x1F,
  0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x3C, 0x01, 0xFF, 0x03, 0xFF, 0x07, 0xFE,
  0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x1F, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x01, 0xF8, 0x38, 0x3F, 0xF1, 0xC3, 0xFF, 0xEE, 0x3F, 0x0F, 0x73, 0xE0,
  0x1F, 0x9E, 0x00, 0x7D, 0xF0, 0x01, 0xEF, 0x00, 0x0F, 0x78, 0x00, 0x7B,
  0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1D, 0xE0, 0x01, 0xEF, 0x00, 0x0F, 0x78, 0x00, 0x7B, 0xC0, 0x03, 0xDF,
  0x00, 0x3E, 0x78, 0x01, 0xF3, 0xF0, 0x3F, 0x8F, 0xFF, 0xDC, 0x3F, 0xFC,
  0xE0, 0x7F, 0xCF, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x90, 0x00, 0x78, 0xE0, 0x07, 0xC7, 0xFF, 0xFC,
  0x3F, 0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0x2A, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x0F, 0xE0, 0xF3, 0xFF, 0x8F,
  0x7F, 0xFC, 0xEF, 0x0F, 0xEF, 0xC0, 0x3E, 0xF8, 0x01, 0xEF, 0x80, 0x1E,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xF0, 0x7F, 0xFE, 0xF2, 0x00, 0x00,
  0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE,
  0xF7, 0xBD, 0xEF, 0x03, 0xC1, 0xF0, 0x7C, 0x0F, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC1, 0xE0, 0x7B, 0xFE, 0xFF, 0x3F, 0x87, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x7B, 0xC0, 0x1E, 0x78,
  0x07, 0x8F, 0x01, 0xF1, 0xE0, 0x7C, 0x3C, 0x1F, 0x07, 0x87, 0xC0, 0xF1,
  0xF0, 0x1E, 0x7C, 0x03, 0xDF, 0x00, 0x73, 0xC0, 0x0E, 0xFC, 0x01, 0xFF,
  0x80, 0x3F, 0x78, 0x07, 0xCF, 0x80, 0xF0, 0xF8, 0x1E, 0x0F, 0x03, 0xC0,
  0xF0, 0x78, 0x1F, 0x0F, 0x01, 0xF1, 0xE0, 0x1E, 0x3C, 0x01, 0xE7, 0x80,
  0x3E, 0xF0, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0xFC, 0x03,
  0xF8, 0x38, 0xFF, 0xC3, 0xFF, 0x8E, 0xFF, 0xF9, 0xFF, 0xF3, 0xBC, 0x3F,
  0xF8, 0x7E, 0xFC, 0x07, 0xF8, 0x0F, 0xBE, 0x00, 0xFC, 0x01, 0xEF, 0x00,
  0x3E, 0x00, 0x7B, 0xC0, 0x07, 0x80, 0x0F, 0xF0, 0x01, 0xE0, 0x03, 0xFC,
  0x00, 0x78, 0x00, 0xFF, 0x00, 0x1E, 0x00, 0x3F, 0xC0, 0x07, 0x80, 0x0F,
  0xF0, 0x01, 0xE0, 0x03, 0xFC, 0x00, 0x78, 0x00, 0xFF, 0x00, 0x1E, 0x00,
  0x3F, 0xC0, 0x07, 0x80, 0x0F, 0xF0, 0x01, 0xE0, 0x03, 0xFC, 0x00, 0x78,
  0x00, 0xFF, 0x00, 0x1E, 0x00, 0x3F, 0xC0, 0x07, 0x80, 0x0F, 0xF0, 0x01,
  0xE0, 0x03, 0xFC, 0x00, 0x78, 0x00, 0xFF, 0x00, 0x1E, 0x00, 0x3F, 0xC0,
  0x07, 0x80, 0x0F, 0xE0, 0xFE, 0x0E, 0x3F, 0xF8, 0xE7, 0xFF, 0xCE, 0xF0,
  0xFE, 0xFC, 0x03, 0xEF, 0x80, 0x1E, 0xF8, 0x01, 0xEF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0x00, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFE, 0x07,
  0xE1, 0xFC, 0x3E, 0x01, 0xF0, 0xF0, 0x03, 0xE7, 0xC0, 0x07, 0x9E, 0x00,
  0x0F, 0x78, 0x00, 0x3D, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xF7, 0x80, 0x03, 0xDE, 0x00, 0x0F, 0x78,
  0x00, 0x3D, 0xE0, 0x01, 0xE3, 0xC0, 0x07, 0x8F, 0x80, 0x3E, 0x1F, 0x01,
  0xF0, 0x3F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x7F, 0xC0, 0xE0, 0xFC, 0x07,
  0x1F, 0xF8, 0x39, 0xFF, 0xE1, 0xDE, 0x1F, 0x8F, 0xC0, 0x3E, 0x7C, 0x00,
  0xF3, 0xC0, 0x03, 0xDE, 0x00, 0x1E, 0xF0, 0x00, 0xF7, 0x80, 0x07, 0xBC,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03,
  0xFE, 0x00, 0x1E, 0xF0, 0x00, 0xF7, 0x80, 0x07, 0xBE, 0x00, 0x7D, 0xF8,
  0x07, 0xCF, 0xE0, 0x7E, 0x77, 0xFF, 0xE3, 0x9F, 0xFE, 0x1E, 0x3F, 0xC0,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xFC, 0x38, 0x3F, 0xF1, 0xC3, 0xFF,
  0xEE, 0x3F, 0x0F, 0x73, 0xE0, 0x1F, 0x9E, 0x00, 0x7D, 0xF0, 0x01, 0xEF,
  0x00, 0x0F, 0x78, 0x00, 0x7B, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3D, 0xE0, 0x01, 0xEF, 0x00, 0x0F, 0x78,
  0x00, 0x7B, 0xC0, 0x03, 0xDF, 0x00, 0x3E, 0x78, 0x01, 0xF3, 0xF0, 0x3F,
  0x8F, 0xFF, 0xDC, 0x3F, 0xFD, 0xE0, 0x7F, 0x8F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0xE0, 0xFF, 0x8F, 0xEE, 0x7F, 0xBB, 0xFE, 0xEE, 0x03, 0xF0, 0x0F,
  0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x07, 0xFC, 0x0F, 0xFF, 0xCF,
  0xFF, 0xCF, 0x83, 0xEF, 0x80, 0x17, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0x7C, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xF0,
  0x00, 0xFE, 0x00, 0xF7, 0xFF, 0xFB, 0xFF, 0xF8, 0x7F, 0xF0, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xFF, 0xC1, 0xFF, 0x03,
  0xFC, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xF7, 0x80, 0x0F, 0x78, 0x01,
  0xF7, 0x80, 0x1F, 0x7E, 0x07, 0xF3, 0xFF, 0xF7, 0x1F, 0xFE, 0x70, 0xFF,
  0xC7, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xF7, 0x80, 0x07, 0xDE, 0x00, 0x1E,
  0x3C, 0x00, 0x78, 0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x07, 0x80, 0x3C, 0x1E,
  0x01, 0xE0, 0x78, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0xF0, 0x07, 0x83,
  0xC0, 0x1E, 0x1E, 0x00, 0x78, 0x78, 0x00, 0xF1, 0xE0, 0x03, 0xCF, 0x00,
  0x0F, 0x3C, 0x00, 0x1E, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xDE,
  0x00, 0x7C, 0x00, 0xF7, 0x80, 0x1F, 0x00, 0x3D, 0xE0, 0x0F, 0xC0, 0x1E,
  0x3C, 0x03, 0xF8, 0x07, 0x8F, 0x00, 0xEE, 0x01, 0xE3, 0xC0, 0x7B, 0x80,
  0x70, 0xF0, 0x1C, 0xF0, 0x3C, 0x1E, 0x07, 0x3C, 0x0F, 0x07, 0x83, 0xC7,
  0x03, 0xC1, 0xE0, 0xF1, 0xE1, 0xE0, 0x38, 0x38, 0x78, 0x78, 0x0F, 0x1E,
  0x0E, 0x1E, 0x03, 0xC7, 0x83, 0x87, 0x00, 0xF1, 0xC0, 0xF3, 0xC0, 0x1C,
  0xF0, 0x3C, 0xF0, 0x07, 0xBC, 0x07, 0x3C, 0x01, 0xEE, 0x01, 0xEE, 0x00,
  0x7B, 0x80, 0x7F, 0x80, 0x0E, 0xE0, 0x0F, 0xE0, 0x03, 0xF0, 0x03, 0xF8,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x07,
  0xC0, 0xF8, 0x00, 0x7B, 0xC0, 0x07, 0x8F, 0x00, 0x7C, 0x7C, 0x03, 0xC1,
  0xE0, 0x3C, 0x07, 0x83, 0xC0, 0x3E, 0x1E, 0x00, 0xF1, 0xE0, 0x03, 0xDE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x7B, 0xC0, 0x07, 0x8F, 0x00, 0x7C, 0x3C,
  0x03, 0xC1, 0xF0, 0x3C, 0x07, 0x83, 0xE0, 0x1E, 0x1E, 0x00, 0xF9, 0xE0,
  0x03, 0xDE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xF7, 0x80, 0x03,
  0xDE, 0x00, 0x1E, 0x3C, 0x00, 0x78, 0xF0, 0x03, 0xE3, 0xC0, 0x0F, 0x07,
  0x80, 0x3C, 0x1E, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0xF0, 0x07, 0x83, 0xC0, 0x1E, 0x0F, 0x00, 0x3C, 0x78, 0x00, 0xF1, 0xE0,
  0x01, 0xC7, 0x00, 0x07, 0xBC, 0x00, 0x1E, 0xF0, 0x00, 0x3B, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3E, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFC,
  0x00, 0x01, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x03, 0xF0,
  0x1F, 0xC0, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0,
  0x0F, 0x03, 0xF8, 0x0F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0x3E, 0x00, 0x78,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3F, 0x80, 0x7F, 0x00,
  0xFC, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x03, 0xF8, 0x0F,
  0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0xF0,
  0x03, 0xE0, 0x07, 0xF0, 0x07, 0xC0, 0x3F, 0x01, 0xFC, 0x0F, 0x00, 0x38,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x03, 0xF0, 0x3F, 0xC0, 0xFC,
  0x03, 0xC0, 0x00, 0x3F, 0xC0, 0x0B, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xE8, 0x01, 0xFE, 0x00,
};

const GFXglyph NotoSans_Regular44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 6, 32, 12, 3, -31 },
  { 25, 12, 11, 18, 3, -31 },
  { 42, 26, 31, 28, 1, -31 },
  { 143, 20, 36, 25, 3, -33 },
  { 233, 32, 32, 37, 2, -32 },
  { 361, 30, 32, 32, 2, -32 },
  { 481, 4, 11, 10, 3, -31 },
  { 487, 10, 38, 13, 2, -31 },
  { 535, 10, 38, 13, 1, -31 },
  { 583, 20, 19, 24, 2, -33 },
  { 631, 21, 21, 25, 2, -26 },
  { 687, 6, 11, 12, 2, -5 },
  { 696, 10, 4, 14, 2, -14 },
  { 701, 6, 6, 12, 3, -5 },
  { 706, 16, 31, 16, 0, -31 },
  { 768, 21, 32, 25, 2, -32 },
  { 852, 12, 31, 25, 4, -31 },
  { 899, 21, 32, 25, 2, -32 },
  { 983, 21, 32, 25, 2, -32 },
  { 1067, 23, 32, 25, 1, -32 },
  { 1159, 20, 31, 25, 3, -31 },
  { 1237, 21, 32, 25, 2, -32 },
  { 1321, 21, 31, 25, 2, -31 },
  { 1403, 21, 32, 25, 2, -32 },
  { 1487, 21, 32, 25, 2, -32 },
  { 1571, 6, 25, 12, 3, -24 },
  { 1590, 8, 30, 12, 1, -24 },
  { 1620, 21, 22, 25, 2, -27 },
  { 1678, 21, 11, 25, 2, -21 },
  { 1707, 21, 22, 25, 2, -27 },
  { 1765, 17, 33, 19, 1, -32 },
  { 1836, 34, 35, 40, 3, -31 },
  { 1985, 28, 32, 28, 0, -32 },
  { 2097, 22, 31, 29, 4, -31 },
  { 2183, 23, 32, 28, 3, -32 },
  { 2275, 25, 31, 32, 4, -31 },
  { 2372, 18, 31, 24, 4, -31 },
  { 2442, 18, 31, 23, 4, -31 },
  { 2512, 26, 32, 32, 3, -32 },
  { 2616, 24, 31, 33, 4, -31 },
  { 2709, 11, 31, 15, 2, -31 },
  { 2752, 11, 39, 12, -3, -31 },
  { 2806, 23, 31, 27, 4, -31 },
  { 2896, 18, 31, 23, 4, -31 },
  { 2966, 32, 31, 40, 4, -31 },
  { 3090, 25, 31, 33, 4, -31 },
  { 3187, 29, 32, 34, 3, -32 },
  { 3303, 20, 31, 27, 4, -31 },
  { 3381, 29, 39, 34, 3, -32 },
  { 3523, 23, 31, 27, 4, -31 },
  { 3613, 20, 32, 24, 2, -32 },
  { 3693, 24, 31, 24, 0, -31 },
  { 3786, 24, 31, 32, 4, -31 },
  { 3879, 26, 31, 26, 0, -31 },
  { 3980, 39, 31, 41, 1, -31 },
  { 4132, 26, 31, 26, 0, -31 },
  { 4233, 25, 31, 25, 0, -31 },
  { 4330, 21, 31, 25, 2, -31 },
  { 4412, 9, 38, 14, 4, -31 },
  { 4455, 16, 31, 16, 0, -31 },
  { 4517, 10, 38, 14, 1, -31 },
  { 4565, 22, 20, 25, 2, -32 },
  { 4620, 20, 3, 20, 0, 4 },
  { 4628, 9, 7, 12, 2, -34 },
  { 4636, 19, 24, 25, 2, -24 },
  { 4693, 21, 33, 27, 4, -33 },
  { 4780, 18, 24, 21, 2, -24 },
  { 4834, 21, 33, 27, 2, -33 },
  { 4921, 21, 24, 25, 2, -24 },
  { 4984, 16, 34, 15, 1, -34 },
  { 5052, 21, 35, 27, 2, -24 },
  { 5144, 20, 33, 27, 4, -33 },
  { 5227, 5, 32, 11, 3, -32 },
  { 5247, 10, 43, 11, -2, -32 },
  { 5301, 19, 33, 24, 4, -33 },
  { 5380, 4, 33, 11, 4, -33 },
  { 5397, 34, 24, 41, 4, -24 },
  { 5499, 20, 24, 27, 4, -24 },
  { 5559, 22, 24, 27, 2, -24 },
  { 5625, 21, 35, 27, 4, -24 },
  { 5717, 21, 35, 27, 2, -24 },
  { 5809, 14, 24, 18, 4, -24 },
  { 5851, 17, 24, 21, 2, -24 },
  { 5902, 14, 29, 16, 1, -29 },
  { 5953, 20, 24, 27, 3, -24 },
  { 6013, 22, 24, 22, 0, -24 },
  { 6079, 34, 24, 35, 0, -24 },
  { 6181, 21, 24, 23, 1, -24 },
  { 6244, 22, 35, 22, 0, -24 },
  { 6341, 17, 24, 21, 2, -24 },
  { 6392, 14, 38, 17, 1, -31 },
  { 6459, 3, 44, 24, 11, -33 },
  { 6476, 14, 38, 17, 1, -31 },
  { 6543, 21, 5, 25, 2, -18 },
};

const GFXfont NotoSans_Regular44pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Regular44pt7bBitmaps,
  (GFXglyph *)NotoSans_Regular44pt7bGlyphs,
  0x20, 0x7E, 60
};

#endif // _NOTOSANS_REGULAR44PT7B_H_
