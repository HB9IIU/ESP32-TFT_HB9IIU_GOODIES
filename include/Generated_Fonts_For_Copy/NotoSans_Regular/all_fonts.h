#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated:Fonts_For_Copy/NotoSans_Regular
// Headers: 67

#include "NotoSans_Regular6pt7b.h"
#include "NotoSans_Regular7pt7b.h"
#include "NotoSans_Regular8pt7b.h"
#include "NotoSans_Regular9pt7b.h"
#include "NotoSans_Regular10pt7b.h"
#include "NotoSans_Regular11pt7b.h"
#include "NotoSans_Regular12pt7b.h"
#include "NotoSans_Regular13pt7b.h"
#include "NotoSans_Regular14pt7b.h"
#include "NotoSans_Regular15pt7b.h"
#include "NotoSans_Regular16pt7b.h"
#include "NotoSans_Regular17pt7b.h"
#include "NotoSans_Regular18pt7b.h"
#include "NotoSans_Regular19pt7b.h"
#include "NotoSans_Regular20pt7b.h"
#include "NotoSans_Regular21pt7b.h"
#include "NotoSans_Regular22pt7b.h"
#include "NotoSans_Regular23pt7b.h"
#include "NotoSans_Regular24pt7b.h"
#include "NotoSans_Regular25pt7b.h"
#include "NotoSans_Regular26pt7b.h"
#include "NotoSans_Regular27pt7b.h"
#include "NotoSans_Regular28pt7b.h"
#include "NotoSans_Regular29pt7b.h"
#include "NotoSans_Regular30pt7b.h"
#include "NotoSans_Regular31pt7b.h"
#include "NotoSans_Regular32pt7b.h"
#include "NotoSans_Regular33pt7b.h"
#include "NotoSans_Regular34pt7b.h"
#include "NotoSans_Regular35pt7b.h"
#include "NotoSans_Regular36pt7b.h"
#include "NotoSans_Regular37pt7b.h"
#include "NotoSans_Regular38pt7b.h"
#include "NotoSans_Regular39pt7b.h"
#include "NotoSans_Regular40pt7b.h"
#include "NotoSans_Regular41pt7b.h"
#include "NotoSans_Regular42pt7b.h"
#include "NotoSans_Regular43pt7b.h"
#include "NotoSans_Regular44pt7b.h"
#include "NotoSans_Regular45pt7b.h"
#include "NotoSans_Regular46pt7b.h"
#include "NotoSans_Regular47pt7b.h"
#include "NotoSans_Regular48pt7b.h"
#include "NotoSans_Regular49pt7b.h"
#include "NotoSans_Regular50pt7b.h"
#include "NotoSans_Regular51pt7b.h"
#include "NotoSans_Regular52pt7b.h"
#include "NotoSans_Regular53pt7b.h"
#include "NotoSans_Regular54pt7b.h"
#include "NotoSans_Regular55pt7b.h"
#include "NotoSans_Regular56pt7b.h"
#include "NotoSans_Regular57pt7b.h"
#include "NotoSans_Regular58pt7b.h"
#include "NotoSans_Regular59pt7b.h"
#include "NotoSans_Regular60pt7b.h"
#include "NotoSans_Regular61pt7b.h"
#include "NotoSans_Regular62pt7b.h"
#include "NotoSans_Regular63pt7b.h"
#include "NotoSans_Regular64pt7b.h"
#include "NotoSans_Regular65pt7b.h"
#include "NotoSans_Regular66pt7b.h"
#include "NotoSans_Regular67pt7b.h"
#include "NotoSans_Regular68pt7b.h"
#include "NotoSans_Regular69pt7b.h"
#include "NotoSans_Regular70pt7b.h"
#include "NotoSans_Regular71pt7b.h"
#include "NotoSans_Regular72pt7b.h"
