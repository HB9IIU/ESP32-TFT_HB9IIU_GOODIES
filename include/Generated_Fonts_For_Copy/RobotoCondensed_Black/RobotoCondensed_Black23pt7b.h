#ifndef _ROBOTOCONDENSED_BLACK23PT7B_H_
#define _ROBOTOCONDENSED_BLACK23PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Black.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Black23pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xF7, 0x77, 0x70, 0x06, 0xFF, 0x60, 0xEF, 0xDF,
  0xBF, 0x7E, 0xD9, 0x80, 0x0D, 0x81, 0xB0, 0x36, 0x06, 0xC1, 0xD8, 0xFF,
  0xDF, 0xF8, 0xDC, 0x1B, 0x03, 0x63, 0xFF, 0x7F, 0xE3, 0xB0, 0x66, 0x0D,
  0xC1, 0xB0, 0x36, 0x00, 0x0C, 0x03, 0x01, 0xE0, 0xFE, 0x7F, 0x9C, 0xFF,
  0x3D, 0xC0, 0x78, 0x1F, 0x03, 0xF0, 0x3E, 0x07, 0x80, 0xFF, 0x3F, 0xCF,
  0xFF, 0x9F, 0xE1, 0xE0, 0x30, 0x0C, 0x00, 0x78, 0x03, 0xE0, 0x3B, 0x31,
  0x99, 0x8C, 0xDC, 0x76, 0xC1, 0xFE, 0x0F, 0x60, 0x07, 0x00, 0x37, 0x03,
  0x7C, 0x1B, 0x71, 0xBB, 0x8D, 0xDC, 0xC6, 0xE0, 0x3E, 0x00, 0xE0, 0x1E,
  0x03, 0xF0, 0x7F, 0x07, 0x38, 0x73, 0x87, 0x70, 0x7F, 0x03, 0xE0, 0x3C,
  0x07, 0xEE, 0xFF, 0xEE, 0xFE, 0xE7, 0xEF, 0x3C, 0xFF, 0xC7, 0xFE, 0x3E,
  0xF0, 0xFF, 0xFF, 0xC0, 0x08, 0x71, 0x8E, 0x31, 0xC7, 0x18, 0xE3, 0x8E,
  0x38, 0xE3, 0x8E, 0x18, 0x71, 0xC3, 0x0E, 0x18, 0x70, 0x80, 0x86, 0x38,
  0xE7, 0x18, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0x9C, 0xEE, 0x62,
  0x00, 0x0E, 0x01, 0xC0, 0x18, 0x3A, 0x6F, 0xFE, 0x1E, 0x07, 0xC1, 0xD8,
  0x31, 0x82, 0x20, 0x1C, 0x0E, 0x07, 0x03, 0x8F, 0xFF, 0xFF, 0xFE, 0x38,
  0x1C, 0x0E, 0x07, 0x00, 0x39, 0xCE, 0x77, 0x39, 0x80, 0xFF, 0xFF, 0xC0,
  0x7F, 0xF7, 0x0E, 0x1C, 0x30, 0xE1, 0xC3, 0x86, 0x1C, 0x38, 0x70, 0xC3,
  0x87, 0x0E, 0x18, 0x70, 0xE1, 0xC0, 0x1E, 0x0F, 0xC7, 0xFB, 0xCE, 0xF3,
  0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xE7,
  0xF8, 0xFC, 0x1E, 0x00, 0x04, 0xFF, 0xFF, 0xFC, 0x71, 0xC7, 0x1C, 0x71,
  0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x3E, 0x1F, 0xEF, 0xFB, 0xCE, 0xE3, 0xC0,
  0xF0, 0x38, 0x1E, 0x07, 0x03, 0xC1, 0xE0, 0xF0, 0x3C, 0x1E, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3E, 0x1F, 0xCF, 0xFB, 0xCE, 0x03, 0xC0, 0xF0, 0x38,
  0x7E, 0x1E, 0x07, 0xE0, 0x3C, 0x0F, 0xE3, 0xFC, 0xFF, 0xF9, 0xFE, 0x3E,
  0x00, 0x07, 0x83, 0xE0, 0xF8, 0x7E, 0x1F, 0x8F, 0xE3, 0xF9, 0xDE, 0x77,
  0xB9, 0xEF, 0xFF, 0xFF, 0xFF, 0xC1, 0xE0, 0x78, 0x1E, 0x07, 0x80, 0x7F,
  0x9F, 0xE7, 0xF9, 0xC0, 0xF0, 0x3C, 0x0F, 0xF3, 0xFE, 0xFF, 0x80, 0xF0,
  0x3C, 0x0F, 0xF3, 0xFC, 0xEF, 0xF9, 0xFC, 0x1E, 0x00, 0x07, 0x07, 0xC3,
  0xF1, 0xF0, 0x78, 0x3C, 0x0F, 0xF3, 0xFE, 0xFF, 0xFC, 0xFF, 0x3F, 0xCF,
  0xF3, 0xFC, 0xF7, 0xF8, 0xFE, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E,
  0x07, 0x81, 0xE0, 0x70, 0x3C, 0x0F, 0x03, 0x81, 0xE0, 0x78, 0x1C, 0x0F,
  0x03, 0xC1, 0xE0, 0x78, 0x00, 0x1E, 0x1F, 0xC7, 0xFB, 0xCE, 0xF3, 0xBC,
  0xE7, 0x39, 0xFE, 0x3F, 0x1F, 0xEF, 0x3B, 0xCF, 0xF3, 0xFC, 0xFF, 0xF9,
  0xFE, 0x3E, 0x00, 0x1E, 0x1F, 0xC7, 0xFB, 0xCE, 0xF3, 0xFC, 0xFF, 0x3F,
  0xCF, 0xFF, 0xDF, 0xF3, 0xFC, 0x0E, 0x07, 0x83, 0xC3, 0xF0, 0xF8, 0x38,
  0x00, 0x77, 0xBC, 0xE0, 0x00, 0x00, 0x03, 0xBD, 0xF7, 0x00, 0x7F, 0xF7,
  0x00, 0x00, 0x00, 0x77, 0x77, 0x7E, 0x40, 0x01, 0x07, 0x1F, 0x7F, 0xFC,
  0xE0, 0xF8, 0x7F, 0x1F, 0x07, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x3E, 0x1F, 0xE1, 0xF8, 0x3C, 0x7F, 0xFE,
  0xF8, 0x70, 0x20, 0x00, 0x1F, 0x1F, 0xE7, 0xF9, 0xCF, 0xF3, 0xC0, 0xF0,
  0x78, 0x1E, 0x0F, 0x03, 0x81, 0xE0, 0x78, 0x00, 0x03, 0x01, 0xE0, 0x78,
  0x0C, 0x00, 0x07, 0xE0, 0x0F, 0xF8, 0x1C, 0x1C, 0x38, 0x0C, 0x70, 0x06,
  0x61, 0xE6, 0xE3, 0xF7, 0xE7, 0x63, 0xCE, 0x63, 0xCE, 0x63, 0xCE, 0x63,
  0xCE, 0x67, 0xCE, 0x66, 0xCE, 0xE6, 0xCF, 0xFC, 0xE7, 0x38, 0x60, 0x00,
  0x70, 0x00, 0x3C, 0x20, 0x1F, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0x1E, 0x00,
  0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xFE, 0x07, 0x38, 0x1C, 0xE0,
  0xF3, 0xC3, 0xCF, 0x0F, 0xFC, 0x7F, 0xF1, 0xFF, 0xE7, 0x87, 0x9E, 0x1E,
  0xF0, 0x3C, 0xFF, 0x1F, 0xFB, 0xFF, 0x78, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F,
  0xFE, 0xFF, 0x9F, 0xFB, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFF, 0xFF, 0xFE,
  0xFF, 0x80, 0x1F, 0x03, 0xFC, 0x7F, 0xE7, 0x9E, 0xF0, 0xEF, 0x0F, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x0F, 0xF0, 0xEF, 0x1E, 0x7F,
  0xE3, 0xFC, 0x1F, 0x00, 0xFE, 0x1F, 0xF3, 0xFF, 0x79, 0xEF, 0x1F, 0xE3,
  0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE7, 0xBF,
  0xF7, 0xFC, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xFE, 0xFF, 0xBF, 0xEF, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0x07, 0x83, 0xC1, 0xFF, 0xFF,
  0xFF, 0xFC, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x00, 0x1F, 0x83,
  0xFC, 0x7F, 0xE7, 0x9E, 0xF0, 0xEF, 0x0F, 0xF0, 0x0F, 0x00, 0xF3, 0xFF,
  0x3F, 0xF3, 0xFF, 0x0F, 0xF0, 0xF7, 0x8F, 0x7F, 0xF3, 0xFE, 0x1F, 0x80,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0xF3, 0xDE, 0xF7, 0xFC, 0xFE, 0x1F, 0x00, 0xF1, 0xFF, 0x1E,
  0xF3, 0xEF, 0x3C, 0xF7, 0x8F, 0x78, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF8,
  0xFF, 0x8F, 0xF8, 0xF3, 0xCF, 0x3C, 0xF3, 0xEF, 0x1E, 0xF1, 0xF0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x3F, 0xF0, 0x7F, 0xF0,
  0xFF, 0xE1, 0xFF, 0xC7, 0xFF, 0x8F, 0xFF, 0x9F, 0xFF, 0x37, 0xFE, 0xEF,
  0xED, 0xDF, 0xDB, 0xBF, 0xBE, 0x7F, 0x7D, 0xFE, 0x7B, 0xFC, 0xF7, 0xF9,
  0xCF, 0xF3, 0x9E, 0xF0, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xFC, 0xFF, 0xCF,
  0xFC, 0xFF, 0xEF, 0xF6, 0xFF, 0x7F, 0xF3, 0xFF, 0x3F, 0xF3, 0xFF, 0x1F,
  0xF1, 0xFF, 0x1F, 0xF0, 0xF0, 0x1F, 0x03, 0xFC, 0x7F, 0xE7, 0x9E, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xF7, 0x9E, 0x7F, 0xE3, 0xFC, 0x1F, 0x00, 0xFF, 0x1F, 0xFB, 0xFF, 0xF8,
  0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xFF, 0xFF, 0xFB, 0xFC, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x00, 0x1F, 0x03, 0xFC, 0x7F, 0xE7,
  0x9E, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xF7, 0x9E, 0x7F, 0xE3, 0xFC, 0x1F, 0xE0, 0x1F, 0x00, 0xE0,
  0x04, 0xFF, 0x1F, 0xFB, 0xFF, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F,
  0xFF, 0xDF, 0xF3, 0xFE, 0x7B, 0xCF, 0x3D, 0xE7, 0xBC, 0xFF, 0x8F, 0xF1,
  0xE0, 0x1F, 0x0F, 0xF9, 0xFF, 0x78, 0xFF, 0x1F, 0xE0, 0x1F, 0x03, 0xF8,
  0x3F, 0x81, 0xF8, 0x0F, 0xF8, 0xFF, 0x1F, 0xE3, 0xDF, 0xF1, 0xFE, 0x1F,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x00, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F,
  0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xDF, 0xFB, 0xFE, 0x1F,
  0x00, 0xF8, 0x7B, 0xC3, 0xDE, 0x1E, 0xF1, 0xE7, 0x8F, 0x1C, 0x78, 0xF3,
  0xC7, 0x9C, 0x3D, 0xE0, 0xEF, 0x07, 0x78, 0x3F, 0x81, 0xFC, 0x07, 0xE0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xF1, 0xC7, 0xB8, 0xE3, 0x9E, 0xF9, 0xCF,
  0x7D, 0xE7, 0xBE, 0xF3, 0xDF, 0x79, 0xEF, 0xBC, 0x77, 0xDC, 0x3F, 0xFE,
  0x1F, 0xBF, 0x0F, 0xDF, 0x87, 0xEF, 0xC3, 0xF7, 0xE0, 0xFB, 0xE0, 0x7D,
  0xF0, 0x3C, 0x78, 0x1E, 0x3C, 0x00, 0xF8, 0xF3, 0xC7, 0x9E, 0x7C, 0x7B,
  0xC3, 0xDE, 0x0E, 0xE0, 0x7F, 0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x07, 0xF0,
  0x3B, 0x83, 0xDE, 0x1E, 0xF1, 0xE3, 0xCF, 0x1E, 0xF8, 0xF8, 0xF0, 0xF3,
  0xC7, 0x9E, 0x3C, 0x73, 0xC3, 0xDE, 0x1E, 0xE0, 0x77, 0x03, 0xF8, 0x1F,
  0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x38, 0x0F, 0x03, 0xC0,
  0x78, 0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x07, 0x80, 0xE0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE,
  0xF7, 0xBD, 0xEF, 0xFF, 0xE0, 0xF0, 0x78, 0x1E, 0x0F, 0x07, 0x81, 0xC0,
  0xF0, 0x78, 0x1C, 0x0F, 0x07, 0x81, 0xC0, 0xF0, 0x78, 0x3C, 0x0F, 0x07,
  0x83, 0xC0, 0xFF, 0xFE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF,
  0x7B, 0xDE, 0xFF, 0xFF, 0xE0, 0x1C, 0x0F, 0x0F, 0x86, 0xC3, 0x73, 0xB9,
  0xCC, 0xC7, 0xFF, 0xFF, 0xFF, 0xE0, 0xF1, 0xC3, 0x8F, 0x3E, 0x3F, 0xBF,
  0xFE, 0xF0, 0x79, 0xFF, 0xFF, 0xEF, 0xE7, 0xFF, 0xFF, 0xEF, 0xF0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0xF3, 0xFE, 0xFF, 0xBC, 0xFF,
  0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xFE, 0xFF, 0xBB, 0xC0, 0x3E, 0x3F,
  0xBF, 0xFC, 0xFE, 0x3F, 0x03, 0x81, 0xC7, 0xE7, 0xFF, 0xDF, 0xC7, 0xC0,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0xEF, 0xFF, 0xFF, 0xF9, 0xF8,
  0xFC, 0x7E, 0x3F, 0x1F, 0xCF, 0xFF, 0xFF, 0x9D, 0xC0, 0x3E, 0x1F, 0xCF,
  0xFB, 0xCE, 0xE3, 0xFF, 0xFF, 0xFF, 0x80, 0xF1, 0x3F, 0xE7, 0xF8, 0xFC,
  0x0E, 0x3C, 0xF9, 0xE3, 0x87, 0x3F, 0xFF, 0xFE, 0x70, 0xE1, 0xC3, 0x87,
  0x0E, 0x1C, 0x38, 0x70, 0x3F, 0xDF, 0xFF, 0xFF, 0xCF, 0xE3, 0xF8, 0xFE,
  0x3F, 0x8F, 0xF3, 0xFF, 0xF7, 0xFC, 0xEF, 0x03, 0xC0, 0xF7, 0xF9, 0xFC,
  0x3E, 0x00, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xFD, 0xFF, 0xFF,
  0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xC0, 0x6F,
  0xF6, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x18, 0xF3, 0xC6, 0x00,
  0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xFF, 0xFB,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x3F, 0xDE, 0xFF,
  0x3F, 0xCF, 0xE3, 0xF8, 0xFF, 0x3F, 0xCF, 0x7B, 0xDE, 0xF3, 0xFC, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0x39, 0xFF,
  0xFB, 0xFF, 0xFF, 0xBC, 0xFF, 0x39, 0xFE, 0x73, 0xFC, 0xE7, 0xF9, 0xCF,
  0xF3, 0x9F, 0xE7, 0x3F, 0xCE, 0x7F, 0x9C, 0xF0, 0xEF, 0x7F, 0xFF, 0xFE,
  0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x70, 0x3E, 0x1F,
  0xCF, 0xFB, 0xCE, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xF3, 0xBF, 0xE7, 0xF0,
  0xF8, 0xFF, 0x3F, 0xEF, 0xFB, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3,
  0xFF, 0xEF, 0xFB, 0xFC, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x00, 0x7B,
  0xFF, 0xFF, 0xFE, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xF3, 0xFF, 0xDF, 0xE7,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x80, 0xEF, 0xFF, 0xF7, 0xEF, 0x1E,
  0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x80, 0x1F, 0x1F, 0xE7, 0xFD, 0xCF, 0x78,
  0x1F, 0xC1, 0xF8, 0x1F, 0xF3, 0xDF, 0xF7, 0xF8, 0x7C, 0x78, 0xF1, 0xE7,
  0xFF, 0xFF, 0xDE, 0x3C, 0x78, 0xF1, 0xE3, 0xC3, 0xE7, 0xC7, 0x80, 0xF3,
  0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xFF, 0xDF, 0xEF,
  0x70, 0xF3, 0xDC, 0xF7, 0xBD, 0xEE, 0x7B, 0x8E, 0xE3, 0xF8, 0xFC, 0x3F,
  0x07, 0xC1, 0xF0, 0x78, 0xF3, 0xBD, 0xCE, 0xF7, 0x7B, 0xDD, 0xEE, 0x77,
  0xB9, 0xDF, 0xE3, 0xFF, 0x8F, 0xBE, 0x3E, 0xF0, 0xF3, 0xC3, 0xCF, 0x07,
  0x1C, 0x73, 0xDE, 0xF7, 0xB8, 0xFE, 0x3F, 0x07, 0xC1, 0xF0, 0xFC, 0x3F,
  0x9E, 0xE7, 0xBF, 0xCF, 0xF3, 0xCE, 0x79, 0xEF, 0x3D, 0xE7, 0xB8, 0x7F,
  0x0F, 0xE1, 0xF8, 0x1F, 0x03, 0xE0, 0x78, 0x0F, 0x00, 0xE0, 0x3C, 0x0F,
  0x01, 0xE0, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xC1, 0xE1, 0xE0, 0xE0, 0xF0,
  0xF0, 0x78, 0x7F, 0xFF, 0xFF, 0xF0, 0x19, 0xDE, 0xE7, 0x39, 0xCE, 0x77,
  0xB9, 0xC7, 0x39, 0xCE, 0x73, 0x9C, 0xF3, 0x8C, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC7, 0x38, 0xE7, 0x39, 0xCE, 0x73, 0xCE, 0x77, 0x39, 0xCE, 0x73,
  0x9D, 0xCE, 0x40, 0x38, 0xDF, 0x3F, 0xFF, 0x9F, 0xE3, 0x80,
};

const GFXglyph RobotoCondensed_Black23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 4, 17, 6, 1, -17 },
  { 10, 7, 6, 7, 0, -17 },
  { 16, 11, 17, 12, 0, -17 },
  { 40, 10, 21, 12, 1, -19 },
  { 67, 13, 17, 15, 1, -17 },
  { 95, 12, 17, 14, 1, -17 },
  { 121, 3, 6, 4, 0, -17 },
  { 124, 6, 23, 7, 1, -18 },
  { 142, 5, 23, 7, 1, -18 },
  { 157, 11, 10, 11, 0, -17 },
  { 171, 9, 11, 11, 1, -13 },
  { 184, 5, 7, 6, 0, -3 },
  { 189, 6, 3, 10, 2, -9 },
  { 192, 4, 4, 7, 1, -4 },
  { 194, 7, 18, 7, 0, -17 },
  { 210, 10, 17, 12, 1, -17 },
  { 232, 6, 17, 12, 2, -17 },
  { 245, 10, 17, 12, 1, -17 },
  { 267, 10, 17, 12, 1, -17 },
  { 289, 10, 17, 12, 1, -17 },
  { 311, 10, 17, 12, 1, -17 },
  { 333, 10, 17, 12, 1, -17 },
  { 355, 10, 17, 12, 1, -17 },
  { 377, 10, 17, 12, 1, -17 },
  { 399, 10, 17, 12, 1, -17 },
  { 421, 5, 13, 7, 1, -13 },
  { 430, 4, 17, 6, 1, -13 },
  { 439, 8, 11, 10, 1, -12 },
  { 450, 9, 8, 12, 1, -11 },
  { 459, 9, 11, 10, 1, -12 },
  { 472, 10, 17, 11, 0, -17 },
  { 494, 16, 21, 18, 1, -16 },
  { 536, 14, 17, 14, 0, -17 },
  { 566, 11, 17, 13, 1, -17 },
  { 590, 12, 17, 13, 1, -17 },
  { 616, 11, 17, 13, 1, -17 },
  { 640, 10, 17, 11, 1, -17 },
  { 662, 9, 17, 11, 1, -17 },
  { 682, 12, 17, 14, 1, -17 },
  { 708, 12, 17, 14, 1, -17 },
  { 734, 4, 17, 6, 1, -17 },
  { 743, 10, 17, 11, 0, -17 },
  { 765, 12, 17, 13, 1, -17 },
  { 791, 9, 17, 11, 1, -17 },
  { 811, 15, 17, 17, 1, -17 },
  { 843, 12, 17, 14, 1, -17 },
  { 869, 12, 17, 14, 1, -17 },
  { 895, 11, 17, 13, 1, -17 },
  { 919, 12, 20, 14, 1, -17 },
  { 949, 11, 17, 13, 1, -17 },
  { 973, 11, 17, 13, 1, -17 },
  { 997, 11, 17, 13, 1, -17 },
  { 1021, 11, 17, 13, 1, -17 },
  { 1045, 13, 17, 13, 0, -17 },
  { 1073, 17, 17, 17, 0, -17 },
  { 1110, 13, 17, 13, 0, -17 },
  { 1138, 13, 17, 13, 0, -17 },
  { 1166, 11, 17, 12, 1, -17 },
  { 1190, 5, 23, 6, 1, -19 },
  { 1205, 9, 18, 9, 0, -17 },
  { 1226, 5, 23, 6, 0, -19 },
  { 1241, 9, 8, 9, 0, -17 },
  { 1250, 9, 3, 9, 0, 0 },
  { 1254, 6, 4, 8, 1, -18 },
  { 1257, 9, 12, 11, 1, -12 },
  { 1271, 10, 18, 11, 1, -18 },
  { 1294, 9, 12, 11, 1, -12 },
  { 1308, 9, 18, 11, 1, -18 },
  { 1329, 10, 12, 11, 1, -12 },
  { 1344, 7, 18, 8, 0, -18 },
  { 1360, 10, 17, 12, 1, -12 },
  { 1382, 9, 18, 11, 1, -18 },
  { 1403, 4, 17, 6, 1, -17 },
  { 1412, 6, 22, 6, -1, -17 },
  { 1429, 10, 18, 11, 1, -18 },
  { 1452, 4, 18, 6, 1, -18 },
  { 1461, 15, 12, 17, 1, -12 },
  { 1484, 9, 12, 11, 1, -12 },
  { 1498, 10, 12, 11, 1, -12 },
  { 1513, 10, 17, 11, 1, -12 },
  { 1535, 9, 17, 11, 1, -12 },
  { 1555, 7, 12, 8, 1, -12 },
  { 1566, 10, 12, 10, 0, -12 },
  { 1581, 7, 15, 7, 0, -15 },
  { 1595, 9, 12, 11, 1, -12 },
  { 1609, 10, 12, 11, 0, -12 },
  { 1624, 14, 12, 14, 0, -12 },
  { 1645, 10, 12, 11, 0, -12 },
  { 1660, 11, 17, 11, 0, -12 },
  { 1684, 9, 12, 11, 1, -12 },
  { 1698, 5, 22, 7, 1, -18 },
  { 1712, 2, 20, 6, 2, -17 },
  { 1717, 5, 22, 7, 1, -18 },
  { 1731, 10, 5, 12, 1, -9 },
};

const GFXfont RobotoCondensed_Black23pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Black23pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Black23pt7bGlyphs,
  0x20, 0x7E, 27
};

#endif // _ROBOTOCONDENSED_BLACK23PT7B_H_
