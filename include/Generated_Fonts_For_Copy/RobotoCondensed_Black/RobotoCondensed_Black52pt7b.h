#ifndef _ROBOTOCONDENSED_BLACK52PT7B_H_
#define _ROBOTOCONDENSED_BLACK52PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Black.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Black52pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F,
  0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0x9F, 0xCF, 0xE7,
  0xF3, 0xF9, 0xFC, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF3, 0xFD,
  0xFE, 0xFF, 0xFF, 0xFF, 0xDF, 0xE7, 0xE0, 0x00, 0xFC, 0x7F, 0xF1, 0xFF,
  0xC7, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F,
  0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7B, 0xC1, 0xE0, 0x00, 0xF8, 0xF0,
  0x00, 0xF9, 0xF0, 0x00, 0xF9, 0xF0, 0x00, 0xF9, 0xF0, 0x00, 0xF1, 0xF0,
  0x01, 0xF1, 0xF0, 0x01, 0xF1, 0xF0, 0x01, 0xF1, 0xE0, 0x01, 0xF3, 0xE0,
  0x01, 0xF3, 0xE0, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x03, 0xE3, 0xC0, 0x03, 0xE7, 0xC0,
  0x03, 0xE7, 0xC0, 0x03, 0xE7, 0xC0, 0x03, 0xC7, 0xC0, 0x07, 0xC7, 0xC0,
  0x07, 0xC7, 0xC0, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x0F, 0x8F, 0x80, 0x0F, 0x8F, 0x80,
  0x0F, 0x8F, 0x80, 0x0F, 0x9F, 0x00, 0x0F, 0x9F, 0x00, 0x0F, 0x9F, 0x00,
  0x0F, 0x9F, 0x00, 0x0F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3, 0xFE,
  0x7F, 0xCF, 0xF8, 0x7F, 0x9F, 0xF0, 0xFF, 0x3F, 0xE1, 0xFE, 0x7F, 0xC3,
  0xFE, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00,
  0x03, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xC0,
  0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x7F, 0x81, 0xFE, 0xFF, 0x83, 0xFD, 0xFF,
  0x07, 0xFB, 0xFE, 0x0F, 0xF3, 0xFC, 0x1F, 0xE7, 0xFC, 0x7F, 0xCF, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07,
  0xFF, 0xC0, 0x80, 0x3F, 0x7E, 0x07, 0x03, 0xF1, 0xF0, 0x7C, 0x1F, 0x8F,
  0xC3, 0xE0, 0xFC, 0x7E, 0x3E, 0x07, 0xE3, 0xF1, 0xF0, 0x3F, 0x1F, 0x9F,
  0x01, 0xF8, 0xF8, 0xF0, 0x07, 0xEF, 0xCF, 0x80, 0x3F, 0xFE, 0x78, 0x00,
  0xFF, 0xE7, 0xC0, 0x07, 0xFF, 0x7C, 0x00, 0x0F, 0xE3, 0xE0, 0x00, 0x08,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0xFF, 0x00, 0x07, 0xCF, 0xFC,
  0x00, 0x3E, 0xFF, 0xF0, 0x03, 0xEF, 0xFF, 0x80, 0x1F, 0x7E, 0x7E, 0x01,
  0xF3, 0xE1, 0xF0, 0x0F, 0x9F, 0x0F, 0x80, 0xF8, 0xF8, 0x7C, 0x07, 0x87,
  0xC3, 0xE0, 0x7C, 0x3E, 0x1F, 0x03, 0xC1, 0xF0, 0xF8, 0x1E, 0x0F, 0xCF,
  0xC0, 0x20, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFC, 0xFF, 0x00,
  0x1F, 0xE3, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x3F,
  0x87, 0xF0, 0x01, 0xFE, 0x3F, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x3F, 0xFF,
  0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x1F, 0xC0, 0xFF, 0xF0, 0xFE, 0x0F,
  0xFF, 0xC7, 0xF0, 0xFF, 0xFF, 0x3F, 0x8F, 0xFF, 0xFB, 0xFC, 0x7F, 0xBF,
  0xFF, 0xC3, 0xFC, 0xFF, 0xFE, 0x1F, 0xE7, 0xFF, 0xF1, 0xFF, 0x1F, 0xFF,
  0x8F, 0xF8, 0x7F, 0xF8, 0x3F, 0xC3, 0xFF, 0xC1, 0xFF, 0x0F, 0xFC, 0x0F,
  0xF8, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0x8F,
  0xF8, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xEF, 0x80, 0x00, 0x20, 0x07, 0x00, 0xF0, 0x1F, 0x03,
  0xF0, 0x7E, 0x07, 0xE0, 0xFC, 0x1F, 0xC1, 0xF8, 0x1F, 0x83, 0xF0, 0x3F,
  0x03, 0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0x81, 0xFC, 0x0F,
  0xC0, 0x7E, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x00, 0x70, 0x02, 0x20,
  0x01, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF8, 0x07,
  0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0xFE, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0x7C,
  0x01, 0xE0, 0x07, 0x00, 0x08, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x18,
  0x1F, 0x03, 0x3E, 0x3E, 0x1E, 0xFF, 0x7D, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0xC0, 0x07, 0xEF, 0x80, 0x1F, 0x9F, 0x80, 0x7E, 0x1F,
  0x81, 0xFC, 0x1F, 0x81, 0xF0, 0x3E, 0x00, 0xC0, 0x38, 0x00, 0x80, 0x20,
  0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1,
  0xFC, 0x7E, 0x1F, 0x8F, 0xE3, 0xF9, 0xFC, 0x7E, 0x3F, 0x87, 0xC0, 0x60,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3E, 0x3F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFE, 0x7E, 0x08, 0x00, 0x00,
  0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01,
  0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x10, 0x00, 0x07, 0xFC,
  0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0x8F, 0xF3, 0xFE, 0x7F, 0x87, 0xF9, 0xFE, 0x0F, 0xF7, 0xF8,
  0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xDF, 0xE0, 0xFF,
  0x7F, 0x83, 0xFD, 0xFE, 0x0F, 0xF7, 0xF8, 0x7F, 0x8F, 0xF3, 0xFE, 0x3F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x07, 0xFF,
  0xC0, 0x07, 0xFC, 0x00, 0x01, 0x00, 0x00, 0x00, 0x06, 0x00, 0x7C, 0x03,
  0xF8, 0x3F, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC7, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x7F,
  0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0x9F, 0xF3, 0xFE, 0xFF, 0x87, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xC1, 0xFF, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x10, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x7F,
  0xE7, 0xFE, 0x7F, 0xC3, 0xFE, 0x7F, 0x83, 0xFE, 0x7F, 0x81, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0x81, 0xFE, 0xFF, 0x81, 0xFE, 0x7F, 0x83, 0xFE, 0x7F,
  0xC7, 0xFE, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x10, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x07,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x7E, 0xFF,
  0x00, 0xFD, 0xFE, 0x03, 0xF3, 0xFC, 0x07, 0xE7, 0xF8, 0x1F, 0xCF, 0xF0,
  0x3F, 0x1F, 0xE0, 0xFE, 0x3F, 0xC1, 0xFC, 0x7F, 0x87, 0xF0, 0xFF, 0x0F,
  0xE1, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x3F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0xFC,
  0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0x9F, 0xC3, 0xFE, 0x06, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0xF7, 0xFC, 0xFF, 0x9F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFE, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0x00, 0x00, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x7F,
  0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF8,
  0x03, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF9, 0xF8, 0x0F, 0xF7, 0xFC, 0x1F,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xF7, 0xFC, 0x3F, 0xEF, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07,
  0xFB, 0xFC, 0x1F, 0xF7, 0xF8, 0x3F, 0xEF, 0xF0, 0x7F, 0x8F, 0xF1, 0xFF,
  0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80,
  0x3F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x02, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x10, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xFC, 0x07,
  0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x9F, 0xF3,
  0xFE, 0x7F, 0xC7, 0xFD, 0xFE, 0x1F, 0xF7, 0xF8, 0x7F, 0xDF, 0xE1, 0xFF,
  0x7F, 0x87, 0xFD, 0xFE, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF0, 0xFF, 0xFF, 0xE7, 0xFC, 0x7F, 0x9F, 0xE1, 0xFF, 0x7F, 0x83, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE,
  0x0F, 0xF7, 0xF8, 0x7F, 0xDF, 0xF3, 0xFF, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xF8, 0x03,
  0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x1F, 0xF3,
  0xFE, 0x7F, 0x87, 0xF9, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x83, 0xFF, 0xFE, 0x0F, 0xF7, 0xF8, 0x3F, 0xDF, 0xF9, 0xFF, 0x7F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x0F, 0xFB, 0xFC,
  0x0F, 0xDF, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0xC0, 0x07, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x1F, 0xFE,
  0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x1F, 0xEF, 0xFB, 0xFE, 0xFF, 0xFF, 0xE7, 0xF8, 0xFC, 0x08, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x1F, 0xEF, 0xFB, 0xFF, 0xFF, 0xFF, 0xE7, 0xF8, 0xFC, 0x08,
  0x00, 0x1F, 0x0F, 0xE7, 0xFD, 0xFF, 0x7F, 0xDF, 0xF7, 0xFC, 0xFE, 0x04,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE,
  0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x1F, 0xC7, 0xE3, 0xF0, 0x7C, 0x06,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x1C, 0x00, 0x0F, 0x80, 0x07, 0xF0, 0x03,
  0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x7F, 0xFF, 0x3F, 0xFF, 0xDF, 0xFF,
  0xC3, 0xFF, 0xE0, 0x7F, 0xF0, 0x0F, 0xF8, 0x01, 0xFF, 0xC0, 0x3F, 0xFE,
  0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x7F,
  0xF0, 0x03, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0xF8, 0x00, 0x07, 0x00, 0x00,
  0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x1C, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xC0,
  0x3F, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF,
  0x80, 0x3F, 0xF0, 0x01, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x7F, 0xFF,
  0x3F, 0xFF, 0xDF, 0xFF, 0xC3, 0xFF, 0xE0, 0x7F, 0xF0, 0x0F, 0xF8, 0x01,
  0xFC, 0x00, 0x3E, 0x00, 0x07, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F,
  0xFF, 0xF9, 0xFF, 0xFF, 0xDF, 0xF9, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xC1, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0,
  0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0x8F, 0xFC, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0x00, 0xFC, 0x1F, 0x80, 0x00, 0x07, 0xC1, 0xF0, 0x07, 0xE0, 0x7E, 0x3F,
  0x01, 0xFF, 0x83, 0xE3, 0xE0, 0x3F, 0xFC, 0x3E, 0x7E, 0x07, 0xFF, 0xC3,
  0xE7, 0xC0, 0xFF, 0xFC, 0x1E, 0x7C, 0x1F, 0xC7, 0xC1, 0xF7, 0xC1, 0xF8,
  0x7C, 0x1F, 0xFC, 0x3F, 0x07, 0xC1, 0xFF, 0xC3, 0xF0, 0xFC, 0x1F, 0xF8,
  0x3F, 0x0F, 0xC1, 0xFF, 0x83, 0xF0, 0xFC, 0x1F, 0xF8, 0x7E, 0x0F, 0xC1,
  0xFF, 0x87, 0xE0, 0xFC, 0x1F, 0xF8, 0x7E, 0x0F, 0xC1, 0xFF, 0x87, 0xE0,
  0xFC, 0x1F, 0xF8, 0x7E, 0x0F, 0xC1, 0xEF, 0x87, 0xE0, 0xF8, 0x3E, 0xF8,
  0x7E, 0x0F, 0x83, 0xEF, 0x87, 0xE1, 0xF8, 0x3E, 0xF8, 0x7F, 0x1F, 0x87,
  0xCF, 0x83, 0xFB, 0xFC, 0xFC, 0xFC, 0x3F, 0xFF, 0xFF, 0x8F, 0xC3, 0xFF,
  0xFF, 0xF0, 0x7C, 0x1F, 0xF7, 0xFE, 0x07, 0xC0, 0xFE, 0x1F, 0xC0, 0x7E,
  0x01, 0x00, 0x70, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x03, 0x80, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x3F, 0xDF, 0xE0, 0x00,
  0x7F, 0x9F, 0xC0, 0x00, 0xFF, 0x3F, 0xC0, 0x01, 0xFC, 0x7F, 0x80, 0x07,
  0xF8, 0xFF, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x7F,
  0xC3, 0xFC, 0x00, 0xFF, 0x07, 0xF8, 0x01, 0xFE, 0x0F, 0xF8, 0x07, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xFF, 0x0F, 0xF8, 0x03, 0xFE, 0x1F, 0xF0, 0x03, 0xFE, 0x3F, 0xE0, 0x07,
  0xFC, 0xFF, 0x80, 0x0F, 0xF9, 0xFF, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0xFF, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFE, 0xFF,
  0x03, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0xFF, 0x03, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x7F, 0xC0,
  0x7F, 0xDF, 0xF0, 0x1F, 0xF7, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFE, 0x00, 0xFF, 0x7F, 0x80, 0x3F, 0xDF, 0xF0, 0x1F, 0xF7, 0xFC, 0x0F,
  0xFC, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC,
  0xFF, 0x07, 0xFE, 0xFF, 0x03, 0xFE, 0xFF, 0x03, 0xFE, 0xFF, 0x01, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x03, 0xFE, 0xFF, 0x03, 0xFE, 0xFF, 0x07, 0xFE, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFE, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xCF,
  0xFC, 0x7F, 0xE0, 0x7F, 0xCF, 0xF8, 0x0F, 0xF9, 0xFF, 0x00, 0xFF, 0x3F,
  0xC0, 0x1F, 0xEF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xBF, 0xC0, 0x1F, 0xF7, 0xFC, 0x03, 0xFE,
  0xFF, 0x80, 0x7F, 0xDF, 0xF8, 0x0F, 0xF9, 0xFF, 0xEF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0x80, 0x00, 0xFF, 0x00,
  0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x87,
  0xFF, 0xFE, 0x1F, 0xF7, 0xFE, 0xFF, 0x9F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x00,
  0xC0, 0x00, 0xFF, 0x00, 0xFF, 0xDF, 0xE0, 0x3F, 0xFB, 0xFC, 0x07, 0xFE,
  0x7F, 0x81, 0xFF, 0x8F, 0xF0, 0x3F, 0xF1, 0xFE, 0x0F, 0xFC, 0x3F, 0xC1,
  0xFF, 0x07, 0xF8, 0x7F, 0xE0, 0xFF, 0x0F, 0xF8, 0x1F, 0xE3, 0xFF, 0x03,
  0xFC, 0x7F, 0xC0, 0x7F, 0x9F, 0xF0, 0x0F, 0xF3, 0xFE, 0x01, 0xFE, 0xFF,
  0x80, 0x3F, 0xDF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF,
  0xDF, 0xF0, 0x1F, 0xFB, 0xFF, 0x03, 0xFE, 0x3F, 0xE0, 0x7F, 0x87, 0xFE,
  0x0F, 0xF0, 0x7F, 0xC1, 0xFE, 0x0F, 0xFC, 0x3F, 0xC1, 0xFF, 0x87, 0xF8,
  0x1F, 0xF8, 0xFF, 0x03, 0xFF, 0x1F, 0xE0, 0x3F, 0xF3, 0xFC, 0x07, 0xFE,
  0x7F, 0x80, 0xFF, 0xEF, 0xF0, 0x0F, 0xFC, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFF, 0xF0, 0x7E, 0xFF, 0xFF, 0xFE, 0x1F, 0xBF, 0xFF, 0xDF, 0x87,
  0xEF, 0xFF, 0xF7, 0xE3, 0xFB, 0xFF, 0xFD, 0xF8, 0xFC, 0xFF, 0xFF, 0x7F,
  0x3F, 0x3F, 0xFF, 0xCF, 0xCF, 0xCF, 0xFF, 0xF3, 0xF7, 0xE7, 0xFF, 0xFC,
  0xFD, 0xF9, 0xFF, 0xFF, 0x3F, 0x7E, 0x7F, 0xFF, 0xC7, 0xFF, 0x9F, 0xFF,
  0xF1, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0xF1, 0xFF, 0xFF, 0x0F, 0xFC, 0x7F,
  0xFF, 0xC3, 0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0xE1,
  0xFF, 0xFF, 0x07, 0xF8, 0x7F, 0xFF, 0xC1, 0xFE, 0x1F, 0xFF, 0xF0, 0x7F,
  0x07, 0xFF, 0xFC, 0x1F, 0xC1, 0xFF, 0xFF, 0x03, 0xF0, 0x7F, 0xC0, 0xFF,
  0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFD, 0xF1, 0xFF, 0xFF, 0x7E, 0x7F, 0xFF, 0xCF, 0x9F, 0xFF, 0xF3, 0xF7,
  0xFF, 0xFC, 0xFD, 0xFF, 0xFF, 0x1F, 0x7F, 0xFF, 0xC7, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFC, 0x7F, 0xE0, 0xFF, 0xCF, 0xF8, 0x0F, 0xF9, 0xFF, 0x00,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xF7, 0xFC,
  0x03, 0xFE, 0xFF, 0x80, 0xFF, 0x9F, 0xF8, 0x3F, 0xF1, 0xFF, 0xDF, 0xFC,
  0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFD, 0xFE, 0x07,
  0xFE, 0xFF, 0x01, 0xFF, 0x7F, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE,
  0x03, 0xFE, 0xFF, 0x01, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x81,
  0xFF, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x7F,
  0xE0, 0x7F, 0xCF, 0xF8, 0x0F, 0xF9, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0,
  0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xF7, 0xFC, 0x03, 0xFE, 0xFF, 0x80,
  0xFF, 0x9F, 0xF8, 0x1F, 0xF1, 0xFF, 0xDF, 0xFE, 0x3F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x60, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xF9, 0xFE, 0x07, 0xFE, 0xFF, 0x01, 0xFF, 0x7F, 0x80, 0xFF, 0xBF,
  0xC0, 0x7F, 0xDF, 0xE0, 0x1F, 0xEF, 0xF0, 0x1F, 0xF7, 0xF8, 0x0F, 0xFB,
  0xFC, 0x07, 0xFD, 0xFE, 0x03, 0xFE, 0xFF, 0x03, 0xFE, 0x7F, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0xFF, 0x1F, 0xF0, 0x7F, 0x8F,
  0xFC, 0x3F, 0xC3, 0xFE, 0x1F, 0xE1, 0xFF, 0x0F, 0xF0, 0xFF, 0xC7, 0xF8,
  0x3F, 0xE3, 0xFC, 0x1F, 0xF9, 0xFE, 0x07, 0xFC, 0xFF, 0x03, 0xFF, 0x7F,
  0x80, 0xFF, 0xBF, 0xC0, 0x7F, 0xDF, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0xFF, 0xC7,
  0xFE, 0x7F, 0xC1, 0xFF, 0x3F, 0xE0, 0x7F, 0xDF, 0xE0, 0x3F, 0xEF, 0xF0,
  0x1F, 0xF7, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F,
  0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xF8,
  0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xBF, 0xC0, 0x3F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x03,
  0xFC, 0xFF, 0xC7, 0xFE, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x00,
  0x30, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xF9, 0xFE,
  0x01, 0xFE, 0x7F, 0xC0, 0xFF, 0x9F, 0xF0, 0x3F, 0xE7, 0xFF, 0x3F, 0xF8,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0x00, 0x00, 0xFF,
  0xC0, 0x0F, 0xFD, 0xFF, 0x00, 0x3F, 0xF7, 0xFC, 0x00, 0xFF, 0x9F, 0xF8,
  0x03, 0xFE, 0x7F, 0xE0, 0x0F, 0xF8, 0xFF, 0x80, 0x7F, 0xE3, 0xFE, 0x01,
  0xFF, 0x0F, 0xF8, 0x07, 0xFC, 0x1F, 0xF0, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF,
  0xC1, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0,
  0x3F, 0xE0, 0xFF, 0x00, 0xFF, 0x87, 0xFC, 0x01, 0xFE, 0x1F, 0xF0, 0x07,
  0xF8, 0x7F, 0xC0, 0x1F, 0xE1, 0xFE, 0x00, 0x7F, 0xC7, 0xF8, 0x00, 0xFF,
  0x3F, 0xE0, 0x03, 0xFC, 0xFF, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x3F, 0xCF,
  0xF0, 0x00, 0x7F, 0xBF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x83, 0xFC, 0x0F, 0xFF, 0xFC,
  0x1F, 0xE0, 0x7F, 0xFF, 0xE0, 0xFF, 0x03, 0xFD, 0xFF, 0x07, 0xFC, 0x1F,
  0xE7, 0xF8, 0x3F, 0xE1, 0xFF, 0x3F, 0xC1, 0xFF, 0x0F, 0xF9, 0xFE, 0x1F,
  0xF8, 0x7F, 0xCF, 0xF8, 0xFF, 0xC3, 0xFC, 0x7F, 0xC7, 0xFE, 0x1F, 0xE3,
  0xFE, 0x3F, 0xF8, 0xFF, 0x0F, 0xF1, 0xFF, 0xC7, 0xF8, 0x7F, 0x8F, 0xFE,
  0x7F, 0xC3, 0xFC, 0xFF, 0xF3, 0xFE, 0x1F, 0xE7, 0xFF, 0x9F, 0xE0, 0xFF,
  0xBF, 0xFE, 0xFF, 0x07, 0xFD, 0xFF, 0xF7, 0xF8, 0x1F, 0xEF, 0xFF, 0xBF,
  0xC0, 0xFF, 0xFF, 0xFD, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xEF, 0xFF, 0xC0,
  0x3F, 0xFF, 0x7F, 0xFE, 0x01, 0xFF, 0xFB, 0xFF, 0xF0, 0x0F, 0xFF, 0x9F,
  0xFF, 0x80, 0x7F, 0xFC, 0xFF, 0xF8, 0x03, 0xFF, 0xE7, 0xFF, 0xC0, 0x1F,
  0xFF, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0xFF, 0xF0, 0x03, 0xFF, 0x87, 0xFF,
  0x80, 0x1F, 0xFC, 0x3F, 0xFC, 0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x07, 0xFF,
  0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x3F, 0xF0, 0x00, 0xFF, 0xC1, 0xFF, 0x80,
  0x07, 0xFC, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x00, 0x7F, 0xE0,
  0x1F, 0xF3, 0xFF, 0x01, 0xFF, 0x8F, 0xF8, 0x0F, 0xFC, 0x7F, 0xE0, 0x7F,
  0xC1, 0xFF, 0x07, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0x3F, 0xE1, 0xFF, 0x01,
  0xFF, 0x1F, 0xF0, 0x0F, 0xF8, 0xFF, 0x80, 0x3F, 0xE7, 0xF8, 0x01, 0xFF,
  0x7F, 0xC0, 0x07, 0xFB, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xEF, 0xF8, 0x01, 0xFF, 0x7F, 0xC0,
  0x0F, 0xF9, 0xFF, 0x00, 0xFF, 0x8F, 0xF8, 0x07, 0xFC, 0x7F, 0xC0, 0x7F,
  0xE1, 0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE1, 0xFF, 0x81,
  0xFF, 0x0F, 0xF8, 0x0F, 0xFC, 0xFF, 0xC0, 0x7F, 0xE7, 0xFE, 0x01, 0xFF,
  0x80, 0xFF, 0xC0, 0x1F, 0xF7, 0xFC, 0x01, 0xFF, 0x7F, 0xC0, 0x3F, 0xE3,
  0xFE, 0x03, 0xFE, 0x3F, 0xE0, 0x3F, 0xE1, 0xFE, 0x07, 0xFC, 0x1F, 0xF0,
  0x7F, 0xC1, 0xFF, 0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x0F, 0xF8,
  0x07, 0xF8, 0xFF, 0x00, 0x7F, 0x8F, 0xF0, 0x07, 0xF9, 0xFE, 0x00, 0x3F,
  0xDF, 0xE0, 0x03, 0xFD, 0xFE, 0x00, 0x1F, 0xDF, 0xC0, 0x01, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFC,
  0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F,
  0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3,
  0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF,
  0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3,
  0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF,
  0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF,
  0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC,
  0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F,
  0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xFC, 0x03,
  0xFF, 0x80, 0x7D, 0xF0, 0x1F, 0xBF, 0x03, 0xF7, 0xE0, 0x7C, 0x7C, 0x1F,
  0x8F, 0xC3, 0xF1, 0xF8, 0x7E, 0x3F, 0x1F, 0x83, 0xF3, 0xF0, 0x7E, 0x7E,
  0x0F, 0xDF, 0x80, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xC0, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x00, 0x10, 0x00,
  0x0F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0x9F, 0xE3, 0xFE, 0x7F, 0x87, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x7F, 0xFE, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE3,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x7F, 0xC7, 0xF9, 0xFE, 0x1F, 0xEF, 0xF8,
  0x7F, 0xBF, 0xE1, 0xFE, 0xFF, 0x87, 0xFB, 0xFE, 0x3F, 0xEF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE1, 0xFF, 0x7F, 0xC3,
  0xF8, 0xFF, 0x00, 0x80, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xE1, 0x00, 0xFF, 0xBF, 0xC3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF3, 0xFD,
  0xFF, 0x8F, 0xF3, 0xFC, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x0F, 0xFC,
  0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0x9F, 0xF1, 0xFE, 0x7F, 0x87, 0xF9, 0xFE, 0x0F, 0xE7, 0xF8,
  0x3F, 0xBF, 0xE0, 0xFE, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0x9F,
  0xE0, 0xFE, 0x7F, 0x87, 0xF9, 0xFF, 0x1F, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0xFF, 0xC0,
  0x00, 0x10, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x10, 0xFF,
  0x07, 0xFB, 0xFC, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFC, 0x7F, 0xDF, 0xE0, 0xFF, 0x7F, 0x83,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE,
  0x0F, 0xF7, 0xF8, 0x3F, 0xDF, 0xE0, 0xFF, 0x7F, 0xC7, 0xFD, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x1F, 0xFD, 0xFC, 0x3F, 0xF7, 0xF0,
  0x7F, 0x9F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0xFF,
  0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xBF, 0xE1, 0xFE, 0xFF, 0x87, 0xFB, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x80, 0x43, 0xFF, 0x07, 0x87, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x18,
  0x00, 0x00, 0x08, 0x01, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x0F, 0xFF, 0x0F,
  0xFF, 0x1F, 0xFF, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F,
  0xE0, 0x1F, 0xE0, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFE, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F,
  0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F,
  0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F,
  0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0xFB, 0xFC, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xF1, 0xFF, 0x7F, 0xC1, 0xFE, 0xFF,
  0x03, 0xFD, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x03,
  0xFD, 0xFE, 0x07, 0xFB, 0xFC, 0x0F, 0xF7, 0xFC, 0x1F, 0xEF, 0xFC, 0x7F,
  0xDF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC,
  0x3F, 0xF7, 0xF8, 0x1F, 0xCF, 0xF0, 0x04, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x83, 0x01, 0xFF, 0x07, 0x8F, 0xFC, 0x1F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x3F, 0xC3, 0xFD, 0xFF, 0x8F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xEF, 0xF8, 0xFF, 0xBF, 0xC1, 0xFE, 0xFF, 0x07, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0,
  0x7F, 0xC0, 0x3F, 0x3F, 0xFF, 0xFF, 0xFF, 0xFB, 0xFD, 0xFC, 0x7C, 0x00,
  0x00, 0x00, 0x0F, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0xBF, 0xDF, 0xEF,
  0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xFD,
  0xFE, 0xFF, 0x7F, 0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xFC, 0x03, 0xF0, 0x3F,
  0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x83, 0xFC, 0x1F, 0xC0, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07,
  0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF,
  0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0,
  0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F,
  0xE0, 0xFF, 0x07, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0x7F, 0xF3,
  0xFF, 0x9F, 0xF0, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x87, 0xFE, 0xFF, 0x87, 0xFC, 0xFF,
  0x8F, 0xFC, 0xFF, 0x9F, 0xF8, 0xFF, 0x9F, 0xF0, 0xFF, 0xBF, 0xE0, 0xFF,
  0xBF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF,
  0x9F, 0xF0, 0xFF, 0x9F, 0xF0, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF,
  0x8F, 0xFC, 0xFF, 0x87, 0xFC, 0xFF, 0x87, 0xFE, 0xFF, 0x83, 0xFE, 0xFF,
  0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC7, 0xF0,
  0x7F, 0x8F, 0xF7, 0xFE, 0x3F, 0xF3, 0xFD, 0xFF, 0xDF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x3F, 0xF1, 0xFF, 0xFF, 0x87, 0xF8, 0x7F, 0xFF, 0xE1, 0xFE, 0x0F, 0xFF,
  0xF8, 0x7F, 0x83, 0xFF, 0xFE, 0x1F, 0xE0, 0xFF, 0xFF, 0x87, 0xF8, 0x3F,
  0xFF, 0xE1, 0xFE, 0x0F, 0xFF, 0xF8, 0x7F, 0x83, 0xFF, 0xFE, 0x1F, 0xE0,
  0xFF, 0xFF, 0x87, 0xF8, 0x3F, 0xFF, 0xE1, 0xFE, 0x0F, 0xFF, 0xF8, 0x7F,
  0x83, 0xFF, 0xFE, 0x1F, 0xE0, 0xFF, 0xFF, 0x87, 0xF8, 0x3F, 0xFF, 0xE1,
  0xFE, 0x0F, 0xFF, 0xF8, 0x7F, 0x83, 0xFF, 0xFE, 0x1F, 0xE0, 0xFF, 0xFF,
  0x87, 0xF8, 0x3F, 0xFF, 0xE1, 0xFE, 0x0F, 0xFF, 0xF8, 0x7F, 0x83, 0xFF,
  0xFE, 0x1F, 0xE0, 0xFF, 0x00, 0x02, 0x03, 0xFC, 0x7F, 0x0F, 0xF7, 0xFE,
  0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF,
  0xE3, 0xFE, 0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1,
  0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF,
  0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF,
  0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x07,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x3F, 0xE3, 0xFE, 0x7F, 0xC3, 0xFE, 0xFF,
  0x07, 0xFD, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xFE, 0xFF, 0x03,
  0xFD, 0xFE, 0x07, 0xFB, 0xFC, 0x0F, 0xF7, 0xFC, 0x3F, 0xEF, 0xF8, 0xFF,
  0x8F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x03,
  0xFC, 0xFF, 0x0F, 0xF7, 0xFE, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xF1, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x3F,
  0xEF, 0xF0, 0xFF, 0x84, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x1F, 0xE7, 0xF0, 0xFF, 0xDF, 0xC7, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xF1, 0xFF, 0x7F, 0x83, 0xFD, 0xFE, 0x0F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8,
  0x3F, 0xDF, 0xE0, 0xFF, 0x7F, 0x83, 0xFD, 0xFF, 0x1F, 0xF7, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC1,
  0xFE, 0xFF, 0x00, 0x43, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x7F, 0xFD, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x83, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F,
  0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8,
  0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0x3F, 0xEF, 0xF0, 0xFF, 0x7F,
  0x87, 0xFB, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x03,
  0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFD,
  0xFE, 0x3F, 0xEF, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x03, 0xFF,
  0xF0, 0x0F, 0xFE, 0x00, 0x02, 0x00, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF,
  0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x7F, 0xFE, 0xFF, 0xFD,
  0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0xC7, 0xFC, 0x0F, 0xF8, 0x1F,
  0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC,
  0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03,
  0xFF, 0xE3, 0xFF, 0xC7, 0xFF, 0x87, 0xFF, 0x0F, 0xFE, 0x07, 0xF8, 0x01,
  0x80, 0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF,
  0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF,
  0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x07,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0x7F, 0xEF,
  0xF0, 0xFE, 0x3F, 0xC0, 0x40, 0x00, 0x7F, 0x81, 0xFE, 0xFF, 0x07, 0xFD,
  0xFF, 0x0F, 0xFB, 0xFE, 0x1F, 0xF3, 0xFC, 0x3F, 0xC7, 0xF8, 0x7F, 0x8F,
  0xF1, 0xFF, 0x1F, 0xF3, 0xFC, 0x1F, 0xE7, 0xF8, 0x3F, 0xCF, 0xF0, 0x7F,
  0x9F, 0xE0, 0xFF, 0x3F, 0x80, 0xFE, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF,
  0xFC, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF,
  0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0xFF, 0x0F, 0xC1, 0xFF, 0xFE, 0x1F, 0x83, 0xFB, 0xFC, 0x3F, 0x8F, 0xF7,
  0xF8, 0x7F, 0x1F, 0xE7, 0xF1, 0xFE, 0x3F, 0xCF, 0xE3, 0xFC, 0x7F, 0x9F,
  0xC7, 0xF8, 0xFE, 0x3F, 0xCF, 0xF9, 0xFC, 0x7F, 0xBF, 0xF3, 0xF8, 0x7F,
  0x7F, 0xE7, 0xF0, 0xFE, 0xFF, 0xDF, 0xE1, 0xFD, 0xFF, 0xFF, 0xC3, 0xFB,
  0xFF, 0xFF, 0x07, 0xFF, 0xDF, 0xFE, 0x07, 0xFF, 0xBF, 0xFC, 0x0F, 0xFF,
  0x7F, 0xF8, 0x1F, 0xFC, 0xFF, 0xF0, 0x3F, 0xF9, 0xFF, 0xC0, 0x7F, 0xF1,
  0xFF, 0x80, 0x7F, 0xE3, 0xFF, 0x00, 0xFF, 0x87, 0xFE, 0x01, 0xFF, 0x0F,
  0xFC, 0x03, 0xFE, 0x1F, 0xF0, 0x07, 0xFC, 0x1F, 0xE0, 0x0F, 0xF8, 0x3F,
  0xC0, 0x0F, 0xE0, 0x7F, 0x80, 0x1F, 0xC0, 0xFF, 0x00, 0xFF, 0x87, 0xFC,
  0xFF, 0x0F, 0xF9, 0xFE, 0x1F, 0xE3, 0xFE, 0x7F, 0xC3, 0xFC, 0xFF, 0x07,
  0xF9, 0xFE, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF,
  0x80, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x03, 0xFE, 0xFF, 0x07, 0xF9, 0xFE,
  0x0F, 0xF3, 0xFE, 0x3F, 0xE3, 0xFC, 0x7F, 0x87, 0xF9, 0xFF, 0x0F, 0xFB,
  0xFC, 0x0F, 0xF0, 0xFF, 0x81, 0xFF, 0x7F, 0x81, 0xFE, 0x7F, 0xC3, 0xFE,
  0x7F, 0xC3, 0xFE, 0x7F, 0xC3, 0xFE, 0x3F, 0xC3, 0xFC, 0x3F, 0xC7, 0xFC,
  0x3F, 0xE7, 0xFC, 0x1F, 0xE7, 0xF8, 0x1F, 0xE7, 0xF8, 0x1F, 0xEF, 0xF8,
  0x0F, 0xEF, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0,
  0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x01, 0xFF,
  0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0xFF,
  0x80, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x20, 0x07, 0x80, 0x7C, 0x07, 0xE0,
  0x7F, 0x83, 0xF8, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F,
  0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF0,
  0x3F, 0x81, 0xFC, 0x1F, 0xE3, 0xFE, 0x1F, 0xE0, 0xFE, 0x07, 0xF0, 0x3F,
  0xC1, 0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xE0, 0xFF,
  0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0x03, 0xFC, 0x0F, 0xC0, 0x3E, 0x00,
  0xF0, 0x01, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x40, 0x07, 0x00, 0xFC, 0x0F,
  0xC0, 0xFE, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x3F, 0x83, 0xF8, 0x3F, 0x83,
  0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83,
  0xF8, 0x3F, 0xC1, 0xFC, 0x1F, 0xF0, 0xFF, 0x07, 0xF0, 0x7F, 0x0F, 0xF1,
  0xFF, 0x1F, 0xC3, 0xFC, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83,
  0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x7F, 0x07,
  0xF0, 0x7F, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0, 0x70, 0x04, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0xF0, 0x3F, 0x1F, 0xF8, 0x3F, 0x3F, 0xF8, 0x3F, 0x7F, 0xFC,
  0x7F, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7E, 0x3F, 0xFE, 0xFC, 0x1F,
  0xFC, 0xFC, 0x0F, 0xF8, 0xFC, 0x07, 0xF0, 0x00, 0x03, 0xE0,
};

const GFXglyph RobotoCondensed_Black52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 9, 38, 14, 3, -37 },
  { 44, 14, 14, 17, 1, -39 },
  { 69, 24, 37, 27, 1, -37 },
  { 180, 23, 49, 27, 2, -43 },
  { 321, 29, 39, 33, 2, -38 },
  { 463, 29, 39, 31, 1, -38 },
  { 605, 6, 15, 8, 1, -39 },
  { 617, 12, 52, 17, 3, -41 },
  { 695, 14, 52, 17, 1, -41 },
  { 786, 23, 23, 24, 1, -37 },
  { 853, 22, 27, 24, 1, -31 },
  { 928, 10, 16, 14, 1, -6 },
  { 948, 13, 7, 22, 4, -20 },
  { 960, 9, 9, 16, 3, -8 },
  { 971, 16, 40, 16, 0, -37 },
  { 1051, 22, 39, 27, 2, -38 },
  { 1159, 15, 37, 27, 4, -37 },
  { 1229, 22, 38, 27, 2, -38 },
  { 1334, 24, 39, 27, 1, -38 },
  { 1451, 23, 37, 27, 2, -37 },
  { 1558, 22, 38, 27, 2, -37 },
  { 1663, 23, 38, 27, 2, -37 },
  { 1773, 22, 37, 27, 2, -37 },
  { 1875, 22, 39, 27, 2, -38 },
  { 1983, 22, 38, 27, 2, -38 },
  { 2088, 10, 29, 15, 3, -28 },
  { 2125, 10, 38, 15, 2, -28 },
  { 2173, 19, 25, 23, 1, -28 },
  { 2233, 20, 18, 27, 3, -25 },
  { 2278, 19, 25, 23, 3, -28 },
  { 2338, 21, 39, 24, 1, -38 },
  { 2441, 36, 48, 40, 2, -36 },
  { 2657, 31, 37, 31, 0, -37 },
  { 2801, 24, 37, 30, 3, -37 },
  { 2912, 26, 39, 30, 2, -38 },
  { 3039, 24, 37, 29, 3, -37 },
  { 3150, 21, 37, 25, 3, -37 },
  { 3248, 21, 37, 25, 3, -37 },
  { 3346, 27, 39, 31, 2, -38 },
  { 3478, 26, 37, 32, 3, -37 },
  { 3599, 9, 37, 15, 3, -37 },
  { 3641, 22, 38, 26, 1, -37 },
  { 3746, 27, 37, 29, 3, -37 },
  { 3871, 21, 37, 25, 3, -37 },
  { 3969, 34, 37, 39, 3, -37 },
  { 4127, 26, 37, 32, 3, -37 },
  { 4248, 27, 39, 31, 2, -38 },
  { 4380, 25, 37, 30, 3, -37 },
  { 4496, 27, 45, 31, 2, -38 },
  { 4648, 25, 37, 29, 3, -37 },
  { 4764, 25, 39, 29, 2, -38 },
  { 4886, 27, 37, 29, 1, -37 },
  { 5011, 26, 38, 30, 2, -37 },
  { 5135, 30, 37, 30, 0, -37 },
  { 5274, 37, 37, 39, 1, -37 },
  { 5446, 29, 37, 29, 0, -37 },
  { 5581, 28, 37, 29, 0, -37 },
  { 5711, 24, 37, 28, 2, -37 },
  { 5822, 10, 52, 14, 3, -43 },
  { 5887, 21, 40, 20, 0, -37 },
  { 5992, 10, 52, 14, 1, -43 },
  { 6057, 19, 18, 21, 1, -37 },
  { 6100, 19, 6, 21, 1, 0 },
  { 6115, 14, 8, 18, 1, -39 },
  { 6129, 22, 29, 24, 1, -28 },
  { 6209, 22, 40, 26, 2, -39 },
  { 6319, 22, 29, 24, 1, -28 },
  { 6399, 22, 40, 26, 1, -39 },
  { 6509, 22, 29, 25, 2, -28 },
  { 6589, 16, 40, 17, 1, -40 },
  { 6669, 23, 39, 26, 1, -28 },
  { 6782, 22, 39, 26, 2, -39 },
  { 6890, 9, 38, 14, 2, -38 },
  { 6933, 13, 49, 13, -2, -38 },
  { 7013, 24, 39, 26, 2, -39 },
  { 7130, 8, 39, 14, 3, -39 },
  { 7169, 34, 28, 38, 2, -28 },
  { 7288, 22, 28, 26, 2, -28 },
  { 7365, 23, 29, 26, 1, -28 },
  { 7449, 22, 39, 26, 2, -28 },
  { 7557, 22, 39, 26, 1, -28 },
  { 7665, 15, 28, 18, 2, -28 },
  { 7718, 21, 29, 24, 1, -28 },
  { 7795, 15, 35, 16, 1, -34 },
  { 7861, 22, 28, 26, 2, -27 },
  { 7938, 23, 27, 24, 0, -27 },
  { 8016, 31, 27, 32, 1, -27 },
  { 8121, 23, 27, 24, 1, -27 },
  { 8199, 24, 38, 24, 0, -27 },
  { 8313, 20, 27, 24, 2, -27 },
  { 8381, 13, 50, 15, 1, -41 },
  { 8463, 5, 44, 13, 4, -37 },
  { 8491, 12, 50, 15, 2, -41 },
  { 8566, 24, 12, 28, 2, -21 },
};

const GFXfont RobotoCondensed_Black52pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Black52pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Black52pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _ROBOTOCONDENSED_BLACK52PT7B_H_
