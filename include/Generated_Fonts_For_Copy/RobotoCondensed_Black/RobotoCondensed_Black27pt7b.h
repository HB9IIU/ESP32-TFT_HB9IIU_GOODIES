#ifndef _ROBOTOCONDENSED_BLACK27PT7B_H_
#define _ROBOTOCONDENSED_BLACK27PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Black.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Black27pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0x80, 0x0E, 0xFF,
  0xDC, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0x0C, 0xC0, 0xDC, 0x1D,
  0xC1, 0xDC, 0x1D, 0xC1, 0xD8, 0xFF, 0xFF, 0xFF, 0x1B, 0x83, 0xB8, 0x3B,
  0x8F, 0xFE, 0xFF, 0xE3, 0x30, 0x33, 0x03, 0x70, 0x77, 0x07, 0x70, 0x77,
  0x00, 0x06, 0x00, 0x60, 0x06, 0x00, 0xF8, 0x3F, 0xC7, 0xFE, 0x7D, 0xE7,
  0x9F, 0x79, 0xF7, 0x80, 0x7C, 0x03, 0xF0, 0x1F, 0xC0, 0xFE, 0x03, 0xE0,
  0x1E, 0xF1, 0xFF, 0x9F, 0xF9, 0xE7, 0xFE, 0x3F, 0xC1, 0xF8, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x3C, 0x00, 0xFC, 0x03, 0xF8, 0xC7, 0x39, 0x8E, 0x77,
  0x1C, 0xEC, 0x3F, 0xB8, 0x3F, 0x60, 0x3D, 0xC0, 0x07, 0x00, 0x0D, 0xE0,
  0x3F, 0xE0, 0x6E, 0xE1, 0xDD, 0xC3, 0x33, 0x8E, 0x77, 0x18, 0xEE, 0x01,
  0xF8, 0x01, 0xE0, 0x0F, 0x00, 0xFE, 0x03, 0xFC, 0x1F, 0xF0, 0x79, 0xC1,
  0xE7, 0x07, 0xBC, 0x0F, 0xE0, 0x3F, 0x00, 0xFC, 0xE7, 0xF3, 0xBF, 0xFE,
  0xF7, 0xFB, 0xCF, 0xEF, 0x3F, 0x3E, 0xFC, 0xFF, 0xF9, 0xFF, 0xE1, 0xF7,
  0xC0, 0xFF, 0xFF, 0xF6, 0x08, 0x73, 0xCE, 0x71, 0xCF, 0x3C, 0xE3, 0x8E,
  0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0x71, 0xC7, 0x0E, 0x3C, 0x70,
  0x80, 0x81, 0xC3, 0x83, 0x87, 0x87, 0x0E, 0x1E, 0x3C, 0x38, 0x70, 0xE1,
  0xE3, 0xC7, 0x8E, 0x1C, 0x38, 0xF1, 0xE3, 0x87, 0x1E, 0x38, 0xE1, 0xC2,
  0x00, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x8E, 0x27, 0xFF, 0x7F, 0xF8, 0x3E,
  0x01, 0xF0, 0x1D, 0x81, 0xCE, 0x0E, 0x38, 0x21, 0x80, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x00, 0x7B, 0xDE, 0xF7, 0x3B, 0xDC, 0x40, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0x07, 0x07, 0x0E, 0x0E, 0x0E, 0x0E, 0x1C, 0x1C,
  0x1C, 0x1C, 0x38, 0x38, 0x38, 0x38, 0x70, 0x70, 0x70, 0x70, 0xE0, 0xE0,
  0xE0, 0x0F, 0x03, 0xFC, 0x7F, 0xC7, 0xFE, 0x79, 0xEF, 0x9E, 0xF1, 0xFF,
  0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x9E, 0x79, 0xE7,
  0xFE, 0x7F, 0xC3, 0xFC, 0x1F, 0x00, 0x03, 0x0F, 0x7F, 0xFF, 0xFF, 0xCF,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x1F, 0x03, 0xFC, 0x7F, 0xEF, 0xFE, 0xF1, 0xEF, 0x1E, 0x01, 0xE0,
  0x1E, 0x03, 0xE0, 0x7C, 0x07, 0x80, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x07,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x07, 0xFC, 0x7F, 0xEF, 0xBE,
  0xF1, 0xE0, 0x1E, 0x01, 0xE0, 0x3E, 0x0F, 0xC0, 0xF8, 0x0F, 0xE0, 0x1E,
  0x01, 0xFF, 0x1F, 0xF1, 0xFF, 0xBE, 0x7F, 0xE7, 0xFC, 0x1F, 0x00, 0x03,
  0xC0, 0x7C, 0x07, 0xC0, 0xFC, 0x0F, 0xC1, 0xFC, 0x1F, 0xC3, 0xBC, 0x3B,
  0xC7, 0xBC, 0x73, 0xCF, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7, 0x80, 0x78, 0x07,
  0x80, 0x77, 0x8F, 0xFC, 0xFF, 0xE7, 0x3E, 0x01, 0xE0, 0x1F, 0x01, 0xFF,
  0x1F, 0xF9, 0xEF, 0xFE, 0x7F, 0xE3, 0xFC, 0x1F, 0x00, 0x03, 0x80, 0xF8,
  0x1F, 0x83, 0xF8, 0x7C, 0x07, 0x80, 0x7F, 0x8F, 0xFE, 0xFF, 0xEF, 0xFF,
  0xF1, 0xFF, 0x0F, 0xF0, 0xFF, 0x8F, 0xF9, 0xF7, 0xFE, 0x7F, 0xE3, 0xFC,
  0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1E, 0x01, 0xE0, 0x3E, 0x03,
  0xC0, 0x3C, 0x07, 0xC0, 0x78, 0x0F, 0x80, 0xF0, 0x0F, 0x01, 0xF0, 0x1E,
  0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x7C, 0x00, 0x1F, 0x03, 0xFC, 0x7F, 0xE7,
  0xFE, 0x79, 0xEF, 0x9E, 0x79, 0xE7, 0xFE, 0x3F, 0xC3, 0xFC, 0x7F, 0xE7,
  0x9E, 0xF9, 0xFF, 0x9F, 0xF9, 0xFF, 0xFE, 0x7F, 0xE3, 0xFC, 0x1F, 0x80,
  0x0F, 0x03, 0xF8, 0x7F, 0xC7, 0xFE, 0xF9, 0xEF, 0x9E, 0xF1, 0xFF, 0x9F,
  0xF9, 0xFF, 0x9F, 0x7F, 0xF3, 0xFE, 0x1F, 0xE0, 0x1E, 0x03, 0xC1, 0xFC,
  0x1F, 0x81, 0xF0, 0x1C, 0x00, 0xF7, 0xBC, 0xE0, 0x00, 0x00, 0x00, 0x01,
  0xEF, 0xF9, 0xC0, 0x7F, 0xDE, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xBD,
  0xEF, 0x7B, 0x9D, 0xC6, 0x00, 0x00, 0x40, 0xF0, 0xFC, 0xFF, 0xFF, 0xBF,
  0x0F, 0x03, 0xF0, 0xFF, 0x8F, 0xF0, 0xFC, 0x0F, 0x00, 0x40, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x3C,
  0x0F, 0xC3, 0xFC, 0x3F, 0xC3, 0xF0, 0x3C, 0x3F, 0x3F, 0xFF, 0xCF, 0xC3,
  0xC0, 0xC0, 0x00, 0x0F, 0x87, 0xF9, 0xFF, 0xBF, 0xF7, 0x9F, 0xF3, 0xC0,
  0x78, 0x1F, 0x07, 0xC0, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x00,
  0x78, 0x1F, 0x01, 0xE0, 0x38, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xC0, 0x3C,
  0x7C, 0x0E, 0x01, 0xC3, 0x80, 0x38, 0x70, 0x03, 0x9C, 0x3C, 0x73, 0x8F,
  0xE6, 0xE3, 0xFC, 0xFC, 0x73, 0x9F, 0x9C, 0x73, 0xF3, 0x8C, 0x7E, 0x71,
  0x8F, 0xCE, 0x71, 0xB9, 0xCE, 0x37, 0x39, 0xCE, 0xE7, 0xFD, 0x9C, 0xFF,
  0xF3, 0x8F, 0x3C, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0xFE,
  0x00, 0x7F, 0xC0, 0x03, 0xF0, 0x00, 0x03, 0xC0, 0x03, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x78, 0x1E, 0x78,
  0x1E, 0x78, 0x1E, 0x7C, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFE,
  0x7C, 0x1E, 0x7C, 0x1E, 0x78, 0x1F, 0xF8, 0x1F, 0xFF, 0xC7, 0xFF, 0x3F,
  0xFD, 0xFF, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0xFF, 0xF7, 0xFF,
  0x3F, 0xFD, 0xF1, 0xFF, 0x87, 0xFC, 0x3F, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xBF, 0xF0, 0x0F, 0xC0, 0x7F, 0xC3, 0xFF, 0x1F, 0xFE, 0x78, 0x7B,
  0xE1, 0xFF, 0x87, 0xFE, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x7F, 0xE1, 0xF7, 0x87, 0x9F, 0xFE, 0x3F, 0xF0, 0xFF, 0xC0, 0xFC,
  0x00, 0xFF, 0x87, 0xFE, 0x3F, 0xF9, 0xFF, 0xEF, 0x8F, 0xFC, 0x7F, 0xE3,
  0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x8F, 0xFC, 0x7F,
  0xE3, 0xFF, 0xFE, 0xFF, 0xE7, 0xFE, 0x3F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xFF, 0xEF, 0xFE, 0xFF,
  0xEF, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xF0, 0x3E, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x7F, 0xC3, 0xFF, 0x9F, 0xFE, 0x78,
  0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x00, 0xF8, 0x03, 0xE7, 0xFF, 0x9F, 0xFE,
  0x7F, 0xF8, 0x7F, 0xE1, 0xF7, 0x87, 0xDF, 0xFF, 0x3F, 0xFC, 0xFF, 0xE0,
  0xFE, 0x00, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0,
  0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xF8,
  0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1F, 0xE7, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xF0, 0x7C,
  0x00, 0xF8, 0x7F, 0xE3, 0xEF, 0x8F, 0xBE, 0x7C, 0xF9, 0xF3, 0xEF, 0x8F,
  0xBC, 0x3F, 0xF0, 0xFF, 0x83, 0xFF, 0x0F, 0xFC, 0x3F, 0xF8, 0xFF, 0xE3,
  0xE7, 0xCF, 0x9F, 0x3E, 0x7E, 0xF8, 0xFB, 0xE3, 0xFF, 0x87, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xFC, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x7F, 0xFE,
  0x1F, 0xFF, 0x87, 0xFF, 0xF1, 0xFF, 0xDC, 0x7F, 0xFF, 0x3F, 0xFF, 0xCE,
  0xFF, 0xFB, 0xBF, 0xEE, 0xEF, 0xFB, 0xF3, 0xFE, 0xFC, 0xFF, 0x9F, 0x3F,
  0xE7, 0xCF, 0xF9, 0xE3, 0xFE, 0x78, 0xFF, 0x8E, 0x3C, 0xF8, 0x3F, 0xE0,
  0xFF, 0xC3, 0xFF, 0x0F, 0xFE, 0x3F, 0xF8, 0xFF, 0xE3, 0xFF, 0xCF, 0xFF,
  0x3F, 0xEE, 0xFF, 0xBB, 0xFE, 0x6F, 0xF9, 0xFF, 0xE7, 0xFF, 0x8F, 0xFE,
  0x3F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xC0, 0x0F, 0xC0, 0x7F, 0xC3, 0xFF,
  0x9F, 0xFE, 0x78, 0x7F, 0xE1, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0,
  0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE1, 0xF7, 0x87, 0xDF, 0xFE, 0x3F,
  0xF8, 0x7F, 0xC0, 0xFC, 0x00, 0xFF, 0xC7, 0xFF, 0x3F, 0xFD, 0xFF, 0xFF,
  0x8F, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF,
  0xCF, 0xFC, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x00,
  0x0F, 0xC0, 0x7F, 0xC3, 0xFF, 0x9F, 0xFE, 0x78, 0x7F, 0xE1, 0xFF, 0x83,
  0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE1,
  0xF7, 0x87, 0xDF, 0xFE, 0x3F, 0xF8, 0x7F, 0xC0, 0xFF, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xE0, 0x01, 0x00, 0xFF, 0xC3, 0xFF, 0xCF, 0xFF, 0x3F, 0xFE,
  0xF8, 0xFB, 0xE1, 0xEF, 0x87, 0xBE, 0x3E, 0xFF, 0xFB, 0xFF, 0xCF, 0xFE,
  0x3F, 0xF8, 0xFB, 0xE3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF8, 0xFB, 0xE3,
  0xEF, 0x87, 0xC0, 0x0F, 0x81, 0xFF, 0x1F, 0xFC, 0xFF, 0xEF, 0x8F, 0xFC,
  0x7D, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0xFF, 0x01, 0xFC, 0x03, 0xE0, 0x0F,
  0xF8, 0x7F, 0xE3, 0xFF, 0xFF, 0x7F, 0xF1, 0xFF, 0x03, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF,
  0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0,
  0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xEF, 0xFF, 0x7F, 0xF1, 0xFF, 0x83, 0xF0,
  0xF8, 0x3F, 0x78, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3C, 0x3C, 0x7C,
  0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x78, 0x1E, 0x78, 0x1E, 0xF8, 0x1F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xC0, 0x78, 0xF1, 0xF7, 0x8F, 0x1E, 0x78, 0xF1, 0xE7, 0x9F, 0x9E,
  0x7D, 0xFB, 0xE7, 0xDF, 0xBE, 0x3D, 0xFB, 0xE3, 0xDF, 0xBC, 0x3D, 0xFB,
  0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0x81, 0xF9,
  0xF8, 0x1F, 0x9F, 0x81, 0xF9, 0xF8, 0x1F, 0x9F, 0x81, 0xF9, 0xF8, 0x0F,
  0x0F, 0x00, 0x7C, 0x3E, 0xF8, 0xF9, 0xF1, 0xF1, 0xF3, 0xC3, 0xEF, 0x83,
  0xDE, 0x07, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x7F,
  0x81, 0xFF, 0x03, 0xDE, 0x0F, 0xBE, 0x1F, 0x3C, 0x7C, 0x7C, 0xF8, 0xFB,
  0xF0, 0xF8, 0xF8, 0x3E, 0xF0, 0xF9, 0xF1, 0xF1, 0xE3, 0xC3, 0xC7, 0x87,
  0xDF, 0x07, 0xBC, 0x0F, 0x78, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1E, 0x01, 0xF0,
  0x0F, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1E,
  0x01, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE,
  0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE,
  0xFB, 0xEF, 0xBE, 0xFF, 0xFF, 0xC0, 0xF8, 0x1F, 0x01, 0xE0, 0x3E, 0x07,
  0xC0, 0x78, 0x0F, 0x01, 0xF0, 0x1E, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0xF0,
  0x1F, 0x01, 0xE0, 0x3C, 0x07, 0xC0, 0xF8, 0x0F, 0x01, 0xF0, 0x3E, 0xFF,
  0xFF, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C,
  0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0xFF, 0xFF, 0xC0, 0x1C, 0x1F, 0x0F, 0x87,
  0xC7, 0x73, 0xB9, 0xDD, 0xCF, 0xE3, 0xF1, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC,
  0xF8, 0xF0, 0xF0, 0xF0, 0x1F, 0x0F, 0xF3, 0xFF, 0x7D, 0xEF, 0x3C, 0x07,
  0xCF, 0xFB, 0xFF, 0xFB, 0xFE, 0x7F, 0xCF, 0xF9, 0xFF, 0xFF, 0xFF, 0xCE,
  0x78, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xFF, 0x8F,
  0xFC, 0xFF, 0xEF, 0xFE, 0xF9, 0xEF, 0x9F, 0xF9, 0xFF, 0x9F, 0xF9, 0xFF,
  0x9F, 0xF9, 0xFF, 0xFE, 0xFF, 0xEF, 0xFC, 0xF7, 0x80, 0x1F, 0x0F, 0xF1,
  0xFF, 0x7D, 0xEF, 0x1F, 0xE3, 0xFC, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC7,
  0xFD, 0xF7, 0xFC, 0xFF, 0x07, 0xC0, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xCF, 0x7B, 0xFF, 0xFF, 0xFF, 0x7F, 0xC7, 0xF8, 0xFF, 0x1F,
  0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFF, 0x7F, 0xFF, 0xBF, 0xF3, 0xDE, 0x1F,
  0x07, 0xF9, 0xFF, 0x7F, 0xFF, 0x1F, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x03, 0xE0, 0x7E, 0xE7, 0xFE, 0x7F, 0xC7, 0xE0, 0x0F, 0x8F, 0xCF, 0xE7,
  0xF3, 0xC1, 0xE3, 0xFD, 0xFE, 0xFF, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC0, 0x3E, 0xF7, 0xFF, 0x7F,
  0xFF, 0xFF, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1,
  0xFF, 0xFF, 0x7F, 0xF7, 0xFF, 0x3D, 0xF0, 0x1E, 0x33, 0xE7, 0xFE, 0x7F,
  0xC1, 0xF0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3D, 0xE7,
  0xFE, 0xFF, 0xFF, 0x7F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F,
  0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1E, 0x77, 0xFE, 0xE0, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1C, 0x7C, 0xF8,
  0xE0, 0x00, 0x0F, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E,
  0x7C, 0xF9, 0xF3, 0xE7, 0xFF, 0xFE, 0xFD, 0xE0, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF9, 0xFF, 0xBE, 0xFB, 0xEF, 0xFC, 0xFF,
  0x8F, 0xF8, 0xFF, 0x0F, 0xF8, 0xFF, 0x8F, 0xFC, 0xFB, 0xCF, 0xBE, 0xFB,
  0xEF, 0x9F, 0xF9, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF3, 0x8F, 0x3D, 0xF7, 0xEF, 0xFF,
  0xFB, 0xFF, 0xFE, 0xF9, 0xE7, 0xFE, 0x79, 0xFF, 0x9E, 0x7F, 0xE7, 0x9F,
  0xF9, 0xE7, 0xFE, 0x79, 0xFF, 0x9E, 0x7F, 0xE7, 0x9F, 0xF9, 0xE7, 0xFE,
  0x79, 0xFF, 0x9E, 0x7C, 0xF3, 0x9F, 0xFB, 0xFF, 0xFD, 0xFF, 0x1F, 0xE3,
  0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC,
  0x78, 0x1F, 0x03, 0xFC, 0x7F, 0xEF, 0xBE, 0xF1, 0xEF, 0x1E, 0xF1, 0xFF,
  0x1F, 0xF1, 0xFF, 0x1E, 0xF1, 0xEF, 0xBE, 0x7F, 0xE3, 0xFC, 0x1F, 0x00,
  0xF7, 0x8F, 0xFC, 0xFF, 0xEF, 0xFE, 0xF9, 0xEF, 0x9F, 0xF9, 0xFF, 0x9F,
  0xF9, 0xFF, 0x9F, 0xF9, 0xEF, 0xFE, 0xFF, 0xEF, 0xFC, 0xFF, 0x8F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x3D, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF,
  0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0xFD, 0xFF, 0xFE,
  0xFF, 0xCF, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0xF7, 0xF7,
  0xFF, 0xFF, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0x3F, 0x1F, 0xEF, 0xFF, 0xCF, 0xF3, 0xFE, 0x0F, 0xE1, 0xFE, 0x1F,
  0xC1, 0xFF, 0x3F, 0xCF, 0xFF, 0xDF, 0xE3, 0xF0, 0x3C, 0x3C, 0x3C, 0xFF,
  0xFF, 0xFF, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3E, 0x3F,
  0x3F, 0x1F, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F,
  0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0xFD, 0xF7, 0xFE, 0xFF, 0xCF, 0x78, 0xF8,
  0xF7, 0x9F, 0x79, 0xF7, 0x9E, 0x7D, 0xE3, 0xDE, 0x3D, 0xE3, 0xFC, 0x3F,
  0xC1, 0xFC, 0x1F, 0xC1, 0xF8, 0x1F, 0x80, 0xF8, 0x0F, 0x80, 0xF9, 0xCF,
  0x79, 0xCF, 0x7B, 0xCF, 0x7B, 0xEF, 0x7B, 0xEF, 0x7B, 0xEE, 0x3B, 0xEE,
  0x3F, 0x7E, 0x3F, 0x7E, 0x3F, 0x7E, 0x3F, 0x7E, 0x3E, 0x7C, 0x1E, 0x3C,
  0x1E, 0x3C, 0x1E, 0x3C, 0x79, 0xF7, 0x9E, 0x7D, 0xE3, 0xFE, 0x3F, 0xC1,
  0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0xC1, 0xFC, 0x3F, 0xC3, 0xDE, 0x7D, 0xE7,
  0x9F, 0xF8, 0xF0, 0xF8, 0xF7, 0x9F, 0x79, 0xF7, 0x9E, 0x7D, 0xE3, 0xFE,
  0x3F, 0xE3, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0x81, 0xF8, 0x0F, 0x80, 0xF0,
  0x0F, 0x00, 0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFC, 0x1F, 0x07, 0x83, 0xC1, 0xF0, 0x78, 0x3E, 0x0F, 0x07, 0xC1, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFC, 0x08, 0x73, 0xCE, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0xF3, 0x8F, 0x1E, 0x79, 0xE7, 0x9E, 0x79, 0xE3, 0x8F, 0x1C, 0x20,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xC3, 0x8F, 0x1C,
  0x71, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x3C, 0x73, 0xDE, 0x79, 0xE7, 0x9E,
  0x79, 0xE7, 0x3C, 0xE3, 0x00, 0x3C, 0x77, 0xE7, 0x7F, 0xFF, 0xFF, 0xE3,
  0xE0, 0x1C,
};

const GFXglyph RobotoCondensed_Black27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 5, 19, 7, 1, -19 },
  { 13, 8, 7, 9, 0, -20 },
  { 20, 12, 19, 14, 1, -19 },
  { 49, 12, 25, 14, 1, -22 },
  { 87, 15, 19, 17, 1, -19 },
  { 123, 14, 19, 16, 1, -19 },
  { 157, 3, 8, 4, 1, -20 },
  { 160, 6, 27, 9, 2, -21 },
  { 181, 7, 27, 9, 1, -21 },
  { 205, 13, 12, 13, 0, -19 },
  { 225, 11, 14, 13, 1, -16 },
  { 245, 5, 9, 7, 1, -3 },
  { 251, 7, 3, 11, 2, -10 },
  { 254, 4, 4, 8, 2, -4 },
  { 256, 8, 21, 8, 0, -19 },
  { 277, 12, 19, 14, 1, -19 },
  { 306, 8, 19, 14, 2, -19 },
  { 325, 12, 19, 14, 1, -19 },
  { 354, 12, 19, 14, 1, -19 },
  { 383, 12, 19, 14, 1, -19 },
  { 412, 12, 19, 14, 1, -19 },
  { 441, 12, 19, 14, 1, -19 },
  { 470, 12, 19, 14, 1, -19 },
  { 499, 12, 19, 14, 1, -19 },
  { 528, 12, 19, 14, 1, -19 },
  { 557, 5, 15, 8, 2, -15 },
  { 567, 5, 21, 8, 1, -15 },
  { 581, 10, 13, 12, 1, -15 },
  { 598, 10, 9, 14, 2, -13 },
  { 610, 10, 13, 12, 1, -15 },
  { 627, 11, 19, 12, 0, -19 },
  { 654, 19, 25, 21, 1, -19 },
  { 714, 16, 19, 16, 0, -19 },
  { 752, 13, 19, 15, 1, -19 },
  { 783, 14, 19, 15, 1, -19 },
  { 817, 13, 19, 15, 1, -19 },
  { 848, 12, 19, 13, 1, -19 },
  { 877, 11, 19, 13, 1, -19 },
  { 904, 14, 19, 16, 1, -19 },
  { 938, 14, 19, 16, 1, -19 },
  { 972, 4, 19, 8, 2, -19 },
  { 982, 11, 19, 13, 1, -19 },
  { 1009, 14, 19, 15, 1, -19 },
  { 1043, 11, 19, 13, 1, -19 },
  { 1070, 18, 19, 20, 1, -19 },
  { 1113, 14, 19, 16, 1, -19 },
  { 1147, 14, 19, 16, 1, -19 },
  { 1181, 13, 19, 16, 1, -19 },
  { 1212, 14, 23, 16, 1, -19 },
  { 1253, 14, 19, 15, 1, -19 },
  { 1287, 13, 19, 15, 1, -19 },
  { 1318, 13, 19, 15, 1, -19 },
  { 1349, 13, 19, 16, 1, -19 },
  { 1380, 16, 19, 16, 0, -19 },
  { 1418, 20, 19, 20, 0, -19 },
  { 1466, 15, 19, 15, 0, -19 },
  { 1502, 15, 19, 15, 0, -19 },
  { 1538, 13, 19, 14, 1, -19 },
  { 1569, 6, 27, 7, 1, -22 },
  { 1590, 11, 21, 10, 0, -19 },
  { 1619, 6, 27, 7, 0, -22 },
  { 1640, 9, 10, 11, 1, -19 },
  { 1652, 10, 3, 11, 0, 0 },
  { 1656, 7, 4, 9, 1, -20 },
  { 1660, 11, 15, 13, 1, -15 },
  { 1681, 12, 21, 13, 1, -21 },
  { 1713, 11, 15, 12, 1, -15 },
  { 1734, 11, 21, 13, 1, -21 },
  { 1763, 11, 15, 13, 1, -15 },
  { 1784, 9, 21, 9, 0, -21 },
  { 1808, 12, 20, 14, 1, -15 },
  { 1838, 11, 21, 13, 1, -21 },
  { 1867, 5, 21, 7, 1, -21 },
  { 1881, 7, 26, 7, -1, -21 },
  { 1904, 12, 21, 13, 1, -21 },
  { 1936, 5, 21, 7, 1, -21 },
  { 1950, 18, 15, 20, 1, -15 },
  { 1984, 11, 15, 13, 1, -15 },
  { 2005, 12, 15, 13, 1, -15 },
  { 2028, 12, 20, 13, 1, -15 },
  { 2058, 11, 20, 13, 1, -15 },
  { 2086, 8, 15, 9, 1, -15 },
  { 2101, 10, 15, 12, 1, -15 },
  { 2120, 8, 18, 8, 0, -18 },
  { 2138, 11, 15, 13, 1, -15 },
  { 2159, 12, 15, 12, 0, -15 },
  { 2182, 16, 15, 17, 0, -15 },
  { 2212, 12, 15, 12, 0, -15 },
  { 2235, 12, 20, 12, 0, -15 },
  { 2265, 10, 15, 12, 1, -15 },
  { 2284, 6, 26, 8, 1, -21 },
  { 2304, 3, 23, 7, 2, -19 },
  { 2313, 6, 26, 8, 1, -21 },
  { 2333, 12, 6, 15, 1, -11 },
};

const GFXfont RobotoCondensed_Black27pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Black27pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Black27pt7bGlyphs,
  0x20, 0x7E, 32
};

#endif // _ROBOTOCONDENSED_BLACK27PT7B_H_
