#ifndef _ROBOTOCONDENSED_BLACK19PT7B_H_
#define _ROBOTOCONDENSED_BLACK19PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Black.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Black19pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xC0, 0xDF, 0x7D, 0xB6, 0xD8, 0x1B,
  0x0D, 0x86, 0xC3, 0x47, 0xFB, 0xFC, 0x58, 0x6C, 0xFF, 0xFF, 0xCD, 0x06,
  0x82, 0xC1, 0x60, 0x08, 0x08, 0x3C, 0x7E, 0xFF, 0xE7, 0xE0, 0xF0, 0x7C,
  0x3E, 0x0F, 0xE7, 0xE7, 0xFF, 0x7E, 0x3C, 0x18, 0x18, 0x70, 0x3E, 0x0D,
  0x93, 0x6C, 0xFA, 0x1D, 0x80, 0x40, 0x30, 0x1B, 0x87, 0xF3, 0x6C, 0xDB,
  0x27, 0xC0, 0xE0, 0x3C, 0x1F, 0x87, 0xE1, 0x98, 0x6E, 0x1F, 0x07, 0x81,
  0xE6, 0xFF, 0xBF, 0xEE, 0xFB, 0xBC, 0xFF, 0x9F, 0xF0, 0xFF, 0xEC, 0x11,
  0xCC, 0xC6, 0x33, 0x9C, 0xE7, 0x39, 0xCE, 0x31, 0x8C, 0x31, 0xC4, 0x8C,
  0xE6, 0x77, 0x33, 0x33, 0x33, 0x37, 0x76, 0xEC, 0x80, 0x0C, 0x04, 0x12,
  0x5F, 0xF1, 0xC1, 0xB1, 0xD8, 0x44, 0x1C, 0x1C, 0x1C, 0x1C, 0xFF, 0xFF,
  0xFF, 0x1C, 0x1C, 0x1C, 0x1C, 0x77, 0x77, 0x64, 0xFF, 0xC0, 0xEF, 0x60,
  0x1C, 0x61, 0x86, 0x38, 0xC3, 0x0C, 0x71, 0x86, 0x18, 0xE3, 0x0C, 0x00,
  0x3C, 0x7E, 0xFE, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xFE,
  0x7E, 0x3C, 0x0C, 0xFF, 0xFF, 0x9C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C,
  0x70, 0x3C, 0x7E, 0xEF, 0xE7, 0xE7, 0x0E, 0x0E, 0x1E, 0x3C, 0x38, 0x70,
  0xF0, 0xFF, 0xFF, 0x1E, 0x3F, 0x9D, 0xEE, 0x70, 0x38, 0x38, 0x78, 0x3E,
  0x03, 0x81, 0xFC, 0xEE, 0xF7, 0xF1, 0xF0, 0x0E, 0x1E, 0x1E, 0x3E, 0x3E,
  0x7E, 0x6E, 0xEE, 0xEE, 0xFF, 0xFF, 0x0E, 0x0E, 0x0E, 0x7E, 0xFE, 0xE0,
  0xE0, 0xE0, 0xFC, 0xFE, 0x6F, 0x07, 0x07, 0xE7, 0xEF, 0x7E, 0x3C, 0x0C,
  0x3C, 0x7C, 0x70, 0xE0, 0xFE, 0xFE, 0xEF, 0xE7, 0xE7, 0xE7, 0xFF, 0x7E,
  0x3C, 0xFF, 0xFF, 0x07, 0x0E, 0x0E, 0x0E, 0x1C, 0x1C, 0x1C, 0x38, 0x38,
  0x78, 0x70, 0x70, 0x3C, 0x7E, 0xFE, 0xE7, 0xE7, 0xFE, 0x7C, 0x7E, 0xE7,
  0xE7, 0xE7, 0xFF, 0x7E, 0x3C, 0x3C, 0x7E, 0xFE, 0xE7, 0xE7, 0xE7, 0xE7,
  0xFF, 0x77, 0x07, 0x0E, 0x3E, 0x3C, 0x30, 0xEF, 0x60, 0x00, 0x0E, 0xF6,
  0xFF, 0x80, 0x00, 0x6D, 0xFD, 0x80, 0x02, 0x1C, 0xFF, 0xEE, 0x1F, 0x8F,
  0x87, 0x02, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x81, 0xC3, 0xE1, 0xF0,
  0xE7, 0xFE, 0x70, 0x80, 0x3C, 0x7E, 0x77, 0xE7, 0x07, 0x0F, 0x0E, 0x1C,
  0x1C, 0x18, 0x00, 0x18, 0x3C, 0x18, 0x0F, 0x80, 0xFF, 0x0C, 0x1C, 0xC0,
  0x6C, 0x79, 0x67, 0xCF, 0x36, 0x7B, 0x33, 0xD9, 0x9E, 0xCC, 0xF6, 0x65,
  0xBF, 0xEC, 0xEE, 0x70, 0x01, 0xC0, 0x07, 0xF0, 0x1F, 0x00, 0x0E, 0x01,
  0xE0, 0x3C, 0x0F, 0x81, 0xF8, 0x37, 0x0E, 0xE1, 0xCC, 0x3F, 0xCF, 0xF9,
  0xFF, 0x38, 0xF7, 0x0F, 0xE1, 0xC0, 0xFE, 0x7F, 0xBF, 0xFC, 0x7E, 0x3F,
  0x3F, 0xFD, 0xFE, 0xE3, 0xF1, 0xF8, 0xFF, 0xFF, 0xF7, 0xF0, 0x3E, 0x3F,
  0xBF, 0xFC, 0x7E, 0x3F, 0x03, 0x81, 0xC0, 0xE0, 0x71, 0xF8, 0xFF, 0xF7,
  0xF1, 0xF0, 0xFC, 0x7F, 0x3F, 0xDC, 0xFE, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3,
  0xF1, 0xF9, 0xFF, 0xEF, 0xE7, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0,
  0xFE, 0xFE, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0xE0, 0xFE, 0xFE, 0xFE, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x3E, 0x3F,
  0xBF, 0xFC, 0x7E, 0x3F, 0x03, 0x81, 0xCF, 0xE7, 0xF1, 0xF8, 0xFF, 0xF7,
  0xF9, 0xF8, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0xF7, 0x7F, 0x7F, 0x3C, 0xE3, 0xB9, 0xEE, 0x73, 0xBC, 0xEE, 0x3F, 0x0F,
  0xC3, 0xF8, 0xFE, 0x3F, 0xCE, 0x73, 0x9E, 0xE7, 0xB8, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0x0F, 0xF8, 0xFF, 0x8F, 0xF9, 0xFF, 0x9B, 0xF9, 0xBF, 0xDF,
  0xEF, 0xFE, 0xF7, 0xEF, 0x7E, 0x77, 0xE7, 0x7E, 0x67, 0xE3, 0xFC, 0xFF,
  0x3F, 0xCF, 0xFB, 0xFE, 0xFE, 0xFF, 0xBF, 0xEF, 0xF9, 0xFE, 0x7F, 0x8F,
  0xE3, 0xF8, 0xF0, 0x3E, 0x1F, 0xCF, 0xFB, 0x8E, 0xE3, 0xF8, 0x7E, 0x1F,
  0x87, 0xE1, 0xF8, 0xFE, 0x3B, 0xFE, 0x7F, 0x0F, 0x80, 0xFE, 0x7F, 0xBF,
  0xFC, 0x7E, 0x3F, 0x1F, 0xFF, 0xFE, 0xFE, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x00, 0x3E, 0x1F, 0xCF, 0xFB, 0x8E, 0xE3, 0xF8, 0x7E, 0x1F, 0x87, 0xE1,
  0xF8, 0xFE, 0x3B, 0xFE, 0x7F, 0x0F, 0xE0, 0x3C, 0x04, 0xFE, 0x7F, 0xBF,
  0xFC, 0x7E, 0x3F, 0x1F, 0xFF, 0xFE, 0xFE, 0x77, 0xB9, 0xDC, 0xEE, 0x7F,
  0x1C, 0x3E, 0x3F, 0xBD, 0xFC, 0x7E, 0x07, 0xC1, 0xF8, 0x7E, 0x0F, 0x73,
  0xF8, 0xFE, 0xF7, 0xF1, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE3,
  0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFF,
  0xF7, 0xF1, 0xF0, 0xF1, 0xFE, 0x3D, 0xC7, 0x38, 0xE7, 0x9C, 0x77, 0x8E,
  0xE1, 0xDC, 0x3B, 0x83, 0x60, 0x7C, 0x0F, 0x81, 0xF0, 0x1C, 0x00, 0xF3,
  0x1D, 0xDE, 0xF7, 0x7B, 0x9D, 0xEE, 0x77, 0xB9, 0xDE, 0xE7, 0x7F, 0x8F,
  0xFE, 0x3F, 0xF0, 0xFF, 0xC3, 0xCF, 0x0F, 0x3C, 0x3C, 0xF0, 0xF3, 0xC0,
  0xF1, 0xCE, 0x79, 0xEE, 0x1D, 0xC3, 0xF8, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x07, 0xF0, 0xEE, 0x3D, 0xC7, 0x3D, 0xE3, 0x80, 0xF1, 0xDC, 0x77, 0x39,
  0xCE, 0x3B, 0x8F, 0xC1, 0xF0, 0x78, 0x1E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0xE0, 0xE0, 0xF0, 0x70, 0x70, 0x38,
  0x38, 0x1C, 0x1F, 0xFF, 0xFF, 0xFC, 0xFF, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE,
  0xEE, 0xEE, 0xEF, 0xF0, 0xE0, 0xF0, 0x70, 0x70, 0x78, 0x38, 0x38, 0x38,
  0x1C, 0x1C, 0x1C, 0x0E, 0x0E, 0x0E, 0x0F, 0xFF, 0x77, 0x77, 0x77, 0x77,
  0x77, 0x77, 0x77, 0x7F, 0xF0, 0x18, 0x70, 0xF1, 0xE6, 0xCC, 0xD9, 0x80,
  0xFF, 0xFC, 0xE3, 0x8C, 0x3E, 0x7F, 0x77, 0x07, 0x3F, 0x7F, 0x77, 0xF7,
  0x7F, 0x3F, 0xE0, 0xE0, 0xE0, 0xE0, 0xFC, 0xFE, 0xEF, 0xE7, 0xE7, 0xE7,
  0xE7, 0xEF, 0xFE, 0xFC, 0x7D, 0xFF, 0xBF, 0x7E, 0x1C, 0x3B, 0xF7, 0xFE,
  0xF8, 0x03, 0x81, 0xC0, 0xE0, 0x73, 0xBB, 0xFD, 0xDE, 0xE7, 0xF3, 0xF9,
  0xDC, 0xEE, 0xF7, 0xF9, 0xDC, 0x7C, 0xFE, 0xEE, 0xE7, 0xFF, 0xFF, 0xE0,
  0xF6, 0xFE, 0x3C, 0x1C, 0xF7, 0x9C, 0xFF, 0xF7, 0x1C, 0x71, 0xC7, 0x1C,
  0x71, 0xC0, 0x7F, 0xFF, 0xEF, 0xE7, 0xE7, 0xE7, 0xE7, 0xEF, 0xFF, 0x77,
  0x07, 0x4F, 0x7E, 0x7C, 0xE0, 0xE0, 0xE0, 0xE0, 0xFC, 0xFE, 0xEF, 0xE7,
  0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x39, 0xCE, 0x03, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xEF, 0xFF, 0x80,
  0xE0, 0xE0, 0xE0, 0xE0, 0xEF, 0xEE, 0xFE, 0xFC, 0xFC, 0xFC, 0xEE, 0xEE,
  0xEF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFE, 0xEF, 0xFF, 0xEF,
  0x7E, 0xF7, 0xEF, 0x7E, 0xF7, 0xEF, 0x7E, 0xF7, 0xEF, 0x7E, 0xF7, 0xFE,
  0xFE, 0xEF, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0x3C, 0xFE, 0xEF,
  0xE7, 0xE7, 0xE7, 0xE7, 0xEF, 0xFE, 0x3C, 0xFC, 0xFE, 0xEF, 0xE7, 0xE7,
  0xE7, 0xE7, 0xEF, 0xFE, 0xFC, 0xE0, 0xE0, 0xE0, 0xE0, 0x3B, 0xBF, 0xDD,
  0xEE, 0x7F, 0x3F, 0x9D, 0xCE, 0xEF, 0x7F, 0x9D, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0xFF, 0xFF, 0xCE, 0x73, 0x9C, 0xE7, 0x00, 0x3C, 0x7F, 0x77, 0x70,
  0x7C, 0x3F, 0x0F, 0xE7, 0x7F, 0x3E, 0x71, 0xC7, 0x3F, 0xFD, 0xC7, 0x1C,
  0x71, 0xC7, 0x9F, 0x3C, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xEF,
  0xFF, 0x77, 0xE7, 0x3B, 0x9D, 0xCE, 0xE7, 0x61, 0xF0, 0xF8, 0x7C, 0x3C,
  0x0E, 0x00, 0xE6, 0x66, 0x6E, 0x6F, 0xE7, 0xFE, 0x7F, 0xE7, 0xFE, 0x3F,
  0xC3, 0x9C, 0x39, 0xC3, 0x9C, 0x77, 0x3B, 0x9F, 0x87, 0xC3, 0xE1, 0xF0,
  0xF8, 0xEE, 0x77, 0x7B, 0x80, 0xE7, 0xBB, 0x9D, 0xCE, 0xE7, 0xE1, 0xF0,
  0xF8, 0x7C, 0x3C, 0x0E, 0x07, 0x07, 0x07, 0x83, 0x80, 0xFF, 0xFC, 0x70,
  0xE3, 0x8F, 0x1C, 0x70, 0xFF, 0xFC, 0x19, 0xCC, 0x63, 0x18, 0xCE, 0xE7,
  0x1C, 0x63, 0x18, 0xC6, 0x38, 0xC0, 0xFF, 0xFF, 0x80, 0x8C, 0xEE, 0xEE,
  0xE6, 0x77, 0x6E, 0xEE, 0xEE, 0xC8, 0x73, 0xFB, 0xDF, 0xCE,
};

const GFXglyph RobotoCondensed_Black19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 3, 14, 5, 1, -14 },
  { 7, 6, 5, 6, 0, -14 },
  { 11, 9, 14, 10, 0, -14 },
  { 27, 8, 18, 10, 1, -16 },
  { 45, 10, 14, 12, 1, -14 },
  { 63, 10, 14, 11, 1, -14 },
  { 81, 3, 5, 3, 0, -14 },
  { 83, 5, 19, 6, 1, -15 },
  { 95, 4, 19, 6, 1, -15 },
  { 105, 9, 8, 9, 0, -14 },
  { 114, 8, 11, 9, 0, -12 },
  { 125, 4, 6, 5, 0, -2 },
  { 128, 5, 2, 8, 1, -7 },
  { 130, 4, 3, 6, 1, -3 },
  { 132, 6, 15, 6, 0, -14 },
  { 144, 8, 14, 10, 1, -14 },
  { 158, 6, 14, 10, 1, -14 },
  { 169, 8, 14, 10, 1, -14 },
  { 183, 9, 14, 10, 0, -14 },
  { 199, 8, 14, 10, 1, -14 },
  { 213, 8, 14, 10, 1, -14 },
  { 227, 8, 14, 10, 1, -14 },
  { 241, 8, 14, 10, 1, -14 },
  { 255, 8, 14, 10, 1, -14 },
  { 269, 8, 14, 10, 1, -14 },
  { 283, 4, 10, 6, 1, -10 },
  { 288, 3, 14, 5, 1, -10 },
  { 294, 7, 9, 9, 0, -10 },
  { 302, 8, 6, 10, 1, -9 },
  { 308, 7, 9, 9, 1, -10 },
  { 316, 8, 14, 9, 0, -14 },
  { 330, 13, 17, 15, 1, -13 },
  { 358, 11, 14, 12, 0, -14 },
  { 378, 9, 14, 11, 1, -14 },
  { 394, 9, 14, 11, 1, -14 },
  { 410, 9, 14, 11, 1, -14 },
  { 426, 8, 14, 9, 1, -14 },
  { 440, 8, 14, 9, 1, -14 },
  { 454, 9, 14, 11, 1, -14 },
  { 470, 10, 14, 12, 1, -14 },
  { 488, 3, 14, 5, 1, -14 },
  { 494, 8, 14, 9, 0, -14 },
  { 508, 10, 14, 11, 1, -14 },
  { 526, 8, 14, 9, 1, -14 },
  { 540, 12, 14, 14, 1, -14 },
  { 561, 10, 14, 12, 1, -14 },
  { 579, 10, 14, 11, 1, -14 },
  { 597, 9, 14, 11, 1, -14 },
  { 613, 10, 16, 11, 1, -14 },
  { 633, 9, 14, 11, 1, -14 },
  { 649, 9, 14, 10, 1, -14 },
  { 665, 10, 14, 11, 0, -14 },
  { 683, 9, 14, 11, 1, -14 },
  { 699, 11, 14, 11, 0, -14 },
  { 719, 14, 14, 14, 0, -14 },
  { 744, 11, 14, 11, 0, -14 },
  { 764, 10, 14, 11, 0, -14 },
  { 782, 9, 14, 10, 1, -14 },
  { 798, 4, 19, 5, 1, -16 },
  { 808, 8, 15, 7, 0, -14 },
  { 823, 4, 19, 5, 0, -16 },
  { 833, 7, 7, 8, 0, -14 },
  { 840, 7, 2, 8, 0, 0 },
  { 842, 5, 3, 6, 1, -14 },
  { 844, 8, 10, 9, 0, -10 },
  { 854, 8, 14, 9, 1, -14 },
  { 868, 7, 10, 9, 1, -10 },
  { 877, 9, 14, 9, 0, -14 },
  { 893, 8, 10, 9, 1, -10 },
  { 903, 6, 14, 6, 0, -14 },
  { 914, 8, 14, 10, 1, -10 },
  { 928, 8, 14, 9, 1, -14 },
  { 942, 3, 14, 5, 1, -14 },
  { 948, 5, 18, 5, -1, -14 },
  { 960, 8, 14, 9, 1, -14 },
  { 974, 3, 14, 5, 1, -14 },
  { 980, 12, 10, 14, 1, -10 },
  { 995, 8, 10, 9, 1, -10 },
  { 1005, 8, 10, 9, 1, -10 },
  { 1015, 8, 14, 9, 1, -10 },
  { 1029, 9, 14, 9, 0, -10 },
  { 1045, 5, 10, 7, 1, -10 },
  { 1052, 8, 10, 9, 0, -10 },
  { 1062, 6, 13, 6, 0, -13 },
  { 1072, 8, 10, 9, 1, -10 },
  { 1082, 9, 10, 9, 0, -10 },
  { 1094, 12, 10, 12, 0, -10 },
  { 1109, 9, 10, 9, 0, -10 },
  { 1121, 9, 14, 9, 0, -10 },
  { 1137, 7, 10, 9, 1, -10 },
  { 1146, 5, 18, 6, 0, -15 },
  { 1158, 1, 17, 5, 2, -14 },
  { 1161, 4, 18, 6, 1, -15 },
  { 1170, 8, 4, 10, 1, -7 },
};

const GFXfont RobotoCondensed_Black19pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Black19pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Black19pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _ROBOTOCONDENSED_BLACK19PT7B_H_
