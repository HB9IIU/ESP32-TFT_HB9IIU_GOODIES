#ifndef _ROBOTOCONDENSED_BLACK32PT7B_H_
#define _ROBOTOCONDENSED_BLACK32PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Black.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Black32pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x1D, 0xFF, 0xFD, 0xC0, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF,
  0xC7, 0xE3, 0x80, 0x07, 0x70, 0x39, 0xC0, 0xE7, 0x03, 0x9C, 0x0E, 0x70,
  0x3B, 0xC7, 0xFF, 0xDF, 0xFF, 0x7F, 0xFC, 0x73, 0x81, 0xCE, 0x07, 0x38,
  0x1C, 0xE0, 0x77, 0x0F, 0xFF, 0xBF, 0xFE, 0xFF, 0xF8, 0xE7, 0x03, 0x9C,
  0x0E, 0x70, 0x3B, 0x80, 0xEE, 0x03, 0xB8, 0x00, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x01, 0xF0, 0x1F, 0xF0, 0xFF, 0xE3, 0xFF, 0x9F, 0xBF, 0x7C, 0x7D,
  0xF1, 0xF7, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFE,
  0x01, 0xF8, 0x03, 0xFF, 0x87, 0xFF, 0x1F, 0x7C, 0x7D, 0xF3, 0xF7, 0xFF,
  0x8F, 0xFE, 0x1F, 0xF0, 0x1F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1E,
  0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x01, 0xCE, 0x38, 0xF3, 0x8E, 0x3C, 0xE7,
  0x0F, 0x39, 0xC1, 0xCE, 0xE0, 0x7F, 0xF0, 0x1F, 0xDC, 0x01, 0xEE, 0x00,
  0x03, 0x80, 0x01, 0xCF, 0x00, 0x7F, 0xE0, 0x3B, 0xFC, 0x0F, 0xE7, 0x07,
  0x79, 0xC1, 0xDE, 0x70, 0xE7, 0x9C, 0x39, 0xE7, 0x04, 0x3F, 0xC0, 0x0F,
  0xE0, 0x00, 0xF0, 0x07, 0xC0, 0x0F, 0xF0, 0x0F, 0xFC, 0x07, 0xFE, 0x03,
  0xCF, 0x01, 0xE7, 0xC0, 0xF3, 0xC0, 0x79, 0xE0, 0x3F, 0xF0, 0x1F, 0xF0,
  0x07, 0xF0, 0x03, 0xF1, 0xE3, 0xFC, 0xF3, 0xFF, 0x7B, 0xEF, 0xFD, 0xF7,
  0xFE, 0xF9, 0xFE, 0x7C, 0x7F, 0x3F, 0x3F, 0x1F, 0xFF, 0xC7, 0xFF, 0xF1,
  0xFF, 0xF8, 0x7E, 0x7E, 0xFF, 0xFF, 0xFF, 0xE0, 0x02, 0x06, 0x0F, 0x1E,
  0x3C, 0x3C, 0x78, 0x78, 0x78, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0x78, 0x78, 0x78, 0x3C, 0x3C,
  0x1E, 0x0F, 0x06, 0x02, 0x40, 0xE0, 0xF0, 0x78, 0x78, 0x3C, 0x3C, 0x1E,
  0x1E, 0x1E, 0x1E, 0x1F, 0x1F, 0x1F, 0x1F, 0x0F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1E, 0x1E, 0x1E, 0x1E, 0x3C, 0x3C, 0x78, 0x78, 0xF0, 0xE0, 0x40,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x02, 0x1C, 0x07, 0x38, 0xCF, 0xFF, 0x9F,
  0xFF, 0x87, 0xF0, 0x07, 0xC0, 0x1D, 0xC0, 0x7B, 0xC1, 0xE3, 0xC1, 0xC7,
  0x81, 0x04, 0x00, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7D, 0xF7, 0xDF, 0x79, 0xE7,
  0xBC, 0xF1, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x7B, 0xEF, 0xFE, 0x78, 0x03,
  0x80, 0xE0, 0x78, 0x1E, 0x07, 0x01, 0xC0, 0xF0, 0x3C, 0x0E, 0x03, 0x81,
  0xE0, 0x78, 0x1C, 0x07, 0x03, 0xC0, 0xF0, 0x38, 0x0E, 0x07, 0x81, 0xE0,
  0x70, 0x1C, 0x0F, 0x03, 0xC0, 0xE0, 0x00, 0x07, 0xC0, 0x7F, 0x83, 0xFF,
  0x1F, 0xFE, 0x7C, 0xF9, 0xF1, 0xF7, 0xC7, 0xFF, 0x1F, 0xF8, 0x7F, 0xE1,
  0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0x7C,
  0x7D, 0xF1, 0xF7, 0xCF, 0x8F, 0xFE, 0x3F, 0xF0, 0x7F, 0x80, 0x7C, 0x00,
  0x00, 0xC1, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x0F, 0xC0, 0x7F, 0xC3, 0xFF, 0x9F, 0xFE,
  0x7C, 0xFB, 0xE3, 0xFF, 0x8F, 0xFE, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x1F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xE0, 0x1F, 0x00, 0xFC,
  0x07, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xC0,
  0xFF, 0xC7, 0xFF, 0x9F, 0xFE, 0xFC, 0xFF, 0xE1, 0xF0, 0x07, 0xC0, 0x3F,
  0x00, 0xF8, 0x3F, 0xE0, 0xFF, 0x03, 0xFC, 0x0F, 0xF8, 0x03, 0xE0, 0x07,
  0xC0, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0xCF, 0xDF, 0xFE, 0x7F, 0xF8, 0xFF,
  0xC0, 0xFC, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0xFE, 0x07, 0xF8,
  0x1F, 0xE0, 0xFF, 0x83, 0xFE, 0x1F, 0xF8, 0x7F, 0xE3, 0xDF, 0x8F, 0x7E,
  0x79, 0xF9, 0xE7, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0xF9, 0xFF, 0xE7,
  0xFF, 0x9F, 0xFE, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7F, 0xE1,
  0xFF, 0xC7, 0xFF, 0xBF, 0xFE, 0x18, 0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0xF8, 0x7F, 0xE1, 0xFF, 0xCF, 0x9F, 0xFE, 0x3F, 0xF0, 0x7F, 0x80, 0xFC,
  0x00, 0x01, 0xE0, 0x1F, 0x80, 0xFE, 0x07, 0xF8, 0x3F, 0x80, 0xF8, 0x07,
  0xE0, 0x1F, 0x00, 0x7D, 0xE3, 0xFF, 0xCF, 0xFF, 0xBF, 0xFF, 0xFC, 0xFF,
  0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xFC, 0x7D, 0xF1, 0xF7, 0xCF, 0xCF, 0xFE,
  0x3F, 0xF8, 0x7F, 0xC0, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0x80,
  0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x0F,
  0xC0, 0x7F, 0xC3, 0xFF, 0x9F, 0xFE, 0x7C, 0xF9, 0xF3, 0xF7, 0xCF, 0xDF,
  0x3E, 0x7C, 0xF8, 0xFF, 0xE1, 0xFF, 0x07, 0xFC, 0x3F, 0xF9, 0xF3, 0xE7,
  0xC7, 0xFF, 0x1F, 0xFC, 0x7F, 0xF1, 0xF7, 0xCF, 0xDF, 0xFE, 0x3F, 0xF8,
  0xFF, 0xC0, 0xFC, 0x00, 0x07, 0xC0, 0x7F, 0x83, 0xFF, 0x1F, 0xFE, 0x7C,
  0xF9, 0xF3, 0xEF, 0xC7, 0xFE, 0x1F, 0xF8, 0x7F, 0xF1, 0xFF, 0xC7, 0xDF,
  0x1F, 0x7F, 0xFC, 0xFF, 0xF3, 0xFF, 0xC3, 0xFE, 0x00, 0xF8, 0x07, 0xE0,
  0x7F, 0x07, 0xF8, 0x1F, 0xC0, 0x7E, 0x01, 0xE0, 0x00, 0x7B, 0xFF, 0xFE,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7B, 0xFF, 0xFE, 0x78, 0x3C, 0xF9,
  0xFB, 0xE3, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x8F, 0x1E,
  0x3C, 0x78, 0xF3, 0xC7, 0x9E, 0x08, 0x00, 0x00, 0x30, 0x0F, 0x03, 0xF0,
  0xFF, 0x3F, 0xFF, 0xFC, 0xFE, 0x0F, 0x80, 0xFE, 0x0F, 0xFC, 0x3F, 0xF0,
  0xFF, 0x03, 0xF0, 0x0F, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80,
  0x1C, 0x03, 0xE0, 0x7F, 0x0F, 0xF8, 0x7F, 0xC3, 0xF8, 0x1F, 0x0F, 0xE7,
  0xFF, 0xFE, 0x7F, 0x0F, 0x81, 0xC0, 0x20, 0x00, 0x1F, 0x81, 0xFF, 0x1F,
  0xFD, 0xFF, 0xEF, 0x9F, 0x7C, 0xFB, 0xE7, 0xE0, 0x3E, 0x01, 0xF0, 0x1F,
  0x81, 0xF8, 0x1F, 0x80, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0x3C, 0x00, 0x00, 0x7E,
  0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xFE, 0x03, 0xE0, 0x7C, 0x1E, 0x00, 0x70,
  0x70, 0x00, 0xE3, 0x80, 0x03, 0x8E, 0x0F, 0x87, 0x78, 0x7F, 0x1D, 0xC3,
  0xFC, 0x77, 0x1E, 0x71, 0xFC, 0x71, 0xC7, 0xF3, 0xC7, 0x1F, 0x8F, 0x1C,
  0x7E, 0x3C, 0x71, 0xF8, 0xF1, 0xC7, 0xE3, 0xCF, 0x1F, 0x8F, 0x3C, 0x7E,
  0x3C, 0xF3, 0xBC, 0xFF, 0xFE, 0xF1, 0xFF, 0xF1, 0xC3, 0xCF, 0x87, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x08, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F,
  0xE0, 0x07, 0xBE, 0x01, 0xF7, 0xC0, 0x3E, 0x78, 0x07, 0xCF, 0x81, 0xF1,
  0xF0, 0x3E, 0x3E, 0x07, 0xC7, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF,
  0xF8, 0xFF, 0xFF, 0x3F, 0x03, 0xE7, 0xE0, 0x7C, 0xF8, 0x0F, 0xFF, 0x01,
  0xF8, 0xFF, 0xC1, 0xFF, 0xE3, 0xFF, 0xE7, 0xFF, 0xEF, 0x8F, 0xDF, 0x0F,
  0xFE, 0x1F, 0xFC, 0x3E, 0xF8, 0x7D, 0xFF, 0xFB, 0xFF, 0xE7, 0xFF, 0xCF,
  0xFF, 0xDF, 0x0F, 0xBE, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE3,
  0xFF, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0x3F, 0xF8, 0x00, 0x07, 0xF0, 0x07,
  0xFE, 0x0F, 0xFF, 0x87, 0xFF, 0xC7, 0xE7, 0xF3, 0xE0, 0xF9, 0xF0, 0x7D,
  0xF8, 0x3E, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x3E, 0x7C, 0x1F, 0x3E, 0x0F, 0x9F,
  0x9F, 0xC7, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xE0, 0x1F, 0xC0, 0xFF, 0x81,
  0xFF, 0xC3, 0xFF, 0xC7, 0xFF, 0xCF, 0x9F, 0xDF, 0x0F, 0xBE, 0x1F, 0x7C,
  0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0x87, 0xFF, 0x0F,
  0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x7D, 0xF0, 0xFB, 0xE7, 0xF7, 0xFF, 0xCF,
  0xFF, 0x1F, 0xFC, 0x3F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xFF, 0xBF, 0xFD,
  0xFF, 0xEF, 0xFF, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3F, 0xFD, 0xFF, 0xEF, 0xFF, 0x7F, 0xFB, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x00, 0x07, 0xF0,
  0x07, 0xFE, 0x0F, 0xFF, 0x87, 0xFF, 0xE7, 0xE3, 0xF3, 0xE0, 0xF9, 0xF0,
  0x7D, 0xF8, 0x3F, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x1F, 0xFF, 0x8F, 0xFF,
  0xC7, 0xFF, 0xE3, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0x7C, 0x1F, 0xBE, 0x0F,
  0xDF, 0xCF, 0xE7, 0xFF, 0xF3, 0xFF, 0xF0, 0x7F, 0xF0, 0x0F, 0xC0, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0xF8, 0xFF, 0xC7, 0xFF, 0x7F, 0xFF, 0xE7, 0xFF, 0x1F, 0xF0,
  0x3E, 0x00, 0xF8, 0x7F, 0xF8, 0x7E, 0xF8, 0xFE, 0xF8, 0xFC, 0xF9, 0xF8,
  0xF9, 0xF8, 0xF9, 0xF0, 0xFB, 0xF0, 0xFB, 0xE0, 0xFF, 0xC0, 0xFF, 0xC0,
  0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xF0, 0xFF, 0xF0, 0xFD, 0xF8, 0xF9, 0xF8,
  0xF8, 0xF8, 0xF8, 0xFC, 0xF8, 0xFC, 0xF8, 0x7E, 0xF8, 0x7E, 0xF8, 0x3F,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFE, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0x7F, 0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFC, 0x77, 0xFF, 0xE7, 0xBF, 0xFF, 0x3D, 0xFF, 0xB9, 0xEF,
  0xFD, 0xEE, 0x7F, 0xEF, 0xF7, 0xFF, 0x7F, 0xBF, 0xF9, 0xFD, 0xFF, 0xCF,
  0xCF, 0xFE, 0x7E, 0x7F, 0xF3, 0xF3, 0xFF, 0x8F, 0x9F, 0xFC, 0x78, 0xFF,
  0xE3, 0xC7, 0xE0, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFE,
  0x1F, 0xFE, 0x1F, 0xFE, 0x1F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x9F, 0xFB,
  0x9F, 0xFB, 0x9F, 0xFB, 0xDF, 0xF9, 0xDF, 0xF9, 0xFF, 0xF8, 0xFF, 0xF8,
  0xFF, 0xF8, 0xFF, 0xF8, 0x7F, 0xF8, 0x7F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8,
  0x3F, 0x03, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x87, 0xFF, 0xC7, 0xF3, 0xF3,
  0xE0, 0xF9, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03,
  0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x3F, 0x7C,
  0x1F, 0xBE, 0x0F, 0x9F, 0xCF, 0xC7, 0xFF, 0xE1, 0xFF, 0xE0, 0x7F, 0xE0,
  0x0F, 0xC0, 0xFF, 0xE1, 0xFF, 0xE3, 0xFF, 0xE7, 0xFF, 0xEF, 0x8F, 0xFF,
  0x0F, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0xFF, 0xE3, 0xFF, 0xFF,
  0xEF, 0xFF, 0xDF, 0xFE, 0x3F, 0xF8, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0,
  0x07, 0xFE, 0x07, 0xFF, 0x87, 0xFF, 0xE7, 0xF3, 0xF3, 0xE0, 0xF9, 0xF0,
  0x7F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF,
  0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0x7C, 0x1F, 0xBE, 0x0F,
  0xDF, 0xCF, 0xC7, 0xFF, 0xE1, 0xFF, 0xE0, 0x7F, 0xE0, 0x0F, 0xF8, 0x00,
  0x7F, 0x00, 0x1F, 0x80, 0x07, 0x00, 0x01, 0x00, 0xFF, 0xE1, 0xFF, 0xE3,
  0xFF, 0xE7, 0xFF, 0xEF, 0x8F, 0xDF, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8,
  0x7F, 0xF0, 0xFF, 0xE3, 0xF7, 0xFF, 0xEF, 0xFF, 0x9F, 0xFE, 0x3F, 0xFC,
  0x7C, 0xF8, 0xF9, 0xF9, 0xF3, 0xF3, 0xE3, 0xF7, 0xC7, 0xEF, 0x87, 0xDF,
  0x0F, 0xFE, 0x1F, 0x80, 0x07, 0xE0, 0x3F, 0xF0, 0xFF, 0xF3, 0xFF, 0xF7,
  0xE7, 0xEF, 0x87, 0xDF, 0x0F, 0xBE, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0xFF,
  0xC0, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0xFC, 0x1F, 0xFC, 0x3F,
  0xF8, 0x7D, 0xF9, 0xFB, 0xFF, 0xF3, 0xFF, 0xC3, 0xFF, 0x01, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0xFC, 0x1F,
  0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F,
  0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F,
  0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0x7C, 0x1F, 0x7C, 0x3F, 0x7E, 0x3F,
  0x7F, 0xFE, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xF0, 0xFC, 0x0F, 0xCF, 0x81,
  0xF9, 0xF8, 0x3F, 0x3F, 0x07, 0xE7, 0xE0, 0xF8, 0x7C, 0x3F, 0x0F, 0x87,
  0xE1, 0xF8, 0xFC, 0x3F, 0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0xFC, 0x0F, 0x9F,
  0x00, 0xFB, 0xE0, 0x1F, 0x7C, 0x03, 0xEF, 0x80, 0x7F, 0xE0, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFC, 0x00, 0x7C, 0x7C, 0x3E, 0xF8, 0xF8, 0x7D, 0xF1, 0xF8, 0xFB,
  0xE3, 0xF3, 0xF7, 0xC7, 0xE7, 0xCF, 0xCF, 0xCF, 0x8F, 0xBF, 0x9F, 0x1F,
  0x7F, 0x3E, 0x3E, 0xFF, 0x7C, 0x7D, 0xFE, 0xF8, 0xFB, 0xFF, 0xE1, 0xF7,
  0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFB, 0xFE, 0x0F, 0xF7,
  0xFC, 0x1F, 0xE7, 0xF0, 0x3F, 0xCF, 0xE0, 0x3F, 0x9F, 0xC0, 0x7F, 0x3F,
  0x80, 0xFC, 0x7F, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0xF8, 0x00, 0x7E, 0x1F,
  0x9F, 0x87, 0xE7, 0xE1, 0xF8, 0xFC, 0xFC, 0x3F, 0x3F, 0x07, 0xCF, 0x81,
  0xFF, 0xE0, 0x3F, 0xF0, 0x0F, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x1F, 0xFE,
  0x07, 0xCF, 0x83, 0xF3, 0xF0, 0xFC, 0xFC, 0x7E, 0x1F, 0x9F, 0x87, 0xEF,
  0xE1, 0xFC, 0xFC, 0x0F, 0x9F, 0x07, 0xE7, 0xE1, 0xF8, 0xF8, 0x7C, 0x3E,
  0x3F, 0x0F, 0xCF, 0x81, 0xF3, 0xE0, 0x7C, 0xF0, 0x0F, 0x7C, 0x03, 0xFF,
  0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x07,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80,
  0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB,
  0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFF,
  0xFF, 0xFF, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xF8, 0x07,
  0xE0, 0x3F, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xC0, 0x3F,
  0x00, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0xFF, 0xFF, 0xFF, 0x7D, 0xF7,
  0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7,
  0xDF, 0x7D, 0xF7, 0xDF, 0xFF, 0xFF, 0xFF, 0x1F, 0x03, 0xE0, 0x7C, 0x1F,
  0xC3, 0xB8, 0x77, 0x1E, 0xF3, 0x9E, 0x71, 0xDE, 0x3F, 0xC7, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3E, 0x0F, 0x83, 0xE0, 0xF0, 0x0F,
  0xC1, 0xFF, 0x1F, 0xFD, 0xFF, 0xEF, 0x9F, 0xFC, 0xFC, 0x07, 0xE3, 0xFF,
  0x7F, 0xFB, 0xFF, 0xFE, 0x7F, 0xF3, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xEF,
  0xDF, 0x3C, 0xF8, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x78, 0xFF, 0xF3, 0xFF, 0xEF, 0xFF, 0xBF, 0x3F,
  0xFC, 0x7F, 0xF1, 0xFF, 0xC7, 0xFF, 0x1F, 0xFC, 0x7F, 0xF1, 0xFF, 0xC7,
  0xFF, 0x3F, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0x3E, 0x78, 0x0F, 0x81, 0xFF,
  0x1F, 0xFC, 0xFF, 0xEF, 0xCF, 0xFC, 0x7F, 0xE3, 0xFF, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF1, 0xFF, 0xCF, 0xBF, 0xF9, 0xFF, 0xC7, 0xFC, 0x0F,
  0xC0, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE3, 0xDF, 0x3F, 0xFB, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0x8F, 0xFC, 0x7F,
  0xE3, 0xFF, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF9, 0xFF, 0xFF, 0xBF,
  0xFC, 0xFD, 0xE3, 0xCF, 0x0F, 0xC0, 0xFF, 0xC7, 0xFF, 0x1F, 0xFE, 0xFC,
  0xFB, 0xE1, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3E,
  0x00, 0xFC, 0x31, 0xFF, 0xE7, 0xFF, 0x8F, 0xFE, 0x0F, 0xE0, 0x07, 0xC3,
  0xF1, 0xFC, 0x7F, 0x3F, 0x0F, 0xC3, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E,
  0x0F, 0x83, 0xE0, 0xF8, 0x1F, 0x7C, 0xFF, 0xF7, 0xFF, 0xDF, 0xFF, 0xFC,
  0xFF, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE,
  0x1F, 0xFC, 0xFD, 0xFF, 0xF7, 0xFF, 0xCF, 0xFF, 0x1F, 0x7C, 0x01, 0xF0,
  0x07, 0xC4, 0x3F, 0x3F, 0xF8, 0xFF, 0xE7, 0xFF, 0x03, 0xF0, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x78,
  0xFB, 0xF3, 0xFF, 0xEF, 0xFF, 0xBF, 0x3E, 0xF8, 0xFB, 0xE3, 0xFF, 0x8F,
  0xFE, 0x3F, 0xF8, 0xFF, 0xE3, 0xFF, 0x8F, 0xFE, 0x3F, 0xF8, 0xFF, 0xE3,
  0xFF, 0x8F, 0xFE, 0x3F, 0x79, 0xFF, 0xDF, 0x78, 0x00, 0x1F, 0x7D, 0xF7,
  0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x1E, 0x1F,
  0x3F, 0x1F, 0x1E, 0x00, 0x00, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x3F, 0xFE, 0xFE, 0xFC, 0xF8, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x7E, 0xFC, 0xFD, 0xFB, 0xF3,
  0xF7, 0xC7, 0xFF, 0x8F, 0xFE, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xF0, 0xFF,
  0xE1, 0xFF, 0xE3, 0xF7, 0xC7, 0xEF, 0xCF, 0xCF, 0x9F, 0x9F, 0xBF, 0x3F,
  0x7E, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF9, 0xE1, 0xE7, 0xDF, 0xBF, 0xBF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xCF, 0xCF, 0xFE, 0x7C, 0x7F, 0xF3, 0xE3, 0xFF,
  0x9F, 0x1F, 0xFC, 0xF8, 0xFF, 0xE7, 0xC7, 0xFF, 0x3E, 0x3F, 0xF9, 0xF1,
  0xFF, 0xCF, 0x8F, 0xFE, 0x7C, 0x7F, 0xF3, 0xE3, 0xFF, 0x9F, 0x1F, 0xFC,
  0xF8, 0xF8, 0xF9, 0xE3, 0xEF, 0xCF, 0xFF, 0xBF, 0xFE, 0xFC, 0xFB, 0xE3,
  0xFF, 0x8F, 0xFE, 0x3F, 0xF8, 0xFF, 0xE3, 0xFF, 0x8F, 0xFE, 0x3F, 0xF8,
  0xFF, 0xE3, 0xFF, 0x8F, 0xFE, 0x3F, 0xF8, 0xFC, 0x0F, 0xC0, 0xFF, 0x87,
  0xFF, 0x1F, 0xFE, 0xFC, 0xFB, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F,
  0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xFC, 0xF9, 0xFF, 0xE7, 0xFF, 0x0F, 0xFC,
  0x0F, 0xC0, 0xF9, 0xE3, 0xFF, 0xCF, 0xFF, 0xBF, 0xFE, 0xFC, 0xFF, 0xF1,
  0xFF, 0xC7, 0xFF, 0x1F, 0xFC, 0x7F, 0xF1, 0xFF, 0xC7, 0xFF, 0x1F, 0xFC,
  0xFF, 0xFF, 0xEF, 0xFF, 0xBF, 0xFC, 0xFD, 0xE3, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x1E, 0x79, 0xFB, 0xDF,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF, 0xC7,
  0xFE, 0x3F, 0xF1, 0xFF, 0xCF, 0xFF, 0xFD, 0xFF, 0xE7, 0xFF, 0x1E, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0xF9,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F,
  0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x00, 0x1F, 0x81, 0xFF, 0x1F, 0xFD,
  0xFF, 0xEF, 0x9F, 0x7C, 0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0x81,
  0xFD, 0xE3, 0xEF, 0x8F, 0xFF, 0xF9, 0xFF, 0xC7, 0xFC, 0x1F, 0x80, 0x3E,
  0x0F, 0x83, 0xE0, 0xF8, 0xFF, 0xBF, 0xEF, 0xFB, 0xFE, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3F, 0x0F, 0xF3, 0xFC, 0x7F,
  0x0F, 0xC0, 0xF8, 0xFF, 0xE3, 0xFF, 0x8F, 0xFE, 0x3F, 0xF8, 0xFF, 0xE3,
  0xFF, 0x8F, 0xFE, 0x3F, 0xF8, 0xFF, 0xE3, 0xFF, 0x8F, 0xFE, 0x3F, 0xFC,
  0xFD, 0xFF, 0xF7, 0xFF, 0xCF, 0xDF, 0x1E, 0x7C, 0xFC, 0x7D, 0xF1, 0xF7,
  0xC7, 0xDF, 0x3F, 0x7C, 0xF8, 0xFB, 0xE3, 0xEF, 0x8F, 0xBC, 0x3E, 0xF0,
  0x7F, 0xC1, 0xFF, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF0,
  0x07, 0xC0, 0x78, 0xF1, 0xE7, 0xCF, 0x3E, 0x7C, 0xF3, 0xE7, 0xDF, 0x3E,
  0x7D, 0xFB, 0xE7, 0xDF, 0xBC, 0x3D, 0xFB, 0xC3, 0xDF, 0xBC, 0x3F, 0xFF,
  0xC3, 0xFF, 0xFC, 0x3F, 0x9F, 0xC1, 0xF9, 0xF8, 0x1F, 0x9F, 0x81, 0xF9,
  0xF8, 0x1F, 0x9F, 0x81, 0xF0, 0xF8, 0x0F, 0x0F, 0x00, 0x7C, 0x7D, 0xF3,
  0xF3, 0xEF, 0x8F, 0xBE, 0x3F, 0xF0, 0x7F, 0xC1, 0xFF, 0x03, 0xF8, 0x0F,
  0xE0, 0x3F, 0x81, 0xFF, 0x07, 0xFC, 0x3E, 0xF8, 0xFB, 0xE7, 0xEF, 0x9F,
  0x1F, 0x7C, 0x7C, 0xFC, 0x7E, 0xF8, 0xF9, 0xF1, 0xF3, 0xE7, 0xE7, 0xCF,
  0x87, 0xDF, 0x0F, 0xBE, 0x1F, 0xFC, 0x3F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0,
  0xFF, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1E, 0x00, 0x7C, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1E, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0xFC,
  0x0F, 0x81, 0xF0, 0x3F, 0x03, 0xE0, 0x7C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x06, 0x1C, 0x79, 0xF3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1,
  0xE7, 0xDF, 0x3C, 0x78, 0xF8, 0xF9, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C,
  0x78, 0xF1, 0xF1, 0xE1, 0xC1, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x40, 0xF0, 0xF0, 0x78, 0x78, 0x7C, 0x7C,
  0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x3C, 0x3F, 0x1F, 0x1F, 0x3F, 0x3C, 0x7C,
  0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x78, 0x78, 0xF0, 0xF0, 0x40,
  0x1E, 0x00, 0x7E, 0x3D, 0xFE, 0x7B, 0xFF, 0xFF, 0x3F, 0xDE, 0x3F, 0x80,
  0x3C, 0x00,
};

const GFXglyph RobotoCondensed_Black32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 5, 23, 8, 2, -23 },
  { 16, 9, 9, 10, 0, -24 },
  { 27, 14, 23, 16, 1, -23 },
  { 68, 14, 29, 16, 1, -26 },
  { 119, 18, 23, 21, 1, -23 },
  { 171, 17, 23, 19, 1, -23 },
  { 220, 3, 9, 5, 1, -24 },
  { 224, 8, 32, 10, 2, -25 },
  { 256, 8, 32, 10, 1, -25 },
  { 288, 15, 14, 15, 0, -23 },
  { 315, 13, 17, 15, 1, -19 },
  { 343, 6, 10, 9, 1, -4 },
  { 351, 8, 4, 13, 3, -12 },
  { 355, 6, 5, 10, 2, -5 },
  { 359, 10, 25, 10, 0, -23 },
  { 391, 14, 23, 16, 1, -23 },
  { 432, 10, 23, 16, 2, -23 },
  { 461, 14, 23, 16, 1, -23 },
  { 502, 14, 23, 16, 1, -23 },
  { 543, 14, 23, 16, 1, -23 },
  { 584, 14, 23, 16, 1, -23 },
  { 625, 14, 23, 16, 1, -23 },
  { 666, 14, 23, 16, 1, -23 },
  { 707, 14, 23, 16, 1, -23 },
  { 748, 14, 23, 16, 1, -23 },
  { 789, 6, 17, 9, 2, -17 },
  { 802, 7, 23, 9, 1, -17 },
  { 823, 12, 15, 14, 1, -17 },
  { 846, 12, 11, 17, 2, -15 },
  { 863, 11, 15, 14, 2, -17 },
  { 884, 13, 23, 15, 1, -23 },
  { 922, 22, 29, 25, 1, -22 },
  { 1002, 19, 23, 19, 0, -23 },
  { 1057, 15, 23, 18, 2, -23 },
  { 1101, 17, 23, 18, 1, -23 },
  { 1150, 15, 23, 18, 2, -23 },
  { 1194, 13, 23, 16, 2, -23 },
  { 1232, 13, 23, 15, 2, -23 },
  { 1270, 17, 23, 19, 1, -23 },
  { 1319, 16, 23, 20, 2, -23 },
  { 1365, 5, 23, 9, 2, -23 },
  { 1380, 13, 23, 16, 1, -23 },
  { 1418, 16, 23, 18, 2, -23 },
  { 1464, 13, 23, 15, 2, -23 },
  { 1502, 21, 23, 24, 2, -23 },
  { 1563, 16, 23, 19, 2, -23 },
  { 1609, 17, 23, 19, 1, -23 },
  { 1658, 15, 23, 18, 2, -23 },
  { 1702, 17, 27, 19, 1, -23 },
  { 1760, 15, 23, 18, 2, -23 },
  { 1804, 15, 23, 18, 1, -23 },
  { 1848, 16, 23, 18, 1, -23 },
  { 1894, 16, 23, 18, 1, -23 },
  { 1940, 19, 23, 19, 0, -23 },
  { 1995, 23, 23, 24, 0, -23 },
  { 2062, 18, 23, 18, 0, -23 },
  { 2114, 18, 23, 18, 0, -23 },
  { 2166, 15, 23, 17, 1, -23 },
  { 2210, 6, 32, 9, 2, -27 },
  { 2234, 13, 25, 12, 0, -23 },
  { 2275, 6, 32, 9, 1, -27 },
  { 2299, 11, 11, 13, 1, -23 },
  { 2315, 12, 4, 13, 0, 0 },
  { 2321, 9, 5, 11, 1, -24 },
  { 2327, 13, 17, 15, 1, -17 },
  { 2355, 14, 24, 16, 1, -24 },
  { 2397, 13, 17, 15, 1, -17 },
  { 2425, 13, 24, 16, 1, -24 },
  { 2464, 14, 17, 15, 1, -17 },
  { 2494, 10, 24, 11, 0, -24 },
  { 2524, 14, 24, 16, 1, -17 },
  { 2566, 14, 24, 16, 1, -24 },
  { 2608, 6, 24, 8, 1, -24 },
  { 2626, 8, 31, 8, -1, -24 },
  { 2657, 15, 24, 16, 1, -24 },
  { 2702, 5, 24, 8, 2, -24 },
  { 2717, 21, 17, 24, 1, -17 },
  { 2762, 14, 17, 16, 1, -17 },
  { 2792, 14, 17, 16, 1, -17 },
  { 2822, 14, 24, 16, 1, -17 },
  { 2864, 13, 24, 16, 1, -17 },
  { 2903, 9, 17, 11, 1, -17 },
  { 2923, 13, 17, 14, 1, -17 },
  { 2951, 10, 21, 10, 0, -21 },
  { 2978, 14, 17, 16, 1, -17 },
  { 3008, 14, 17, 15, 0, -17 },
  { 3038, 20, 17, 20, 0, -17 },
  { 3081, 14, 17, 15, 0, -17 },
  { 3111, 15, 24, 15, 0, -17 },
  { 3156, 12, 17, 15, 1, -17 },
  { 3182, 7, 31, 9, 1, -25 },
  { 3210, 3, 27, 8, 3, -23 },
  { 3221, 8, 31, 9, 1, -25 },
  { 3252, 15, 7, 17, 1, -13 },
};

const GFXfont RobotoCondensed_Black32pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Black32pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Black32pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _ROBOTOCONDENSED_BLACK32PT7B_H_
