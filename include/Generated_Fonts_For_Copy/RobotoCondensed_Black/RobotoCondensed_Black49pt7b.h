#ifndef _ROBOTOCONDENSED_BLACK49PT7B_H_
#define _ROBOTOCONDENSED_BLACK49PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Black.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Black49pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0xBF,
  0xDF, 0xEF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7,
  0xF3, 0xF8, 0xFC, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xC7, 0xF3, 0xFF, 0xFF,
  0xFF, 0x7F, 0xBF, 0x8F, 0x80, 0xF8, 0xFF, 0xE3, 0xFF, 0x8F, 0xFE, 0x3F,
  0xF8, 0xFB, 0xE3, 0xEF, 0x8F, 0xBE, 0x3E, 0xF8, 0xFB, 0xE3, 0xEF, 0x0F,
  0xBC, 0x3E, 0xF0, 0xFB, 0xC3, 0xE0, 0x00, 0xF1, 0xE0, 0x07, 0xCF, 0x80,
  0x1F, 0x3E, 0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xE0, 0x07, 0x8F, 0x80, 0x1E,
  0x3C, 0x00, 0x78, 0xF0, 0x01, 0xE3, 0xC0, 0x0F, 0x9F, 0x03, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF0, 0x3C, 0x78, 0x00,
  0xF1, 0xE0, 0x07, 0xCF, 0x80, 0x1F, 0x3E, 0x00, 0x7C, 0xF8, 0x01, 0xF3,
  0xE0, 0x07, 0x8F, 0x03, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xF8, 0x3E, 0x7C, 0x00, 0xF9, 0xF0, 0x03, 0xE7, 0xC0, 0x0F,
  0x1E, 0x00, 0x3C, 0x78, 0x00, 0xF1, 0xE0, 0x07, 0xCF, 0x80, 0x1F, 0x3E,
  0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x7E, 0x00, 0x1F,
  0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC,
  0x7F, 0x9F, 0xE7, 0xF8, 0x7F, 0xBF, 0xC3, 0xFD, 0xFE, 0x1F, 0xEF, 0xF0,
  0xFF, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF,
  0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0x7F, 0x87, 0xFB, 0xFE, 0x7F,
  0xDF, 0xFF, 0xFC, 0x7F, 0xFF, 0xE1, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x1F,
  0xFE, 0x00, 0x3F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x81, 0x81, 0xF1,
  0xF8, 0x7C, 0x3E, 0x1F, 0x1F, 0x07, 0xC3, 0xE3, 0xE0, 0xF8, 0x7C, 0xF8,
  0x1F, 0x0F, 0x9E, 0x03, 0xE3, 0xF7, 0xC0, 0x3F, 0xFC, 0xF0, 0x07, 0xFF,
  0xBE, 0x00, 0x7F, 0xE7, 0x80, 0x0F, 0xF9, 0xF0, 0x00, 0x7E, 0x3C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x1F, 0x80, 0x03, 0xEF, 0xF8, 0x00, 0xFB, 0xFF, 0x80, 0x1E, 0x7F, 0xF8,
  0x07, 0xDF, 0xBF, 0x00, 0xF3, 0xE3, 0xE0, 0x3E, 0x7C, 0x7C, 0x07, 0x8F,
  0x8F, 0x81, 0xF1, 0xF1, 0xF0, 0x3C, 0x3E, 0x3E, 0x0F, 0x87, 0xC7, 0xC0,
  0xE0, 0xFD, 0xF8, 0x04, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xC0, 0x07, 0xFB, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0xC7, 0xF0, 0x03,
  0xF8, 0xFE, 0x00, 0x7F, 0x1F, 0x80, 0x0F, 0xE3, 0xF0, 0x01, 0xFE, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x7E, 0x0F, 0xFF, 0x8F,
  0xC3, 0xFF, 0xFB, 0xF8, 0xFF, 0xFF, 0x7F, 0x1F, 0xFF, 0xFF, 0xE3, 0xF9,
  0xFF, 0xFC, 0xFF, 0x1F, 0xFF, 0x1F, 0xE3, 0xFF, 0xE3, 0xFC, 0x3F, 0xFC,
  0x7F, 0xC3, 0xFF, 0x07, 0xF8, 0x3F, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8,
  0x1F, 0xF8, 0xFF, 0x80, 0x30, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFB, 0xEF, 0xBE, 0xFB, 0xE0, 0x00, 0x40, 0x0E, 0x01, 0xE0, 0x3E,
  0x07, 0xE0, 0xFC, 0x0F, 0xC1, 0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x03, 0xF0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFE, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0xFC,
  0x07, 0xE0, 0x3E, 0x01, 0xE0, 0x0E, 0x00, 0x40, 0x20, 0x03, 0x80, 0x1E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x7E,
  0x03, 0xF0, 0x1F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0xC0, 0xFE, 0x07, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x0F, 0xC0, 0x7E,
  0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0x3F, 0x01,
  0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x7E, 0x01, 0xE0,
  0x0E, 0x00, 0x20, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0x78, 0x01, 0x01, 0xE0, 0x07, 0x87, 0x87, 0xBF,
  0x9E, 0x7E, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF1, 0xFF, 0xFE, 0x00, 0x7F,
  0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x7D, 0xF0, 0x03, 0xF7, 0xE0,
  0x1F, 0x8F, 0xC0, 0xFC, 0x1F, 0x01, 0xF0, 0x7E, 0x03, 0x80, 0xE0, 0x00,
  0x01, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC,
  0x7E, 0x7F, 0x3F, 0x1F, 0x9F, 0xCF, 0xCF, 0xC3, 0xE0, 0x60, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3E, 0x3F, 0xBF, 0xDF, 0xFF,
  0xFF, 0xF9, 0xFC, 0x78, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0,
  0x3F, 0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0xFF, 0xF1, 0xFF, 0x7F, 0xCF, 0xF1,
  0xFE, 0x7F, 0x07, 0xF7, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07,
  0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF,
  0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F,
  0xDF, 0xC1, 0xFC, 0xFF, 0x1F, 0xE7, 0xFD, 0xFF, 0x1F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x83, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x7F, 0x00,
  0x00, 0x0C, 0x01, 0xF0, 0x1F, 0xC3, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFC, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xFE, 0x07, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE3, 0xFC, 0xFF, 0x9F, 0xE1, 0xFE,
  0x7F, 0x87, 0xF9, 0xFE, 0x1F, 0xE7, 0xF0, 0x3F, 0xBF, 0xC1, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFE, 0x07,
  0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xE7, 0xFC, 0xFF, 0x9F, 0xE1,
  0xFE, 0x7F, 0x83, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x1F, 0xFF, 0x00, 0x7F, 0xF8, 0x01,
  0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE1, 0xFF, 0x7F, 0xCF, 0xF9, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x1F, 0xFE,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x3F,
  0xFC, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0,
  0x7D, 0xFE, 0x07, 0xEF, 0xF0, 0x3F, 0x7F, 0x83, 0xF3, 0xFC, 0x1F, 0x9F,
  0xE1, 0xFC, 0xFF, 0x0F, 0xC7, 0xF8, 0xFE, 0x3F, 0xC7, 0xE1, 0xFE, 0x7F,
  0x0F, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE3, 0xFF,
  0xFF, 0x3F, 0xFF, 0xF9, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF7, 0xE0, 0x3F, 0xFF,
  0xC1, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x87,
  0x83, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE,
  0x1F, 0xEF, 0xF9, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0x87, 0xFF, 0xF8,
  0x1F, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0x80, 0x01,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x3F, 0xFE,
  0x01, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x1F, 0x03, 0xFD, 0xFF, 0x0F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xEF, 0xF8, 0xFF,
  0xBF, 0xC1, 0xFE, 0xFF, 0x07, 0xFB, 0xFC, 0x0F, 0xEF, 0xF0, 0x3F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0xE7, 0xF0, 0x7F, 0x9F, 0xE1,
  0xFE, 0x7F, 0xCF, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xF8,
  0x0F, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F,
  0xFF, 0xF9, 0xFF, 0x7F, 0xCF, 0xF1, 0xFE, 0x7F, 0x8F, 0xF3, 0xFC, 0x7F,
  0x9F, 0xE3, 0xFC, 0xFF, 0x1F, 0xE7, 0xF8, 0xFF, 0x1F, 0xEF, 0xF0, 0xFF,
  0xFF, 0x83, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x07, 0xFF, 0xF8,
  0x7F, 0xFF, 0xC7, 0xF8, 0xFF, 0x3F, 0xC3, 0xFB, 0xFC, 0x1F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x1F, 0xF7,
  0xFD, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC, 0x1F, 0xFF,
  0xC0, 0x7F, 0xFC, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xF0, 0x03,
  0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xF1, 0xFF, 0x7F,
  0xCF, 0xF1, 0xFE, 0xFF, 0x07, 0xF7, 0xF8, 0x3F, 0xBF, 0xC1, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x87, 0xFB, 0xFC, 0x7F, 0xDF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xFF,
  0xFF, 0x8F, 0xFF, 0xF8, 0x3F, 0xDF, 0xC0, 0x7D, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF,
  0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0x80, 0x01,
  0xE0, 0x00, 0x3E, 0x3F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFC, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xC7, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0x8F, 0x80, 0x1F, 0x1F, 0xE7,
  0xF9, 0xFF, 0x7F, 0xDF, 0xE3, 0xF8, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x0F, 0xC7, 0xF1,
  0xF8, 0xFE, 0x3F, 0x0F, 0x80, 0x40, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00,
  0x7C, 0x00, 0x7F, 0x00, 0x7F, 0xC0, 0xFF, 0xF0, 0xFF, 0xFC, 0xFF, 0xFE,
  0xFF, 0xFE, 0x3F, 0xFE, 0x0F, 0xFC, 0x03, 0xFC, 0x00, 0xFF, 0xC0, 0x3F,
  0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xF0, 0x07,
  0xFC, 0x00, 0x7F, 0x00, 0x07, 0xC0, 0x00, 0x70, 0x00, 0x04, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x38, 0x00, 0x0F, 0x80, 0x03, 0xF8, 0x00, 0xFF, 0x80, 0x3F,
  0xF8, 0x0F, 0xFF, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0xC1, 0xFF, 0xF0, 0x0F,
  0xFC, 0x00, 0xFF, 0x00, 0xFF, 0xC1, 0xFF, 0xF1, 0xFF, 0xFD, 0xFF, 0xFC,
  0xFF, 0xFC, 0x3F, 0xF8, 0x0F, 0xF8, 0x03, 0xF8, 0x00, 0xF8, 0x00, 0x38,
  0x00, 0x08, 0x00, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83,
  0xFF, 0xFC, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0xFF, 0x9F, 0xEF, 0xF1, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x1F,
  0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0,
  0x03, 0xFC, 0x00, 0x3F, 0x80, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0xFC,
  0x00, 0x0F, 0x80, 0x3F, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x7E, 0x01, 0xF0, 0x3E, 0x0F, 0x80, 0xFF, 0x83,
  0xE1, 0xF0, 0x3F, 0xFC, 0x7C, 0x7C, 0x0F, 0xFF, 0x8F, 0x8F, 0x83, 0xFF,
  0xF0, 0xF1, 0xF0, 0x7C, 0x7E, 0x1E, 0x7C, 0x1F, 0x8F, 0xC3, 0xEF, 0x83,
  0xE1, 0xF0, 0x7D, 0xF0, 0xFC, 0x3E, 0x0F, 0xBE, 0x1F, 0x87, 0xC1, 0xF7,
  0xC3, 0xE0, 0xF8, 0x3E, 0xF8, 0x7C, 0x1F, 0x07, 0xDF, 0x1F, 0x83, 0xE0,
  0xFB, 0xE3, 0xF0, 0x7C, 0x1E, 0x7C, 0x7E, 0x0F, 0x83, 0xCF, 0x8F, 0xC1,
  0xF0, 0x79, 0xF1, 0xF8, 0x3E, 0x1F, 0x3E, 0x3F, 0x0F, 0xC3, 0xE7, 0xC3,
  0xF1, 0xF8, 0x78, 0xF8, 0x7E, 0x7F, 0x1F, 0x1F, 0x0F, 0xFF, 0xFF, 0xC3,
  0xE0, 0xFF, 0xFF, 0xF8, 0x7E, 0x1F, 0xF7, 0xFE, 0x07, 0xC1, 0xFC, 0x7F,
  0x00, 0xF8, 0x04, 0x03, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x08, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xDF, 0xC0,
  0x00, 0xFE, 0x7F, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x7F, 0x9F, 0xC0, 0x03,
  0xF8, 0xFF, 0x00, 0x1F, 0xC3, 0xF8, 0x01, 0xFE, 0x1F, 0xC0, 0x0F, 0xF0,
  0xFF, 0x00, 0x7F, 0x07, 0xF8, 0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC3, 0xFE, 0x01, 0xFE, 0x1F, 0xE0,
  0x0F, 0xF8, 0xFF, 0x00, 0x3F, 0xCF, 0xF8, 0x01, 0xFE, 0x7F, 0xC0, 0x0F,
  0xFB, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFE, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFE, 0xFF, 0x9F, 0xFE, 0xFF, 0x83, 0xFE, 0xFF, 0x81, 0xFE, 0xFF,
  0x81, 0xFE, 0xFF, 0x81, 0xFE, 0xFF, 0x81, 0xFE, 0xFF, 0x81, 0xFE, 0xFF,
  0x83, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0x83, 0xFE, 0xFF,
  0x81, 0xFE, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x87, 0xFE, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xF0, 0x01,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF8, 0xFF, 0x83, 0xFE, 0x7F, 0x80, 0xFF, 0x7F, 0xC0, 0x7F,
  0xBF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xC0, 0x7F, 0xDF, 0xE0, 0x3F, 0xCF, 0xF8, 0x3F, 0xE7, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xF8,
  0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF8, 0xFF, 0xBF, 0xFC, 0xFF, 0x87, 0xFC, 0xFF, 0x83, 0xFE, 0xFF, 0x81,
  0xFE, 0xFF, 0x81, 0xFE, 0xFF, 0x81, 0xFE, 0xFF, 0x81, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFE, 0xFF, 0x81, 0xFE, 0xFF, 0x81,
  0xFE, 0xFF, 0x83, 0xFE, 0xFF, 0x87, 0xFC, 0xFF, 0x9F, 0xFC, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0x80, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xF8, 0x00, 0x7F,
  0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xF8, 0x01, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFC, 0xFF, 0x81, 0xFE, 0x7F, 0x80, 0xFF, 0xBF, 0xC0, 0x3F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x07, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xBF, 0xC0,
  0x3F, 0xDF, 0xE0, 0x1F, 0xEF, 0xF8, 0x0F, 0xF3, 0xFF, 0xBF, 0xF9, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x01,
  0xFF, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3, 0xFF, 0xFF, 0x1F,
  0xE7, 0xFD, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x1F,
  0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x7F, 0x00, 0xFF, 0x80, 0xFF, 0xFF, 0xE0,
  0x7F, 0xEF, 0xF8, 0x1F, 0xF3, 0xFE, 0x0F, 0xFC, 0xFF, 0x83, 0xFE, 0x3F,
  0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x3F, 0xE0, 0xFF, 0x8F, 0xF8,
  0x3F, 0xE7, 0xFC, 0x0F, 0xF9, 0xFE, 0x03, 0xFE, 0xFF, 0x80, 0xFF, 0xBF,
  0xC0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0x7F,
  0xC0, 0xFF, 0xCF, 0xF8, 0x3F, 0xE3, 0xFE, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE,
  0x1F, 0xF0, 0xFF, 0x87, 0xFE, 0x3F, 0xE0, 0xFF, 0x8F, 0xF8, 0x3F, 0xF3,
  0xFE, 0x07, 0xFC, 0xFF, 0x81, 0xFF, 0x3F, 0xE0, 0x7F, 0xEF, 0xF8, 0x0F,
  0xF8, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0xFC, 0x3F, 0xFF, 0xFF,
  0x7E, 0x3F, 0x7F, 0xFF, 0xBF, 0x1F, 0xBF, 0xFF, 0xDF, 0x8F, 0xDF, 0xFF,
  0xE7, 0xC7, 0xCF, 0xFF, 0xF3, 0xF7, 0xE7, 0xFF, 0xF9, 0xFB, 0xF3, 0xFF,
  0xFC, 0xFD, 0xF9, 0xFF, 0xFE, 0x3E, 0xF8, 0xFF, 0xFF, 0x1F, 0xFC, 0x7F,
  0xFF, 0x8F, 0xFE, 0x3F, 0xFF, 0xE3, 0xFF, 0x1F, 0xFF, 0xF1, 0xFF, 0x0F,
  0xFF, 0xF8, 0xFF, 0x87, 0xFF, 0xFC, 0x7F, 0xC3, 0xFF, 0xFE, 0x1F, 0xC1,
  0xFF, 0xFF, 0x0F, 0xE0, 0xFF, 0xFF, 0x87, 0xF0, 0x7F, 0xFF, 0xC3, 0xF8,
  0x3F, 0xFF, 0xE0, 0xF8, 0x1F, 0xE0, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xBE, 0x7F, 0xFF,
  0xDF, 0xBF, 0xFF, 0xE7, 0xDF, 0xFF, 0xF3, 0xEF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF1, 0xFF, 0x07, 0xFC, 0x7F, 0x80,
  0xFF, 0xBF, 0xE0, 0x1F, 0xEF, 0xF8, 0x07, 0xFB, 0xFC, 0x01, 0xFE, 0xFF,
  0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC,
  0x01, 0xFE, 0xFF, 0x80, 0x7F, 0xBF, 0xE0, 0x1F, 0xE7, 0xF8, 0x0F, 0xF9,
  0xFF, 0x07, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0xFF, 0x87, 0xFE, 0xFF,
  0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0x87, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF1, 0xFF, 0x07,
  0xFC, 0x7F, 0x80, 0xFF, 0xBF, 0xE0, 0x1F, 0xEF, 0xF8, 0x07, 0xFB, 0xFC,
  0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xBF, 0xE0, 0x1F, 0xE7,
  0xF8, 0x0F, 0xF9, 0xFF, 0x07, 0xFE, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x08,
  0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF3, 0xFE, 0x3F, 0xF9, 0xFF,
  0x07, 0xFC, 0xFF, 0x81, 0xFE, 0x7F, 0xC0, 0xFF, 0xBF, 0xE0, 0x7F, 0xDF,
  0xF0, 0x3F, 0xEF, 0xF8, 0x1F, 0xF7, 0xFC, 0x0F, 0xFB, 0xFE, 0x07, 0xF9,
  0xFF, 0x07, 0xFC, 0xFF, 0x8F, 0xFE, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x81, 0xFF, 0x3F, 0xE0, 0xFF, 0x8F, 0xF0, 0x7F, 0xC7, 0xFC, 0x3F, 0xE3,
  0xFE, 0x1F, 0xF0, 0xFF, 0x8F, 0xF8, 0x7F, 0xC7, 0xFC, 0x1F, 0xE3, 0xFE,
  0x0F, 0xF9, 0xFF, 0x07, 0xFC, 0xFF, 0x81, 0xFF, 0x7F, 0xC0, 0xFF, 0xBF,
  0xE0, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x9F, 0xF9, 0xFF, 0x3F,
  0xC1, 0xFF, 0x7F, 0x81, 0xFE, 0xFF, 0x03, 0xFD, 0xFE, 0x07, 0xFB, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF,
  0x80, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF,
  0xC0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x0F, 0xF7,
  0xFE, 0x7F, 0xEF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0x80, 0xFF, 0x7F, 0x81, 0xFF, 0x7F, 0x81, 0xFE, 0x7F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x1F, 0xF7, 0xFC,
  0x01, 0xFF, 0x7F, 0xC0, 0x1F, 0xF7, 0xFC, 0x01, 0xFE, 0x7F, 0xC0, 0x3F,
  0xE3, 0xFC, 0x03, 0xFE, 0x3F, 0xE0, 0x3F, 0xE3, 0xFE, 0x03, 0xFC, 0x1F,
  0xE0, 0x3F, 0xC1, 0xFE, 0x07, 0xFC, 0x1F, 0xE0, 0x7F, 0xC1, 0xFF, 0x07,
  0xF8, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x07, 0xF8, 0x0F, 0xF0, 0xFF, 0x00,
  0xFF, 0x8F, 0xF0, 0x07, 0xF8, 0xFF, 0x00, 0x7F, 0x8F, 0xF0, 0x07, 0xF8,
  0xFE, 0x00, 0x3F, 0x9F, 0xE0, 0x03, 0xF9, 0xFE, 0x00, 0x3F, 0xDF, 0xE0,
  0x03, 0xFD, 0xFC, 0x00, 0x1F, 0xDF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x03,
  0xF8, 0x3F, 0xDF, 0xE0, 0xFF, 0x07, 0xFB, 0xFC, 0x1F, 0xE0, 0xFF, 0x7F,
  0x83, 0xFC, 0x1F, 0xE7, 0xF8, 0x7F, 0x83, 0xFC, 0xFF, 0x0F, 0xF8, 0x7F,
  0x9F, 0xE1, 0xFF, 0x0F, 0xE3, 0xFC, 0x7F, 0xE3, 0xFC, 0x7F, 0x8F, 0xFC,
  0x7F, 0x8F, 0xF1, 0xFF, 0x8F, 0xF0, 0xFE, 0x3F, 0xF1, 0xFE, 0x1F, 0xE7,
  0xFF, 0x3F, 0xC3, 0xFD, 0xFF, 0xE7, 0xF0, 0x7F, 0xBF, 0xFD, 0xFE, 0x0F,
  0xF7, 0xFF, 0xBF, 0xC1, 0xFE, 0xFF, 0xF7, 0xF8, 0x1F, 0xDF, 0xFF, 0xFF,
  0x03, 0xFB, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0x7F, 0xFC, 0x03, 0xFF,
  0xCF, 0xFF, 0x80, 0x7F, 0xF9, 0xFF, 0xF0, 0x0F, 0xFF, 0x3F, 0xFC, 0x01,
  0xFF, 0xE7, 0xFF, 0x80, 0x3F, 0xFC, 0x7F, 0xF0, 0x07, 0xFF, 0x8F, 0xFE,
  0x00, 0x7F, 0xE1, 0xFF, 0xC0, 0x0F, 0xFC, 0x3F, 0xF8, 0x01, 0xFF, 0x87,
  0xFE, 0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x07, 0xFE, 0x0F, 0xF8, 0x00, 0xFF,
  0x81, 0xFF, 0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x3F, 0xEF,
  0xF8, 0x0F, 0xF8, 0xFF, 0x81, 0xFF, 0x1F, 0xF0, 0x3F, 0xC1, 0xFE, 0x0F,
  0xF8, 0x3F, 0xE1, 0xFF, 0x07, 0xFC, 0x3F, 0xC0, 0x7F, 0x8F, 0xF8, 0x0F,
  0xF9, 0xFE, 0x00, 0xFF, 0x3F, 0xC0, 0x1F, 0xEF, 0xF0, 0x01, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFB, 0xFC, 0x00, 0xFF, 0x3F, 0xC0,
  0x3F, 0xE7, 0xF8, 0x07, 0xF8, 0xFF, 0x81, 0xFF, 0x0F, 0xF0, 0x3F, 0xE1,
  0xFF, 0x0F, 0xF8, 0x3F, 0xE1, 0xFF, 0x03, 0xFE, 0x7F, 0xE0, 0x7F, 0xCF,
  0xF8, 0x0F, 0xFD, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0xEF, 0xF0,
  0x07, 0xF9, 0xFF, 0x01, 0xFF, 0x1F, 0xE0, 0x3F, 0xC3, 0xFC, 0x07, 0xF8,
  0x7F, 0xC1, 0xFF, 0x07, 0xF8, 0x3F, 0xC0, 0xFF, 0x07, 0xF8, 0x0F, 0xF1,
  0xFE, 0x01, 0xFE, 0x3F, 0xC0, 0x1F, 0xC7, 0xF8, 0x03, 0xF8, 0xFE, 0x00,
  0x7F, 0xBF, 0xC0, 0x07, 0xF7, 0xF0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xFF,
  0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x7F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3,
  0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF,
  0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF,
  0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC,
  0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x07, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC,
  0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00,
  0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0,
  0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3,
  0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF,
  0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF,
  0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC,
  0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xF0,
  0x1F, 0x7E, 0x07, 0xCF, 0x83, 0xF3, 0xE0, 0xF8, 0xFC, 0x3E, 0x1F, 0x1F,
  0x87, 0xE7, 0xE1, 0xFB, 0xF0, 0x3E, 0xFC, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0x80, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7E, 0x01, 0xFC, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xFF,
  0xC3, 0xFF, 0xFE, 0x3F, 0xFF, 0xF9, 0xFE, 0x3F, 0xCF, 0xF1, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x7F, 0xFC, 0x1F, 0xFF, 0xE1, 0xFF, 0xFF,
  0x1F, 0xFF, 0xF9, 0xFF, 0x3F, 0xCF, 0xF1, 0xFE, 0xFF, 0x0F, 0xF7, 0xF8,
  0x7F, 0xBF, 0xC3, 0xFD, 0xFE, 0x1F, 0xEF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x1F, 0xEF, 0xF0, 0x3E, 0x3F, 0xC0, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x7E, 0x0F, 0xF7, 0xFC, 0x7F, 0xFF, 0xF3,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFC, 0x7F, 0xBF, 0xC1,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x3F, 0xDF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xFC, 0xFF, 0x8F, 0xE3, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0xC1, 0xFF, 0xFE, 0x3F,
  0xFF, 0xE7, 0xFF, 0xFF, 0x7F, 0x8F, 0xF7, 0xF8, 0x7F, 0x7F, 0x07, 0xFF,
  0xF0, 0x7F, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x07, 0xF7, 0xF0, 0x7F, 0x7F, 0x87,
  0xF7, 0xF8, 0xFF, 0x7F, 0xFF, 0xE3, 0xFF, 0xFE, 0x1F, 0xFF, 0xC1, 0xFF,
  0xFC, 0x07, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x07,
  0xCF, 0xF0, 0xFF, 0x7F, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFB, 0xFE, 0x7F, 0xDF, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0,
  0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF,
  0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xBF, 0xC3,
  0xFD, 0xFF, 0x3F, 0xEF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xC7,
  0xFE, 0xFE, 0x1F, 0xE7, 0xF0, 0x3E, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x7F,
  0xF8, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x87, 0xFF, 0xFE, 0x3F, 0xFF, 0xFB,
  0xFE, 0x3F, 0xDF, 0xE0, 0xFE, 0xFF, 0x07, 0xF7, 0xF8, 0x3F, 0xBF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x21, 0xFF, 0x8F,
  0x87, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFC, 0x0F,
  0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x00, 0x10, 0x03, 0xFC, 0x1F, 0xF8, 0x7F,
  0xF0, 0xFF, 0xE3, 0xFF, 0xC7, 0xFF, 0x8F, 0xF0, 0x1F, 0xE0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x0F, 0xFF, 0xDF, 0xFF, 0xBF, 0xFF, 0x7F, 0xFE, 0xFF,
  0xFD, 0xFF, 0xF8, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE,
  0x01, 0xFC, 0x03, 0xF8, 0x00, 0x03, 0xF1, 0xFC, 0x3F, 0xFF, 0xF1, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFC, 0x7F,
  0xDF, 0xE0, 0xFF, 0x7F, 0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x03, 0xFD, 0xFE, 0x0F, 0xF7, 0xF8, 0x3F, 0xDF, 0xF1, 0xFF,
  0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x0F,
  0xFB, 0xFC, 0x0F, 0xCF, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x38, 0x3F, 0xE0, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF3, 0xF0, 0xFF, 0x7F, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x0F, 0xF0, 0x3C, 0x3F, 0xBF, 0xDF, 0xFF, 0xFF, 0xF9,
  0xFC, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF,
  0x7F, 0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0xBF, 0xDF,
  0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0xBF, 0xDF, 0xEF, 0xF0, 0x01,
  0xC0, 0x3F, 0x83, 0xFC, 0x1F, 0xF0, 0xFF, 0x87, 0xF8, 0x1F, 0xC0, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0,
  0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F,
  0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC,
  0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83,
  0xFC, 0x1F, 0xC1, 0xFE, 0x1F, 0xF7, 0xFF, 0xBF, 0xFD, 0xFF, 0xCF, 0xFC,
  0x7F, 0xC3, 0xF8, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC3,
  0xFF, 0xFF, 0x0F, 0xFB, 0xFC, 0x7F, 0xCF, 0xF1, 0xFE, 0x3F, 0xCF, 0xF8,
  0xFF, 0x7F, 0xC3, 0xFD, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xBF, 0xC3,
  0xFC, 0xFF, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0xFC, 0xFF, 0x0F, 0xF3, 0xFC,
  0x3F, 0xEF, 0xF0, 0xFF, 0xBF, 0xC1, 0xFF, 0xFF, 0x07, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x1F, 0x03, 0xF0, 0xFF, 0x7F, 0xC7, 0xF8, 0xFF, 0xFF, 0xEF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0x9F, 0xF9, 0xFF, 0xFF, 0x0F, 0xF0, 0xFF, 0xFF, 0x0F, 0xF0, 0xFF, 0xFF,
  0x0F, 0xF0, 0xFF, 0xFF, 0x0F, 0xF0, 0xFF, 0xFF, 0x0F, 0xF0, 0xFF, 0xFF,
  0x0F, 0xF0, 0xFF, 0xFF, 0x0F, 0xF0, 0xFF, 0xFF, 0x0F, 0xF0, 0xFF, 0xFF,
  0x0F, 0xF0, 0xFF, 0xFF, 0x0F, 0xF0, 0xFF, 0xFF, 0x0F, 0xF0, 0xFF, 0xFF,
  0x0F, 0xF0, 0xFF, 0xFF, 0x0F, 0xF0, 0xFF, 0xFF, 0x0F, 0xF0, 0xFF, 0xFF,
  0x0F, 0xF0, 0xFF, 0xFF, 0x0F, 0xF0, 0xFF, 0xFF, 0x0F, 0xF0, 0xFF, 0xFF,
  0x0F, 0xF0, 0xFF, 0xFF, 0x0F, 0xF0, 0xFF, 0xFE, 0x1F, 0x0F, 0xE7, 0xFC,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF,
  0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xE7, 0xFC, 0xFF, 0x9F, 0xE1, 0xFE, 0x7F, 0x83,
  0xFB, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFD, 0xFE,
  0x0F, 0xF7, 0xF8, 0x7F, 0x9F, 0xF1, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x07, 0xF8, 0x00,
  0xFF, 0x3F, 0x07, 0xFB, 0xFE, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFB, 0xFE, 0x3F, 0xDF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF,
  0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83,
  0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF,
  0xC1, 0xFF, 0xFF, 0x1F, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF,
  0x9F, 0xFF, 0xF8, 0xFF, 0x7F, 0x87, 0xF9, 0xF8, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xE3, 0xF8, 0x7F, 0xDF, 0xC7, 0xFE, 0xFE, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFD, 0xFF, 0x3F, 0xEF, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8,
  0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF,
  0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xDF, 0xE1,
  0xFE, 0xFF, 0x1F, 0xF7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x1F, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x3F,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x83, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0xFF,
  0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0xFF, 0xE7, 0xF9, 0xFE, 0x7F,
  0x0F, 0xF7, 0xF0, 0xFF, 0x7F, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xF0, 0x03,
  0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xFE,
  0x00, 0x7F, 0xEF, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0x7F, 0x9F,
  0xE7, 0xFF, 0xFE, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0x3F,
  0xC0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x0F,
  0xFF, 0xBF, 0xFE, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x83, 0xFF,
  0xC7, 0xFF, 0x1F, 0xFC, 0x7F, 0xF0, 0xFF, 0xC0, 0xFE, 0xFF, 0x0F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0x7F, 0x1F, 0xE7, 0xF0,
  0xFC, 0x7F, 0x7F, 0x83, 0xFD, 0xFE, 0x0F, 0xF7, 0xF8, 0x7F, 0x9F, 0xE1,
  0xFE, 0x3F, 0x87, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x0F, 0xF3, 0xFC,
  0x1F, 0xCF, 0xF0, 0x7F, 0x3F, 0xC1, 0xFC, 0xFE, 0x07, 0xFB, 0xF8, 0x0F,
  0xEF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x07, 0xFF,
  0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0xFE, 0x1F, 0x87, 0xFF, 0xF0, 0xFC, 0x3F, 0xFF, 0x87, 0xF1,
  0xFD, 0xFE, 0x3F, 0x8F, 0xE7, 0xF1, 0xFC, 0x7F, 0x3F, 0x9F, 0xE3, 0xF9,
  0xFC, 0xFF, 0x1F, 0xCF, 0xE7, 0xFD, 0xFC, 0x7F, 0x3F, 0xEF, 0xE3, 0xF9,
  0xFF, 0x7F, 0x0F, 0xDF, 0xFB, 0xF8, 0x7F, 0xFF, 0xDF, 0xC3, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFE, 0xFF, 0xE0, 0xFF, 0xF7, 0xFF, 0x03, 0xFF, 0xBF, 0xF8,
  0x1F, 0xF9, 0xFF, 0xC0, 0xFF, 0xC7, 0xFE, 0x07, 0xFE, 0x3F, 0xE0, 0x3F,
  0xF1, 0xFF, 0x00, 0xFF, 0x0F, 0xF8, 0x07, 0xF8, 0x7F, 0xC0, 0x3F, 0xC1,
  0xFE, 0x01, 0xFE, 0x0F, 0xE0, 0x0F, 0xF0, 0x7F, 0x00, 0x3F, 0x03, 0xF8,
  0x00, 0xFF, 0x07, 0xFF, 0xFC, 0x7F, 0x9F, 0xE3, 0xFC, 0xFF, 0x1F, 0xC3,
  0xFD, 0xFE, 0x1F, 0xEF, 0xF0, 0x7F, 0x7F, 0x03, 0xFF, 0xF8, 0x1F, 0xFF,
  0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03,
  0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0xFF, 0xFE,
  0x07, 0xFF, 0xF0, 0x7F, 0xBF, 0x83, 0xFD, 0xFE, 0x3F, 0xCF, 0xF1, 0xFE,
  0x3F, 0xCF, 0xF1, 0xFE, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xC0, 0xFF, 0x83,
  0xFD, 0xFE, 0x0F, 0xF7, 0xF8, 0x7F, 0xDF, 0xE1, 0xFE, 0x7F, 0x87, 0xF8,
  0xFF, 0x1F, 0xE3, 0xFC, 0xFF, 0x8F, 0xF3, 0xFC, 0x1F, 0xCF, 0xF0, 0x7F,
  0x3F, 0xC1, 0xFE, 0xFE, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF,
  0x80, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x60, 0x1E, 0x03, 0xE0, 0x7F, 0x07, 0xF0, 0xFE, 0x0F, 0xC1, 0xFC,
  0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC,
  0x1F, 0xC1, 0xFC, 0x1F, 0xC3, 0xF8, 0xFF, 0x8F, 0xF0, 0xFE, 0x0F, 0xC0,
  0xFF, 0x0F, 0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC,
  0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC,
  0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x7F, 0x03, 0xE0, 0x1E, 0x00, 0x60, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x20, 0x07, 0x80, 0x7C, 0x07, 0xE0, 0x7F, 0x03, 0xF0, 0x3F, 0x83,
  0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81,
  0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xF0, 0xFF, 0x07, 0xF0,
  0x3F, 0x07, 0xF0, 0xFF, 0x1F, 0xE1, 0xFC, 0x1F, 0xC1, 0xF8, 0x1F, 0x81,
  0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83,
  0xF8, 0x3F, 0x83, 0xF0, 0x7F, 0x07, 0xE0, 0x7C, 0x07, 0x80, 0x20, 0x00,
  0x07, 0x80, 0x00, 0x7F, 0x81, 0xF3, 0xFF, 0x07, 0xDF, 0xFE, 0x3F, 0x7F,
  0xFC, 0xFD, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xBF, 0x0F, 0xFE, 0xFC, 0x1F,
  0xF3, 0xF0, 0x3F, 0x80, 0x00, 0x7C, 0x00,
};

const GFXglyph RobotoCondensed_Black49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 9, 35, 13, 2, -35 },
  { 41, 14, 14, 16, 1, -37 },
  { 66, 22, 35, 25, 1, -35 },
  { 163, 21, 45, 25, 2, -40 },
  { 282, 27, 35, 32, 2, -35 },
  { 401, 27, 36, 29, 1, -35 },
  { 523, 6, 14, 8, 1, -37 },
  { 534, 12, 49, 16, 3, -38 },
  { 608, 13, 49, 16, 1, -38 },
  { 688, 22, 21, 23, 1, -35 },
  { 746, 20, 25, 23, 1, -29 },
  { 809, 9, 15, 13, 1, -6 },
  { 826, 12, 6, 21, 4, -18 },
  { 835, 9, 8, 15, 3, -8 },
  { 844, 15, 38, 15, 0, -35 },
  { 916, 21, 35, 25, 2, -35 },
  { 1008, 14, 35, 25, 4, -35 },
  { 1070, 22, 35, 25, 1, -35 },
  { 1167, 22, 35, 25, 1, -35 },
  { 1264, 21, 35, 25, 2, -35 },
  { 1356, 21, 35, 25, 2, -35 },
  { 1448, 22, 35, 25, 2, -35 },
  { 1545, 22, 35, 25, 1, -35 },
  { 1642, 21, 35, 25, 2, -35 },
  { 1734, 21, 35, 25, 2, -35 },
  { 1826, 9, 27, 14, 3, -27 },
  { 1857, 10, 36, 14, 2, -27 },
  { 1902, 18, 23, 22, 1, -26 },
  { 1954, 19, 16, 25, 3, -23 },
  { 1992, 18, 23, 22, 3, -26 },
  { 2044, 20, 35, 23, 1, -35 },
  { 2132, 35, 45, 38, 1, -34 },
  { 2329, 29, 35, 30, 0, -35 },
  { 2456, 24, 35, 28, 2, -35 },
  { 2561, 25, 35, 28, 2, -35 },
  { 2671, 24, 35, 28, 2, -35 },
  { 2776, 21, 35, 24, 2, -35 },
  { 2868, 20, 35, 23, 2, -35 },
  { 2956, 25, 35, 29, 2, -35 },
  { 3066, 26, 35, 30, 2, -35 },
  { 3180, 8, 35, 14, 3, -35 },
  { 3215, 21, 35, 24, 1, -35 },
  { 3307, 26, 35, 27, 2, -35 },
  { 3421, 20, 35, 23, 2, -35 },
  { 3509, 33, 35, 37, 2, -35 },
  { 3654, 25, 35, 30, 2, -35 },
  { 3764, 26, 35, 30, 2, -35 },
  { 3878, 24, 35, 28, 2, -35 },
  { 3983, 26, 41, 30, 2, -35 },
  { 4117, 25, 35, 28, 2, -35 },
  { 4227, 23, 35, 27, 2, -35 },
  { 4328, 25, 35, 27, 1, -35 },
  { 4438, 24, 35, 28, 2, -35 },
  { 4543, 28, 35, 29, 0, -35 },
  { 4666, 35, 35, 36, 1, -35 },
  { 4820, 27, 35, 28, 0, -35 },
  { 4939, 27, 35, 27, 0, -35 },
  { 5058, 24, 35, 26, 1, -35 },
  { 5163, 10, 49, 13, 2, -41 },
  { 5225, 20, 38, 19, 0, -35 },
  { 5320, 10, 49, 13, 1, -41 },
  { 5382, 18, 17, 20, 1, -35 },
  { 5421, 19, 6, 19, 0, 0 },
  { 5436, 14, 8, 17, 1, -37 },
  { 5450, 21, 26, 23, 1, -26 },
  { 5519, 21, 37, 24, 2, -37 },
  { 5617, 20, 26, 22, 1, -26 },
  { 5682, 21, 37, 24, 1, -37 },
  { 5780, 21, 26, 24, 2, -26 },
  { 5849, 15, 38, 16, 1, -38 },
  { 5921, 22, 36, 25, 1, -26 },
  { 6020, 20, 37, 24, 2, -37 },
  { 6113, 9, 37, 13, 2, -37 },
  { 6155, 13, 47, 13, -2, -37 },
  { 6232, 22, 37, 24, 2, -37 },
  { 6334, 8, 37, 13, 2, -37 },
  { 6371, 32, 26, 36, 2, -26 },
  { 6475, 20, 26, 24, 2, -26 },
  { 6540, 22, 26, 24, 1, -26 },
  { 6612, 21, 36, 24, 2, -26 },
  { 6707, 21, 36, 24, 1, -26 },
  { 6802, 14, 26, 17, 2, -26 },
  { 6848, 20, 26, 22, 1, -26 },
  { 6913, 14, 32, 15, 1, -32 },
  { 6969, 20, 26, 24, 2, -26 },
  { 7034, 22, 26, 23, 0, -26 },
  { 7106, 29, 26, 31, 1, -26 },
  { 7201, 21, 26, 22, 1, -26 },
  { 7270, 22, 36, 23, 0, -26 },
  { 7369, 18, 26, 22, 2, -26 },
  { 7428, 12, 47, 14, 1, -38 },
  { 7499, 5, 41, 13, 4, -35 },
  { 7525, 12, 47, 14, 1, -38 },
  { 7596, 22, 11, 27, 2, -20 },
};

const GFXfont RobotoCondensed_Black49pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Black49pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Black49pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _ROBOTOCONDENSED_BLACK49PT7B_H_
