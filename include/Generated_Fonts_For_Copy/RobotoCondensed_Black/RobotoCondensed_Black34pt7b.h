#ifndef _ROBOTOCONDENSED_BLACK34PT7B_H_
#define _ROBOTOCONDENSED_BLACK34PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Black.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Black34pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF,
  0xBE, 0x00, 0x07, 0x3E, 0xFF, 0xFF, 0x9C, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF,
  0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0x80, 0x07, 0x38, 0x0E, 0x70, 0x1C,
  0xE0, 0x3B, 0xC0, 0xF7, 0x01, 0xCE, 0x03, 0x9C, 0x3F, 0xFF, 0x7F, 0xFE,
  0xFF, 0xFC, 0x3B, 0xC0, 0xF7, 0x81, 0xCE, 0x03, 0x9C, 0x3F, 0xFF, 0x7F,
  0xFE, 0xFF, 0xFC, 0x3B, 0xC0, 0xF7, 0x81, 0xEE, 0x03, 0x9C, 0x07, 0x38,
  0x0E, 0x70, 0x1C, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x3F, 0x01,
  0xFF, 0x07, 0xFF, 0x0F, 0xFF, 0x3F, 0x3E, 0x7E, 0x7E, 0xFC, 0xFD, 0xF8,
  0xFB, 0xF0, 0x03, 0xF0, 0x07, 0xF8, 0x07, 0xFC, 0x07, 0xFC, 0x03, 0xFC,
  0x01, 0xF8, 0x01, 0xFF, 0xE3, 0xFF, 0xC7, 0xEF, 0x8F, 0xDF, 0x9F, 0xBF,
  0xFE, 0x3F, 0xFC, 0x3F, 0xF0, 0x1F, 0x80, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x3E, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0x9E, 0x38, 0xE7, 0x8E,
  0x39, 0xE7, 0x0E, 0x7B, 0xC3, 0x9E, 0xE0, 0xFF, 0x78, 0x1F, 0xDC, 0x03,
  0xCE, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x77, 0xC0, 0x3B, 0xF8, 0x1F,
  0xFF, 0x07, 0x79, 0xC3, 0xDC, 0x70, 0xE7, 0x1C, 0x71, 0xC7, 0x1C, 0x79,
  0xC2, 0x1F, 0xF0, 0x03, 0xF8, 0x00, 0x7C, 0x07, 0xC0, 0x01, 0xFE, 0x00,
  0x7F, 0xC0, 0x1F, 0xFC, 0x03, 0xEF, 0x80, 0x7C, 0xF0, 0x0F, 0x1E, 0x01,
  0xF3, 0xC0, 0x3E, 0xF8, 0x07, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x03,
  0xFC, 0x78, 0xFF, 0xCF, 0x1F, 0xFF, 0xE7, 0xFF, 0xFC, 0xF9, 0xFF, 0x9F,
  0x1F, 0xE3, 0xF3, 0xFC, 0x7F, 0x7F, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F,
  0xFF, 0xE0, 0x7E, 0x7E, 0xFF, 0xFF, 0xFF, 0xEE, 0xEE, 0x02, 0x07, 0x0F,
  0x1E, 0x1E, 0x3C, 0x3C, 0x78, 0x78, 0x78, 0x78, 0xF8, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF8, 0x78, 0x78, 0x78, 0x78,
  0x3C, 0x3C, 0x1E, 0x1E, 0x0F, 0x07, 0x02, 0x40, 0x70, 0x3C, 0x0F, 0x07,
  0x81, 0xE0, 0xF0, 0x3C, 0x1E, 0x0F, 0x87, 0xC3, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0xC3, 0xC1, 0xE0, 0xF0, 0x78, 0x7C, 0x3E, 0x1F, 0x0F,
  0x07, 0x87, 0x83, 0xC3, 0xC1, 0xE1, 0xE0, 0xE0, 0x20, 0x00, 0x03, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x61, 0xC6, 0x7D, 0xDE, 0x7F, 0xFF,
  0x1F, 0xFC, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0xF0, 0x1E, 0x78, 0x3C, 0x78,
  0x1C, 0x38, 0x08, 0x10, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7D, 0xF7,
  0xDF, 0x7D, 0xF7, 0x9E, 0xFB, 0xC6, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x31,
  0xFF, 0xFF, 0xFD, 0xE0, 0x03, 0xC0, 0xF0, 0x3C, 0x1E, 0x07, 0x81, 0xE0,
  0x78, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0xF0,
  0x3C, 0x0F, 0x03, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x03, 0xC0, 0xF0, 0x3C,
  0x00, 0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xE1, 0xFF, 0xE7, 0xEF, 0xCF, 0x8F,
  0x9F, 0x1F, 0xBE, 0x3F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE1, 0xFF,
  0xC3, 0xFF, 0x87, 0xFF, 0x0F, 0xFE, 0x3F, 0x7C, 0x7E, 0xF8, 0xFD, 0xF1,
  0xF3, 0xF7, 0xE3, 0xFF, 0xC7, 0xFF, 0x07, 0xFC, 0x03, 0xE0, 0x00, 0x83,
  0xC7, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x07, 0xE0, 0x3F, 0xE0, 0xFF, 0xE3, 0xFF, 0xE7, 0xEF, 0xDF, 0x8F,
  0xBF, 0x1F, 0xFC, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0xFC,
  0x03, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xC0,
  0x3F, 0xE0, 0xFF, 0xE3, 0xFF, 0xE7, 0xEF, 0xDF, 0x8F, 0xFF, 0x1F, 0x80,
  0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x1F, 0xE0, 0x3F, 0x80, 0x7F, 0x80, 0xFF,
  0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0xF0, 0x7F, 0xF1, 0xFF, 0xF7, 0xF7,
  0xFF, 0xCF, 0xFF, 0x8F, 0xFC, 0x07, 0xE0, 0x00, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0xFF, 0x01, 0xFE, 0x07, 0xFC, 0x0F, 0xF8,
  0x3D, 0xF0, 0x7B, 0xE1, 0xE7, 0xC3, 0xCF, 0x8F, 0x9F, 0x1E, 0x3E, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x3F, 0xFC, 0x7F, 0xF8, 0xFF, 0xF3, 0xFF, 0xE7,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7D, 0xE0, 0xFF, 0xF1, 0xFF,
  0xF3, 0xFF, 0xE3, 0x87, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7F,
  0xF8, 0xFF, 0xF1, 0xFB, 0xF7, 0xE7, 0xFF, 0xC7, 0xFF, 0x07, 0xFC, 0x03,
  0xE0, 0x00, 0xF0, 0x07, 0xE0, 0x3F, 0xC0, 0xFF, 0x81, 0xFE, 0x07, 0xE0,
  0x0F, 0x80, 0x3F, 0x00, 0x7D, 0xF0, 0xFF, 0xF3, 0xFF, 0xF7, 0xFF, 0xFF,
  0xEF, 0xFF, 0x8F, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x3E, 0xF8, 0x7D, 0xF1,
  0xFB, 0xF7, 0xF3, 0xFF, 0xC3, 0xFF, 0x03, 0xFE, 0x03, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00,
  0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7C,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x01,
  0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x07, 0xE0, 0x3F, 0xE0, 0xFF,
  0xE3, 0xFF, 0xE7, 0xEF, 0xCF, 0xCF, 0x9F, 0x1F, 0x3E, 0x3E, 0x7E, 0x7C,
  0x7D, 0xF8, 0xFF, 0xE0, 0xFF, 0x81, 0xFF, 0x87, 0xFF, 0x9F, 0x9F, 0x3E,
  0x3F, 0x7C, 0x7F, 0xF8, 0xFD, 0xF1, 0xFB, 0xF7, 0xF7, 0xFF, 0xC7, 0xFF,
  0x87, 0xFE, 0x03, 0xF0, 0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xE1, 0xFF, 0xC7,
  0xEF, 0xCF, 0x8F, 0x9F, 0x1F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF8, 0xFD, 0xF1,
  0xFB, 0xF3, 0xF7, 0xFF, 0xE7, 0xFF, 0xC7, 0xFF, 0x87, 0xBE, 0x00, 0x7C,
  0x01, 0xF8, 0x07, 0xE0, 0x7F, 0xC0, 0xFF, 0x01, 0xFC, 0x03, 0xF0, 0x07,
  0x00, 0x31, 0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC7,
  0xFF, 0xFF, 0xF7, 0x80, 0x18, 0xF9, 0xFB, 0xF7, 0xE7, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x9F,
  0x3C, 0xF0, 0x60, 0x00, 0x10, 0x07, 0x01, 0xF0, 0x7F, 0x1F, 0xF7, 0xFE,
  0xFF, 0x8F, 0xC0, 0xFC, 0x0F, 0xF8, 0x7F, 0xE1, 0xFF, 0x07, 0xF0, 0x1F,
  0x00, 0x70, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x80, 0x0E, 0x00,
  0xF8, 0x0F, 0xE0, 0xFF, 0x87, 0xFF, 0x1F, 0xF0, 0x3F, 0x03, 0xF1, 0xFF,
  0x7F, 0xFF, 0xF8, 0xFE, 0x0F, 0x80, 0xE0, 0x08, 0x00, 0x0F, 0xC1, 0xFF,
  0x1F, 0xFD, 0xFF, 0xFF, 0xDF, 0xFC, 0x7F, 0xE3, 0xE0, 0x1F, 0x01, 0xF8,
  0x0F, 0x80, 0xFC, 0x0F, 0xC0, 0xFC, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0x3E, 0x00, 0xE0,
  0x00, 0x7F, 0x00, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x07, 0xC0, 0xF8,
  0x0F, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x3C, 0x1F, 0x0E,
  0x38, 0x7F, 0x8E, 0x78, 0xFF, 0xCE, 0x70, 0xF3, 0x8F, 0x71, 0xE3, 0x8F,
  0xF1, 0xE3, 0x87, 0xF1, 0xC3, 0x87, 0xF3, 0xC3, 0x87, 0xF3, 0xC7, 0x8F,
  0xF3, 0xC7, 0x8E, 0xF3, 0xC7, 0x8E, 0xF3, 0xC7, 0x8E, 0xF3, 0xEF, 0x9E,
  0xF1, 0xFF, 0xFC, 0x71, 0xFB, 0xF8, 0x70, 0xF1, 0xF0, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xC3, 0x80,
  0x0F, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xE0,
  0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xDF, 0x00, 0x7D, 0xF0, 0x0F, 0xDF,
  0x00, 0xF9, 0xF8, 0x0F, 0x8F, 0x81, 0xF8, 0xF8, 0x1F, 0x8F, 0x81, 0xFF,
  0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x7E,
  0x07, 0xE7, 0xE0, 0x3F, 0x7E, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0xFF,
  0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0xF8, 0x3E, 0xF8, 0x3F, 0xF8,
  0x3F, 0xF8, 0x3E, 0xF8, 0x7E, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xFC, 0xFF,
  0xFE, 0xF8, 0x3E, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF0, 0x03, 0xF0, 0x03,
  0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x7F, 0xFF, 0x9F, 0x87, 0xE7, 0xC0,
  0xFB, 0xF0, 0x3E, 0xFC, 0x0F, 0xFF, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0xFC, 0x0F, 0x9F,
  0x03, 0xE7, 0xE1, 0xF9, 0xFF, 0xFE, 0x3F, 0xFF, 0x07, 0xFF, 0x80, 0xFF,
  0xC0, 0x0F, 0xC0, 0xFF, 0xC0, 0xFF, 0xF0, 0xFF, 0xF8, 0xFF, 0xFC, 0xFF,
  0xFC, 0xF8, 0x7E, 0xF8, 0x3E, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8,
  0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8,
  0x3F, 0xF8, 0x3E, 0xF8, 0x7E, 0xF9, 0xFC, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF,
  0xF0, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xFF, 0xBF, 0xFE,
  0xFF, 0xFB, 0xFF, 0xEF, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0x03, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0xFE, 0x7F, 0xFF, 0x9F,
  0x83, 0xE7, 0xE0, 0xFD, 0xF0, 0x3F, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF1, 0xFF, 0xFC, 0x7F, 0xFF, 0x1F, 0xFF, 0xC7, 0xFF, 0xF0, 0x3F,
  0x7C, 0x0F, 0xDF, 0x83, 0xF7, 0xE0, 0xFD, 0xFF, 0xFF, 0x3F, 0xFF, 0xC7,
  0xFF, 0xE0, 0xFF, 0xF0, 0x0F, 0xE0, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07,
  0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8,
  0x1F, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03,
  0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0xF8, 0xFF, 0xE3, 0xFF, 0xCF,
  0xFF, 0xFF, 0x7F, 0xF9, 0xFF, 0xC3, 0xFE, 0x03, 0xF0, 0xF8, 0x3F, 0xFC,
  0x1F, 0xBE, 0x1F, 0xDF, 0x0F, 0xCF, 0x8F, 0xE7, 0xC7, 0xE3, 0xE7, 0xE1,
  0xF3, 0xF0, 0xFB, 0xF0, 0x7D, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFF,
  0x07, 0xFF, 0x83, 0xFF, 0xE1, 0xFF, 0xF0, 0xFD, 0xFC, 0x7C, 0x7E, 0x3E,
  0x3F, 0x9F, 0x0F, 0xCF, 0x87, 0xF7, 0xC3, 0xFB, 0xE0, 0xFD, 0xF0, 0x7F,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1,
  0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0xF7, 0xFE, 0xF3, 0xDF,
  0xFB, 0xCF, 0x7F, 0xEF, 0x3D, 0xFF, 0xBD, 0xE7, 0xFE, 0x7F, 0x9F, 0xF9,
  0xFE, 0x7F, 0xE7, 0xFB, 0xFF, 0x8F, 0xCF, 0xFE, 0x3F, 0x3F, 0xF8, 0xFC,
  0xFF, 0xE3, 0xE3, 0xFF, 0x87, 0x8F, 0xFE, 0x1E, 0x3F, 0xFC, 0x1F, 0xFE,
  0x0F, 0xFF, 0x07, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xF8, 0xFF, 0xFC, 0x7F,
  0xFE, 0x3F, 0xFF, 0x9F, 0xFF, 0xCF, 0xFE, 0xF7, 0xFF, 0x7B, 0xFF, 0x9D,
  0xFF, 0xCF, 0xFF, 0xE3, 0xFF, 0xF1, 0xFF, 0xF8, 0xFF, 0xFC, 0x3F, 0xFE,
  0x1F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F,
  0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xF0, 0xFF, 0xFC, 0x7F, 0xFF, 0x9F,
  0x87, 0xE7, 0xE0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0,
  0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F,
  0xFC, 0x0F, 0xDF, 0x83, 0xF7, 0xE1, 0xF9, 0xFF, 0xFE, 0x3F, 0xFF, 0x07,
  0xFF, 0xC0, 0xFF, 0xC0, 0x0F, 0xC0, 0xFF, 0xE0, 0xFF, 0xF8, 0xFF, 0xFC,
  0xFF, 0xFE, 0xFF, 0xFE, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F,
  0xF8, 0x3F, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8,
  0xFF, 0xE0, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0x81, 0xFF,
  0xF0, 0xFF, 0xFC, 0x7F, 0xFF, 0x9F, 0x87, 0xF7, 0xE0, 0xFD, 0xF0, 0x3F,
  0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0x7C, 0x0F, 0xDF, 0x83, 0xF7, 0xE1,
  0xFD, 0xFF, 0xFE, 0x3F, 0xFF, 0x87, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x70, 0x00, 0x08, 0xFF, 0xE0, 0xFF,
  0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8,
  0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3E, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFC, 0xFF, 0xF0, 0xFF, 0xF8, 0xF9, 0xF8, 0xF8, 0xFC, 0xF8, 0xFC, 0xF8,
  0xFE, 0xF8, 0x7E, 0xF8, 0x7E, 0xF8, 0x3F, 0xF8, 0x3F, 0x07, 0xF0, 0x0F,
  0xFE, 0x0F, 0xFF, 0x87, 0xFF, 0xE7, 0xF7, 0xF3, 0xF0, 0xF9, 0xF0, 0x7E,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x7F,
  0xC0, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0xFC, 0x1F, 0x7E, 0x0F, 0xBF,
  0x07, 0xCF, 0xEF, 0xE7, 0xFF, 0xF1, 0xFF, 0xF0, 0x7F, 0xF0, 0x07, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8,
  0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8,
  0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8,
  0x3F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFF, 0xFE, 0x7F, 0xFE, 0x7F, 0xFC, 0x3F,
  0xF8, 0x0F, 0xE0, 0xFE, 0x07, 0xF7, 0xE0, 0x7E, 0x7E, 0x07, 0xE7, 0xE0,
  0x7E, 0x7E, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x1F,
  0x0F, 0x81, 0xF1, 0xF8, 0x1F, 0x9F, 0x81, 0xF9, 0xF8, 0x0F, 0x9F, 0x00,
  0xF9, 0xF0, 0x0F, 0xBF, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0,
  0x07, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8,
  0x00, 0x1F, 0x80, 0xF8, 0x7C, 0x3F, 0xF8, 0x7C, 0x3E, 0xFC, 0x7C, 0x3E,
  0xFC, 0x7E, 0x3E, 0xFC, 0xFE, 0x7E, 0xFC, 0xFE, 0x7E, 0x7C, 0xFE, 0x7E,
  0x7C, 0xFE, 0x7C, 0x7C, 0xFF, 0x7C, 0x7F, 0xFF, 0x7C, 0x7F, 0xFF, 0x7C,
  0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xEF, 0xF8, 0x3F, 0xEF, 0xF8,
  0x3F, 0xEF, 0xF8, 0x3F, 0xEF, 0xF8, 0x1F, 0xEF, 0xF8, 0x1F, 0xE7, 0xF8,
  0x1F, 0xC7, 0xF0, 0x1F, 0xC7, 0xF0, 0x1F, 0xC7, 0xF0, 0x1F, 0xC7, 0xF0,
  0x0F, 0xC3, 0xF0, 0x7E, 0x0F, 0xEF, 0xC1, 0xF8, 0xFC, 0x7F, 0x1F, 0x8F,
  0xC3, 0xF1, 0xF8, 0x3F, 0x7E, 0x07, 0xEF, 0xC0, 0x7D, 0xF0, 0x0F, 0xFE,
  0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF8,
  0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xBE, 0x03, 0xF7, 0xE0, 0x7E, 0xFC,
  0x1F, 0x8F, 0xC3, 0xF1, 0xF8, 0xFE, 0x3F, 0x9F, 0x83, 0xF7, 0xF0, 0x7F,
  0xFC, 0x0F, 0xCF, 0xC1, 0xF9, 0xF8, 0x3F, 0x1F, 0x0F, 0xC3, 0xF1, 0xF8,
  0x7E, 0x3E, 0x07, 0xC7, 0xC0, 0xF9, 0xF8, 0x0F, 0xBE, 0x01, 0xF7, 0xC0,
  0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7E, 0x00, 0x7C, 0x00,
  0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3E, 0x00, 0x7E,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE,
  0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xFF, 0xFF, 0xF0, 0xFC,
  0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x0F,
  0xC0, 0x1F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x3F, 0x00,
  0x7C, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0xFF, 0xFF, 0xFF,
  0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF,
  0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0x01, 0xF0, 0x1F, 0x81, 0xF8, 0x3F, 0x83, 0xFC, 0x3B, 0xC7, 0x9C, 0x79,
  0xE7, 0x1E, 0xF0, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFC, 0x3F, 0x0F, 0x83, 0xE0, 0xF8, 0x0F, 0xC0, 0xFF, 0xC7, 0xFF, 0x9F,
  0xFE, 0xFC, 0xFB, 0xF3, 0xE0, 0x0F, 0x83, 0xFE, 0x3F, 0xF9, 0xFF, 0xEF,
  0xCF, 0xBE, 0x3E, 0xF8, 0xFB, 0xE3, 0xEF, 0xFF, 0xBF, 0xFF, 0x7F, 0xFC,
  0x79, 0xF0, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xFB, 0xE3, 0xFF, 0xCF, 0xFF, 0xBF, 0xFE, 0xFD,
  0xFF, 0xE3, 0xFF, 0x8F, 0xFE, 0x3F, 0xF8, 0xFF, 0xE3, 0xFF, 0x8F, 0xFE,
  0x3F, 0xF8, 0xFF, 0xF3, 0xFF, 0xFF, 0xBF, 0xFE, 0xFF, 0xF3, 0xCF, 0x80,
  0x0F, 0xC0, 0xFF, 0xC7, 0xFF, 0x9F, 0xFE, 0xFC, 0xFB, 0xF1, 0xFF, 0x87,
  0xFE, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x1F, 0xFC, 0x7F, 0xF3,
  0xE7, 0xFF, 0x9F, 0xFE, 0x3F, 0xF0, 0x3F, 0x00, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x1F, 0x7C,
  0xFF, 0xF7, 0xFF, 0xDF, 0xFF, 0xFC, 0xFF, 0xF1, 0xFF, 0x87, 0xFE, 0x1F,
  0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xFC, 0x7F, 0xF3, 0xF7, 0xFF,
  0xDF, 0xFF, 0x3F, 0xFC, 0x7D, 0xF0, 0x0F, 0xE0, 0x3F, 0xE0, 0xFF, 0xE3,
  0xFF, 0xE7, 0xEF, 0xDF, 0x8F, 0xBF, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xC0, 0x0F, 0xC7, 0x1F, 0xFF, 0x1F, 0xFE,
  0x1F, 0xF8, 0x0F, 0xC0, 0x03, 0xE1, 0xFC, 0x7F, 0x8F, 0xF1, 0xF8, 0x7E,
  0x0F, 0xC1, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0x0F, 0x3E, 0x7F, 0xFD, 0xFF, 0xFB, 0xFF, 0xFF,
  0xEF, 0xFF, 0x8F, 0xFF, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE1,
  0xFF, 0xC3, 0xFF, 0xC7, 0xFF, 0xDF, 0xDF, 0xFF, 0xBF, 0xFF, 0x3F, 0xFE,
  0x1E, 0xFC, 0x01, 0xF8, 0x03, 0xF1, 0x8F, 0xC7, 0xFF, 0x8F, 0xFE, 0x1F,
  0xF8, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFD, 0xF3, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xF1, 0xFF, 0xC7, 0xFF, 0x1F, 0xFC, 0x7F, 0xF1, 0xFF, 0xC7,
  0xFF, 0x1F, 0xFC, 0x7F, 0xF1, 0xFF, 0xC7, 0xFF, 0x1F, 0xFC, 0x7F, 0xF1,
  0xF0, 0x7D, 0xFF, 0xDF, 0x38, 0x00, 0x1F, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7,
  0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7C, 0x1F, 0x1F, 0x3F, 0x1F,
  0x0E, 0x00, 0x00, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x3F,
  0xFF, 0xFE, 0xFC, 0xF8, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0xFD, 0xF3, 0xFB, 0xE7,
  0xE7, 0xDF, 0x8F, 0xBE, 0x1F, 0xFC, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1,
  0xFF, 0xC3, 0xFF, 0x87, 0xFF, 0x8F, 0xBF, 0x1F, 0x3F, 0x3E, 0x7E, 0x7C,
  0x7E, 0xF8, 0xFD, 0xF1, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF9, 0xE1,
  0xE3, 0xFF, 0xDF, 0xCF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFD, 0xFD, 0xFB,
  0xE3, 0xE3, 0xEF, 0x8F, 0x8F, 0xFE, 0x3E, 0x3F, 0xF8, 0xF8, 0xFF, 0xE3,
  0xE3, 0xFF, 0x8F, 0x8F, 0xFE, 0x3E, 0x3F, 0xF8, 0xF8, 0xFF, 0xE3, 0xE3,
  0xFF, 0x8F, 0x8F, 0xFE, 0x3E, 0x3F, 0xF8, 0xF8, 0xFF, 0xE3, 0xE3, 0xF0,
  0xFC, 0xF3, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xF1, 0xFF, 0xC7,
  0xFF, 0x1F, 0xFC, 0x7F, 0xF1, 0xFF, 0xC7, 0xFF, 0x1F, 0xFC, 0x7F, 0xF1,
  0xFF, 0xC7, 0xFF, 0x1F, 0xFC, 0x7F, 0xF1, 0xF0, 0x0F, 0xC0, 0x3F, 0xE0,
  0xFF, 0xE3, 0xFF, 0xE7, 0xEF, 0xDF, 0x8F, 0xFF, 0x1F, 0xFC, 0x3F, 0xF8,
  0x7F, 0xF0, 0xFF, 0xE1, 0xFF, 0xE3, 0xFF, 0xC7, 0xEF, 0xDF, 0x9F, 0xFF,
  0x1F, 0xFC, 0x1F, 0xF0, 0x1F, 0x80, 0xFB, 0xE3, 0xFF, 0xCF, 0xFF, 0xBF,
  0xFE, 0xFD, 0xFF, 0xE3, 0xFF, 0x8F, 0xFE, 0x3F, 0xF8, 0xFF, 0xE3, 0xFF,
  0x8F, 0xFE, 0x3F, 0xF8, 0xFF, 0xF3, 0xFF, 0xFF, 0xBF, 0xFE, 0xFF, 0xF3,
  0xEF, 0x8F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x00, 0x1F, 0x3C, 0xFF, 0xF7, 0xFF, 0xDF, 0xFF, 0xFC, 0xFF, 0xF1,
  0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xFC,
  0x7F, 0xF3, 0xF7, 0xFF, 0xDF, 0xFF, 0x3F, 0xFC, 0x7D, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0xFD, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x00, 0x0F, 0xC1, 0xFF,
  0x9F, 0xFD, 0xFF, 0xFF, 0x8F, 0xFC, 0x7F, 0xF0, 0x0F, 0xE0, 0x7F, 0xE0,
  0xFF, 0x83, 0xFE, 0x07, 0xFF, 0x8F, 0xFC, 0x7F, 0xFF, 0xEF, 0xFF, 0x3F,
  0xF0, 0x7E, 0x00, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xFC, 0x7F, 0x1F, 0xC1, 0xF0, 0xFC, 0x7F, 0xF1, 0xFF, 0xC7,
  0xFF, 0x1F, 0xFC, 0x7F, 0xF1, 0xFF, 0xC7, 0xFF, 0x1F, 0xFC, 0x7F, 0xF1,
  0xFF, 0xC7, 0xFF, 0x1F, 0xFC, 0x7D, 0xFB, 0xF7, 0xFF, 0xDF, 0xFF, 0x3F,
  0xFC, 0x79, 0xF0, 0xFC, 0x7E, 0xF8, 0xFD, 0xF1, 0xFB, 0xF3, 0xE7, 0xE7,
  0xC7, 0xCF, 0x8F, 0xBF, 0x1F, 0x7C, 0x1E, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0,
  0xFF, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x7C, 0x79, 0xFB, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x1E, 0x7E, 0xF8, 0xF7, 0xF7, 0xC7, 0xFF, 0xBC, 0x3F, 0xFF,
  0xE1, 0xFE, 0xFF, 0x0F, 0xF7, 0xF8, 0x3F, 0xBF, 0xC1, 0xFC, 0xFC, 0x0F,
  0xC7, 0xE0, 0x7E, 0x3F, 0x03, 0xF1, 0xF8, 0x0F, 0x8F, 0xC0, 0x7C, 0x3C,
  0x00, 0x7C, 0x7E, 0xFC, 0xFC, 0xF9, 0xF1, 0xF7, 0xE3, 0xFF, 0x83, 0xFF,
  0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0xC1,
  0xFF, 0x87, 0xFF, 0x0F, 0x9F, 0x3F, 0x3E, 0x7E, 0x7E, 0xF8, 0x7C, 0xFC,
  0x3E, 0x7C, 0x7E, 0x7C, 0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0x3E, 0xFC, 0x3E,
  0xFC, 0x3E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3E,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x01, 0xF8, 0x1F,
  0x80, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x3F, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x02, 0x0E, 0x1F, 0x1E, 0x3E,
  0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3C, 0x7C, 0xFC, 0xF8, 0xF0,
  0xF8, 0x7C, 0x3C, 0x3C, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E,
  0x1E, 0x1F, 0x0E, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x40, 0xF0, 0xF8, 0x78, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C,
  0x7C, 0x7C, 0x7C, 0x3C, 0x3E, 0x3F, 0x1F, 0x0F, 0x1F, 0x3E, 0x3C, 0x7C,
  0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x78, 0xF8, 0x70, 0x40,
  0x1E, 0x00, 0x3F, 0x0F, 0x7F, 0x8F, 0x7F, 0xDF, 0x7B, 0xFE, 0x79, 0xFE,
  0xF0, 0xFC, 0x00, 0x78,
};

const GFXglyph RobotoCondensed_Black34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 6, 24, 9, 2, -24 },
  { 19, 10, 9, 11, 0, -26 },
  { 31, 15, 24, 17, 1, -24 },
  { 76, 15, 30, 17, 1, -27 },
  { 133, 18, 24, 22, 2, -24 },
  { 187, 19, 24, 20, 1, -24 },
  { 244, 4, 10, 5, 1, -26 },
  { 249, 8, 34, 11, 2, -27 },
  { 283, 9, 34, 11, 1, -27 },
  { 322, 16, 15, 16, 0, -24 },
  { 352, 14, 17, 16, 1, -20 },
  { 382, 6, 11, 9, 1, -4 },
  { 391, 8, 4, 14, 3, -12 },
  { 395, 6, 6, 10, 2, -6 },
  { 400, 10, 26, 11, 0, -24 },
  { 433, 15, 24, 17, 1, -24 },
  { 478, 9, 24, 17, 3, -24 },
  { 505, 15, 24, 17, 1, -24 },
  { 550, 15, 24, 17, 1, -24 },
  { 595, 15, 24, 17, 1, -24 },
  { 640, 15, 24, 17, 1, -24 },
  { 685, 15, 24, 17, 1, -24 },
  { 730, 15, 24, 17, 1, -24 },
  { 775, 15, 24, 17, 1, -24 },
  { 820, 15, 24, 17, 1, -24 },
  { 865, 6, 19, 10, 2, -19 },
  { 880, 7, 26, 10, 1, -19 },
  { 903, 12, 16, 15, 1, -18 },
  { 927, 13, 11, 18, 2, -16 },
  { 945, 12, 16, 15, 2, -18 },
  { 969, 13, 24, 16, 1, -24 },
  { 1008, 24, 31, 26, 1, -23 },
  { 1101, 20, 24, 21, 0, -24 },
  { 1161, 16, 24, 19, 2, -24 },
  { 1209, 18, 24, 19, 1, -24 },
  { 1263, 16, 24, 19, 2, -24 },
  { 1311, 14, 24, 17, 2, -24 },
  { 1353, 13, 24, 16, 2, -24 },
  { 1392, 18, 24, 20, 1, -24 },
  { 1446, 17, 24, 21, 2, -24 },
  { 1497, 6, 24, 10, 2, -24 },
  { 1515, 14, 24, 17, 1, -24 },
  { 1557, 17, 24, 19, 2, -24 },
  { 1608, 13, 24, 16, 2, -24 },
  { 1647, 22, 24, 26, 2, -24 },
  { 1713, 17, 24, 21, 2, -24 },
  { 1764, 18, 24, 21, 1, -24 },
  { 1818, 16, 24, 20, 2, -24 },
  { 1866, 18, 28, 21, 1, -24 },
  { 1929, 16, 24, 19, 2, -24 },
  { 1977, 17, 24, 19, 1, -24 },
  { 2028, 17, 24, 19, 1, -24 },
  { 2079, 16, 24, 20, 2, -24 },
  { 2127, 20, 24, 20, 0, -24 },
  { 2187, 24, 24, 25, 1, -24 },
  { 2259, 19, 24, 19, 0, -24 },
  { 2316, 19, 24, 19, 0, -24 },
  { 2373, 16, 24, 18, 1, -24 },
  { 2421, 6, 34, 9, 2, -28 },
  { 2447, 14, 26, 13, 0, -24 },
  { 2493, 6, 34, 9, 1, -28 },
  { 2519, 12, 12, 14, 1, -24 },
  { 2537, 13, 4, 13, 0, 0 },
  { 2544, 9, 5, 12, 1, -25 },
  { 2550, 14, 18, 16, 1, -18 },
  { 2582, 14, 26, 17, 2, -26 },
  { 2628, 14, 18, 16, 1, -18 },
  { 2660, 14, 26, 17, 1, -26 },
  { 2706, 15, 18, 16, 1, -18 },
  { 2740, 11, 26, 11, 0, -26 },
  { 2776, 15, 25, 17, 1, -18 },
  { 2823, 14, 26, 17, 1, -26 },
  { 2869, 6, 25, 9, 1, -25 },
  { 2888, 8, 32, 9, -1, -25 },
  { 2920, 15, 26, 17, 2, -26 },
  { 2969, 5, 26, 9, 2, -26 },
  { 2986, 22, 18, 25, 2, -18 },
  { 3036, 14, 18, 17, 1, -18 },
  { 3068, 15, 18, 17, 1, -18 },
  { 3102, 14, 25, 17, 2, -18 },
  { 3146, 14, 25, 17, 1, -18 },
  { 3190, 10, 18, 12, 1, -18 },
  { 3213, 13, 18, 15, 1, -18 },
  { 3243, 10, 22, 11, 0, -22 },
  { 3271, 14, 18, 17, 1, -18 },
  { 3303, 15, 18, 16, 0, -18 },
  { 3337, 21, 18, 21, 0, -18 },
  { 3385, 15, 18, 16, 0, -18 },
  { 3419, 16, 25, 16, 0, -18 },
  { 3469, 13, 18, 16, 1, -18 },
  { 3499, 8, 33, 10, 1, -27 },
  { 3532, 3, 28, 9, 3, -24 },
  { 3543, 8, 33, 10, 1, -27 },
  { 3576, 16, 8, 18, 1, -14 },
};

const GFXfont RobotoCondensed_Black34pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Black34pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Black34pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _ROBOTOCONDENSED_BLACK34PT7B_H_
