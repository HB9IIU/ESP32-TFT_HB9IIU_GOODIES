#ifndef _ROBOTOCONDENSED_BLACK33PT7B_H_
#define _ROBOTOCONDENSED_BLACK33PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Black.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Black33pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x1D, 0xFF, 0xFD, 0xC0, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xEF,
  0x3B, 0xCE, 0xF3, 0x80, 0x07, 0x78, 0x0E, 0xE0, 0x3D, 0xC0, 0x73, 0x80,
  0xE7, 0x01, 0xCE, 0x1F, 0xFF, 0xBF, 0xFF, 0x7F, 0xFE, 0x1D, 0xC0, 0x73,
  0x80, 0xE7, 0x01, 0xCE, 0x03, 0x9C, 0x3F, 0xFF, 0x7F, 0xFE, 0xFF, 0xFC,
  0x73, 0x80, 0xE7, 0x01, 0xCE, 0x03, 0x9C, 0x07, 0x38, 0x0E, 0xF0, 0x00,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x3E, 0x01, 0xFF, 0x07, 0xFF, 0x0F,
  0xFF, 0x3F, 0x7E, 0x7C, 0x7C, 0xF8, 0xF9, 0xF9, 0xFB, 0xF0, 0x03, 0xF8,
  0x07, 0xF8, 0x03, 0xFC, 0x03, 0xFC, 0x01, 0xFC, 0x01, 0xFB, 0xF1, 0xF7,
  0xE3, 0xE7, 0xC7, 0xCF, 0xCF, 0x9F, 0xFF, 0x1F, 0xFC, 0x1F, 0xF0, 0x0F,
  0xC0, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0xE0, 0x01,
  0xFE, 0x00, 0x39, 0xC3, 0x0F, 0x3C, 0xE1, 0xE7, 0xBC, 0x1C, 0xF7, 0x03,
  0x9D, 0xC0, 0x7F, 0xB8, 0x07, 0xEE, 0x00, 0x79, 0xC0, 0x00, 0x70, 0x00,
  0x0E, 0xF0, 0x03, 0xBF, 0x80, 0xFF, 0xF0, 0x1D, 0xCF, 0x07, 0x39, 0xE0,
  0xE7, 0x3C, 0x38, 0xE7, 0x87, 0x1C, 0xF0, 0x43, 0xFC, 0x00, 0x3F, 0x80,
  0x03, 0xC0, 0x07, 0xC0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0xFF, 0xE0, 0x3E,
  0xF8, 0x0F, 0x1E, 0x03, 0xC7, 0x80, 0xFB, 0xE0, 0x3F, 0xF0, 0x07, 0xF8,
  0x01, 0xFC, 0x00, 0x7E, 0x3E, 0x3F, 0xCF, 0x9F, 0xFB, 0xEF, 0xBF, 0xF3,
  0xE7, 0xFC, 0xF9, 0xFF, 0x3E, 0x3F, 0x8F, 0xCF, 0xE3, 0xFF, 0xF8, 0x7F,
  0xFF, 0x0F, 0xFF, 0xE0, 0xFC, 0xFC, 0xFF, 0xFF, 0xEE, 0xEE, 0xE0, 0x02,
  0x06, 0x0F, 0x1E, 0x1C, 0x3C, 0x38, 0x78, 0x78, 0x78, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF8, 0x78, 0x78,
  0x78, 0x38, 0x3C, 0x1C, 0x1E, 0x0F, 0x06, 0x02, 0x40, 0xE0, 0xF0, 0x78,
  0x78, 0x3C, 0x3C, 0x1E, 0x1E, 0x1E, 0x1F, 0x1F, 0x1F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x1F, 0x1F, 0x1F, 0x1E, 0x1E, 0x1E, 0x3C, 0x3C,
  0x78, 0x78, 0xF0, 0xE0, 0x40, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x02, 0x1C,
  0x07, 0x18, 0xEF, 0xFF, 0xDF, 0xFF, 0x87, 0xF8, 0x07, 0xC0, 0x1F, 0xC0,
  0x7B, 0xC0, 0xE3, 0xC1, 0xC3, 0x81, 0x04, 0x00, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7D, 0xF7, 0xDF, 0x7D, 0xE7, 0xBE, 0xF1, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7B, 0xFF, 0xFF, 0x78, 0x03, 0xC0, 0xF0, 0x38, 0x1E, 0x07, 0x81, 0xE0,
  0x70, 0x3C, 0x0F, 0x03, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x03, 0xC0, 0xF0,
  0x3C, 0x0E, 0x07, 0x81, 0xE0, 0x78, 0x1C, 0x0F, 0x03, 0xC0, 0xF0, 0x00,
  0x07, 0xC0, 0x7F, 0xC3, 0xFF, 0x8F, 0xFE, 0x7E, 0xFD, 0xF1, 0xF7, 0xC7,
  0xFF, 0x1F, 0xFC, 0x7F, 0xF1, 0xFF, 0xC7, 0xFF, 0x1F, 0xFC, 0x7F, 0xF1,
  0xFF, 0xC7, 0xFF, 0x1F, 0x7C, 0x7D, 0xF1, 0xF7, 0xEF, 0xCF, 0xFE, 0x3F,
  0xF8, 0x7F, 0xC0, 0x7C, 0x00, 0x01, 0x83, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x07, 0xC0, 0x3F, 0xE0, 0xFF,
  0xE3, 0xFF, 0xE7, 0xCF, 0xDF, 0x8F, 0xBE, 0x1F, 0x7C, 0x3E, 0x00, 0x7C,
  0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x80, 0x7E, 0x01, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0xC0, 0x7F, 0xE1, 0xFF, 0xE3, 0xFF, 0xEF, 0xCF,
  0xDF, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x0F, 0xF0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0xF8, 0x7F, 0xF0,
  0xFB, 0xF3, 0xF3, 0xFF, 0xE7, 0xFF, 0x87, 0xFE, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x80, 0xFF, 0x03, 0xFE,
  0x07, 0x7C, 0x1E, 0xF8, 0x3D, 0xF0, 0xF3, 0xE1, 0xE7, 0xC7, 0xCF, 0x8F,
  0x1F, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x3F, 0xFC, 0xFF, 0xF7, 0xFF,
  0xDF, 0xFF, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7F, 0xE1, 0xFF,
  0xC7, 0xFF, 0x9F, 0xFF, 0x18, 0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0xFC,
  0x7F, 0xF1, 0xF7, 0xCF, 0xDF, 0xFE, 0x3F, 0xF8, 0x7F, 0xC0, 0x7C, 0x00,
  0x00, 0xF0, 0x07, 0xE0, 0x3F, 0xC0, 0xFF, 0x83, 0xFC, 0x07, 0xE0, 0x1F,
  0x80, 0x3E, 0x00, 0x7D, 0xF0, 0xFF, 0xF3, 0xFF, 0xF7, 0xFF, 0xEF, 0xEF,
  0xFF, 0x8F, 0xFF, 0x1F, 0xFE, 0x1F, 0x7C, 0x7E, 0xF8, 0xFD, 0xFB, 0xF1,
  0xFF, 0xE3, 0xFF, 0x83, 0xFE, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF8,
  0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0,
  0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xF0,
  0x00, 0x07, 0xC0, 0x7F, 0xC3, 0xFF, 0x9F, 0xFF, 0x7E, 0xFD, 0xF1, 0xF7,
  0xC7, 0xDF, 0x1F, 0x7E, 0xFC, 0xFF, 0xE1, 0xFF, 0x07, 0xFC, 0x3F, 0xF9,
  0xF3, 0xF7, 0xC7, 0xFF, 0x1F, 0xFC, 0x7F, 0xF1, 0xF7, 0xEF, 0xDF, 0xFF,
  0x3F, 0xF8, 0x7F, 0xC0, 0xFE, 0x00, 0x07, 0xC0, 0x7F, 0x83, 0xFF, 0x0F,
  0xFE, 0x7E, 0xFD, 0xF1, 0xFF, 0xC7, 0xFF, 0x1F, 0xFC, 0x7F, 0xF1, 0xF7,
  0xC7, 0xDF, 0x1F, 0x7F, 0xFC, 0xFF, 0xF3, 0xFF, 0xC3, 0xDF, 0x00, 0xF8,
  0x07, 0xE0, 0x7F, 0x07, 0xFC, 0x1F, 0xE0, 0x7E, 0x01, 0xE0, 0x00, 0x7B,
  0xFF, 0xFF, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xEF, 0xFF, 0xFD,
  0xE0, 0x7C, 0xFD, 0xFB, 0xE3, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x1E, 0x3C, 0x78, 0xF1, 0xE7, 0x8F, 0x3C, 0x10, 0x00, 0x10,
  0x07, 0x01, 0xF0, 0x7F, 0x1F, 0xF7, 0xFE, 0xFF, 0x0F, 0xC0, 0xFC, 0x0F,
  0xF0, 0x7F, 0xE1, 0xFF, 0x07, 0xF0, 0x1F, 0x00, 0x70, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x80, 0x0E, 0x00, 0xF8, 0x0F, 0xE0, 0xFF, 0x87,
  0xFE, 0x1F, 0xF0, 0x3F, 0x03, 0xF1, 0xFF, 0x7F, 0xEF, 0xF8, 0xFE, 0x0F,
  0x80, 0xE0, 0x08, 0x00, 0x1F, 0x81, 0xFF, 0x1F, 0xFD, 0xFF, 0xFF, 0xDF,
  0xFC, 0x7F, 0xE3, 0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x81, 0xF8, 0x1F, 0x80,
  0xF8, 0x07, 0xC0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x3F,
  0x01, 0xF8, 0x07, 0xC0, 0x3C, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0x80,
  0x1F, 0xFF, 0x80, 0x7C, 0x07, 0x81, 0xF0, 0x07, 0x83, 0xC0, 0x07, 0x0F,
  0x00, 0x07, 0x1C, 0x1F, 0x0E, 0x78, 0x7F, 0x9E, 0xE1, 0xFF, 0x1D, 0xC7,
  0xDE, 0x3F, 0x8F, 0x3C, 0x7F, 0x1C, 0x78, 0xFE, 0x78, 0xF1, 0xFC, 0xF1,
  0xE3, 0xF1, 0xE3, 0xC7, 0xE3, 0xC7, 0x0F, 0xC7, 0x8E, 0x3F, 0xCF, 0x1C,
  0x77, 0x9E, 0x78, 0xEF, 0x1F, 0xFF, 0x8E, 0x3F, 0x7E, 0x1E, 0x3C, 0x78,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x0C, 0x00,
  0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0xF9, 0xF0, 0x0F, 0x9F,
  0x00, 0xF9, 0xF0, 0x1F, 0x9F, 0x01, 0xF0, 0xF8, 0x1F, 0x0F, 0x83, 0xFF,
  0xF8, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7, 0xE0, 0x7E, 0x7E,
  0x07, 0xE7, 0xC0, 0x3E, 0xFC, 0x03, 0xF0, 0xFF, 0xE1, 0xFF, 0xF3, 0xFF,
  0xF7, 0xFF, 0xFF, 0x8F, 0xFF, 0x0F, 0xFE, 0x0F, 0xFC, 0x3F, 0xF8, 0x7F,
  0xFF, 0xFB, 0xFF, 0xE7, 0xFF, 0xCF, 0xFF, 0xDF, 0x0F, 0xFE, 0x0F, 0xFC,
  0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0x3F, 0xF8, 0x00, 0x03, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x87, 0xFF, 0xE7,
  0xF7, 0xF3, 0xF0, 0xFD, 0xF0, 0x7F, 0xF8, 0x1F, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x1F, 0x7C, 0x1F, 0xBE, 0x0F, 0xDF, 0xDF, 0xC7, 0xFF, 0xE3, 0xFF, 0xE0,
  0x7F, 0xE0, 0x1F, 0xC0, 0xFF, 0x81, 0xFF, 0xC3, 0xFF, 0xE7, 0xFF, 0xCF,
  0x9F, 0xDF, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0,
  0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x3F, 0xF8, 0x7F,
  0xF0, 0xFF, 0xE7, 0xF7, 0xFF, 0xEF, 0xFF, 0x9F, 0xFC, 0x3F, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xFF, 0xCF, 0xFF, 0x3F, 0xFC, 0xFF, 0xF3, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3F, 0xFE, 0xFF,
  0xFB, 0xFF, 0xEF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0xFD, 0xFF,
  0xEF, 0xFF, 0x7F, 0xFB, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x07, 0xFE, 0x07,
  0xFF, 0x87, 0xFF, 0xE7, 0xF3, 0xFB, 0xF0, 0xFD, 0xF0, 0x3F, 0xF8, 0x1F,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE3,
  0xFF, 0xF0, 0x3F, 0xF8, 0x1F, 0x7C, 0x0F, 0xBF, 0x07, 0xDF, 0xEF, 0xE7,
  0xFF, 0xF1, 0xFF, 0xF8, 0x7F, 0xF0, 0x0F, 0xE0, 0xF8, 0x1F, 0xFC, 0x0F,
  0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0,
  0x3F, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07,
  0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7E, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0xF8, 0xFF, 0xE3, 0xEF, 0xDF, 0xBF, 0xFE, 0x7F,
  0xF0, 0xFF, 0x80, 0xF8, 0x00, 0xF8, 0x3F, 0x7C, 0x3F, 0xBE, 0x1F, 0x9F,
  0x1F, 0xCF, 0x8F, 0xC7, 0xCF, 0xC3, 0xE7, 0xE1, 0xF7, 0xE0, 0xFB, 0xE0,
  0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF,
  0xE1, 0xFB, 0xF0, 0xF9, 0xFC, 0x7C, 0x7E, 0x3E, 0x3F, 0x1F, 0x0F, 0xCF,
  0x87, 0xE7, 0xC3, 0xFB, 0xE0, 0xFC, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFE, 0x03, 0xFF, 0xF0,
  0x1F, 0xFF, 0x80, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE3,
  0xFF, 0xF7, 0x1D, 0xFF, 0xBD, 0xEF, 0xFD, 0xEF, 0x7F, 0xEF, 0x7B, 0xFF,
  0x3B, 0x9F, 0xF9, 0xFC, 0xFF, 0xCF, 0xE7, 0xFE, 0x7F, 0x3F, 0xF1, 0xF1,
  0xFF, 0x8F, 0x8F, 0xFC, 0x7C, 0x7F, 0xE1, 0xC3, 0xE0, 0xF8, 0x1F, 0xFC,
  0x1F, 0xFC, 0x1F, 0xFE, 0x1F, 0xFE, 0x1F, 0xFE, 0x1F, 0xFF, 0x1F, 0xFF,
  0x1F, 0xFF, 0x9F, 0xFF, 0x9F, 0xFB, 0x9F, 0xFB, 0xDF, 0xF9, 0xDF, 0xF9,
  0xFF, 0xF9, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0x7F, 0xF8, 0x7F, 0xF8,
  0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x1F, 0x03, 0xF0, 0x03, 0xFF, 0x01,
  0xFF, 0xE0, 0xFF, 0xFC, 0x7F, 0xFF, 0x9F, 0x87, 0xE7, 0xC0, 0xFB, 0xF0,
  0x3E, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F,
  0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3E, 0x7C, 0x0F, 0x9F, 0x87, 0xE7,
  0xFF, 0xF8, 0xFF, 0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0x00, 0xFF,
  0xE0, 0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0xF8, 0xFE, 0xF8, 0x3E, 0xF8,
  0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3E, 0xF8, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFC, 0xFF, 0xF8, 0xFF, 0xE0, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x03,
  0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x7F, 0xFF, 0x9F, 0x87, 0xE7, 0xC0,
  0xFB, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F,
  0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0x7C, 0x0F, 0x9F,
  0x87, 0xE7, 0xFF, 0xF8, 0xFF, 0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0x3F,
  0xF0, 0x00, 0xFE, 0x00, 0x0F, 0x80, 0x01, 0xC0, 0x00, 0x20, 0xFF, 0xE0,
  0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0xF8, 0xFE, 0xF8, 0x7E, 0xF8, 0x3E,
  0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x7E, 0xF8, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8,
  0xFF, 0xF0, 0xFF, 0xF0, 0xF9, 0xF8, 0xF9, 0xF8, 0xF8, 0xFC, 0xF8, 0xFC,
  0xF8, 0x7E, 0xF8, 0x7E, 0xF8, 0x7E, 0xF8, 0x3F, 0x07, 0xF0, 0x1F, 0xF8,
  0x3F, 0xFC, 0x7F, 0xFE, 0x7E, 0x7F, 0x7C, 0x3F, 0x7C, 0x3F, 0x7E, 0x00,
  0x7F, 0x00, 0x3F, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0xFE,
  0x00, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0x7E, 0x7F, 0x7F, 0xFE,
  0x3F, 0xFE, 0x1F, 0xFC, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0,
  0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F,
  0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC,
  0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xC7, 0xFF,
  0x03, 0xF8, 0x00, 0xFC, 0x07, 0xEF, 0xC0, 0xFD, 0xF8, 0x3F, 0x3F, 0x07,
  0xE7, 0xE0, 0xFC, 0x7C, 0x1F, 0x8F, 0xC3, 0xE1, 0xF8, 0xFC, 0x1F, 0x1F,
  0x83, 0xE3, 0xE0, 0x7C, 0x7C, 0x0F, 0xCF, 0x80, 0xFB, 0xF0, 0x1F, 0x7C,
  0x03, 0xEF, 0x80, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0xF8, 0x7C,
  0x7F, 0xF0, 0xF8, 0xFF, 0xE3, 0xF1, 0xFF, 0xE7, 0xE3, 0xEF, 0xCF, 0xC7,
  0xDF, 0x9F, 0xCF, 0x9F, 0x3F, 0x9F, 0x3E, 0x7F, 0x7E, 0x7D, 0xFE, 0xF8,
  0xFB, 0xFD, 0xF1, 0xFF, 0xFB, 0xE3, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0x0F, 0xFB, 0xFC, 0x1F, 0xF7, 0xF8, 0x3F, 0xCF, 0xF0, 0x3F,
  0x9F, 0xE0, 0x7F, 0x3F, 0xC0, 0xFE, 0x3F, 0x81, 0xFC, 0x7E, 0x03, 0xF0,
  0xFC, 0x07, 0xE1, 0xF8, 0x00, 0x7E, 0x0F, 0xDF, 0x87, 0xE3, 0xF1, 0xF8,
  0xFC, 0x7E, 0x3F, 0x3F, 0x07, 0xEF, 0xC1, 0xFB, 0xE0, 0x3F, 0xF8, 0x0F,
  0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFF,
  0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x1F, 0xBE, 0x07, 0xEF, 0xC3, 0xF3, 0xF0,
  0xFC, 0x7E, 0x7E, 0x1F, 0x9F, 0x87, 0xFF, 0xE0, 0xFC, 0xFC, 0x0F, 0xDF,
  0x83, 0xE7, 0xE1, 0xF8, 0xF8, 0x7E, 0x3E, 0x1F, 0x0F, 0xCF, 0xC1, 0xF3,
  0xE0, 0x7C, 0xF8, 0x0F, 0xBE, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xE0,
  0x07, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7E, 0x00,
  0x7C, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x07,
  0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3E,
  0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB,
  0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xFF, 0xFF, 0xFC,
  0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xF8, 0x03, 0xF0,
  0x0F, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xFC, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xF8, 0xFF, 0xFF, 0xFF, 0x7D,
  0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D,
  0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0x01, 0xF0,
  0x1F, 0x01, 0xF8, 0x3F, 0x83, 0xB8, 0x3B, 0xC7, 0xBC, 0x79, 0xCF, 0x1E,
  0xF1, 0xEF, 0x0E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x3F,
  0x0F, 0x83, 0xE0, 0xF8, 0x0F, 0xC0, 0xFF, 0xC7, 0xFF, 0x1F, 0xFE, 0xFC,
  0xFB, 0xE3, 0xE0, 0x0F, 0x87, 0xFE, 0x7F, 0xF9, 0xFF, 0xEF, 0xCF, 0xBE,
  0x3E, 0xF8, 0xFB, 0xFF, 0xEF, 0xFF, 0x9F, 0xFE, 0x3E, 0xFC, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFD, 0xE3, 0xFF, 0xEF, 0xFF, 0xBF, 0xFF, 0xFC, 0xFF, 0xF1, 0xFF, 0xC7,
  0xFF, 0x1F, 0xFC, 0x7F, 0xF1, 0xFF, 0xC7, 0xFF, 0x1F, 0xFC, 0x7F, 0xFF,
  0xFF, 0xFF, 0xBE, 0xFE, 0xF9, 0xE0, 0x0F, 0xC1, 0xFF, 0x1F, 0xFC, 0xFF,
  0xFF, 0xCF, 0xFC, 0x7F, 0xE3, 0xFF, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x3F,
  0xF1, 0xFF, 0xCF, 0xBF, 0xFD, 0xFF, 0xC7, 0xFC, 0x0F, 0xC0, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x1E, 0x7C, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xE1, 0xFF, 0x87,
  0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xFC, 0xFF, 0xFF,
  0xF7, 0xFF, 0xCF, 0xFF, 0x1E, 0x7C, 0x0F, 0xC0, 0xFF, 0xC7, 0xFF, 0x9F,
  0xFE, 0xFC, 0xFF, 0xF1, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0x00, 0xFE, 0x31, 0xFF, 0xE3, 0xFF, 0xC7, 0xFE, 0x0F, 0xE0,
  0x03, 0xE1, 0xFC, 0x7F, 0x8F, 0xF1, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0xFF,
  0xDF, 0xFB, 0xFF, 0x7F, 0xE3, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x00, 0x1F,
  0x7C, 0xFF, 0xF7, 0xFF, 0xDF, 0xFF, 0xFC, 0x7F, 0xF1, 0xFF, 0x87, 0xFE,
  0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xFC, 0xFD, 0xFF, 0xF7,
  0xFF, 0xCF, 0xFF, 0x1F, 0x7C, 0x01, 0xF0, 0x07, 0xC4, 0x3F, 0x3F, 0xFC,
  0xFF, 0xE3, 0xFF, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFD, 0xE3, 0xFF, 0xEF, 0xFF,
  0xBF, 0xFF, 0xFC, 0xFF, 0xF1, 0xFF, 0xC7, 0xFF, 0x1F, 0xFC, 0x7F, 0xF1,
  0xFF, 0xC7, 0xFF, 0x1F, 0xFC, 0x7F, 0xF1, 0xFF, 0xC7, 0xFF, 0x1F, 0xFC,
  0x7C, 0x79, 0xFF, 0xDF, 0x38, 0x00, 0x1F, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7,
  0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x1E, 0x1F, 0x3F, 0x1F, 0x0E,
  0x00, 0x00, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x3F, 0xFF, 0xFE,
  0xFC, 0xF8, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0xFF, 0xF9, 0xFB, 0xF7, 0xE7, 0xEF,
  0xCF, 0xFF, 0x1F, 0xFC, 0x3F, 0xF0, 0x7F, 0xF0, 0xFF, 0xE1, 0xFF, 0xE3,
  0xFF, 0xC7, 0xEF, 0xCF, 0xDF, 0x9F, 0x9F, 0xBF, 0x3F, 0x7E, 0x3F, 0xFC,
  0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF9, 0xF1, 0xE3, 0xFF, 0xEF, 0xEF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFE, 0xFC, 0xFC, 0xFF, 0xF3, 0xF3, 0xFF, 0xCF, 0xC7,
  0xFF, 0x3F, 0x1F, 0xFC, 0xFC, 0x7F, 0xF3, 0xF1, 0xFF, 0xCF, 0xC7, 0xFF,
  0x3F, 0x1F, 0xFC, 0xFC, 0x7F, 0xF3, 0xF1, 0xFF, 0xCF, 0xC7, 0xFF, 0x3F,
  0x1F, 0xFC, 0xFC, 0x7C, 0xF9, 0xF3, 0xEF, 0xEF, 0xFF, 0xBF, 0xFF, 0xFC,
  0xFF, 0xF1, 0xFF, 0xC7, 0xFF, 0x1F, 0xFC, 0x7F, 0xF1, 0xFF, 0xC7, 0xFF,
  0x1F, 0xFC, 0x7F, 0xF1, 0xFF, 0xC7, 0xFF, 0x1F, 0xFC, 0x7C, 0x0F, 0xC0,
  0xFF, 0xC7, 0xFF, 0x9F, 0xFE, 0xFC, 0xFF, 0xF1, 0xFF, 0x87, 0xFE, 0x1F,
  0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xFC, 0xFD, 0xFF, 0xE7, 0xFF,
  0x8F, 0xFC, 0x0F, 0xC0, 0xF9, 0xE3, 0xFF, 0xEF, 0xFF, 0xBF, 0xFF, 0xFC,
  0xFF, 0xF1, 0xFF, 0xC7, 0xFF, 0x1F, 0xFC, 0x7F, 0xF1, 0xFF, 0xC7, 0xFF,
  0x1F, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFE, 0xFD, 0xE3, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x1F, 0x7C,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xE1, 0xFF, 0x87, 0xFE, 0x1F,
  0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xFC, 0xFF, 0xFF, 0xF7, 0xFF,
  0xCF, 0xFF, 0x1E, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x00, 0x1F, 0x81, 0xFF, 0x1F, 0xFD, 0xFF, 0xFF, 0x8F, 0xFC, 0x7F,
  0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0x81, 0xFF, 0xF3, 0xFF, 0x8F, 0xFF,
  0xFD, 0xFF, 0xC7, 0xFC, 0x1F, 0x80, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0xC3, 0xFC, 0x7F, 0x1F, 0xC1, 0xF0, 0xFC, 0x7F,
  0xF1, 0xFF, 0xC7, 0xFF, 0x1F, 0xFC, 0x7F, 0xF1, 0xFF, 0xC7, 0xFF, 0x1F,
  0xFC, 0x7F, 0xF1, 0xFF, 0xC7, 0xFF, 0x1F, 0xFC, 0xFD, 0xFF, 0xF7, 0xFF,
  0xCF, 0xFF, 0x1E, 0x7C, 0xFC, 0x7E, 0xF8, 0xF9, 0xF1, 0xF3, 0xE3, 0xE7,
  0xEF, 0xC7, 0xDF, 0x0F, 0xBE, 0x1F, 0x7C, 0x1E, 0xF8, 0x3F, 0xE0, 0x7F,
  0xC0, 0xFF, 0x80, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xC0,
  0x7C, 0xF1, 0xF7, 0xCF, 0x1F, 0x7C, 0xF9, 0xF7, 0xCF, 0x9E, 0x7D, 0xFB,
  0xE3, 0xDF, 0xBE, 0x3D, 0xFF, 0xE3, 0xDF, 0xFE, 0x3F, 0xFF, 0xC3, 0xFD,
  0xFC, 0x1F, 0xDF, 0xC1, 0xF9, 0xFC, 0x1F, 0x9F, 0xC1, 0xF8, 0xFC, 0x1F,
  0x8F, 0x81, 0xF8, 0xF8, 0x0F, 0x0F, 0x80, 0x7C, 0x7E, 0xFC, 0xF8, 0xFB,
  0xF1, 0xF7, 0xC1, 0xFF, 0x83, 0xFE, 0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xE0,
  0x1F, 0xE0, 0x7F, 0xC0, 0xFF, 0xC3, 0xEF, 0x87, 0xDF, 0x1F, 0x9F, 0x3E,
  0x3E, 0x7C, 0x7E, 0xFC, 0x7E, 0xF8, 0xFD, 0xF1, 0xF3, 0xE3, 0xE7, 0xEF,
  0xC7, 0xDF, 0x8F, 0xBE, 0x1F, 0x7C, 0x1F, 0xF8, 0x3F, 0xE0, 0x7F, 0xC0,
  0xFF, 0x80, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x7C, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x81,
  0xF8, 0x0F, 0x80, 0xFC, 0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x02, 0x0E, 0x1F, 0x1E, 0x3E, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x7C, 0xF8, 0xF8, 0xF0, 0xF8, 0x7C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3E, 0x3E, 0x1F, 0x0E, 0x02,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x40,
  0xF0, 0xF8, 0x78, 0x78, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x3C,
  0x3C, 0x3F, 0x1F, 0x0F, 0x3F, 0x3E, 0x3C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C,
  0x7C, 0x7C, 0x7C, 0x78, 0xF8, 0xF0, 0x40, 0x1E, 0x00, 0x7E, 0x1D, 0xFE,
  0x7B, 0xFE, 0xF7, 0xBF, 0xFE, 0x3F, 0xBC, 0x3F, 0x00, 0x3C,
};

const GFXglyph RobotoCondensed_Black33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 5, 23, 9, 2, -23 },
  { 16, 10, 9, 10, 0, -25 },
  { 28, 15, 23, 17, 1, -23 },
  { 72, 15, 29, 17, 1, -26 },
  { 127, 19, 23, 21, 1, -23 },
  { 182, 18, 23, 20, 1, -23 },
  { 234, 4, 9, 5, 1, -25 },
  { 239, 8, 33, 11, 2, -26 },
  { 272, 8, 33, 11, 1, -26 },
  { 305, 15, 14, 15, 0, -23 },
  { 332, 13, 17, 15, 1, -20 },
  { 360, 6, 10, 9, 1, -4 },
  { 368, 8, 4, 14, 3, -12 },
  { 372, 6, 5, 10, 2, -5 },
  { 376, 10, 25, 10, 0, -23 },
  { 408, 14, 23, 17, 1, -23 },
  { 449, 9, 23, 17, 3, -23 },
  { 475, 15, 23, 17, 1, -23 },
  { 519, 15, 23, 17, 1, -23 },
  { 563, 15, 23, 17, 1, -23 },
  { 607, 14, 23, 17, 1, -23 },
  { 648, 15, 23, 17, 1, -23 },
  { 692, 14, 23, 17, 1, -23 },
  { 733, 14, 23, 17, 1, -23 },
  { 774, 14, 23, 17, 1, -23 },
  { 815, 6, 18, 10, 2, -18 },
  { 829, 7, 24, 9, 1, -18 },
  { 850, 12, 16, 15, 1, -18 },
  { 874, 13, 11, 17, 2, -16 },
  { 892, 12, 16, 15, 2, -18 },
  { 916, 13, 23, 15, 1, -23 },
  { 954, 23, 30, 25, 1, -23 },
  { 1041, 20, 23, 20, 0, -23 },
  { 1099, 15, 23, 19, 2, -23 },
  { 1143, 17, 23, 19, 1, -23 },
  { 1192, 15, 23, 19, 2, -23 },
  { 1236, 14, 23, 16, 2, -23 },
  { 1277, 13, 23, 16, 2, -23 },
  { 1315, 17, 23, 20, 1, -23 },
  { 1364, 17, 23, 20, 2, -23 },
  { 1413, 5, 23, 9, 2, -23 },
  { 1428, 14, 23, 16, 1, -23 },
  { 1469, 17, 23, 18, 2, -23 },
  { 1518, 13, 23, 16, 2, -23 },
  { 1556, 21, 23, 25, 2, -23 },
  { 1617, 16, 23, 20, 2, -23 },
  { 1663, 18, 23, 20, 1, -23 },
  { 1715, 16, 23, 19, 2, -23 },
  { 1761, 18, 27, 20, 1, -23 },
  { 1822, 16, 23, 19, 2, -23 },
  { 1868, 16, 23, 18, 1, -23 },
  { 1914, 17, 23, 18, 1, -23 },
  { 1963, 15, 23, 19, 2, -23 },
  { 2007, 19, 23, 19, 0, -23 },
  { 2062, 23, 23, 25, 1, -23 },
  { 2129, 18, 23, 19, 0, -23 },
  { 2181, 18, 23, 18, 0, -23 },
  { 2233, 16, 23, 18, 1, -23 },
  { 2279, 6, 33, 9, 2, -27 },
  { 2304, 14, 25, 13, 0, -23 },
  { 2348, 6, 33, 9, 1, -27 },
  { 2373, 12, 12, 13, 1, -23 },
  { 2391, 13, 4, 13, 0, 0 },
  { 2398, 9, 5, 11, 1, -25 },
  { 2404, 14, 17, 15, 1, -17 },
  { 2434, 14, 25, 16, 1, -25 },
  { 2478, 13, 17, 15, 1, -17 },
  { 2506, 14, 25, 16, 1, -25 },
  { 2550, 14, 17, 16, 1, -17 },
  { 2580, 11, 25, 11, 0, -25 },
  { 2615, 14, 24, 17, 1, -17 },
  { 2657, 14, 25, 16, 1, -25 },
  { 2701, 6, 24, 9, 1, -24 },
  { 2719, 8, 31, 8, -1, -24 },
  { 2750, 15, 25, 16, 1, -25 },
  { 2797, 5, 25, 9, 2, -25 },
  { 2813, 22, 17, 24, 1, -17 },
  { 2860, 14, 17, 16, 1, -17 },
  { 2890, 14, 17, 16, 1, -17 },
  { 2920, 14, 24, 16, 1, -17 },
  { 2962, 14, 24, 16, 1, -17 },
  { 3004, 10, 17, 11, 1, -17 },
  { 3026, 13, 17, 15, 1, -17 },
  { 3054, 10, 22, 10, 0, -22 },
  { 3082, 14, 17, 16, 1, -17 },
  { 3112, 15, 17, 15, 0, -17 },
  { 3144, 20, 17, 21, 0, -17 },
  { 3187, 15, 17, 15, 0, -17 },
  { 3219, 15, 24, 15, 0, -17 },
  { 3264, 13, 17, 15, 1, -17 },
  { 3292, 8, 32, 10, 1, -26 },
  { 3324, 3, 27, 8, 3, -23 },
  { 3335, 8, 32, 10, 1, -26 },
  { 3367, 15, 8, 18, 1, -14 },
};

const GFXfont RobotoCondensed_Black33pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Black33pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Black33pt7bGlyphs,
  0x20, 0x7E, 39
};

#endif // _ROBOTOCONDENSED_BLACK33PT7B_H_
