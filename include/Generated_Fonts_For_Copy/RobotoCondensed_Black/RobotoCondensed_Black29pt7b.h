#ifndef _ROBOTOCONDENSED_BLACK29PT7B_H_
#define _ROBOTOCONDENSED_BLACK29PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Black.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Black29pt7bBitmaps[] PROGMEM = {
  0x00, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBC, 0x00, 0x7B,
  0xFE, 0xF7, 0x80, 0xF7, 0xFB, 0xFD, 0xFC, 0xEE, 0x77, 0x3B, 0x9D, 0xCE,
  0x0E, 0xE0, 0x77, 0x03, 0xB8, 0x19, 0xC0, 0xCC, 0x0E, 0x63, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xEE, 0x06, 0x70, 0x33, 0x0F, 0xFF, 0x7F, 0xFB, 0xFF,
  0xC7, 0x70, 0x3B, 0x81, 0xDC, 0x0C, 0xE0, 0x66, 0x07, 0x30, 0x00, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x1F, 0x01, 0xFE, 0x1F, 0xF9, 0xFF, 0xCF, 0x9E,
  0x78, 0xFB, 0xE7, 0xDF, 0x00, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF7, 0xC7, 0xFE, 0x3F, 0xF1, 0xE7, 0xFF, 0x3F, 0xF8, 0xFF,
  0x81, 0xF0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x3C, 0x00, 0x7E, 0x00, 0x7F,
  0x10, 0xE7, 0x18, 0xE7, 0x38, 0xE7, 0x30, 0xE7, 0x70, 0x7F, 0x60, 0x7E,
  0xE0, 0x3C, 0xC0, 0x01, 0xC0, 0x03, 0xBC, 0x03, 0xFF, 0x07, 0x7F, 0x07,
  0xE7, 0x0E, 0xE7, 0x0E, 0xE7, 0x1C, 0xE7, 0x0C, 0x7F, 0x00, 0x7F, 0x00,
  0x3C, 0x0F, 0x80, 0x1F, 0xC0, 0x3F, 0xE0, 0x3F, 0xE0, 0x7D, 0xE0, 0x78,
  0xE0, 0x7D, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0, 0x1F, 0x80, 0x3F, 0x1E, 0x7F,
  0x9C, 0xFF, 0xFC, 0xFF, 0xFC, 0xFB, 0xFC, 0xF9, 0xFC, 0xF9, 0xF8, 0xFF,
  0xF8, 0x7F, 0xFC, 0x7F, 0xFE, 0x1F, 0x3E, 0xFF, 0xFF, 0xFF, 0x04, 0x18,
  0x71, 0xE3, 0x8F, 0x1C, 0x38, 0xF1, 0xE3, 0xC7, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xC3, 0xC7, 0x8F, 0x0E, 0x1C, 0x3C, 0x38, 0x78, 0x70, 0x60, 0x40,
  0xC1, 0xC3, 0xC3, 0x87, 0x87, 0x0F, 0x1E, 0x1C, 0x3C, 0x78, 0xF1, 0xE3,
  0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xC7, 0x8F, 0x1C, 0x78, 0xE3, 0xC7,
  0x0C, 0x00, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x86, 0x17, 0x33, 0xBF, 0xFC,
  0xFF, 0xC0, 0xF0, 0x0F, 0xC0, 0xEE, 0x0F, 0x38, 0x71, 0xE0, 0x04, 0x00,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x7B,
  0xDE, 0xF7, 0xBB, 0xDC, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0x77, 0xFF, 0xF7,
  0x00, 0x07, 0x83, 0x81, 0xC0, 0xE0, 0xF0, 0x70, 0x38, 0x1C, 0x1E, 0x0E,
  0x07, 0x03, 0x83, 0xC1, 0xC0, 0xE0, 0x70, 0x78, 0x38, 0x1C, 0x0E, 0x0F,
  0x07, 0x03, 0x80, 0x0F, 0x80, 0xFE, 0x0F, 0xF8, 0xFF, 0xE7, 0x9F, 0x7C,
  0x7B, 0xE3, 0xDF, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F,
  0xFC, 0x7F, 0xE3, 0xCF, 0x1E, 0x79, 0xF3, 0xFF, 0x8F, 0xF8, 0x3F, 0x80,
  0xF8, 0x00, 0x01, 0x87, 0xCF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3E, 0x1F, 0x0F,
  0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1,
  0xF0, 0xF8, 0x0F, 0x81, 0xFF, 0x1F, 0xF8, 0xFF, 0xEF, 0x9F, 0x7C, 0x7B,
  0xE3, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x0F, 0x80, 0xFC, 0x07,
  0xC0, 0x7C, 0x07, 0xC0, 0x7E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0x81, 0xFF, 0x1F, 0xF9, 0xFF, 0xEF, 0x9F, 0x7C, 0x78, 0x03,
  0xC0, 0x3E, 0x0F, 0xF0, 0x7F, 0x03, 0xF0, 0x1F, 0xE0, 0x1F, 0x00, 0x7C,
  0x03, 0xFE, 0x1F, 0xF8, 0xF7, 0xFF, 0x9F, 0xFC, 0x7F, 0xC1, 0xF8, 0x00,
  0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x83,
  0xBC, 0x1D, 0xE1, 0xEF, 0x0E, 0x78, 0xF3, 0xC7, 0x9E, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0x7F,
  0xF3, 0xFF, 0x9F, 0xFC, 0xFF, 0xE7, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0xF8,
  0x7F, 0xE7, 0xFF, 0xBE, 0x7C, 0x03, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xFF,
  0x1E, 0xF9, 0xF7, 0xFF, 0x9F, 0xF8, 0x7F, 0x80, 0xF8, 0x00, 0x01, 0xC0,
  0x3E, 0x07, 0xF0, 0x7F, 0x83, 0xE0, 0x3E, 0x01, 0xE0, 0x0F, 0x78, 0xFF,
  0xE7, 0xFF, 0xBF, 0xFD, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF, 0x1F,
  0x78, 0xFB, 0xFF, 0x8F, 0xFC, 0x3F, 0xC0, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x03, 0xE0,
  0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x00, 0x0F, 0x81, 0xFF, 0x1F,
  0xF8, 0xFF, 0xE7, 0x9F, 0x3C, 0x79, 0xE3, 0xCF, 0x3E, 0x7F, 0xE1, 0xFF,
  0x0F, 0xF0, 0xFF, 0xC7, 0x9F, 0x7C, 0x7B, 0xE3, 0xFF, 0x1F, 0xF8, 0xF3,
  0xFF, 0x9F, 0xFC, 0x7F, 0xC0, 0xF8, 0x00, 0x0F, 0x80, 0xFE, 0x0F, 0xF8,
  0xFF, 0xE7, 0x9F, 0x7C, 0x7B, 0xE3, 0xDF, 0x1F, 0xF8, 0xFF, 0xC7, 0xDF,
  0x7E, 0xFF, 0xF3, 0xFF, 0x0F, 0x78, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0xFE,
  0x07, 0xE0, 0x3E, 0x01, 0xC0, 0x00, 0x77, 0xFF, 0xF7, 0x00, 0x00, 0x00,
  0x00, 0xEF, 0xFF, 0xEE, 0x39, 0xF7, 0xDF, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x3C, 0x60, 0x00, 0x40, 0x70, 0x7C,
  0x7F, 0x7F, 0xFF, 0xCF, 0x83, 0xE0, 0xFF, 0x1F, 0xF1, 0xFC, 0x1F, 0x01,
  0xC0, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x38, 0x0F, 0x83, 0xF8, 0xFF, 0x8F, 0xF0,
  0x7C, 0x3F, 0x3F, 0xFF, 0xEF, 0xE3, 0xE0, 0xE0, 0x20, 0x00, 0x1F, 0x0F,
  0xFB, 0xFF, 0xFF, 0xFF, 0xBF, 0xE3, 0xC0, 0xF8, 0x1F, 0x07, 0xC1, 0xF0,
  0x3E, 0x0F, 0x81, 0xE0, 0x3C, 0x00, 0x00, 0x00, 0x0E, 0x03, 0xE0, 0x7C,
  0x0F, 0x80, 0xE0, 0x00, 0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0xDF, 0x81, 0xE0,
  0x3C, 0x3C, 0x01, 0xE3, 0x80, 0x0E, 0x78, 0x78, 0x67, 0x0F, 0xE7, 0x71,
  0xFE, 0x7E, 0x3C, 0xE7, 0xE3, 0x8E, 0x7E, 0x79, 0xE7, 0xE7, 0x9C, 0x7E,
  0x79, 0xC7, 0xE7, 0x9C, 0x7E, 0x79, 0xC7, 0xE7, 0x9C, 0xEE, 0x3F, 0xFE,
  0xE3, 0xFF, 0xC7, 0x1C, 0x78, 0x70, 0x00, 0x03, 0x80, 0x00, 0x3E, 0x00,
  0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x1E,
  0xF0, 0x0F, 0x7C, 0x07, 0x9E, 0x07, 0xCF, 0x03, 0xE7, 0xC1, 0xE3, 0xE1,
  0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0xFE, 0x7F, 0xFF, 0x3E, 0x0F, 0x9F, 0x03,
  0xEF, 0x81, 0xFF, 0x80, 0xF8, 0xFF, 0xC3, 0xFF, 0xCF, 0xFF, 0xBF, 0xFF,
  0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0xFB, 0xFF, 0xEF, 0xFF,
  0x3F, 0xFE, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFE, 0xFF, 0xE0, 0x07, 0xE0, 0x3F, 0xE0, 0xFF, 0xE3,
  0xFF, 0xE7, 0xC7, 0xDF, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x0F, 0xFC, 0x1F,
  0x7C, 0x7E, 0xFF, 0xF8, 0xFF, 0xE0, 0xFF, 0xC0, 0x7E, 0x00, 0xFF, 0x83,
  0xFF, 0x8F, 0xFF, 0x3F, 0xFE, 0xF8, 0xFB, 0xE1, 0xFF, 0x87, 0xFE, 0x1F,
  0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87,
  0xFE, 0x1F, 0xF8, 0xFB, 0xFF, 0xEF, 0xFF, 0x3F, 0xF8, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xFF, 0xE7, 0xFF, 0x3F, 0xF9, 0xFF, 0xCF, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x00, 0x07, 0xE0, 0x3F, 0xF0, 0xFF, 0xF3,
  0xFF, 0xE7, 0xC3, 0xEF, 0x87, 0xFE, 0x0F, 0xFC, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE3, 0xFF, 0xC7, 0xFF, 0x8F, 0xFF, 0x07, 0xFE, 0x0F, 0xBE, 0x1F,
  0x7C, 0x3E, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xC0, 0x7E, 0x00, 0xF8, 0x3F,
  0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0x07,
  0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF,
  0x83, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0xF1, 0xFF,
  0x9F, 0xF9, 0xFF, 0xFE, 0x7F, 0xE7, 0xFC, 0x1F, 0x00, 0xF8, 0x7F, 0xF0,
  0xFF, 0xE3, 0xF7, 0xC7, 0xCF, 0x9F, 0x9F, 0x3E, 0x3E, 0xF8, 0x7D, 0xF0,
  0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x87, 0xFF, 0x0F, 0xFE, 0x1F, 0xFE, 0x3F,
  0x7C, 0x7C, 0xFC, 0xF8, 0xF9, 0xF1, 0xFB, 0xE1, 0xF7, 0xC3, 0xFF, 0x87,
  0xE0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x9F, 0xFF, 0xF9, 0xFF, 0xFB, 0x9D,
  0xFF, 0xB9, 0xDF, 0xFB, 0xFD, 0xFF, 0xBF, 0xDF, 0xF9, 0xF9, 0xFF, 0x9F,
  0x9F, 0xF9, 0xF9, 0xFF, 0x9F, 0x9F, 0xF8, 0xF1, 0xFF, 0x8F, 0x1F, 0xF8,
  0xF1, 0xF0, 0xF8, 0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xF1, 0xFF, 0xE3, 0xFF,
  0xC7, 0xFF, 0xCF, 0xFF, 0x9F, 0xFF, 0xBF, 0xF7, 0x7F, 0xEE, 0xFF, 0xCF,
  0xFF, 0x9F, 0xFF, 0x3F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF8, 0x7F, 0xF0, 0xFF,
  0xE1, 0xFF, 0xC1, 0xFF, 0x83, 0xE0, 0x07, 0xE0, 0x3F, 0xE0, 0xFF, 0xE3,
  0xFF, 0xE7, 0xC7, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0,
  0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F,
  0x7C, 0x7E, 0xFF, 0xF8, 0xFF, 0xE0, 0xFF, 0x80, 0x7E, 0x00, 0xFF, 0xC1,
  0xFF, 0xE3, 0xFF, 0xE7, 0xFF, 0xEF, 0x87, 0xDF, 0x0F, 0xBE, 0x0F, 0x7C,
  0x1F, 0xF8, 0x7D, 0xF0, 0xFB, 0xFF, 0xF7, 0xFF, 0xCF, 0xFF, 0x1F, 0xFC,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x00, 0x07, 0xE0, 0x3F, 0xE0, 0xFF, 0xE3, 0xFF, 0xE7, 0xC7, 0xEF,
  0x87, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0,
  0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xBC, 0x1F, 0x7C, 0x7E, 0xFF, 0xF8,
  0xFF, 0xE0, 0xFF, 0xC0, 0x7F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0E, 0x00,
  0x08, 0xFF, 0xC1, 0xFF, 0xE3, 0xFF, 0xE7, 0xFF, 0xEF, 0x87, 0xDF, 0x0F,
  0xBE, 0x1F, 0x7C, 0x3E, 0xF8, 0x7D, 0xF0, 0xFB, 0xFF, 0xE7, 0xFF, 0xCF,
  0xFF, 0x1F, 0xFE, 0x3E, 0x7C, 0x7C, 0xF8, 0xF8, 0xF9, 0xF1, 0xF3, 0xE1,
  0xF7, 0xC3, 0xEF, 0x87, 0xE0, 0x0F, 0xC0, 0xFF, 0xC3, 0xFF, 0x9F, 0xFE,
  0x7C, 0x7F, 0xE1, 0xF7, 0x80, 0x1F, 0x00, 0x7F, 0x00, 0xFF, 0x01, 0xFF,
  0x01, 0xFE, 0x01, 0xF8, 0x03, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7D, 0xFF,
  0xF7, 0xFF, 0x87, 0xFC, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0xF8, 0x7F, 0xE1, 0xFF, 0x87,
  0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1,
  0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0x7C,
  0x7D, 0xFF, 0xF3, 0xFF, 0x8F, 0xFC, 0x0F, 0xE0, 0xFC, 0x1F, 0xBE, 0x0F,
  0x9F, 0x07, 0xCF, 0x83, 0xE7, 0xC3, 0xF1, 0xF1, 0xF0, 0xF8, 0xF8, 0x7C,
  0x7C, 0x3E, 0x3E, 0x0F, 0x3E, 0x07, 0xDF, 0x03, 0xEF, 0x80, 0xF7, 0x80,
  0x7B, 0xC0, 0x3D, 0xE0, 0x1F, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x3E, 0x00, 0x78, 0x78, 0xFB, 0xC7, 0xC7, 0xDF, 0x3E,
  0x3E, 0xF9, 0xF1, 0xE7, 0xCF, 0xCF, 0x3E, 0x7E, 0xF8, 0xF3, 0xF7, 0xC7,
  0xBF, 0xBE, 0x3D, 0xFD, 0xF1, 0xFF, 0xEF, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xC1, 0xFF, 0xFE, 0x0F, 0xEF, 0xF0, 0x7F, 0x7F, 0x83, 0xF9, 0xF8, 0x1F,
  0xCF, 0xC0, 0xFE, 0x7E, 0x03, 0xE3, 0xF0, 0x1F, 0x1F, 0x80, 0xF8, 0xFC,
  0x00, 0x7C, 0x3F, 0x7C, 0x3E, 0x7E, 0x3E, 0x3E, 0x7C, 0x3E, 0x7C, 0x1F,
  0x7C, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF8, 0x1F, 0x7C, 0x3E, 0x7C, 0x3E,
  0x7E, 0x7E, 0x3E, 0x7C, 0x3E, 0xFC, 0x3F, 0xFC, 0x3F, 0x7C, 0x3E, 0x7C,
  0x3E, 0x3C, 0x3C, 0x3E, 0x7C, 0x3E, 0x7C, 0x1E, 0x78, 0x1F, 0xF8, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xF8, 0x07, 0xC0,
  0x1F, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00,
  0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB,
  0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xFF, 0xFC,
  0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x7C, 0x03, 0xC0, 0x3E, 0x03, 0xE0,
  0x1E, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x7C,
  0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0xFF,
  0xFF, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C,
  0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xFF, 0xFF, 0xFC, 0x1E, 0x07, 0x83,
  0xE0, 0xFC, 0x3F, 0x1D, 0xE7, 0x3B, 0xCE, 0xE3, 0xF8, 0x70, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x7C, 0x3E, 0x1E, 0x1F, 0x83, 0xFC, 0x7F,
  0xEF, 0xBE, 0xF9, 0xE0, 0x1E, 0x1F, 0xE7, 0xFE, 0xFF, 0xEF, 0x9E, 0xF1,
  0xEF, 0x1E, 0xFB, 0xEF, 0xFE, 0x7F, 0xF3, 0xDF, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xEF, 0x1F, 0xFC, 0xFF, 0xF7, 0xFF,
  0xBE, 0x3D, 0xF1, 0xEF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF,
  0xC7, 0xBF, 0xFD, 0xFF, 0xEF, 0xFE, 0x7D, 0xE0, 0x1F, 0x03, 0xFC, 0x7F,
  0xEF, 0xFE, 0xF9, 0xEF, 0x9F, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF1,
  0xFF, 0x9E, 0xFF, 0xE7, 0xFE, 0x3F, 0xC1, 0xF8, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x3D, 0xF7, 0xFF, 0x7F, 0xFF, 0xFF, 0xF9,
  0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x9F, 0xFF,
  0xF7, 0xFF, 0x7E, 0xF3, 0xCF, 0x1F, 0x83, 0xFC, 0x7F, 0xE7, 0xFF, 0xF8,
  0xFF, 0x8F, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x80, 0x7F,
  0xE7, 0xFF, 0x3F, 0xE0, 0xFC, 0x07, 0x8F, 0xC7, 0xE7, 0xF3, 0xE1, 0xF3,
  0xFF, 0xFF, 0xFF, 0x9F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0x1E, 0xF7, 0xFF, 0x7F, 0xFF, 0xFF,
  0xF8, 0xFF, 0x8F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF8, 0xFF, 0x8F,
  0xFF, 0xF7, 0xFF, 0x7F, 0xF1, 0xEF, 0x00, 0xF0, 0x1F, 0x3F, 0xF7, 0xFE,
  0x7F, 0xE1, 0xF8, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xFB, 0xCF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0x9F, 0xF8, 0xFF, 0x8F,
  0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F,
  0x33, 0xFF, 0xF7, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0C, 0x3C, 0xF9, 0xF1, 0xC0, 0x00, 0x0F, 0x1E, 0x3C,
  0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F,
  0x3F, 0xFF, 0xFF, 0xEF, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE7, 0xFF, 0x3E, 0xFB, 0xE7, 0xDF, 0x3F, 0xF1, 0xFF,
  0x0F, 0xF8, 0x7F, 0xC3, 0xFF, 0x1F, 0xF8, 0xFF, 0xE7, 0xDF, 0x3E, 0x7D,
  0xF3, 0xEF, 0x8F, 0xFC, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFB, 0xC7, 0x9F, 0xFD, 0xFB,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0x3F, 0xF3, 0xE7, 0xFE, 0x7C, 0xFF,
  0xCF, 0x9F, 0xF9, 0xF3, 0xFF, 0x3E, 0x7F, 0xE7, 0xCF, 0xFC, 0xF9, 0xFF,
  0x9F, 0x3F, 0xF3, 0xE7, 0xFE, 0x7C, 0xFF, 0xCF, 0x9F, 0xFB, 0xCF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0x9F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F,
  0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0x1F, 0x81, 0xFE,
  0x1F, 0xF9, 0xFF, 0xEF, 0x9F, 0x7C, 0x7B, 0xC3, 0xDE, 0x1F, 0xF0, 0xFF,
  0x87, 0xBE, 0x3D, 0xF1, 0xEF, 0xFF, 0x3F, 0xF0, 0xFF, 0x03, 0xF0, 0xFB,
  0xC7, 0xFF, 0x3F, 0xFD, 0xFF, 0xEF, 0x8F, 0x7C, 0x7B, 0xE3, 0xFF, 0x1F,
  0xF8, 0xFF, 0xC7, 0xFE, 0x3D, 0xF1, 0xEF, 0xFF, 0x7F, 0xFB, 0xFF, 0x9F,
  0x78, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x00, 0x3E,
  0xF7, 0xFF, 0x7F, 0xFF, 0xFF, 0xF9, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1,
  0xFF, 0x1F, 0xF1, 0xFF, 0x9F, 0xFF, 0xF7, 0xFF, 0x7F, 0xF3, 0xDF, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0xFB, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0x1F, 0x0F, 0xFB, 0xFF, 0xFD, 0xFF, 0x1F, 0xF0, 0x3F, 0x83, 0xFC, 0x3F,
  0xC1, 0xFC, 0x0F, 0xF8, 0xFF, 0x3F, 0xFF, 0xDF, 0xF0, 0xF8, 0x3E, 0x1F,
  0x0F, 0x9F, 0xEF, 0xF7, 0xF8, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7F, 0x3F, 0x8F, 0xC3, 0xE0, 0xF8, 0xFF, 0x8F, 0xF8,
  0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8,
  0xFF, 0x9F, 0xFF, 0xF7, 0xFF, 0x7F, 0xF3, 0xCF, 0xF8, 0xFB, 0xC7, 0xDF,
  0x3C, 0xF9, 0xE7, 0xDF, 0x1E, 0xF8, 0xF7, 0x87, 0xBC, 0x3F, 0xE0, 0xFF,
  0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0xF9, 0xE7,
  0xDE, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xF7, 0x9E, 0xFD, 0xE3,
  0xFF, 0xF8, 0xFF, 0xFC, 0x3F, 0xFF, 0x0F, 0xEF, 0xC3, 0xF3, 0xF0, 0x7C,
  0xFC, 0x1F, 0x3E, 0x07, 0xCF, 0x81, 0xF1, 0xE0, 0x78, 0x78, 0x7C, 0xFB,
  0xE7, 0x8F, 0x7C, 0x7B, 0xE3, 0xFE, 0x0F, 0xF0, 0x7F, 0x01, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xF8, 0x7F, 0xC3, 0xDF, 0x3E, 0xF9, 0xF3, 0xEF, 0x1F,
  0xF8, 0xFB, 0xC7, 0xDF, 0x3E, 0xF9, 0xE7, 0xDF, 0x1E, 0xF8, 0xF7, 0x87,
  0xFC, 0x3F, 0xE0, 0xFF, 0x07, 0xF0, 0x3F, 0x80, 0xFC, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x78, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x1E, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7C, 0x0F, 0x03, 0xE0, 0xF8, 0x1F,
  0x07, 0xC0, 0xF0, 0x3E, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x04, 0x38,
  0xF9, 0xE3, 0xCF, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x9E, 0x38, 0x78,
  0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x1E, 0x3C, 0x7C, 0x70, 0x20, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x41, 0xC3, 0xC3,
  0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC3, 0xC7, 0xC7, 0x9F, 0x7C,
  0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x79, 0xE3, 0x82, 0x00, 0x1C, 0x03,
  0xF1, 0xDF, 0xCE, 0xFF, 0xFF, 0x3F, 0xF8, 0xF8, 0x03, 0x80,
};

const GFXglyph RobotoCondensed_Black29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 5, 21, 8, 1, -21 },
  { 15, 9, 8, 9, 0, -22 },
  { 24, 13, 21, 15, 1, -21 },
  { 59, 13, 27, 15, 1, -24 },
  { 103, 16, 21, 19, 1, -21 },
  { 145, 16, 21, 17, 1, -21 },
  { 187, 3, 8, 4, 1, -22 },
  { 190, 7, 29, 9, 2, -23 },
  { 216, 7, 29, 9, 1, -23 },
  { 242, 13, 13, 14, 0, -21 },
  { 264, 12, 15, 13, 1, -17 },
  { 287, 5, 9, 8, 1, -4 },
  { 293, 8, 4, 12, 2, -11 },
  { 297, 5, 5, 9, 2, -5 },
  { 301, 9, 23, 9, 0, -21 },
  { 327, 13, 21, 15, 1, -21 },
  { 362, 9, 21, 15, 2, -21 },
  { 386, 13, 21, 15, 1, -21 },
  { 421, 13, 21, 15, 1, -21 },
  { 456, 13, 21, 15, 1, -21 },
  { 491, 13, 21, 15, 1, -21 },
  { 526, 13, 21, 15, 1, -21 },
  { 561, 13, 21, 15, 1, -21 },
  { 596, 13, 21, 15, 1, -21 },
  { 631, 13, 21, 15, 1, -21 },
  { 666, 5, 16, 8, 2, -16 },
  { 676, 6, 21, 8, 1, -16 },
  { 692, 10, 14, 13, 1, -16 },
  { 710, 11, 10, 15, 2, -14 },
  { 724, 10, 14, 13, 2, -16 },
  { 742, 11, 21, 13, 1, -21 },
  { 771, 20, 26, 22, 1, -20 },
  { 836, 17, 21, 18, 0, -21 },
  { 881, 14, 21, 16, 1, -21 },
  { 918, 15, 21, 17, 1, -21 },
  { 958, 14, 21, 16, 1, -21 },
  { 995, 13, 21, 14, 1, -21 },
  { 1030, 12, 21, 14, 1, -21 },
  { 1062, 15, 21, 17, 1, -21 },
  { 1102, 15, 21, 18, 1, -21 },
  { 1142, 4, 21, 8, 2, -21 },
  { 1153, 12, 21, 14, 1, -21 },
  { 1185, 15, 21, 16, 1, -21 },
  { 1225, 12, 21, 14, 1, -21 },
  { 1257, 20, 21, 22, 1, -21 },
  { 1310, 15, 21, 18, 1, -21 },
  { 1350, 15, 21, 18, 1, -21 },
  { 1390, 15, 21, 17, 1, -21 },
  { 1430, 15, 25, 18, 1, -21 },
  { 1477, 15, 21, 16, 1, -21 },
  { 1517, 14, 21, 16, 1, -21 },
  { 1554, 14, 21, 16, 1, -21 },
  { 1591, 14, 21, 17, 1, -21 },
  { 1628, 17, 21, 17, 0, -21 },
  { 1673, 21, 21, 22, 0, -21 },
  { 1729, 16, 21, 16, 0, -21 },
  { 1771, 16, 21, 16, 0, -21 },
  { 1813, 14, 21, 15, 1, -21 },
  { 1850, 6, 29, 8, 1, -24 },
  { 1872, 12, 23, 11, 0, -21 },
  { 1907, 6, 29, 8, 0, -24 },
  { 1929, 10, 10, 12, 1, -21 },
  { 1942, 11, 4, 11, 0, 0 },
  { 1948, 8, 4, 10, 1, -21 },
  { 1952, 12, 16, 14, 1, -16 },
  { 1976, 13, 22, 14, 1, -22 },
  { 2012, 12, 16, 13, 1, -16 },
  { 2036, 12, 22, 14, 1, -22 },
  { 2069, 12, 16, 14, 1, -16 },
  { 2093, 9, 22, 10, 0, -22 },
  { 2118, 12, 22, 15, 1, -16 },
  { 2151, 12, 22, 14, 1, -22 },
  { 2184, 5, 23, 8, 1, -23 },
  { 2199, 7, 29, 7, -1, -23 },
  { 2225, 13, 22, 14, 1, -22 },
  { 2261, 5, 22, 8, 1, -22 },
  { 2275, 19, 16, 21, 1, -16 },
  { 2313, 12, 16, 14, 1, -16 },
  { 2337, 13, 16, 14, 1, -16 },
  { 2363, 13, 22, 14, 1, -16 },
  { 2399, 12, 22, 14, 1, -16 },
  { 2432, 8, 16, 10, 1, -16 },
  { 2448, 11, 16, 13, 1, -16 },
  { 2470, 9, 19, 9, 0, -19 },
  { 2492, 12, 16, 14, 1, -16 },
  { 2516, 13, 16, 13, 0, -16 },
  { 2542, 18, 16, 18, 0, -16 },
  { 2578, 13, 16, 13, 0, -16 },
  { 2604, 13, 22, 13, 0, -16 },
  { 2640, 11, 16, 13, 1, -16 },
  { 2662, 7, 28, 9, 1, -23 },
  { 2687, 3, 25, 7, 2, -21 },
  { 2697, 7, 28, 9, 1, -23 },
  { 2722, 13, 7, 16, 1, -12 },
};

const GFXfont RobotoCondensed_Black29pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Black29pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Black29pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _ROBOTOCONDENSED_BLACK29PT7B_H_
