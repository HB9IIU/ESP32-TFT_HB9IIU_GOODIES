#ifndef _ROBOTOCONDENSED_BLACK13PT7B_H_
#define _ROBOTOCONDENSED_BLACK13PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Black.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Black13pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xF3, 0xC0, 0xFF, 0xBB, 0x28, 0xA2, 0x9F, 0x2B, 0xF7, 0x14,
  0x50, 0x23, 0xBF, 0xBC, 0x38, 0x7B, 0xFB, 0x88, 0xE1, 0x52, 0xA7, 0x81,
  0x05, 0x9F, 0xAF, 0x0C, 0x38, 0xF1, 0xA3, 0xC7, 0x6F, 0xF7, 0xBE, 0x7E,
  0xFF, 0x2B, 0x69, 0x24, 0x9B, 0x22, 0x44, 0x62, 0x23, 0x33, 0x22, 0x64,
  0x40, 0x30, 0x4F, 0xCC, 0x79, 0x20, 0x30, 0xCF, 0xFF, 0x30, 0xC0, 0x6D,
  0x60, 0xFC, 0xF0, 0x33, 0x22, 0x66, 0x44, 0xC8, 0x77, 0xF7, 0xBD, 0xEF,
  0x7F, 0x70, 0x3F, 0xB3, 0x33, 0x33, 0x30, 0x39, 0xFE, 0xC3, 0x18, 0xE7,
  0x1F, 0x7C, 0x39, 0xFE, 0xCF, 0x38, 0x3C, 0xDF, 0x78, 0x1C, 0x73, 0xCF,
  0x7D, 0xFF, 0xC7, 0x1C, 0x7D, 0xF6, 0x1E, 0x7C, 0x3E, 0xDF, 0x38, 0x33,
  0xB1, 0xEF, 0xEF, 0x7F, 0x70, 0xFF, 0xF0, 0xC6, 0x18, 0xE3, 0x0C, 0x60,
  0x77, 0xF7, 0xFF, 0x6F, 0x7F, 0x70, 0x77, 0xF7, 0xBF, 0xFC, 0x6E, 0x60,
  0xF0, 0x3C, 0x6C, 0x00, 0xDB, 0xC0, 0x09, 0xFD, 0xE3, 0x84, 0xFF, 0xC0,
  0x0F, 0xFC, 0x8E, 0x77, 0xE8, 0x7F, 0xF6, 0x33, 0x18, 0x06, 0x30, 0x1E,
  0x0C, 0x46, 0x09, 0x3A, 0x5A, 0xB4, 0xAD, 0x2B, 0x5A, 0x5B, 0x10, 0x02,
  0x20, 0x78, 0x18, 0x38, 0x3C, 0x3C, 0x6C, 0x7E, 0x7E, 0x66, 0xE7, 0xFB,
  0xFC, 0xF6, 0xFB, 0x3C, 0xFF, 0xF8, 0x3C, 0xFD, 0x9F, 0x0E, 0x1C, 0x19,
  0xBF, 0x3C, 0xF3, 0xED, 0xF3, 0xCF, 0x3D, 0xFE, 0xF0, 0xFF, 0xF1, 0xFF,
  0xE3, 0x1F, 0xF8, 0xFF, 0xF1, 0xFF, 0xE3, 0x18, 0xC0, 0x7B, 0xFC, 0xF0,
  0xDF, 0x7C, 0xFF, 0x78, 0xCF, 0x3C, 0xFF, 0xFF, 0x3C, 0xF3, 0xCC, 0xFF,
  0xFF, 0xC0, 0x0C, 0x30, 0xC3, 0x0C, 0x3C, 0xDE, 0x78, 0xDF, 0x6F, 0xBC,
  0xF3, 0xED, 0xB7, 0xCC, 0xC6, 0x31, 0x8C, 0x63, 0x1F, 0xF8, 0xE7, 0xE7,
  0xE7, 0xE7, 0xFF, 0xFF, 0xDB, 0xDB, 0xDB, 0xCF, 0x3E, 0xFB, 0xFF, 0x7D,
  0xF7, 0xCC, 0x3C, 0xFD, 0x9F, 0x3E, 0x7C, 0xD9, 0xBF, 0x3C, 0xFB, 0xFC,
  0xF3, 0xFF, 0xEC, 0x30, 0xC0, 0x3C, 0xFD, 0x9B, 0x3E, 0x6C, 0xD9, 0xBF,
  0x3C, 0x0C, 0x08, 0xFB, 0xFC, 0xF3, 0xFB, 0xED, 0xB6, 0xCC, 0x38, 0xF9,
  0xBB, 0x83, 0xC1, 0xBB, 0xBF, 0x3C, 0xFF, 0xFC, 0xE1, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xFF, 0x78, 0xE6, 0xE6, 0x66,
  0x6E, 0x6C, 0x3C, 0x3C, 0x38, 0x38, 0xCD, 0xF6, 0xDF, 0x6F, 0xB7, 0xFB,
  0xF9, 0xDC, 0x6E, 0x33, 0x00, 0xE6, 0xD9, 0xB1, 0xE3, 0x87, 0x9B, 0x37,
  0xE6, 0xE6, 0xD9, 0xB1, 0x63, 0x87, 0x0E, 0x1C, 0x38, 0xFF, 0xF8, 0x30,
  0xC3, 0x86, 0x18, 0x3F, 0xFE, 0xFF, 0xFF, 0xFF, 0xC0, 0xC7, 0x18, 0xC7,
  0x18, 0xC7, 0x18, 0xC0, 0xFD, 0xB6, 0xDB, 0x6D, 0xFE, 0x33, 0x94, 0xBD,
  0x80, 0xFF, 0xC0, 0x63, 0x79, 0xE1, 0xDF, 0xFF, 0xF6, 0xC0, 0xC6, 0x31,
  0xEF, 0xEF, 0x7B, 0xFF, 0x80, 0x79, 0xEC, 0xF0, 0xCD, 0xE7, 0x80, 0x0C,
  0x30, 0xDF, 0x7F, 0x3C, 0xF3, 0x7D, 0xF0, 0x79, 0xFE, 0xFF, 0xE1, 0xE3,
  0x80, 0x37, 0x6F, 0x66, 0x66, 0x66, 0x7D, 0xFC, 0xF3, 0xCD, 0xF7, 0xC3,
  0x7D, 0xE0, 0xC6, 0x31, 0xEF, 0xEF, 0x7B, 0xDE, 0xC0, 0xF3, 0xFF, 0xF0,
  0x6C, 0x36, 0xDB, 0x6D, 0xFC, 0xC6, 0x31, 0xBF, 0x7B, 0xDE, 0xFE, 0xC0,
  0xFF, 0xFF, 0xF0, 0xF6, 0xFF, 0xDB, 0xDB, 0xDB, 0xDB, 0xDB, 0xF7, 0xF7,
  0xBD, 0xEF, 0x60, 0x79, 0xFC, 0xF3, 0xCD, 0xF7, 0x80, 0xF7, 0xF7, 0xBD,
  0xFF, 0xD8, 0xC6, 0x00, 0x7D, 0xFC, 0xF3, 0xCD, 0xF7, 0xC3, 0x0C, 0x30,
  0xFF, 0x6D, 0xB0, 0x79, 0xEE, 0x1E, 0x1B, 0xE7, 0x80, 0x66, 0xF6, 0x66,
  0x67, 0x70, 0xDE, 0xF7, 0xBD, 0xFF, 0xE0, 0xCF, 0xE7, 0x9E, 0x78, 0xC3,
  0x00, 0xDB, 0xDB, 0x5A, 0x7E, 0x7E, 0x76, 0x66, 0xFD, 0xE7, 0x8C, 0x79,
  0xEC, 0xC0, 0xCF, 0xF7, 0x9E, 0x78, 0xC3, 0x0C, 0x71, 0x80, 0x7B, 0xCE,
  0x66, 0x3F, 0xE0, 0x2D, 0xB6, 0xF3, 0x6D, 0x90, 0xFF, 0xE0, 0x44, 0x66,
  0x66, 0x36, 0x66, 0x64, 0xEF, 0xE6,
};

const GFXglyph RobotoCondensed_Black13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 2, 9, 3, 1, -9 },
  { 4, 4, 4, 4, 0, -10 },
  { 6, 6, 9, 7, 0, -9 },
  { 13, 5, 11, 7, 1, -10 },
  { 20, 7, 9, 8, 1, -9 },
  { 28, 7, 9, 8, 0, -9 },
  { 36, 2, 4, 2, 0, -10 },
  { 37, 3, 13, 4, 1, -10 },
  { 42, 4, 13, 4, 0, -10 },
  { 49, 6, 6, 6, 0, -9 },
  { 54, 6, 6, 6, 0, -7 },
  { 59, 3, 4, 4, 0, -2 },
  { 61, 3, 2, 5, 1, -5 },
  { 62, 2, 2, 4, 1, -2 },
  { 63, 4, 10, 4, 0, -9 },
  { 68, 5, 9, 7, 1, -9 },
  { 74, 4, 9, 7, 1, -9 },
  { 79, 6, 9, 7, 0, -9 },
  { 86, 6, 9, 7, 0, -9 },
  { 93, 6, 9, 7, 0, -9 },
  { 100, 6, 9, 7, 0, -9 },
  { 107, 5, 9, 7, 1, -9 },
  { 113, 6, 9, 7, 0, -9 },
  { 120, 5, 9, 7, 1, -9 },
  { 126, 5, 9, 7, 1, -9 },
  { 132, 2, 7, 4, 1, -7 },
  { 134, 3, 9, 4, 0, -7 },
  { 138, 5, 6, 6, 0, -7 },
  { 142, 5, 6, 7, 1, -7 },
  { 146, 4, 6, 6, 1, -7 },
  { 149, 5, 9, 6, 0, -9 },
  { 155, 10, 12, 10, 0, -9 },
  { 170, 8, 9, 8, 0, -9 },
  { 179, 6, 9, 7, 1, -9 },
  { 186, 7, 9, 7, 0, -9 },
  { 194, 6, 9, 7, 1, -9 },
  { 201, 5, 9, 6, 1, -9 },
  { 207, 5, 9, 6, 1, -9 },
  { 213, 6, 9, 8, 1, -9 },
  { 220, 6, 9, 8, 1, -9 },
  { 227, 2, 9, 4, 1, -9 },
  { 230, 6, 9, 6, 0, -9 },
  { 237, 6, 9, 7, 1, -9 },
  { 244, 5, 9, 6, 1, -9 },
  { 250, 8, 9, 10, 1, -9 },
  { 259, 6, 9, 8, 1, -9 },
  { 266, 7, 9, 8, 0, -9 },
  { 274, 6, 9, 7, 1, -9 },
  { 281, 7, 11, 8, 0, -9 },
  { 291, 6, 9, 7, 1, -9 },
  { 298, 7, 9, 7, 0, -9 },
  { 306, 7, 9, 7, 0, -9 },
  { 314, 6, 9, 8, 1, -9 },
  { 321, 8, 9, 8, 0, -9 },
  { 330, 9, 9, 10, 0, -9 },
  { 341, 7, 9, 7, 0, -9 },
  { 349, 7, 9, 7, 0, -9 },
  { 357, 7, 9, 7, 0, -9 },
  { 365, 2, 13, 3, 1, -11 },
  { 369, 5, 10, 5, 0, -9 },
  { 376, 3, 13, 3, 0, -11 },
  { 381, 5, 5, 5, 0, -9 },
  { 385, 5, 2, 5, 0, 0 },
  { 387, 4, 2, 4, 0, -10 },
  { 388, 6, 7, 6, 0, -7 },
  { 394, 5, 10, 6, 1, -10 },
  { 401, 6, 7, 6, 0, -7 },
  { 407, 6, 10, 6, 0, -10 },
  { 415, 6, 7, 6, 0, -7 },
  { 421, 4, 10, 4, 0, -10 },
  { 426, 6, 10, 7, 0, -7 },
  { 434, 5, 10, 6, 1, -10 },
  { 441, 2, 10, 3, 1, -10 },
  { 444, 3, 13, 3, 0, -10 },
  { 449, 5, 10, 6, 1, -10 },
  { 456, 2, 10, 3, 1, -10 },
  { 459, 8, 7, 10, 1, -7 },
  { 466, 5, 7, 6, 1, -7 },
  { 471, 6, 7, 6, 0, -7 },
  { 477, 5, 10, 6, 1, -7 },
  { 484, 6, 10, 6, 0, -7 },
  { 492, 3, 7, 4, 1, -7 },
  { 495, 6, 7, 6, 0, -7 },
  { 501, 4, 9, 4, 0, -9 },
  { 506, 5, 7, 6, 1, -7 },
  { 511, 6, 7, 6, 0, -7 },
  { 517, 8, 7, 8, 0, -7 },
  { 524, 6, 7, 6, 0, -7 },
  { 530, 6, 10, 6, 0, -7 },
  { 538, 5, 7, 6, 0, -7 },
  { 543, 3, 12, 4, 0, -10 },
  { 548, 1, 11, 3, 1, -9 },
  { 550, 4, 12, 4, 0, -10 },
  { 556, 5, 3, 7, 1, -5 },
};

const GFXfont RobotoCondensed_Black13pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Black13pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Black13pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _ROBOTOCONDENSED_BLACK13PT7B_H_
