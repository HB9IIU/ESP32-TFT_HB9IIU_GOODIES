#ifndef _ROBOTOCONDENSED_BLACK8PT7B_H_
#define _ROBOTOCONDENSED_BLACK8PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Black.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Black8pt7bBitmaps[] PROGMEM = {
  0x00, 0xF5, 0x30, 0xF0, 0x46, 0xF6, 0x66, 0x06, 0x74, 0x2F, 0x60, 0x45,
  0x98, 0x66, 0x8C, 0x63, 0x18, 0xEF, 0x38, 0xC0, 0x56, 0x94, 0x95, 0x56,
  0x0D, 0x62, 0x4B, 0xA0, 0x50, 0xC0, 0xC0, 0x55, 0xA0, 0x6F, 0xFF, 0xF6,
  0x75, 0x50, 0x6F, 0x32, 0x4F, 0x6F, 0x36, 0xB6, 0x22, 0x66, 0xF2, 0x74,
  0xE3, 0xF6, 0x24, 0xEF, 0xD6, 0xF3, 0x22, 0x64, 0x6F, 0x76, 0xF6, 0x6F,
  0xF7, 0x26, 0x43, 0xC1, 0x40, 0x79, 0x80, 0xF0, 0xF0, 0xC7, 0xC0, 0x74,
  0xA0, 0x80, 0x21, 0x27, 0x6D, 0xB6, 0xE4, 0x0C, 0x23, 0x14, 0xA7, 0x6C,
  0xED, 0xDF, 0xDF, 0x65, 0xCC, 0xD7, 0xEF, 0xDD, 0xDE, 0xFC, 0xCE, 0xCF,
  0xFC, 0xCE, 0xCC, 0x75, 0xCF, 0xD7, 0xDE, 0xF7, 0xFD, 0xEC, 0xFF, 0xF0,
  0x33, 0x33, 0xF6, 0xD7, 0xB9, 0xCF, 0x68, 0xCC, 0xCC, 0xCF, 0xCF, 0x3F,
  0xFF, 0xFF, 0xF0, 0xDD, 0xFF, 0xDD, 0x62, 0xB7, 0xBD, 0x38, 0xED, 0xDF,
  0xCC, 0x62, 0xB7, 0xBD, 0x38, 0x40, 0xED, 0xDF, 0xFD, 0x6D, 0x43, 0xD7,
  0xF2, 0x22, 0x22, 0xDD, 0xDD, 0xD7, 0xDE, 0x94, 0xE6, 0x30, 0xBF, 0xFF,
  0x9E, 0x79, 0xE0, 0xD7, 0x66, 0x7D, 0xD5, 0x66, 0x22, 0xF3, 0x26, 0x4F,
  0xFF, 0xFF, 0x99, 0x26, 0x40, 0xFF, 0xFF, 0x4A, 0x80, 0xE0, 0x40, 0xE6,
  0xEE, 0xCC, 0xFF, 0xFE, 0xFB, 0xB0, 0x33, 0xFB, 0xF7, 0x6F, 0xC7, 0x6B,
  0xA4, 0x80, 0xFF, 0xF7, 0x36, 0xCC, 0xFF, 0xFF, 0xCF, 0xF0, 0xCF, 0xFE,
  0xCC, 0xEE, 0xEF, 0xFF, 0xF0, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xF6,
  0xFF, 0xFE, 0xCC, 0xFB, 0xF7, 0x33, 0xFB, 0x60, 0xF8, 0xF0, 0x75, 0x40,
  0xFF, 0xF7, 0xE6, 0x66, 0xAF, 0xD4, 0xA0, 0xE6, 0x6E, 0xE6, 0x66, 0x44,
  0xED, 0x70, 0x56, 0x54, 0x7E, 0x95, 0x5C, 0xF0,
};

const GFXglyph RobotoCondensed_Black8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 6, 2, 0, -6 },
  { 3, 2, 2, 3, 0, -6 },
  { 4, 4, 6, 4, 0, -6 },
  { 7, 4, 8, 4, 0, -7 },
  { 11, 5, 6, 5, 0, -6 },
  { 15, 5, 6, 5, 0, -6 },
  { 19, 1, 2, 1, 0, -6 },
  { 20, 2, 8, 3, 0, -6 },
  { 22, 2, 8, 3, 0, -6 },
  { 24, 4, 4, 4, 0, -6 },
  { 26, 3, 4, 4, 0, -5 },
  { 28, 2, 3, 2, 0, -1 },
  { 29, 2, 1, 3, 1, -3 },
  { 30, 2, 1, 2, 0, -1 },
  { 31, 2, 6, 2, 0, -6 },
  { 33, 4, 6, 4, 0, -6 },
  { 36, 2, 6, 4, 1, -6 },
  { 38, 4, 6, 4, 0, -6 },
  { 41, 4, 6, 4, 0, -6 },
  { 44, 4, 6, 4, 0, -6 },
  { 47, 4, 6, 4, 0, -6 },
  { 50, 4, 6, 4, 0, -6 },
  { 53, 4, 6, 4, 0, -6 },
  { 56, 4, 6, 4, 0, -6 },
  { 59, 4, 6, 4, 0, -6 },
  { 62, 2, 4, 2, 0, -4 },
  { 63, 2, 6, 2, 0, -4 },
  { 65, 3, 4, 4, 0, -4 },
  { 67, 4, 3, 4, 0, -4 },
  { 69, 3, 4, 4, 0, -4 },
  { 71, 3, 6, 4, 0, -6 },
  { 74, 6, 8, 6, 0, -6 },
  { 80, 5, 6, 5, 0, -6 },
  { 84, 4, 6, 5, 0, -6 },
  { 87, 4, 6, 5, 0, -6 },
  { 90, 4, 6, 5, 0, -6 },
  { 93, 4, 6, 4, 0, -6 },
  { 96, 4, 6, 4, 0, -6 },
  { 99, 4, 6, 5, 0, -6 },
  { 102, 5, 6, 5, 0, -6 },
  { 106, 2, 6, 2, 0, -6 },
  { 108, 4, 6, 4, 0, -6 },
  { 111, 5, 6, 4, 0, -6 },
  { 115, 4, 6, 4, 0, -6 },
  { 118, 6, 6, 6, 0, -6 },
  { 123, 4, 6, 5, 0, -6 },
  { 126, 5, 6, 5, 0, -6 },
  { 130, 4, 6, 5, 0, -6 },
  { 133, 5, 7, 5, 0, -6 },
  { 138, 4, 6, 5, 0, -6 },
  { 141, 4, 6, 4, 0, -6 },
  { 144, 4, 6, 4, 0, -6 },
  { 147, 4, 6, 5, 0, -6 },
  { 150, 5, 6, 5, 0, -6 },
  { 154, 6, 6, 6, 0, -6 },
  { 159, 4, 6, 5, 0, -6 },
  { 162, 4, 6, 4, 0, -6 },
  { 165, 4, 6, 4, 0, -6 },
  { 168, 2, 8, 2, 0, -7 },
  { 170, 3, 6, 3, 0, -6 },
  { 173, 2, 8, 2, 0, -7 },
  { 175, 3, 3, 3, 0, -6 },
  { 177, 3, 1, 3, 0, 0 },
  { 178, 2, 1, 3, 0, -6 },
  { 179, 4, 4, 4, 0, -4 },
  { 181, 4, 6, 4, 0, -6 },
  { 184, 3, 4, 4, 0, -4 },
  { 186, 4, 6, 4, 0, -6 },
  { 189, 4, 4, 4, 0, -4 },
  { 191, 3, 6, 3, 0, -6 },
  { 194, 4, 6, 4, 0, -4 },
  { 197, 4, 6, 4, 0, -6 },
  { 200, 2, 6, 2, 0, -6 },
  { 202, 2, 8, 2, 0, -6 },
  { 204, 4, 6, 4, 0, -6 },
  { 207, 2, 6, 2, 0, -6 },
  { 209, 6, 4, 6, 0, -4 },
  { 212, 4, 4, 4, 0, -4 },
  { 214, 4, 4, 4, 0, -4 },
  { 216, 4, 6, 4, 0, -4 },
  { 219, 4, 6, 4, 0, -4 },
  { 222, 3, 4, 3, 0, -4 },
  { 224, 3, 4, 4, 0, -4 },
  { 226, 2, 5, 3, 0, -5 },
  { 228, 4, 4, 4, 0, -4 },
  { 230, 4, 4, 4, 0, -4 },
  { 232, 5, 4, 5, 0, -4 },
  { 235, 4, 4, 4, 0, -4 },
  { 237, 4, 6, 4, 0, -4 },
  { 240, 3, 4, 4, 0, -4 },
  { 242, 2, 7, 2, 0, -6 },
  { 244, 1, 7, 2, 1, -6 },
  { 245, 2, 7, 2, 0, -6 },
  { 247, 4, 2, 4, 0, -3 },
};

const GFXfont RobotoCondensed_Black8pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Black8pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Black8pt7bGlyphs,
  0x20, 0x7E, 9
};

#endif // _ROBOTOCONDENSED_BLACK8PT7B_H_
