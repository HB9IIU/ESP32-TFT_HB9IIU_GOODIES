#ifndef _ROBOTOCONDENSED_BLACK25PT7B_H_
#define _ROBOTOCONDENSED_BLACK25PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Black.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Black25pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xEF, 0x39, 0xCE, 0x73, 0x9C, 0xE0, 0x01, 0xDE, 0xF3,
  0x80, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0x80, 0x1D, 0x83, 0xB0, 0x66,
  0x0C, 0xC1, 0xB9, 0xFF, 0xFF, 0xF9, 0xD8, 0x3B, 0x06, 0x60, 0xCC, 0x7F,
  0xEF, 0xFC, 0x6E, 0x1D, 0x83, 0xB0, 0x76, 0x0C, 0xC0, 0x06, 0x00, 0xC0,
  0x18, 0x0F, 0x83, 0xF8, 0xFF, 0x9E, 0xF3, 0xCF, 0x79, 0xEF, 0x01, 0xF0,
  0x1F, 0x81, 0xF8, 0x0F, 0x80, 0xFF, 0x8F, 0xF1, 0xFF, 0x7D, 0xFF, 0x1F,
  0xC1, 0xF0, 0x0C, 0x01, 0x80, 0x3C, 0x01, 0xF0, 0x0E, 0xE6, 0x3B, 0x98,
  0xEE, 0xE3, 0xBB, 0x07, 0xDC, 0x0F, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x67,
  0x01, 0xBE, 0x0D, 0xDC, 0x77, 0x71, 0x9D, 0xCE, 0x77, 0x00, 0xF8, 0x01,
  0xC0, 0x1E, 0x01, 0xFC, 0x1F, 0xE0, 0xF7, 0x07, 0x3C, 0x3D, 0xC1, 0xFE,
  0x07, 0xE0, 0x3E, 0x03, 0xF3, 0xBF, 0xDD, 0xFF, 0xEF, 0x7F, 0x79, 0xFB,
  0xCF, 0x9F, 0xFE, 0x7F, 0xF1, 0xF3, 0xC0, 0xFF, 0xFC, 0x04, 0x31, 0xCE,
  0x38, 0xE7, 0x1C, 0x71, 0xCF, 0x3C, 0xF3, 0xCF, 0x1C, 0x71, 0xC7, 0x1C,
  0x38, 0xE3, 0x87, 0x0C, 0x10, 0x83, 0x0E, 0x1C, 0x70, 0xE3, 0x8E, 0x3C,
  0xF3, 0xC7, 0x1C, 0x73, 0xCF, 0x3C, 0xF3, 0x8E, 0x39, 0xC7, 0x38, 0xC2,
  0x00, 0x06, 0x00, 0x60, 0x06, 0x06, 0x66, 0x7F, 0xE3, 0xFC, 0x0F, 0x01,
  0xF8, 0x39, 0x83, 0x9C, 0x10, 0x80, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x80,
  0x77, 0x77, 0x7E, 0xE4, 0xFF, 0xFF, 0xC0, 0x77, 0xFE, 0xE0, 0x06, 0x0E,
  0x0E, 0x0E, 0x0C, 0x1C, 0x1C, 0x1C, 0x18, 0x38, 0x38, 0x38, 0x30, 0x70,
  0x70, 0x70, 0x60, 0xE0, 0xE0, 0xE0, 0x1F, 0x07, 0xF1, 0xFF, 0x3D, 0xEF,
  0x1D, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F,
  0xE3, 0x9E, 0xF3, 0xFE, 0x3F, 0x83, 0xE0, 0x02, 0x3F, 0xFF, 0xFF, 0xF3,
  0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x1F,
  0x07, 0xF1, 0xFF, 0x7D, 0xEF, 0x3D, 0xE7, 0x80, 0xF0, 0x1E, 0x07, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xE0, 0xF8, 0x1F, 0x07, 0xFF, 0xFF, 0xFF, 0xFC,
  0x1F, 0x0F, 0xF3, 0xFF, 0x79, 0xEF, 0x1E, 0x07, 0x80, 0xF0, 0xFC, 0x1F,
  0x03, 0xF8, 0x0F, 0x00, 0xF0, 0x1F, 0xE3, 0xFC, 0xFF, 0xFE, 0x7F, 0x87,
  0xE0, 0x07, 0xC0, 0xF8, 0x3F, 0x07, 0xE1, 0xFC, 0x3F, 0x8E, 0xF1, 0xDE,
  0x73, 0xCE, 0x7B, 0xCF, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x7F, 0xCF, 0xF9, 0xFF, 0x38, 0x07, 0x01, 0xE0, 0x3F, 0xC7,
  0xFC, 0xFF, 0xC4, 0x78, 0x07, 0x80, 0xF0, 0x1F, 0xE7, 0xBC, 0xF3, 0xFE,
  0x7F, 0x83, 0xE0, 0x07, 0x81, 0xF0, 0xFE, 0x1F, 0x07, 0x80, 0xF0, 0x3D,
  0xE7, 0xFE, 0xFF, 0xDE, 0x7F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xDE, 0xFB,
  0xFE, 0x3F, 0x83, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xE0, 0x3C, 0x07,
  0x81, 0xE0, 0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x0F, 0x81, 0xE0, 0x3C, 0x0F,
  0x81, 0xE0, 0x3C, 0x0F, 0x80, 0x1F, 0x07, 0xF1, 0xFF, 0x7D, 0xEF, 0x3D,
  0xE7, 0x9E, 0xF3, 0xFC, 0x3F, 0x8F, 0xF9, 0xEF, 0x78, 0xFF, 0x1F, 0xE3,
  0xFE, 0xF3, 0xFE, 0x7F, 0x83, 0xE0, 0x1E, 0x07, 0xF1, 0xFF, 0x3D, 0xEF,
  0x3D, 0xE3, 0xFC, 0x7F, 0x8F, 0xFB, 0xEF, 0xFD, 0xFF, 0x9E, 0xE0, 0x3C,
  0x07, 0x83, 0xE1, 0xF8, 0x3E, 0x07, 0x00, 0x77, 0xDE, 0xE0, 0x00, 0x00,
  0x00, 0x1C, 0xF7, 0xB8, 0x77, 0xFE, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xE7,
  0x39, 0xCE, 0x77, 0x10, 0x00, 0x81, 0xC3, 0xEF, 0xFF, 0xE7, 0xC3, 0xE1,
  0xFC, 0x7F, 0x87, 0xC0, 0xE0, 0x10, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0x80, 0x78, 0x3F, 0x1F, 0xE3, 0xF8, 0x7C, 0x3E, 0x7F,
  0xFF, 0x7E, 0x3C, 0x10, 0x00, 0x1F, 0x07, 0xF9, 0xFF, 0x3D, 0xEF, 0x9E,
  0x07, 0xC0, 0xF0, 0x3E, 0x0F, 0x81, 0xE0, 0x38, 0x07, 0x00, 0x00, 0x00,
  0x03, 0x80, 0xF8, 0x1E, 0x01, 0xC0, 0x03, 0xF0, 0x07, 0xFE, 0x07, 0x87,
  0x87, 0x00, 0xE3, 0x80, 0x33, 0x8F, 0x1D, 0x8F, 0xEF, 0xCF, 0x73, 0xE7,
  0x39, 0xF3, 0x98, 0xF3, 0x8C, 0x79, 0xC6, 0x3C, 0xE3, 0x1E, 0x73, 0x9F,
  0x3D, 0xCD, 0xCF, 0xFE, 0xE3, 0x9E, 0x30, 0x00, 0x1C, 0x00, 0x0F, 0x00,
  0x03, 0xE3, 0x00, 0xFF, 0x80, 0x1F, 0x80, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xBC, 0x0F, 0x78, 0x1E, 0xF0,
  0x3C, 0xE0, 0xF1, 0xE1, 0xE3, 0xC3, 0xFF, 0x8F, 0xFF, 0x9F, 0xFF, 0x3C,
  0x1E, 0x78, 0x3F, 0xF0, 0x7C, 0xFF, 0x8F, 0xFE, 0xFF, 0xEF, 0x1F, 0xF0,
  0xFF, 0x0F, 0xF1, 0xFF, 0xFE, 0xFF, 0xCF, 0xFE, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF1, 0xFF, 0xFF, 0xFF, 0xEF, 0xF8, 0x0F, 0x81, 0xFF, 0x1F,
  0xFC, 0xFB, 0xEF, 0x8F, 0xF8, 0x3F, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x0F, 0xF8, 0x7D, 0xF7, 0xCF, 0xFE, 0x3F, 0xE0,
  0x7C, 0x00, 0xFF, 0x0F, 0xFC, 0xFF, 0xEF, 0x3E, 0xF1, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x1F, 0xF3,
  0xEF, 0xFE, 0xFF, 0xCF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0xFE, 0xFF, 0xDF, 0xFB, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x00, 0x0F, 0x81, 0xFF, 0x1F, 0xFC, 0xFB, 0xEF,
  0x8F, 0xF8, 0x3F, 0xC0, 0x1E, 0x00, 0xF3, 0xFF, 0x9F, 0xFC, 0xFF, 0xE0,
  0xFF, 0x07, 0xFC, 0x3D, 0xF3, 0xEF, 0xFF, 0x3F, 0xF0, 0x7E, 0x00, 0xF0,
  0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE,
  0x0F, 0xF0, 0x7F, 0x83, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0xF3, 0xFC, 0xFF, 0x7F,
  0xFE, 0x7F, 0x8F, 0x80, 0xF0, 0xFF, 0x8F, 0xBC, 0x7D, 0xE7, 0xCF, 0x3C,
  0x7B, 0xE3, 0xDE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xF1, 0xFF, 0x8F,
  0xBE, 0x79, 0xF3, 0xC7, 0x9E, 0x3E, 0xF0, 0xF7, 0x87, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x1F, 0xFE,
  0x0F, 0xFF, 0x07, 0xFF, 0x87, 0xFF, 0xE3, 0xFF, 0xF1, 0xFF, 0xF8, 0xFF,
  0xFC, 0x7F, 0xF7, 0x77, 0xFB, 0xBB, 0xFD, 0xDD, 0xFE, 0xEE, 0xFF, 0x3E,
  0x7F, 0x9F, 0x3F, 0xCF, 0x9F, 0xE7, 0xCF, 0xF1, 0xC7, 0xF8, 0xE3, 0xC0,
  0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF8, 0xFF, 0xC7, 0xFF, 0x3F, 0xF9, 0xFE,
  0xCF, 0xF7, 0x7F, 0xBB, 0xFC, 0xFF, 0xE7, 0xFF, 0x1F, 0xF8, 0xFF, 0xC7,
  0xFE, 0x1F, 0xF0, 0xFF, 0x83, 0xC0, 0x0F, 0x81, 0xFF, 0x1F, 0xFC, 0xFB,
  0xEF, 0x8F, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F,
  0xE0, 0xFF, 0x07, 0xFC, 0x7D, 0xF7, 0xCF, 0xFE, 0x3F, 0xE0, 0x7C, 0x00,
  0xFF, 0x8F, 0xFE, 0xFF, 0xEF, 0x1F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF1, 0xFF, 0xFE, 0xFF, 0xEF, 0xF8, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0x0F, 0x81, 0xFF, 0x1F, 0xFC, 0xFB, 0xEF, 0x8F, 0xF8,
  0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07,
  0xFC, 0x7D, 0xF7, 0xCF, 0xFE, 0x3F, 0xE0, 0x7F, 0x80, 0x3E, 0x00, 0xE0,
  0x02, 0x00, 0xFF, 0x87, 0xFF, 0x3F, 0xF9, 0xE3, 0xEF, 0x0F, 0x78, 0x7B,
  0xC3, 0xDE, 0x1E, 0xF1, 0xF7, 0xFF, 0x3F, 0xF1, 0xFF, 0x8F, 0x3C, 0x79,
  0xF3, 0xC7, 0x9E, 0x3E, 0xF1, 0xF7, 0x87, 0x80, 0x1F, 0x83, 0xFC, 0x7F,
  0xEF, 0x9E, 0xF8, 0xFF, 0x8F, 0x78, 0x07, 0xE0, 0x3F, 0x81, 0xFE, 0x07,
  0xE0, 0x1F, 0xF0, 0xFF, 0x0F, 0xF9, 0xF7, 0xFE, 0x3F, 0xE0, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x8F, 0xF9,
  0xF7, 0xFE, 0x3F, 0xE1, 0xF8, 0xF8, 0x3C, 0xF0, 0xF9, 0xE1, 0xF3, 0xC3,
  0xE7, 0xC7, 0x87, 0x8F, 0x0F, 0x3E, 0x1E, 0x78, 0x3C, 0xF0, 0x3D, 0xE0,
  0x7B, 0xC0, 0xF7, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0xF9, 0xE3, 0xDE, 0x78, 0xF7, 0x9E, 0x3D, 0xE7, 0xDF,
  0x79, 0xF7, 0x9E, 0x7D, 0xE7, 0xBF, 0x78, 0xFF, 0xDE, 0x3F, 0xFF, 0x8F,
  0xFF, 0xE3, 0xFF, 0xF0, 0xFE, 0xFC, 0x3F, 0xBF, 0x07, 0xEF, 0xC1, 0xF3,
  0xF0, 0x7C, 0xFC, 0x1F, 0x1E, 0x07, 0xC7, 0x80, 0xF8, 0x7D, 0xF1, 0xE7,
  0xCF, 0x8F, 0x3C, 0x3E, 0xF0, 0x7F, 0x81, 0xFE, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0xFB, 0xC3, 0xCF, 0x1F, 0x3E,
  0x7C, 0x7B, 0xE1, 0xF0, 0xF8, 0x79, 0xE1, 0xE7, 0x8F, 0x8F, 0x3C, 0x3C,
  0xF0, 0xF3, 0x81, 0xFE, 0x07, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1E, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78,
  0x0F, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x3C, 0x07, 0x80, 0x78, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B,
  0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xFF, 0xF8, 0xF0, 0x3E, 0x07, 0x81, 0xE0,
  0x78, 0x0F, 0x03, 0xC0, 0xF0, 0x1E, 0x07, 0x81, 0xE0, 0x7C, 0x0F, 0x03,
  0xC0, 0xF8, 0x1E, 0x07, 0x81, 0xF0, 0x3C, 0x0F, 0xFF, 0xFE, 0xF7, 0xBD,
  0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBF, 0xFF, 0xF8,
  0x1E, 0x07, 0x81, 0xE0, 0xFC, 0x3F, 0x0C, 0xC7, 0x39, 0xCE, 0x73, 0x80,
  0xFF, 0xFF, 0xFF, 0xFC, 0xF1, 0xE3, 0xC7, 0x3E, 0x1F, 0xEF, 0xFB, 0xCF,
  0x03, 0xCF, 0xF7, 0xFF, 0xCF, 0xF3, 0xFC, 0xFF, 0xFF, 0xFF, 0x7B, 0xC0,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3D, 0xE7, 0xFE, 0xFF,
  0xDE, 0x7B, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x9F, 0xFF, 0xDF,
  0xFB, 0xDE, 0x00, 0x3E, 0x1F, 0xEF, 0xFB, 0xCF, 0xF3, 0xFC, 0x0F, 0x03,
  0xC0, 0xF3, 0xFC, 0xFF, 0xF9, 0xFE, 0x3E, 0x00, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF3, 0xFD, 0xFF, 0xFF, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3,
  0xFC, 0xFF, 0x3F, 0xCF, 0xFF, 0xDF, 0xF3, 0xDC, 0x1F, 0x0F, 0xF3, 0xFF,
  0x79, 0xEF, 0x1D, 0xFF, 0xBF, 0xFF, 0xFF, 0xF0, 0x1F, 0x31, 0xFF, 0x3F,
  0xE1, 0xF0, 0x0F, 0x1F, 0x3F, 0x3C, 0x3C, 0x3C, 0xFF, 0xFF, 0xFF, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3D, 0xEF, 0xFF,
  0xFF, 0xF9, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x7F, 0xFF,
  0xBF, 0xF3, 0xDE, 0x07, 0xC8, 0xF3, 0xFE, 0x7F, 0x87, 0xE0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x7B, 0xFF, 0xFF, 0xFC, 0xFF, 0x3F,
  0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x3C, 0x7F, 0xF7,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1C, 0xF3, 0xC7, 0x00, 0xF3,
  0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0xFF, 0xEF,
  0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0xFF, 0x9E,
  0xF7, 0x9F, 0xF3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFF, 0x3F, 0xE7, 0xBE, 0xF3,
  0xDE, 0x7F, 0xC7, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xF7, 0x9E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xEF, 0xF3, 0xCF,
  0xF3, 0xCF, 0xF3, 0xCF, 0xF3, 0xCF, 0xF3, 0xCF, 0xF3, 0xCF, 0xF3, 0xCF,
  0xF3, 0xCF, 0xF3, 0xCF, 0xF7, 0xBF, 0xFF, 0xFF, 0xCF, 0xF3, 0xFC, 0xFF,
  0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xC0, 0x1F, 0x0F, 0xF3,
  0xFF, 0x79, 0xEF, 0x3F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x7B, 0xFF,
  0x3F, 0xC1, 0xF0, 0xF7, 0x9F, 0xFB, 0xFF, 0x79, 0xEF, 0x1F, 0xE3, 0xFC,
  0x7F, 0x8F, 0xF1, 0xFE, 0x7B, 0xFF, 0x7F, 0xEF, 0x79, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x00, 0x3D, 0xDF, 0xFF, 0xFF, 0xCF, 0xF3, 0xFC, 0xFF,
  0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0xFD, 0xFF, 0x3F, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0xF7, 0xFF, 0xFF, 0xFF, 0x1E, 0x3C, 0x78, 0xF1, 0xE3,
  0xC7, 0x8F, 0x00, 0x1F, 0x07, 0xF9, 0xFF, 0x3D, 0xF7, 0x80, 0xFC, 0x0F,
  0xE0, 0x7E, 0x03, 0xEE, 0x3D, 0xFF, 0x1F, 0xE1, 0xF0, 0x3C, 0x78, 0xF7,
  0xFF, 0xFF, 0xCF, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0xCF, 0x8F, 0xF3,
  0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF,
  0xFD, 0xFF, 0x39, 0xC0, 0xF9, 0xEF, 0x3D, 0xE7, 0xBD, 0xE7, 0xBC, 0x77,
  0x8F, 0xF1, 0xFC, 0x3F, 0x83, 0xF0, 0x7C, 0x0F, 0x80, 0xF0, 0xF3, 0x9E,
  0xE7, 0xBD, 0xCF, 0x7B, 0xDE, 0xF7, 0xFD, 0xCF, 0xFB, 0x8F, 0xFF, 0x1F,
  0x7E, 0x3E, 0xFC, 0x7C, 0xF0, 0xF9, 0xE0, 0xF3, 0xC1, 0xC7, 0x80, 0x79,
  0xEF, 0x3C, 0xEF, 0x1F, 0xE3, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x3F, 0x87,
  0xF9, 0xEF, 0x3C, 0xFF, 0x9E, 0xF1, 0xEF, 0x3D, 0xE7, 0xBD, 0xE7, 0xBC,
  0x77, 0x8F, 0xF1, 0xFC, 0x1F, 0x83, 0xF0, 0x7C, 0x0F, 0x80, 0xF0, 0x1C,
  0x07, 0x81, 0xF0, 0x3C, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xE1, 0xF0, 0xF0,
  0xF0, 0x78, 0x78, 0x7C, 0x3C, 0x3F, 0xFF, 0xFF, 0xF8, 0x08, 0xE3, 0x9E,
  0x79, 0xE7, 0x9E, 0x79, 0xCF, 0x38, 0xF1, 0xC7, 0x1E, 0x79, 0xE7, 0x9E,
  0x78, 0xE3, 0x82, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC3, 0x8F, 0x1C,
  0x71, 0xC7, 0x1C, 0x71, 0xE3, 0xC7, 0x3D, 0xE7, 0x1C, 0x71, 0xC7, 0x1C,
  0x73, 0xCE, 0x30, 0x38, 0x6F, 0x9D, 0xFB, 0xF3, 0xFE, 0x7D, 0xC7, 0x00,
};

const GFXglyph RobotoCondensed_Black25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 5, 18, 7, 1, -18 },
  { 13, 7, 7, 8, 0, -19 },
  { 20, 11, 18, 13, 1, -18 },
  { 45, 11, 23, 13, 1, -21 },
  { 77, 14, 18, 16, 1, -18 },
  { 109, 13, 18, 15, 1, -18 },
  { 139, 2, 7, 4, 1, -19 },
  { 141, 6, 26, 8, 1, -20 },
  { 161, 6, 26, 8, 1, -20 },
  { 181, 12, 11, 12, 0, -18 },
  { 198, 10, 14, 12, 1, -16 },
  { 216, 4, 8, 7, 1, -3 },
  { 220, 6, 3, 11, 2, -9 },
  { 223, 5, 4, 8, 1, -4 },
  { 226, 8, 20, 8, 0, -18 },
  { 246, 11, 18, 13, 1, -18 },
  { 271, 7, 18, 13, 2, -18 },
  { 287, 11, 18, 13, 1, -18 },
  { 312, 11, 18, 13, 1, -18 },
  { 337, 11, 18, 13, 1, -18 },
  { 362, 11, 18, 13, 1, -18 },
  { 387, 11, 18, 13, 1, -18 },
  { 412, 11, 18, 13, 1, -18 },
  { 437, 11, 18, 13, 1, -18 },
  { 462, 11, 18, 13, 1, -18 },
  { 487, 5, 14, 7, 1, -14 },
  { 496, 5, 19, 7, 1, -14 },
  { 508, 9, 12, 11, 1, -13 },
  { 522, 9, 8, 13, 2, -12 },
  { 531, 9, 12, 11, 1, -13 },
  { 545, 11, 18, 11, 0, -18 },
  { 570, 17, 23, 19, 1, -17 },
  { 619, 15, 18, 15, 0, -18 },
  { 653, 12, 18, 14, 1, -18 },
  { 680, 13, 18, 14, 1, -18 },
  { 710, 12, 18, 14, 1, -18 },
  { 737, 11, 18, 12, 1, -18 },
  { 762, 10, 18, 12, 1, -18 },
  { 785, 13, 18, 15, 1, -18 },
  { 815, 13, 18, 15, 1, -18 },
  { 845, 5, 18, 7, 1, -18 },
  { 857, 10, 18, 12, 1, -18 },
  { 880, 13, 18, 14, 1, -18 },
  { 910, 10, 18, 12, 1, -18 },
  { 933, 17, 18, 19, 1, -18 },
  { 972, 13, 18, 15, 1, -18 },
  { 1002, 13, 18, 15, 1, -18 },
  { 1032, 12, 18, 14, 1, -18 },
  { 1059, 13, 21, 15, 1, -18 },
  { 1094, 13, 18, 14, 1, -18 },
  { 1124, 12, 18, 14, 1, -18 },
  { 1151, 12, 18, 14, 1, -18 },
  { 1178, 12, 18, 14, 1, -18 },
  { 1205, 15, 18, 15, 0, -18 },
  { 1239, 18, 18, 19, 0, -18 },
  { 1280, 14, 18, 14, 0, -18 },
  { 1312, 14, 18, 14, 0, -18 },
  { 1344, 12, 18, 13, 1, -18 },
  { 1371, 5, 25, 7, 1, -21 },
  { 1387, 10, 20, 10, 0, -18 },
  { 1412, 5, 25, 7, 0, -21 },
  { 1428, 10, 9, 10, 0, -18 },
  { 1440, 10, 3, 10, 0, 0 },
  { 1444, 6, 4, 9, 1, -19 },
  { 1447, 10, 13, 12, 1, -13 },
  { 1464, 11, 19, 12, 1, -19 },
  { 1491, 10, 13, 11, 1, -13 },
  { 1508, 10, 19, 12, 1, -19 },
  { 1532, 11, 13, 12, 1, -13 },
  { 1550, 8, 19, 8, 0, -19 },
  { 1569, 11, 18, 13, 1, -13 },
  { 1594, 10, 19, 12, 1, -19 },
  { 1618, 4, 18, 7, 1, -18 },
  { 1627, 6, 23, 6, -1, -18 },
  { 1645, 11, 19, 12, 1, -19 },
  { 1672, 4, 19, 7, 1, -19 },
  { 1682, 16, 13, 18, 1, -13 },
  { 1708, 10, 13, 12, 1, -13 },
  { 1725, 11, 13, 12, 1, -13 },
  { 1743, 11, 18, 12, 1, -13 },
  { 1768, 10, 18, 12, 1, -13 },
  { 1791, 7, 13, 9, 1, -13 },
  { 1803, 11, 13, 11, 0, -13 },
  { 1821, 7, 16, 8, 0, -16 },
  { 1835, 10, 13, 12, 1, -13 },
  { 1852, 11, 13, 12, 0, -13 },
  { 1870, 15, 13, 16, 0, -13 },
  { 1895, 11, 13, 11, 0, -13 },
  { 1913, 11, 18, 12, 0, -13 },
  { 1938, 9, 13, 11, 1, -13 },
  { 1953, 6, 24, 7, 1, -20 },
  { 1971, 2, 21, 6, 2, -18 },
  { 1977, 6, 24, 7, 1, -20 },
  { 1995, 11, 6, 14, 1, -10 },
};

const GFXfont RobotoCondensed_Black25pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Black25pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Black25pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _ROBOTOCONDENSED_BLACK25PT7B_H_
