#ifndef _ROBOTOCONDENSED_BLACK31PT7B_H_
#define _ROBOTOCONDENSED_BLACK31PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Black.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Black31pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xEF, 0x7B, 0xC0, 0x03,
  0xBF, 0xFF, 0xB8, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0x8F, 0xC7,
  0xE3, 0x80, 0x0E, 0x70, 0x39, 0xC0, 0xE6, 0x03, 0xB8, 0x0E, 0xE0, 0x3B,
  0x87, 0xFF, 0xDF, 0xFF, 0x7F, 0xFC, 0x73, 0x81, 0xDC, 0x07, 0x70, 0x1D,
  0xC3, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0x39, 0xC0, 0xE6, 0x03, 0xB8, 0x0E,
  0xE0, 0x3B, 0x80, 0xCE, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xF0,
  0x1F, 0xE0, 0xFF, 0xC7, 0xFF, 0x9F, 0x3E, 0x7C, 0xFD, 0xF1, 0xF7, 0xC0,
  0x1F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0xFF, 0x00, 0xFE, 0x01, 0xF8, 0x03,
  0xEF, 0x87, 0xBE, 0x3E, 0x7C, 0xF9, 0xFF, 0xE3, 0xFF, 0x87, 0xFC, 0x0F,
  0xC0, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x3E, 0x00, 0x1F, 0xC0, 0x07, 0xF8,
  0x83, 0xCE, 0x38, 0xF3, 0x9C, 0x3C, 0xE6, 0x0F, 0x3B, 0x81, 0xFF, 0xC0,
  0x7F, 0x70, 0x07, 0xB8, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xDE, 0x00,
  0xEF, 0xE0, 0x3F, 0xF8, 0x1D, 0xCE, 0x06, 0x73, 0xC3, 0x9C, 0xF1, 0xC7,
  0x38, 0x31, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0xF0,
  0x0F, 0xF8, 0x07, 0xFE, 0x03, 0xCF, 0x03, 0xE7, 0x80, 0xF3, 0xC0, 0x7B,
  0xE0, 0x3F, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xF3, 0xE7, 0xFD, 0xF7,
  0xFF, 0xF3, 0xEF, 0xF9, 0xF3, 0xFC, 0xF9, 0xFE, 0x7C, 0x7E, 0x3F, 0xFF,
  0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFC, 0xF8, 0xFF, 0xFF, 0xFF, 0xE0, 0x06,
  0x1C, 0x78, 0xE3, 0xC7, 0x1E, 0x3C, 0x71, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C,
  0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x1C, 0x3C, 0x78, 0x70, 0xF0, 0xE1,
  0xE1, 0xC1, 0x00, 0x40, 0xE0, 0xF0, 0x70, 0x78, 0x3C, 0x3C, 0x3C, 0x1E,
  0x1E, 0x1E, 0x1E, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1E, 0x1E,
  0x1E, 0x1E, 0x3C, 0x3C, 0x3C, 0x78, 0x70, 0xF0, 0xE0, 0x40, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x73, 0x9D, 0xFF, 0xF7, 0xFF, 0xC3, 0xF8,
  0x07, 0xC0, 0x3F, 0x81, 0xEE, 0x0F, 0x1C, 0x38, 0x70, 0x20, 0x80, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC3, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC3, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x7B, 0xDE, 0xF7, 0xBD, 0xFE, 0xF3, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0x77, 0xFF, 0xF7, 0x00, 0x03, 0x83, 0xC1, 0xE0, 0xE0, 0x70, 0x78, 0x3C,
  0x1C, 0x0E, 0x0F, 0x07, 0x83, 0x81, 0xC1, 0xE0, 0xF0, 0x70, 0x38, 0x3C,
  0x1E, 0x0E, 0x07, 0x07, 0x83, 0xC1, 0xC0, 0x0F, 0x80, 0x7F, 0x83, 0xFF,
  0x1F, 0xFC, 0x7C, 0xF9, 0xF3, 0xEF, 0x8F, 0xBE, 0x1E, 0xF8, 0x7F, 0xE1,
  0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xBE, 0x3E, 0x7C,
  0xF9, 0xF3, 0xE7, 0xFF, 0x0F, 0xFC, 0x1F, 0xE0, 0x3E, 0x00, 0x00, 0x83,
  0xC7, 0xFF, 0xFF, 0xFF, 0xFF, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x0F,
  0xC0, 0xFF, 0x87, 0xFF, 0x1F, 0xFE, 0xFC, 0xFB, 0xE3, 0xEF, 0x8F, 0x80,
  0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xE0, 0x3F, 0x00,
  0xF8, 0x07, 0xC0, 0x3F, 0x01, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0x80, 0xFF, 0x87, 0xFF, 0x1F, 0xFE, 0xFC, 0xFB, 0xE3,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x3F, 0xC0, 0xFE, 0x03, 0xF8, 0x0F,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0xF8, 0x7F, 0xE3, 0xEF, 0xFF, 0x9F,
  0xFC, 0x3F, 0xE0, 0x3F, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xFC,
  0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0x07, 0xFC, 0x1D, 0xF0, 0xF7, 0xC3, 0xDF,
  0x1E, 0x7C, 0x79, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0xFB, 0xFF, 0xDF,
  0xFE, 0xFF, 0xF7, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x78, 0x7F, 0xF3, 0xFF,
  0xBF, 0xFE, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xFF, 0x1F, 0xF8, 0xFF,
  0xE7, 0xDF, 0xFE, 0x7F, 0xE1, 0xFE, 0x07, 0xC0, 0x01, 0xE0, 0x1F, 0x80,
  0xFE, 0x07, 0xF8, 0x3F, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x78, 0x7F, 0xF3,
  0xFF, 0xEF, 0xFF, 0xBF, 0x3F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F,
  0x78, 0x7D, 0xF3, 0xE7, 0xFF, 0x8F, 0xFC, 0x1F, 0xE0, 0x1F, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00,
  0xF8, 0x00, 0x0F, 0xC0, 0xFF, 0x0F, 0xFC, 0xFF, 0xF7, 0xCF, 0xBE, 0x7D,
  0xF3, 0xEF, 0x9F, 0x7C, 0xF9, 0xFF, 0x87, 0xF8, 0x7F, 0xC7, 0xFF, 0x3E,
  0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF, 0xE7, 0xDF, 0xFE, 0xFF, 0xF3, 0xFF,
  0x07, 0xE0, 0x0F, 0x80, 0x7F, 0x83, 0xFF, 0x1F, 0xFC, 0x7C, 0xF9, 0xF3,
  0xEF, 0x8F, 0xBE, 0x3E, 0xF8, 0xFB, 0xE3, 0xF7, 0xCF, 0xDF, 0xFE, 0x7F,
  0xF8, 0xFF, 0xE1, 0xFF, 0x80, 0x3E, 0x01, 0xF0, 0x0F, 0xC1, 0xFE, 0x07,
  0xF0, 0x1F, 0x80, 0x78, 0x00, 0x7B, 0xEF, 0xBE, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7B, 0xEF, 0xFE, 0x70, 0x39, 0xF7, 0xDF, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xF3, 0xCF, 0x3C, 0xF7, 0x9E, 0x7B, 0xC2, 0x00,
  0x00, 0x20, 0x1C, 0x0F, 0x87, 0xF3, 0xFF, 0xFF, 0x3F, 0x87, 0xC0, 0xFE,
  0x1F, 0xF0, 0xFF, 0x87, 0xF0, 0x3E, 0x01, 0xC0, 0x08, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x80, 0x1C, 0x03, 0xE0, 0x7F, 0x0F, 0xF8, 0x7F, 0xC3, 0xF8,
  0x1F, 0x0F, 0xE7, 0xFF, 0xFE, 0x7F, 0x0F, 0x81, 0xC0, 0x20, 0x00, 0x1F,
  0x87, 0xFC, 0xFF, 0xEF, 0xFF, 0xF9, 0xFF, 0x9F, 0x01, 0xF0, 0x1F, 0x03,
  0xE0, 0x7E, 0x0F, 0xC0, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x00, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xFE, 0x00, 0x7F, 0xFC, 0x03, 0xC0, 0x78, 0x1E, 0x00, 0xF0, 0xF0, 0x01,
  0xC3, 0x83, 0xC3, 0x9E, 0x3F, 0xCE, 0x71, 0xFF, 0x39, 0xC7, 0x9C, 0xEF,
  0x3C, 0xF1, 0xF8, 0xF3, 0xC7, 0xE3, 0x8F, 0x1F, 0x8E, 0x3C, 0x7E, 0x38,
  0xE1, 0xB9, 0xE3, 0x8E, 0xE3, 0x8E, 0x3B, 0x8F, 0x78, 0xEE, 0x3F, 0xFF,
  0x3C, 0x7D, 0xF8, 0x70, 0xE3, 0xC1, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x02, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x7F,
  0x00, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3D, 0xE0, 0x0F, 0xBC, 0x01, 0xF7,
  0xC0, 0x3C, 0xF8, 0x0F, 0x8F, 0x01, 0xF1, 0xF0, 0x3E, 0x3E, 0x0F, 0xFF,
  0xC1, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xF1, 0xF8, 0x3F, 0x3E, 0x07,
  0xE7, 0xC0, 0x7D, 0xF8, 0x0F, 0x80, 0xFF, 0xE1, 0xFF, 0xF3, 0xFF, 0xF7,
  0xFF, 0xFF, 0xC7, 0xFF, 0x87, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF9,
  0xFB, 0xFF, 0xE7, 0xFF, 0xCF, 0xFF, 0xDF, 0x87, 0xFF, 0x0F, 0xFE, 0x1F,
  0xFC, 0x3F, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0x9F, 0xFE, 0x00,
  0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFE, 0x7E, 0x3E, 0x7C, 0x1F,
  0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x1F, 0xFC, 0x1F, 0x7C, 0x3F, 0x7E, 0x3E,
  0x7F, 0xFE, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xE0, 0xFF, 0xC1, 0xFF, 0xE3,
  0xFF, 0xE7, 0xFF, 0xEF, 0xCF, 0xDF, 0x8F, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC,
  0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0x87, 0xFF, 0x0F,
  0xFE, 0x1F, 0xFC, 0x7F, 0xF9, 0xFB, 0xFF, 0xF7, 0xFF, 0xCF, 0xFF, 0x1F,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xFF, 0xCF, 0xFF, 0x3F, 0xFC, 0xFF,
  0xF3, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xFF, 0xBF, 0xFD, 0xFF,
  0xEF, 0xFF, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x00, 0x07, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC, 0x3F,
  0xFE, 0x7E, 0x3E, 0x7C, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0x1F, 0xFC,
  0x1F, 0x7C, 0x1F, 0x7E, 0x3F, 0x3F, 0xFF, 0x3F, 0xFF, 0x1F, 0xFC, 0x07,
  0xF0, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC,
  0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC,
  0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xFF,
  0x1F, 0xF9, 0xFF, 0xCF, 0xBF, 0xFC, 0xFF, 0xC3, 0xFC, 0x0F, 0xC0, 0xFC,
  0x3F, 0x7E, 0x1F, 0xBF, 0x1F, 0x9F, 0x8F, 0x8F, 0xCF, 0xC7, 0xE7, 0xC3,
  0xF7, 0xE1, 0xFB, 0xE0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFE,
  0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xE1, 0xF9, 0xF0, 0xFC, 0xFC, 0x7E,
  0x3E, 0x3F, 0x1F, 0x9F, 0x8F, 0xCF, 0xC3, 0xF7, 0xE1, 0xF8, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFE, 0x03,
  0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xDC, 0x7F,
  0xFE, 0xF3, 0xFF, 0xF7, 0x9D, 0xFF, 0xBD, 0xEF, 0xFE, 0xEF, 0x7F, 0xF7,
  0xF3, 0xFF, 0xBF, 0x9F, 0xFC, 0xFC, 0xFF, 0xE7, 0xE7, 0xFF, 0x3E, 0x3F,
  0xF9, 0xF1, 0xFF, 0xC7, 0x8F, 0xFE, 0x3C, 0x7C, 0xFC, 0x1F, 0xFC, 0x1F,
  0xFE, 0x1F, 0xFE, 0x1F, 0xFE, 0x1F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x9F,
  0xFF, 0x9F, 0xFF, 0xDF, 0xFD, 0xDF, 0xFD, 0xDF, 0xFD, 0xFF, 0xFC, 0xFF,
  0xFC, 0xFF, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x1F, 0xFC, 0x1F, 0x07, 0xE0, 0x0F, 0xFC, 0x0F, 0xFF, 0x07, 0xFF,
  0xC7, 0xE3, 0xF3, 0xE0, 0xFB, 0xF0, 0x7D, 0xF8, 0x3E, 0xF8, 0x1F, 0x7C,
  0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFB, 0xF0, 0x7D,
  0xF8, 0x3E, 0x7C, 0x1F, 0x3F, 0x1F, 0x8F, 0xFF, 0x87, 0xFF, 0x81, 0xFF,
  0x80, 0x3F, 0x00, 0xFF, 0xE0, 0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0xFC,
  0x7E, 0xFC, 0x3E, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3E, 0xFC,
  0x7E, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xE0, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x0F, 0xFC, 0x0F, 0xFF, 0x07, 0xFF, 0xC7, 0xE3, 0xF3, 0xE0, 0xFB,
  0xF0, 0x7D, 0xF8, 0x3E, 0xFC, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03,
  0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xF0, 0x7D, 0xF8, 0x3E, 0x7C, 0x1F, 0x3F,
  0x1F, 0x8F, 0xFF, 0x87, 0xFF, 0x81, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0xFC,
  0x00, 0x3E, 0x00, 0x0E, 0x00, 0x02, 0x00, 0xFF, 0xC1, 0xFF, 0xE3, 0xFF,
  0xE7, 0xFF, 0xEF, 0x8F, 0xDF, 0x0F, 0xBE, 0x1F, 0x7C, 0x3E, 0xF8, 0x7D,
  0xF1, 0xFB, 0xFF, 0xE7, 0xFF, 0xCF, 0xFE, 0x1F, 0xFC, 0x3E, 0xFC, 0x7C,
  0xF8, 0xF9, 0xF9, 0xF1, 0xF3, 0xE3, 0xF7, 0xC7, 0xEF, 0x87, 0xDF, 0x0F,
  0xC0, 0x07, 0xE0, 0x3F, 0xF0, 0xFF, 0xF3, 0xFF, 0xE7, 0xC7, 0xEF, 0x87,
  0xDF, 0x0F, 0xBE, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x7F, 0xC0,
  0x3F, 0xC0, 0x1F, 0x80, 0x1F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF8, 0xFD, 0xFF,
  0xF1, 0xFF, 0xE1, 0xFF, 0x80, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x00, 0xFC, 0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0x87,
  0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE1, 0xFF,
  0xC3, 0xFF, 0x87, 0xFF, 0x0F, 0xFE, 0x1F, 0x7C, 0x3E, 0xF8, 0xFD, 0xFF,
  0xF9, 0xFF, 0xE1, 0xFF, 0x80, 0xFC, 0x00, 0xFC, 0x0F, 0xDF, 0x03, 0xF7,
  0xC0, 0xF9, 0xF8, 0x7E, 0x7E, 0x1F, 0x8F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3F, 0x3F, 0x07, 0xCF, 0x81, 0xF3, 0xE0, 0x7C, 0xF8, 0x0F, 0x3E,
  0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7C, 0x7C, 0x7C,
  0xF8, 0xF8, 0xF9, 0xF1, 0xF1, 0xF3, 0xE3, 0xE3, 0xE7, 0xCF, 0xC7, 0xCF,
  0x9F, 0xCF, 0x8F, 0xBF, 0xBE, 0x1F, 0x7F, 0x7C, 0x3E, 0xFE, 0xF8, 0x7D,
  0xFD, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC1, 0xFE, 0xFF, 0x03, 0xFD,
  0xFE, 0x07, 0xFB, 0xFC, 0x0F, 0xF7, 0xF8, 0x1F, 0xEF, 0xF0, 0x3F, 0x8F,
  0xE0, 0x3F, 0x1F, 0x80, 0x7E, 0x3F, 0x00, 0xFC, 0x7E, 0x01, 0xF8, 0xFC,
  0x00, 0x7C, 0x1F, 0xBF, 0x0F, 0x9F, 0x8F, 0xC7, 0xC7, 0xE3, 0xF3, 0xE0,
  0xFB, 0xF0, 0x7D, 0xF0, 0x1F, 0xF8, 0x0F, 0xF8, 0x03, 0xFC, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xF0, 0x3E, 0xF8, 0x1F,
  0x7E, 0x1F, 0x9F, 0x0F, 0x8F, 0xCF, 0xC7, 0xE7, 0xE1, 0xFF, 0xE0, 0xFC,
  0xFC, 0x1F, 0xBE, 0x0F, 0x9F, 0x07, 0xC7, 0xC7, 0xE3, 0xE3, 0xE1, 0xF1,
  0xF0, 0x7D, 0xF0, 0x3E, 0xF8, 0x0F, 0x7C, 0x07, 0xFC, 0x03, 0xFE, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x7E,
  0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x03,
  0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xBF, 0x7E,
  0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF,
  0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x07, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF,
  0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1E, 0x03, 0xE0, 0x7C, 0x1F, 0x83, 0xF8, 0x77, 0x1E, 0xE3, 0x9E, 0xF3,
  0xDE, 0x3B, 0x87, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x7C,
  0x3E, 0x1E, 0x0F, 0x0F, 0x81, 0xFF, 0x1F, 0xFD, 0xFF, 0xEF, 0x9F, 0x00,
  0xF8, 0x07, 0xC3, 0xFE, 0x7F, 0xF7, 0xFF, 0xBE, 0x7D, 0xF3, 0xEF, 0x9F,
  0x7F, 0xFB, 0xFF, 0xCF, 0xFE, 0x3C, 0xF8, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xBE, 0x3F, 0xFC, 0xFF, 0xFB, 0xFF,
  0xEF, 0xCF, 0xBE, 0x3E, 0xF8, 0x7B, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8,
  0x7B, 0xE3, 0xEF, 0x8F, 0xBF, 0xFE, 0xFF, 0xFB, 0xFF, 0xCF, 0xBE, 0x00,
  0x0F, 0x83, 0xFE, 0x7F, 0xE7, 0xFF, 0xF9, 0xFF, 0x8F, 0xF8, 0xFF, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x8F, 0xF9, 0xF7, 0xFF, 0x7F, 0xF3, 0xFE,
  0x0F, 0x80, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x7B, 0xEF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC,
  0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xFF, 0xF7, 0xFF,
  0xBF, 0xFC, 0x7B, 0xE0, 0x0F, 0xC1, 0xFF, 0x1F, 0xFC, 0xFF, 0xFF, 0x8F,
  0xFC, 0x7F, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xF0, 0x0F,
  0xC2, 0x3F, 0xF9, 0xFF, 0xE7, 0xFE, 0x0F, 0xC0, 0x07, 0xC3, 0xF1, 0xFC,
  0x7F, 0x3F, 0x0F, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xE0, 0xF8, 0x3E,
  0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0x1F, 0x79, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFC, 0x7F, 0xE3,
  0xFF, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0xCF, 0xBF, 0xFD,
  0xFF, 0xE7, 0xFF, 0x1E, 0xF8, 0x07, 0xC0, 0x3E, 0x7F, 0xF3, 0xFF, 0x3F,
  0xF0, 0x7E, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE7, 0x9F, 0xFE, 0xFF, 0xF7, 0xFF, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F,
  0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF,
  0x8F, 0xFC, 0x7F, 0xE3, 0xE0, 0x79, 0xFF, 0xDF, 0x78, 0x00, 0x1F, 0x7D,
  0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x1E,
  0x1F, 0x3F, 0x1F, 0x1E, 0x00, 0x00, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x3F, 0xFE, 0xFE, 0xFC, 0xF8, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x8F, 0xFE, 0x7E, 0xF9, 0xF3, 0xEF, 0xCF, 0xBE,
  0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x3F, 0xF8, 0xFF, 0xE3, 0xF7,
  0xCF, 0x9F, 0x3E, 0x7E, 0xF8, 0xFB, 0xE3, 0xFF, 0x87, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xF9, 0xE3, 0xCF, 0xBF, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xF9, 0xFF, 0x8F, 0x9F, 0xF8, 0xF9, 0xFF, 0x8F, 0x9F, 0xF8, 0xF9, 0xFF,
  0x8F, 0x9F, 0xF8, 0xF9, 0xFF, 0x8F, 0x9F, 0xF8, 0xF9, 0xFF, 0x8F, 0x9F,
  0xF8, 0xF9, 0xFF, 0x8F, 0x9F, 0xF8, 0xF9, 0xF0, 0xF9, 0xE7, 0xFF, 0xBF,
  0xFD, 0xFF, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF, 0xC7,
  0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0xF8,
  0x0F, 0x81, 0xFF, 0x1F, 0xFC, 0xFF, 0xFF, 0xCF, 0xFC, 0x7F, 0xE3, 0xFF,
  0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xBF, 0xFD, 0xFF,
  0xC7, 0xFC, 0x0F, 0x80, 0xFB, 0xE3, 0xFF, 0xCF, 0xFF, 0xBF, 0xFE, 0xFC,
  0xFB, 0xE3, 0xEF, 0x87, 0xBE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x8F, 0xBE,
  0x3E, 0xFC, 0xFB, 0xFF, 0xEF, 0xFF, 0x3F, 0xFC, 0xFB, 0xC3, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x1E, 0x7B, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF,
  0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xFF, 0xFD, 0xFF, 0xEF, 0xFF, 0x1E,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0xFB,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x00, 0x1F, 0x83, 0xFE, 0x7F, 0xEF,
  0xBF, 0xF9, 0xFF, 0x80, 0xFC, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x07, 0xF0,
  0x1F, 0xF1, 0xFF, 0x9F, 0x7F, 0xE7, 0xFE, 0x1F, 0x80, 0x3E, 0x1F, 0x0F,
  0x9F, 0xFF, 0xFF, 0xFF, 0xFE, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1,
  0xF0, 0xF8, 0x7C, 0x3F, 0x9F, 0xC7, 0xE1, 0xF0, 0xF8, 0xFF, 0xC7, 0xFE,
  0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF, 0xC7,
  0xFE, 0x3F, 0xF1, 0xFF, 0xCF, 0xBF, 0xFD, 0xFF, 0xEF, 0xFF, 0x1E, 0xF8,
  0xFC, 0x7D, 0xF3, 0xF7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF8, 0xF3, 0xE3, 0xEF,
  0x0F, 0xFC, 0x3F, 0xF0, 0x7F, 0xC1, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x3F,
  0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x78, 0xE3, 0xEF, 0x1E, 0x7D, 0xE7,
  0xCF, 0x3E, 0xF9, 0xE7, 0xDF, 0x3C, 0xFB, 0xF7, 0x8F, 0x7F, 0xF1, 0xFF,
  0xFE, 0x3F, 0xFF, 0x87, 0xF7, 0xF0, 0xFE, 0xFE, 0x0F, 0xDF, 0xC1, 0xF9,
  0xF8, 0x3E, 0x3E, 0x07, 0xC7, 0xC0, 0xF8, 0xF8, 0x1F, 0x1F, 0x00, 0x7C,
  0x7D, 0xF3, 0xE3, 0xEF, 0x8F, 0xBC, 0x3F, 0xF0, 0x7F, 0xC1, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xFC, 0x3F, 0xF0, 0xFB, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0x7C, 0xFC, 0x7D, 0xF1, 0xF7, 0xCF, 0xDF, 0x3E,
  0x7C, 0xF8, 0xFB, 0xE3, 0xFF, 0x0F, 0xFC, 0x1F, 0xF0, 0x7F, 0x81, 0xFE,
  0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0x80, 0x1E,
  0x00, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xC0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0xF8, 0x1F, 0x81,
  0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x04, 0x1C, 0x79, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF3, 0xEF, 0x9E,
  0x3C, 0x7C, 0x78, 0xF8, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0x78,
  0x70, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x41, 0xE3, 0xC3,
  0xC7, 0x8F, 0x1F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE3, 0xE3, 0xC7, 0x9F, 0x3C,
  0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3C, 0x78, 0xF3, 0xC7, 0x84, 0x00, 0x1E,
  0x00, 0xFC, 0x77, 0xFB, 0xDF, 0xFF, 0xF3, 0xFF, 0xC7, 0xE0, 0x0F, 0x00,
};

const GFXglyph RobotoCondensed_Black31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 5, 22, 8, 2, -22 },
  { 15, 9, 9, 10, 0, -23 },
  { 26, 14, 22, 16, 1, -22 },
  { 65, 14, 28, 16, 1, -25 },
  { 114, 18, 22, 20, 1, -22 },
  { 164, 17, 22, 18, 1, -22 },
  { 211, 3, 9, 5, 1, -23 },
  { 215, 7, 31, 10, 2, -24 },
  { 243, 8, 31, 10, 1, -24 },
  { 274, 14, 14, 14, 0, -22 },
  { 299, 13, 16, 14, 1, -18 },
  { 325, 5, 10, 8, 1, -4 },
  { 332, 8, 4, 13, 2, -12 },
  { 336, 5, 5, 9, 2, -5 },
  { 340, 9, 24, 10, 0, -22 },
  { 367, 14, 22, 16, 1, -22 },
  { 406, 9, 22, 16, 2, -22 },
  { 431, 14, 22, 16, 1, -22 },
  { 470, 14, 22, 16, 1, -22 },
  { 509, 14, 22, 16, 1, -22 },
  { 548, 13, 22, 16, 1, -22 },
  { 584, 14, 22, 16, 1, -22 },
  { 623, 14, 22, 16, 1, -22 },
  { 662, 13, 22, 16, 1, -22 },
  { 698, 14, 22, 16, 1, -22 },
  { 737, 6, 17, 9, 2, -17 },
  { 750, 6, 23, 9, 1, -17 },
  { 768, 11, 15, 14, 1, -17 },
  { 789, 12, 11, 16, 2, -15 },
  { 806, 11, 15, 14, 2, -17 },
  { 827, 12, 22, 14, 1, -22 },
  { 860, 22, 28, 24, 1, -21 },
  { 937, 19, 22, 19, 0, -22 },
  { 990, 15, 22, 18, 1, -22 },
  { 1032, 16, 22, 18, 1, -22 },
  { 1076, 15, 22, 17, 1, -22 },
  { 1118, 14, 22, 15, 1, -22 },
  { 1157, 13, 22, 15, 1, -22 },
  { 1193, 16, 22, 18, 1, -22 },
  { 1237, 16, 22, 19, 1, -22 },
  { 1281, 5, 22, 9, 2, -22 },
  { 1295, 13, 22, 15, 1, -22 },
  { 1331, 17, 22, 17, 1, -22 },
  { 1378, 13, 22, 15, 1, -22 },
  { 1414, 21, 22, 24, 1, -22 },
  { 1472, 16, 22, 19, 1, -22 },
  { 1516, 17, 22, 19, 1, -22 },
  { 1563, 16, 22, 18, 1, -22 },
  { 1607, 17, 26, 19, 1, -22 },
  { 1663, 15, 22, 18, 2, -22 },
  { 1705, 15, 22, 17, 1, -22 },
  { 1747, 15, 22, 17, 1, -22 },
  { 1789, 15, 22, 18, 1, -22 },
  { 1831, 18, 22, 18, 0, -22 },
  { 1881, 23, 22, 23, 0, -22 },
  { 1945, 17, 22, 17, 0, -22 },
  { 1992, 17, 22, 17, 0, -22 },
  { 2039, 15, 22, 17, 1, -22 },
  { 2081, 7, 31, 8, 1, -26 },
  { 2109, 13, 24, 12, 0, -22 },
  { 2148, 6, 31, 8, 1, -26 },
  { 2172, 11, 11, 12, 1, -22 },
  { 2188, 12, 4, 12, 0, 0 },
  { 2194, 8, 5, 11, 1, -24 },
  { 2199, 13, 17, 14, 1, -17 },
  { 2227, 14, 23, 15, 1, -23 },
  { 2268, 12, 17, 14, 1, -17 },
  { 2294, 13, 23, 15, 1, -23 },
  { 2332, 13, 17, 15, 1, -17 },
  { 2360, 10, 23, 10, 0, -23 },
  { 2389, 13, 23, 16, 1, -17 },
  { 2427, 13, 23, 15, 1, -23 },
  { 2465, 6, 24, 8, 1, -24 },
  { 2483, 8, 30, 8, -1, -24 },
  { 2513, 14, 23, 15, 1, -23 },
  { 2554, 5, 23, 8, 2, -23 },
  { 2569, 20, 17, 23, 1, -17 },
  { 2612, 13, 17, 15, 1, -17 },
  { 2640, 13, 17, 15, 1, -17 },
  { 2668, 14, 23, 15, 1, -17 },
  { 2709, 13, 23, 15, 1, -17 },
  { 2747, 9, 17, 11, 1, -17 },
  { 2767, 12, 17, 14, 1, -17 },
  { 2793, 9, 20, 10, 0, -20 },
  { 2816, 13, 17, 15, 1, -17 },
  { 2844, 14, 17, 14, 0, -17 },
  { 2874, 19, 17, 19, 0, -17 },
  { 2915, 14, 17, 14, 0, -17 },
  { 2945, 14, 23, 14, 0, -17 },
  { 2986, 12, 17, 14, 1, -17 },
  { 3012, 7, 29, 9, 1, -24 },
  { 3038, 2, 26, 8, 3, -22 },
  { 3045, 7, 29, 9, 1, -24 },
  { 3071, 14, 7, 17, 1, -13 },
};

const GFXfont RobotoCondensed_Black31pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Black31pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Black31pt7bGlyphs,
  0x20, 0x7E, 36
};

#endif // _ROBOTOCONDENSED_BLACK31PT7B_H_
