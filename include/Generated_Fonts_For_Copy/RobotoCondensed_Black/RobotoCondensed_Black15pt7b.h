#ifndef _ROBOTOCONDENSED_BLACK15PT7B_H_
#define _ROBOTOCONDENSED_BLACK15PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Black.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Black15pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0x3C, 0xDD, 0xDD, 0x14, 0x68, 0xF1, 0xE7, 0xE5, 0x0A,
  0x7F, 0x28, 0xD1, 0xE0, 0x10, 0x47, 0xBF, 0xCF, 0x0E, 0x1E, 0x1F, 0x3C,
  0xFF, 0x78, 0xC0, 0xE0, 0xB4, 0xB4, 0xBC, 0xE8, 0x18, 0x16, 0x3F, 0x2B,
  0x4F, 0x06, 0x38, 0x3E, 0x1B, 0x0D, 0x83, 0xC1, 0xC1, 0xED, 0xDE, 0xEF,
  0x3F, 0x8E, 0xC0, 0xFF, 0x2D, 0xED, 0xB6, 0xDB, 0x66, 0xC8, 0x46, 0x63,
  0x33, 0x33, 0x33, 0x33, 0x66, 0x40, 0x10, 0x23, 0x5B, 0xE3, 0x8D, 0x81,
  0x00, 0x38, 0x70, 0xE7, 0xFF, 0xE7, 0x0E, 0x1C, 0x6D, 0xB4, 0xFF, 0xF8,
  0x11, 0x8C, 0x62, 0x31, 0x8C, 0x46, 0x31, 0x80, 0x7B, 0xED, 0xF3, 0xCF,
  0x3C, 0xF3, 0xDF, 0xE7, 0x80, 0x1B, 0xFE, 0x73, 0x9C, 0xE7, 0x39, 0xCE,
  0x3C, 0xFD, 0xBF, 0x70, 0xE1, 0x86, 0x1C, 0x70, 0xFD, 0xF8, 0x3C, 0xFD,
  0xB8, 0x71, 0xC3, 0x83, 0x83, 0xEE, 0xFC, 0xF0, 0x0C, 0x38, 0x71, 0xE3,
  0xCD, 0x9B, 0x7F, 0x7E, 0x18, 0x30, 0x7E, 0xFD, 0x83, 0x07, 0xCF, 0xC3,
  0x83, 0x6E, 0xF8, 0xF0, 0x39, 0xEE, 0x30, 0xFB, 0xFC, 0xF3, 0xCF, 0xF7,
  0x80, 0xFF, 0xFC, 0x38, 0x60, 0xC3, 0x86, 0x0C, 0x38, 0x61, 0xC0, 0x7B,
  0xFD, 0xF7, 0xFB, 0xED, 0xF3, 0xDF, 0xF7, 0x80, 0x73, 0xED, 0xF3, 0xCF,
  0xF6, 0xC7, 0x19, 0xE6, 0x00, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x36, 0xDA,
  0x00, 0x04, 0x77, 0xB8, 0x78, 0x70, 0x40, 0xFF, 0xF0, 0x3F, 0xFC, 0x87,
  0x1E, 0x37, 0xF2, 0x00, 0x79, 0xFE, 0xC3, 0x1C, 0x63, 0x8C, 0x00, 0xE3,
  0x00, 0x0F, 0x07, 0x38, 0x81, 0x33, 0xB4, 0xD6, 0xB6, 0x76, 0xDE, 0xDB,
  0x5B, 0x49, 0xB9, 0x80, 0x1C, 0x81, 0xF0, 0x1C, 0x0E, 0x07, 0x06, 0xC3,
  0x61, 0xB1, 0xDC, 0xFE, 0x7F, 0x31, 0xF8, 0xE0, 0xF9, 0xFB, 0x3E, 0x7F,
  0xDF, 0xB3, 0xE7, 0xCF, 0xFB, 0xF0, 0x79, 0xFF, 0x3E, 0x3C, 0x18, 0x30,
  0x63, 0xCF, 0xFD, 0xE0, 0xF9, 0xFB, 0x36, 0x7C, 0xF9, 0xF3, 0xE7, 0xCD,
  0xFB, 0xE0, 0xFF, 0xFC, 0x30, 0xFB, 0xEC, 0x30, 0xC3, 0xFF, 0xC0, 0xFF,
  0xFC, 0x30, 0xC3, 0xFF, 0xF0, 0xC3, 0x0C, 0x00, 0x7D, 0xFF, 0x9E, 0x3C,
  0x1B, 0xF7, 0xE3, 0xE7, 0xFD, 0xF0, 0xC7, 0x8F, 0x1E, 0x3F, 0xFF, 0xF1,
  0xE3, 0xC7, 0x8F, 0x18, 0xFF, 0xFF, 0xFC, 0x0E, 0x1C, 0x38, 0x70, 0xE1,
  0xC3, 0x87, 0xEE, 0xF8, 0xE0, 0xCE, 0xCE, 0xDC, 0xD8, 0xF8, 0xF8, 0xF8,
  0xFC, 0xCC, 0xCE, 0xCE, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0xFF,
  0xC0, 0xE3, 0xF8, 0xFF, 0x3F, 0xCF, 0xF7, 0xFD, 0xFD, 0x7F, 0x77, 0xDD,
  0xF7, 0x7C, 0xDC, 0xC7, 0xCF, 0x9F, 0xBF, 0x7A, 0xF7, 0xE7, 0xCF, 0x9F,
  0x18, 0x3D, 0xFF, 0x9E, 0x3C, 0x78, 0xF1, 0xE3, 0xE7, 0xFD, 0xF0, 0xF9,
  0xFB, 0x3E, 0x7C, 0xFF, 0xFE, 0x60, 0xC1, 0x83, 0x00, 0x3C, 0xFE, 0xE6,
  0xC6, 0xC6, 0xC7, 0xC6, 0xC6, 0xE6, 0xFE, 0x3C, 0x0E, 0x04, 0xF9, 0xFB,
  0x3E, 0x7C, 0xFF, 0xBE, 0x6E, 0xDD, 0x9F, 0x38, 0x3C, 0x7E, 0x67, 0x60,
  0x78, 0x3E, 0x0E, 0x67, 0x67, 0x7E, 0x3C, 0xFF, 0xFF, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3,
  0xE7, 0xCF, 0xF9, 0xE0, 0xE3, 0xF1, 0x99, 0xCE, 0xE7, 0x61, 0xB0, 0xD8,
  0x7C, 0x3C, 0x0E, 0x07, 0x00, 0xEE, 0xFD, 0xDD, 0xBB, 0x37, 0x66, 0xEC,
  0xFF, 0x9E, 0xF3, 0xDE, 0x3B, 0x87, 0x70, 0xEE, 0x00, 0xE7, 0x77, 0x76,
  0x3E, 0x3C, 0x1C, 0x3C, 0x3E, 0x76, 0x67, 0xE7, 0xE7, 0x67, 0x66, 0x76,
  0x3C, 0x3C, 0x1C, 0x18, 0x18, 0x18, 0x18, 0xFF, 0xFF, 0x0E, 0x0C, 0x1C,
  0x18, 0x38, 0x30, 0x70, 0x7F, 0x7F, 0xFF, 0x6D, 0xB6, 0xDB, 0x6D, 0xBF,
  0xE3, 0x86, 0x1C, 0x70, 0xC3, 0x0E, 0x18, 0x61, 0xC3, 0xFD, 0xB6, 0xDB,
  0x6D, 0xB6, 0xFF, 0x30, 0xC7, 0x9A, 0xCC, 0xFF, 0xF0, 0x63, 0x38, 0xF9,
  0xB3, 0xE6, 0xDD, 0xBF, 0x3F, 0xC3, 0x0C, 0x30, 0xFB, 0xFC, 0xF3, 0xCF,
  0x3F, 0xFE, 0x38, 0xF9, 0xB7, 0x0E, 0x0D, 0x9F, 0x1C, 0x0E, 0x1C, 0x38,
  0x77, 0xEF, 0xFB, 0xF7, 0xEF, 0xDD, 0xFB, 0xB0, 0x3C, 0xF9, 0x9F, 0xFF,
  0xEC, 0x1F, 0x1E, 0x3B, 0xDC, 0xEF, 0xFD, 0xCE, 0x73, 0x9C, 0xE0, 0x3E,
  0xFF, 0x9F, 0x3E, 0x7C, 0xDF, 0x9B, 0x0E, 0xFC, 0xF0, 0xC3, 0x0C, 0x30,
  0xFB, 0xFD, 0xF7, 0xDF, 0x7D, 0xF7, 0xF3, 0xFF, 0xFC, 0x33, 0x03, 0x33,
  0x33, 0x33, 0x33, 0xFE, 0xC3, 0x0C, 0x30, 0xDF, 0x6F, 0xBC, 0xFB, 0x6D,
  0xF3, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xF7, 0x7B, 0xBD, 0xDE, 0xEF, 0x77,
  0xBB, 0xFB, 0xFD, 0xF7, 0xDF, 0x7D, 0xF7, 0x3C, 0xFD, 0xBF, 0x3E, 0x6D,
  0xDF, 0x9E, 0xFB, 0xFC, 0xF3, 0xCF, 0x3F, 0xFE, 0xC3, 0x0C, 0x00, 0x76,
  0xFF, 0xBF, 0x7E, 0xFD, 0xDF, 0xBF, 0x0E, 0x1C, 0x38, 0xFF, 0xCC, 0xCC,
  0xCC, 0x79, 0xF6, 0xDE, 0x3F, 0xB7, 0xDE, 0x66, 0xFF, 0x66, 0x66, 0x73,
  0xDF, 0x7D, 0xF7, 0xDF, 0x7F, 0xFB, 0xEE, 0xD9, 0xB3, 0x67, 0xC7, 0x0E,
  0x1C, 0xED, 0xF6, 0xDF, 0x6F, 0xE7, 0xF3, 0xB9, 0xDC, 0x66, 0xEC, 0xD9,
  0xF1, 0xC3, 0x8F, 0x9B, 0x77, 0xEF, 0xD9, 0xB3, 0xE7, 0xC7, 0x0E, 0x1C,
  0x30, 0xE1, 0x80, 0xFF, 0xCE, 0xE6, 0x73, 0xFF, 0x33, 0x66, 0x66, 0xEE,
  0x66, 0x66, 0x63, 0x10, 0xFF, 0xFF, 0xFF, 0xC0, 0x46, 0x66, 0x66, 0x33,
  0x66, 0x66, 0x66, 0x40, 0xE7, 0xF9, 0xC0,
};

const GFXglyph RobotoCondensed_Black15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 2, 11, 4, 1, -11 },
  { 4, 4, 4, 5, 0, -11 },
  { 6, 7, 11, 8, 0, -11 },
  { 16, 6, 14, 8, 1, -13 },
  { 27, 8, 11, 10, 1, -11 },
  { 38, 9, 11, 9, 0, -11 },
  { 51, 2, 4, 2, 0, -11 },
  { 52, 3, 15, 5, 1, -12 },
  { 58, 4, 15, 5, 0, -12 },
  { 66, 7, 7, 7, 0, -11 },
  { 73, 7, 8, 7, 0, -9 },
  { 80, 3, 5, 4, 0, -2 },
  { 82, 4, 2, 6, 1, -6 },
  { 83, 3, 2, 5, 1, -2 },
  { 84, 5, 12, 5, 0, -11 },
  { 92, 6, 11, 8, 1, -11 },
  { 101, 5, 11, 8, 1, -11 },
  { 108, 7, 11, 8, 0, -11 },
  { 118, 7, 11, 8, 0, -11 },
  { 128, 7, 11, 8, 0, -11 },
  { 138, 7, 11, 8, 0, -11 },
  { 148, 6, 11, 8, 1, -11 },
  { 157, 7, 11, 8, 0, -11 },
  { 167, 6, 11, 8, 1, -11 },
  { 176, 6, 11, 8, 1, -11 },
  { 185, 3, 8, 4, 1, -8 },
  { 188, 3, 11, 4, 1, -8 },
  { 193, 6, 7, 7, 0, -8 },
  { 199, 6, 5, 8, 1, -7 },
  { 203, 5, 7, 7, 1, -8 },
  { 208, 6, 11, 7, 0, -11 },
  { 217, 11, 13, 12, 0, -10 },
  { 235, 9, 11, 9, 0, -11 },
  { 248, 7, 11, 9, 1, -11 },
  { 258, 7, 11, 9, 1, -11 },
  { 268, 7, 11, 8, 1, -11 },
  { 278, 6, 11, 7, 1, -11 },
  { 287, 6, 11, 7, 1, -11 },
  { 296, 7, 11, 9, 1, -11 },
  { 306, 7, 11, 9, 1, -11 },
  { 316, 2, 11, 4, 1, -11 },
  { 319, 7, 11, 7, 0, -11 },
  { 329, 8, 11, 8, 1, -11 },
  { 340, 6, 11, 7, 1, -11 },
  { 349, 10, 11, 11, 1, -11 },
  { 363, 7, 11, 9, 1, -11 },
  { 373, 7, 11, 9, 1, -11 },
  { 383, 7, 11, 9, 1, -11 },
  { 393, 8, 13, 9, 1, -11 },
  { 406, 7, 11, 9, 1, -11 },
  { 416, 8, 11, 8, 0, -11 },
  { 427, 8, 11, 8, 0, -11 },
  { 438, 7, 11, 9, 1, -11 },
  { 448, 9, 11, 9, 0, -11 },
  { 461, 11, 11, 11, 0, -11 },
  { 477, 8, 11, 8, 0, -11 },
  { 488, 8, 11, 8, 0, -11 },
  { 499, 8, 11, 8, 0, -11 },
  { 510, 3, 16, 4, 1, -13 },
  { 516, 6, 12, 6, 0, -11 },
  { 525, 3, 16, 4, 0, -13 },
  { 531, 6, 5, 6, 0, -11 },
  { 535, 6, 2, 6, 0, 0 },
  { 537, 4, 2, 5, 0, -11 },
  { 538, 7, 8, 7, 0, -8 },
  { 545, 6, 12, 7, 1, -12 },
  { 554, 7, 8, 7, 0, -8 },
  { 561, 7, 12, 7, 0, -12 },
  { 572, 7, 8, 7, 0, -8 },
  { 579, 5, 12, 5, 0, -12 },
  { 587, 7, 11, 8, 0, -8 },
  { 597, 6, 12, 7, 1, -12 },
  { 606, 2, 11, 4, 1, -11 },
  { 609, 4, 14, 4, -1, -11 },
  { 616, 6, 12, 7, 1, -12 },
  { 625, 2, 12, 4, 1, -12 },
  { 628, 9, 8, 11, 1, -8 },
  { 637, 6, 8, 7, 1, -8 },
  { 643, 7, 8, 7, 0, -8 },
  { 650, 6, 11, 7, 1, -8 },
  { 659, 7, 11, 7, 0, -8 },
  { 669, 4, 8, 5, 1, -8 },
  { 673, 6, 8, 7, 0, -8 },
  { 679, 4, 10, 5, 0, -10 },
  { 684, 6, 8, 7, 1, -8 },
  { 690, 7, 8, 7, 0, -8 },
  { 697, 9, 8, 9, 0, -8 },
  { 706, 7, 8, 7, 0, -8 },
  { 713, 7, 11, 7, 0, -8 },
  { 723, 5, 8, 7, 1, -8 },
  { 728, 4, 15, 4, 0, -12 },
  { 736, 2, 13, 4, 1, -11 },
  { 740, 4, 15, 4, 0, -12 },
  { 748, 6, 3, 8, 1, -6 },
};

const GFXfont RobotoCondensed_Black15pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Black15pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Black15pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _ROBOTOCONDENSED_BLACK15PT7B_H_
