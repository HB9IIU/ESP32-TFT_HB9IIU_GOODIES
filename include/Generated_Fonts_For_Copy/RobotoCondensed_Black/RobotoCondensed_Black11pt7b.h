#ifndef _ROBOTOCONDENSED_BLACK11PT7B_H_
#define _ROBOTOCONDENSED_BLACK11PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Black.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Black11pt7bBitmaps[] PROGMEM = {
  0x00, 0xFB, 0xB6, 0x80, 0x31, 0x9E, 0xE5, 0x7D, 0x4A, 0x13, 0x9E, 0xB7,
  0x1F, 0x6F, 0x71, 0x00, 0x60, 0xF1, 0xE3, 0x81, 0xC5, 0xCB, 0x86, 0x71,
  0xE5, 0x9C, 0x7F, 0x7D, 0x9F, 0xE8, 0x5A, 0xAA, 0x94, 0x89, 0xB2, 0x4B,
  0x6A, 0x00, 0x25, 0x5E, 0xA5, 0x00, 0x21, 0x3F, 0xF2, 0x10, 0x5C, 0xE0,
  0xB0, 0x25, 0xA4, 0x96, 0x80, 0x73, 0xD7, 0xBD, 0xAD, 0xEE, 0x3D, 0xB6,
  0xDB, 0x72, 0xF6, 0x33, 0x31, 0x9F, 0x76, 0xC6, 0x33, 0x0F, 0x6E, 0x19,
  0xCE, 0xB5, 0xFC, 0x63, 0x7A, 0x10, 0xE5, 0x8F, 0x6E, 0x33, 0x91, 0xFD,
  0xE5, 0xEE, 0xF8, 0xC6, 0x23, 0x19, 0x8C, 0x73, 0xD6, 0xF7, 0x2D, 0xEE,
  0x73, 0xF6, 0xB7, 0x8C, 0xCC, 0xB0, 0xB0, 0x4C, 0x00, 0x96, 0x17, 0xC7,
  0x10, 0xF0, 0xF0, 0x8E, 0x3E, 0x80, 0x76, 0xC6, 0x62, 0x00, 0x84, 0x1C,
  0x62, 0x5D, 0x55, 0xF5, 0xB5, 0xF5, 0x5E, 0x60, 0x3C, 0x30, 0x70, 0xE3,
  0x46, 0xCF, 0x93, 0x62, 0xF5, 0xE7, 0x2F, 0x4E, 0x7E, 0x39, 0xFC, 0xF0,
  0xC3, 0x37, 0xCE, 0xE5, 0xA7, 0x39, 0xCE, 0xDC, 0xF8, 0x88, 0xF8, 0x8F,
  0xF8, 0x88, 0xF8, 0x88, 0x39, 0xB4, 0xF0, 0xDD, 0x36, 0xCE, 0x9C, 0xE7,
  0x3F, 0xCE, 0x73, 0xFF, 0x18, 0xC6, 0x31, 0x8F, 0x6E, 0x9D, 0xAD, 0xCF,
  0x7A, 0xF3, 0x88, 0x88, 0x88, 0x8F, 0xCF, 0x9F, 0x3F, 0x7B, 0xF6, 0xED,
  0xDB, 0xDE, 0xF7, 0x7B, 0xDE, 0x73, 0x39, 0xBC, 0xF3, 0xCF, 0x36, 0xCE,
  0xF5, 0xE7, 0x3F, 0x42, 0x10, 0x39, 0xBC, 0xF3, 0xCF, 0x36, 0xCE, 0x0C,
  0xF5, 0xE7, 0x7F, 0x5A, 0xD3, 0x79, 0xB4, 0x1C, 0x3B, 0x36, 0xCE, 0xFC,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x9C, 0xE7, 0x39, 0xCF, 0x7E, 0xCF, 0x36,
  0xDA, 0x78, 0xE3, 0x8C, 0xDB, 0xDB, 0x5B, 0x7A, 0x7E, 0x7E, 0x7E, 0x66,
  0xCD, 0xE7, 0x8E, 0x39, 0xE7, 0xB3, 0xCD, 0x27, 0x9E, 0x30, 0xC3, 0x0C,
  0xFC, 0x61, 0x8C, 0x31, 0x86, 0x3F, 0xEA, 0xAA, 0xAC, 0xC6, 0x18, 0xC6,
  0x10, 0xC6, 0x10, 0xD5, 0x55, 0x5C, 0x66, 0x7D, 0xF0, 0x4C, 0x76, 0xDF,
  0xBD, 0xBC, 0xC6, 0x31, 0xFD, 0xEF, 0x7B, 0xF8, 0x76, 0xF1, 0x8D, 0xB8,
  0x18, 0xC6, 0xFD, 0xEF, 0x7B, 0x78, 0x72, 0xF7, 0xF6, 0x3C, 0x76, 0x6E,
  0x66, 0x66, 0x60, 0x7E, 0xF7, 0xBD, 0xBD, 0x6E, 0xC6, 0x31, 0xFD, 0xEF,
  0x7B, 0xD8, 0x51, 0x55, 0x40, 0x51, 0x55, 0x7C, 0xC6, 0x31, 0xBF, 0x7B,
  0xDB, 0xD8, 0xFF, 0x80, 0xFE, 0xDB, 0xDB, 0xDB, 0xDB, 0xDB, 0xFE, 0xF7,
  0xBD, 0xEC, 0x76, 0xF7, 0xBD, 0xB8, 0xFE, 0xF7, 0xBD, 0xFF, 0x18, 0x7E,
  0xF7, 0xBD, 0xBC, 0x63, 0xFF, 0xCC, 0xCC, 0x76, 0xD8, 0x6D, 0xB8, 0x5D,
  0x24, 0xD8, 0xDE, 0xF7, 0xBD, 0xBC, 0xDE, 0xD4, 0xE7, 0x38, 0xD7, 0xA9,
  0xF3, 0x66, 0xCD, 0x80, 0xDA, 0x9C, 0xE5, 0x6C, 0xDE, 0xD4, 0xE7, 0x11,
  0x8C, 0xF9, 0x8C, 0xC6, 0x7C, 0x2D, 0x25, 0x92, 0x4C, 0x80, 0xFF, 0x80,
  0xC9, 0x24, 0x52, 0x4B, 0x00, 0x6B, 0xF6,
};

const GFXglyph RobotoCondensed_Black11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 1, 8, 3, 1, -8 },
  { 2, 3, 3, 3, 0, -8 },
  { 4, 5, 8, 6, 0, -8 },
  { 9, 5, 10, 6, 0, -9 },
  { 16, 7, 8, 7, 0, -8 },
  { 23, 6, 8, 7, 0, -8 },
  { 29, 2, 3, 2, 0, -8 },
  { 30, 2, 11, 4, 1, -9 },
  { 33, 3, 11, 4, 0, -9 },
  { 38, 5, 5, 5, 0, -8 },
  { 42, 5, 6, 5, 0, -7 },
  { 46, 2, 3, 3, 0, -1 },
  { 47, 3, 1, 5, 1, -4 },
  { 48, 2, 2, 3, 1, -2 },
  { 49, 3, 9, 3, 0, -8 },
  { 53, 5, 8, 6, 0, -8 },
  { 58, 3, 8, 6, 1, -8 },
  { 61, 5, 8, 6, 0, -8 },
  { 66, 5, 8, 6, 0, -8 },
  { 71, 5, 8, 6, 0, -8 },
  { 76, 5, 8, 6, 0, -8 },
  { 81, 5, 8, 6, 0, -8 },
  { 86, 5, 8, 6, 0, -8 },
  { 91, 5, 8, 6, 0, -8 },
  { 96, 5, 8, 6, 0, -8 },
  { 101, 2, 6, 3, 1, -6 },
  { 103, 3, 8, 3, 0, -6 },
  { 106, 4, 5, 5, 0, -6 },
  { 109, 4, 3, 6, 1, -5 },
  { 111, 4, 5, 5, 1, -6 },
  { 114, 5, 8, 5, 0, -8 },
  { 119, 8, 10, 8, 0, -8 },
  { 129, 7, 8, 7, 0, -8 },
  { 136, 5, 8, 6, 1, -8 },
  { 141, 6, 8, 6, 0, -8 },
  { 147, 5, 8, 6, 1, -8 },
  { 152, 4, 8, 5, 1, -8 },
  { 156, 4, 8, 5, 1, -8 },
  { 160, 6, 8, 7, 0, -8 },
  { 166, 5, 8, 7, 1, -8 },
  { 171, 1, 8, 3, 1, -8 },
  { 172, 5, 8, 5, 0, -8 },
  { 177, 5, 8, 6, 1, -8 },
  { 182, 4, 8, 5, 1, -8 },
  { 186, 7, 8, 8, 1, -8 },
  { 193, 5, 8, 7, 1, -8 },
  { 198, 6, 8, 7, 0, -8 },
  { 204, 5, 8, 6, 1, -8 },
  { 209, 6, 9, 7, 0, -8 },
  { 216, 5, 8, 6, 1, -8 },
  { 221, 6, 8, 6, 0, -8 },
  { 227, 6, 8, 6, 0, -8 },
  { 233, 5, 8, 6, 1, -8 },
  { 238, 6, 8, 6, 0, -8 },
  { 244, 8, 8, 8, 0, -8 },
  { 252, 6, 8, 6, 0, -8 },
  { 258, 6, 8, 6, 0, -8 },
  { 264, 6, 8, 6, 0, -8 },
  { 270, 2, 11, 3, 1, -9 },
  { 273, 5, 9, 4, 0, -8 },
  { 279, 2, 11, 3, 0, -9 },
  { 282, 4, 4, 4, 0, -8 },
  { 284, 4, 1, 4, 0, 0 },
  { 285, 3, 2, 4, 0, -9 },
  { 286, 5, 6, 5, 0, -6 },
  { 290, 5, 9, 5, 0, -9 },
  { 296, 5, 6, 5, 0, -6 },
  { 300, 5, 9, 5, 0, -9 },
  { 306, 5, 6, 5, 0, -6 },
  { 310, 4, 9, 4, 0, -9 },
  { 315, 5, 8, 6, 0, -6 },
  { 320, 5, 9, 5, 0, -9 },
  { 326, 2, 9, 3, 0, -9 },
  { 329, 2, 11, 3, 0, -9 },
  { 332, 5, 9, 5, 0, -9 },
  { 338, 1, 9, 3, 1, -9 },
  { 340, 8, 6, 8, 0, -6 },
  { 346, 5, 6, 5, 0, -6 },
  { 350, 5, 6, 5, 0, -6 },
  { 354, 5, 8, 5, 0, -6 },
  { 359, 5, 8, 5, 0, -6 },
  { 364, 4, 6, 4, 0, -6 },
  { 367, 5, 6, 5, 0, -6 },
  { 371, 3, 7, 3, 0, -7 },
  { 374, 5, 6, 5, 0, -6 },
  { 378, 5, 6, 5, 0, -6 },
  { 382, 7, 6, 7, 0, -6 },
  { 388, 5, 6, 5, 0, -6 },
  { 392, 5, 8, 5, 0, -6 },
  { 397, 5, 6, 5, 0, -6 },
  { 401, 3, 11, 3, 0, -9 },
  { 406, 1, 9, 3, 1, -8 },
  { 408, 3, 11, 3, 0, -9 },
  { 413, 5, 3, 6, 0, -5 },
};

const GFXfont RobotoCondensed_Black11pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Black11pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Black11pt7bGlyphs,
  0x20, 0x7E, 13
};

#endif // _ROBOTOCONDENSED_BLACK11PT7B_H_
