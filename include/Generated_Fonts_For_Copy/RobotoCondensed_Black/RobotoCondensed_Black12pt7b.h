#ifndef _ROBOTOCONDENSED_BLACK12PT7B_H_
#define _ROBOTOCONDENSED_BLACK12PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Black.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Black12pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xE3, 0xC0, 0xFA, 0xA0, 0x28, 0xA2, 0x9F, 0x33, 0xE5, 0x14,
  0x50, 0x10, 0xE7, 0x9B, 0x60, 0xE1, 0x93, 0x78, 0xE1, 0x00, 0xC2, 0xAB,
  0x34, 0x20, 0xF5, 0x55, 0x1C, 0x30, 0xF1, 0xA3, 0xC7, 0x0E, 0xB7, 0x7E,
  0x7E, 0xFC, 0x4B, 0x49, 0x24, 0x99, 0x20, 0x89, 0xB2, 0x49, 0x6D, 0x40,
  0x22, 0x87, 0x9C, 0x48, 0x31, 0xBF, 0xF3, 0x18, 0x57, 0xFC, 0xF0, 0x22,
  0x26, 0x64, 0x4C, 0xC8, 0x39, 0xE4, 0xD3, 0xCD, 0x34, 0xDE, 0x38, 0x3F,
  0xB6, 0xDB, 0x60, 0x79, 0xEC, 0x86, 0x18, 0xC7, 0x1F, 0xFC, 0x7B, 0xE0,
  0xC6, 0x38, 0x3C, 0xDE, 0x78, 0x18, 0xE3, 0x9E, 0x79, 0xFF, 0xC6, 0x18,
  0x79, 0xE4, 0x1E, 0x58, 0x3C, 0xDE, 0x38, 0x19, 0xE6, 0x16, 0xFF, 0x34,
  0xDE, 0x38, 0xFF, 0xE1, 0x86, 0x18, 0xC3, 0x0C, 0x60, 0xF7, 0xB5, 0xEF,
  0x6A, 0x7E, 0xF0, 0x31, 0xE4, 0xD3, 0x7D, 0xF1, 0x8E, 0x30, 0xF0, 0x3C,
  0x6C, 0x00, 0x1B, 0x58, 0x0B, 0xF0, 0xF0, 0x80, 0xFF, 0x0F, 0xF0, 0x8E,
  0x3E, 0x80, 0x77, 0xC6, 0x33, 0x10, 0x06, 0x30, 0x1E, 0x11, 0x93, 0x4A,
  0xDD, 0x4E, 0xA7, 0x54, 0xBE, 0x40, 0x30, 0x0F, 0x00, 0x18, 0x70, 0xE1,
  0x66, 0xCF, 0x9F, 0x73, 0xC6, 0xF7, 0xF7, 0xBF, 0xEF, 0x7F, 0xF0, 0x38,
  0xF9, 0x9E, 0x0C, 0x18, 0x19, 0xBE, 0x38, 0xF7, 0xF7, 0xBD, 0xEF, 0x7F,
  0xF0, 0xFF, 0xF1, 0xEF, 0x63, 0x1F, 0xF8, 0xFF, 0xCF, 0xFC, 0xCC, 0xC0,
  0x38, 0xF9, 0x9B, 0x0E, 0x0D, 0xD9, 0xBF, 0x3C, 0xCF, 0x3C, 0xFF, 0xFF,
  0x3C, 0xF3, 0xCC, 0xFF, 0xFF, 0xC0, 0x18, 0xC6, 0x31, 0x8F, 0x7F, 0x70,
  0xDF, 0x6F, 0x3C, 0xF3, 0xCF, 0xB6, 0xDC, 0xCC, 0xCC, 0xCC, 0xCF, 0xF0,
  0xC7, 0xE7, 0xEF, 0xEF, 0xAB, 0xEB, 0xFB, 0xDF, 0xD7, 0xCF, 0x3E, 0xFB,
  0xEF, 0xFD, 0xF7, 0xCC, 0x38, 0xF9, 0x9E, 0x3C, 0x78, 0xD9, 0xBE, 0x38,
  0xF7, 0xF7, 0xBF, 0xFB, 0x18, 0xC0, 0x38, 0xF9, 0x9F, 0x3E, 0x7C, 0xD9,
  0xBE, 0x3C, 0x1C, 0x10, 0xF3, 0xED, 0xB6, 0xFB, 0xCF, 0xB6, 0xD8, 0x39,
  0xF6, 0xDC, 0x38, 0x3C, 0xDF, 0x38, 0xFF, 0xF3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xDE, 0xF7, 0xBD, 0xEF, 0x7F, 0x70, 0xC7, 0xDD, 0xB3, 0x66, 0xC5,
  0x8E, 0x1C, 0x38, 0xC9, 0xEE, 0x9F, 0xCF, 0xE7, 0xF3, 0xB9, 0xDC, 0xEE,
  0x36, 0x00, 0xEC, 0xD9, 0xB1, 0xC3, 0x87, 0x1B, 0x36, 0xEC, 0xCC, 0xD9,
  0xB3, 0xC3, 0x86, 0x0C, 0x18, 0x30, 0xFF, 0xF1, 0x86, 0x30, 0xC6, 0x1F,
  0xFC, 0xFF, 0xFF, 0xFF, 0xC6, 0x18, 0xC6, 0x18, 0xC6, 0x38, 0xC0, 0xED,
  0xB6, 0xDB, 0x6D, 0xF0, 0x23, 0x95, 0xA0, 0xF8, 0x62, 0x76, 0xC6, 0xFD,
  0xED, 0xE0, 0x84, 0x2D, 0xE9, 0xCE, 0x7E, 0xB0, 0x73, 0xF7, 0x8C, 0x3D,
  0xE0, 0x18, 0xDE, 0xFD, 0xEF, 0x6F, 0x68, 0x79, 0xEC, 0xBF, 0xC1, 0xE7,
  0x80, 0x37, 0xF6, 0x66, 0x66, 0x60, 0x7D, 0xFC, 0xF3, 0xCD, 0xF7, 0xD6,
  0x78, 0xC6, 0x37, 0xFC, 0xE7, 0x39, 0xC8, 0xA3, 0xFF, 0xF0, 0x48, 0x36,
  0xDB, 0x6F, 0x60, 0x84, 0x2F, 0x6E, 0x73, 0xD6, 0x98, 0xFF, 0xFF, 0xC0,
  0xBF, 0xFE, 0xDD, 0xBB, 0x76, 0xED, 0x80, 0xDF, 0xF3, 0x9C, 0xE7, 0x20,
  0x79, 0xEC, 0xF3, 0xCD, 0xE7, 0x80, 0xB7, 0xA7, 0x39, 0xFA, 0xD0, 0x80,
  0x6B, 0xF7, 0xBD, 0xBD, 0xE3, 0x18, 0xBE, 0x49, 0x20, 0x76, 0xF8, 0xE1,
  0xED, 0xC0, 0x6F, 0x66, 0x66, 0x77, 0xCE, 0x73, 0x9C, 0xBD, 0xA0, 0xDE,
  0xDE, 0xF7, 0x38, 0xC0, 0xDF, 0xBD, 0x7B, 0xF6, 0xED, 0x9B, 0x00, 0xDB,
  0xDC, 0xE7, 0x3F, 0x60, 0xDB, 0x67, 0x9E, 0x70, 0xC3, 0x18, 0x60, 0x7B,
  0xCC, 0x66, 0x3F, 0xE0, 0x2D, 0xB7, 0x9B, 0x6C, 0x80, 0xFF, 0xE0, 0x49,
  0xB6, 0x5B, 0x69, 0x00, 0xCF, 0xEC,
};

const GFXglyph RobotoCondensed_Black12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 2, 9, 3, 1, -9 },
  { 4, 4, 3, 4, 0, -9 },
  { 6, 6, 9, 6, 0, -9 },
  { 13, 6, 11, 6, 0, -10 },
  { 22, 6, 9, 8, 1, -9 },
  { 29, 7, 9, 7, 0, -9 },
  { 37, 2, 3, 2, 0, -9 },
  { 38, 3, 12, 4, 1, -9 },
  { 43, 3, 12, 4, 0, -9 },
  { 48, 6, 5, 6, 0, -9 },
  { 52, 5, 6, 6, 0, -7 },
  { 56, 2, 4, 3, 0, -1 },
  { 57, 3, 2, 5, 1, -5 },
  { 58, 2, 2, 4, 1, -2 },
  { 59, 4, 10, 4, 0, -9 },
  { 64, 6, 9, 6, 0, -9 },
  { 71, 3, 9, 6, 1, -9 },
  { 75, 6, 9, 6, 0, -9 },
  { 82, 6, 9, 6, 0, -9 },
  { 89, 6, 9, 6, 0, -9 },
  { 96, 6, 9, 6, 0, -9 },
  { 103, 6, 9, 6, 0, -9 },
  { 110, 6, 9, 6, 0, -9 },
  { 117, 5, 9, 6, 1, -9 },
  { 123, 6, 9, 6, 0, -9 },
  { 130, 2, 7, 4, 1, -7 },
  { 132, 3, 10, 3, 0, -7 },
  { 136, 5, 5, 5, 0, -6 },
  { 140, 4, 5, 6, 1, -6 },
  { 143, 4, 5, 5, 1, -6 },
  { 146, 5, 9, 6, 0, -9 },
  { 152, 9, 11, 9, 0, -8 },
  { 165, 7, 9, 7, 0, -9 },
  { 173, 5, 9, 7, 1, -9 },
  { 179, 7, 9, 7, 0, -9 },
  { 187, 5, 9, 7, 1, -9 },
  { 193, 5, 9, 6, 1, -9 },
  { 199, 4, 9, 6, 1, -9 },
  { 204, 7, 9, 7, 0, -9 },
  { 212, 6, 9, 7, 1, -9 },
  { 219, 2, 9, 3, 1, -9 },
  { 222, 5, 9, 6, 0, -9 },
  { 228, 6, 9, 7, 1, -9 },
  { 235, 4, 9, 6, 1, -9 },
  { 240, 8, 9, 9, 1, -9 },
  { 249, 6, 9, 7, 1, -9 },
  { 256, 7, 9, 7, 0, -9 },
  { 264, 5, 9, 7, 1, -9 },
  { 270, 7, 11, 7, 0, -9 },
  { 280, 6, 9, 7, 1, -9 },
  { 287, 6, 9, 7, 0, -9 },
  { 294, 6, 9, 7, 0, -9 },
  { 301, 5, 9, 7, 1, -9 },
  { 307, 7, 9, 7, 0, -9 },
  { 315, 9, 9, 9, 0, -9 },
  { 326, 7, 9, 7, 0, -9 },
  { 334, 7, 9, 7, 0, -9 },
  { 342, 6, 9, 6, 0, -9 },
  { 349, 2, 12, 3, 1, -10 },
  { 352, 5, 10, 5, 0, -9 },
  { 359, 3, 12, 3, 0, -10 },
  { 364, 5, 4, 5, 0, -9 },
  { 367, 5, 1, 5, 0, 0 },
  { 368, 4, 2, 4, 0, -9 },
  { 369, 5, 7, 6, 0, -7 },
  { 374, 5, 9, 6, 1, -9 },
  { 380, 5, 7, 6, 0, -7 },
  { 385, 5, 9, 6, 0, -9 },
  { 391, 6, 7, 6, 0, -7 },
  { 397, 4, 9, 4, 0, -9 },
  { 402, 6, 9, 6, 0, -7 },
  { 409, 5, 9, 6, 0, -9 },
  { 415, 2, 10, 3, 1, -10 },
  { 418, 3, 12, 3, 0, -10 },
  { 423, 5, 9, 6, 1, -9 },
  { 429, 2, 9, 3, 1, -9 },
  { 432, 7, 7, 9, 1, -7 },
  { 439, 5, 7, 6, 0, -7 },
  { 444, 6, 7, 6, 0, -7 },
  { 450, 5, 9, 6, 1, -7 },
  { 456, 5, 9, 6, 0, -7 },
  { 462, 3, 7, 4, 1, -7 },
  { 465, 5, 7, 5, 0, -7 },
  { 470, 4, 8, 4, 0, -8 },
  { 474, 5, 7, 6, 0, -7 },
  { 479, 5, 7, 6, 0, -7 },
  { 484, 7, 7, 8, 0, -7 },
  { 491, 5, 7, 6, 0, -7 },
  { 496, 6, 9, 6, 0, -7 },
  { 503, 5, 7, 6, 0, -7 },
  { 508, 3, 11, 4, 0, -9 },
  { 513, 1, 11, 3, 1, -9 },
  { 515, 3, 11, 4, 0, -9 },
  { 520, 5, 3, 7, 1, -5 },
};

const GFXfont RobotoCondensed_Black12pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Black12pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Black12pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _ROBOTOCONDENSED_BLACK12PT7B_H_
