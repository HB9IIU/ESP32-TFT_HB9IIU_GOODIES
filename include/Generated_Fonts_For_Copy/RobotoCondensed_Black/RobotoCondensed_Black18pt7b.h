#ifndef _ROBOTOCONDENSED_BLACK18PT7B_H_
#define _ROBOTOCONDENSED_BLACK18PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Black.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Black18pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xE3, 0xFE, 0xDE, 0xF7, 0xBD, 0x80, 0x1A, 0x0D,
  0x07, 0x8F, 0xF7, 0xF9, 0xB0, 0xD8, 0x68, 0xFF, 0x7F, 0x8B, 0x05, 0x82,
  0xC0, 0x18, 0x30, 0xF3, 0xFE, 0xFC, 0xF8, 0x38, 0x3C, 0x3C, 0x3F, 0x3E,
  0xFF, 0xCF, 0x08, 0x10, 0x70, 0x3E, 0x0D, 0xB3, 0x68, 0xFE, 0x1D, 0x00,
  0xC0, 0x6E, 0x1F, 0xCD, 0xB3, 0x6C, 0x9F, 0x03, 0x80, 0x1C, 0x0F, 0x83,
  0x71, 0xDC, 0x36, 0x0F, 0x83, 0xDD, 0xF7, 0x6F, 0x99, 0xE7, 0x79, 0xFE,
  0x3D, 0xC0, 0xFB, 0x6C, 0x13, 0x76, 0x6E, 0xCC, 0xCC, 0xCC, 0xE6, 0x67,
  0x31, 0x43, 0x18, 0x63, 0x1C, 0xE3, 0x18, 0xC6, 0x73, 0x98, 0xCC, 0x62,
  0x00, 0x18, 0x18, 0x49, 0xFF, 0x1C, 0x3C, 0x76, 0x22, 0x1C, 0x1C, 0x1C,
  0xFF, 0xFF, 0xFF, 0x1C, 0x1C, 0x1C, 0x77, 0x76, 0x64, 0xFF, 0xC0, 0xFF,
  0x80, 0x18, 0xC6, 0x33, 0x18, 0xCE, 0x63, 0x19, 0xCC, 0x60, 0x38, 0xFF,
  0xBF, 0x7E, 0x7C, 0xF9, 0xF3, 0xE7, 0xDF, 0xBB, 0xF3, 0x80, 0x0C, 0xFF,
  0xF7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x3D, 0xFF, 0xBE, 0x70,
  0xE1, 0xC7, 0x0E, 0x38, 0xE3, 0xC7, 0xFF, 0xE0, 0x3E, 0x7F, 0x77, 0x07,
  0x07, 0x1E, 0x1F, 0x07, 0x03, 0xE3, 0x77, 0x7F, 0x3C, 0x1E, 0x1E, 0x3E,
  0x3E, 0x7E, 0x6E, 0xEE, 0xCE, 0xFF, 0xFF, 0x0E, 0x0E, 0x0E, 0xFF, 0xFF,
  0x87, 0x0F, 0xDF, 0xD3, 0x87, 0x0F, 0xDF, 0xBF, 0xF3, 0x80, 0x1C, 0x3C,
  0x78, 0xE0, 0xFC, 0xFE, 0xEE, 0xE7, 0xE7, 0xE7, 0xEE, 0x7E, 0x3C, 0xFF,
  0xFC, 0x38, 0x70, 0xC3, 0x87, 0x0C, 0x38, 0x71, 0xC3, 0x87, 0x00, 0x3D,
  0xFF, 0xBF, 0x7E, 0xEF, 0x9F, 0xF7, 0xE7, 0xDF, 0xBF, 0xF3, 0xC0, 0x38,
  0xFB, 0xBF, 0x7E, 0x7C, 0xFB, 0xFF, 0x7E, 0x1C, 0x73, 0xC7, 0x00, 0xFF,
  0x80, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0x6D, 0xFD, 0x80, 0x02, 0x1C, 0xFF,
  0xEE, 0x1F, 0x0F, 0x87, 0x02, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x81, 0xC3,
  0xE1, 0xF0, 0xE7, 0xFE, 0x70, 0x80, 0x3C, 0x7E, 0x7F, 0xE7, 0x06, 0x0E,
  0x1C, 0x18, 0x18, 0x00, 0x18, 0x38, 0x18, 0x0F, 0x83, 0xFC, 0x70, 0x66,
  0x03, 0xC7, 0x3C, 0xFB, 0xD9, 0xB9, 0x9B, 0x99, 0xB9, 0xB3, 0xDF, 0xEC,
  0xDC, 0xC0, 0x06, 0x00, 0x3F, 0x01, 0xF0, 0x0E, 0x01, 0xC0, 0x7C, 0x0F,
  0x81, 0xB0, 0x77, 0x0E, 0xE1, 0xDC, 0x71, 0x8F, 0xF9, 0xFF, 0x38, 0xEE,
  0x1E, 0xFE, 0xFF, 0xE7, 0xE7, 0xE7, 0xFE, 0xFF, 0xE7, 0xE7, 0xE7, 0xE7,
  0xFF, 0xFE, 0x3E, 0x3F, 0xBD, 0xDC, 0x7E, 0x3F, 0x03, 0x81, 0xC0, 0xE3,
  0xF1, 0xFD, 0xCF, 0xE3, 0xE0, 0xFC, 0xFE, 0xEF, 0xE7, 0xE7, 0xE7, 0xE7,
  0xE7, 0xE7, 0xE7, 0xEF, 0xFE, 0xFC, 0xFF, 0xFF, 0x87, 0x0E, 0x1F, 0xFF,
  0xF0, 0xE1, 0xC3, 0x87, 0xFF, 0xE0, 0xFF, 0xFF, 0x87, 0x0E, 0x1C, 0x3F,
  0xFF, 0xE1, 0xC3, 0x87, 0x0E, 0x00, 0x3E, 0x3F, 0xBD, 0xFC, 0x7E, 0x07,
  0x03, 0xBF, 0xDF, 0xE3, 0xF1, 0xFD, 0xEF, 0xF3, 0xE0, 0xE3, 0xF1, 0xF8,
  0xFC, 0x7E, 0x3F, 0x1F, 0xFF, 0xFF, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x38,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0xE7, 0x77, 0x7E, 0x3C, 0xE7, 0xF3, 0xBB, 0xDD, 0xCF, 0xC7,
  0xE3, 0xF1, 0xFC, 0xFE, 0x77, 0xB9, 0xDC, 0xEE, 0x78, 0xE1, 0xC3, 0x87,
  0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0xFF, 0xE0, 0xF0, 0xFF, 0x1F,
  0xF1, 0xFF, 0x9F, 0xF9, 0xFF, 0x9F, 0xFB, 0xFF, 0xB7, 0xEF, 0x7E, 0xF7,
  0xEE, 0x7E, 0xE7, 0xE6, 0x70, 0xE3, 0xF1, 0xFC, 0xFE, 0x7F, 0xBF, 0xDF,
  0xAF, 0xDF, 0xEF, 0xF3, 0xF9, 0xFC, 0xFE, 0x38, 0x3E, 0x3F, 0xBD, 0xFC,
  0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xFD, 0xEF, 0xE3, 0xE0, 0xFC,
  0x7F, 0xB9, 0xDC, 0xFE, 0x3F, 0x1F, 0x9D, 0xFE, 0xFE, 0x70, 0x38, 0x1C,
  0x0E, 0x00, 0x3E, 0x3F, 0xBD, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3,
  0xF1, 0xFD, 0xEF, 0xE3, 0xF0, 0x1C, 0x04, 0xFE, 0x7F, 0xB9, 0xDC, 0xEE,
  0x77, 0x3B, 0xFD, 0xFC, 0xEE, 0x77, 0x39, 0xDC, 0xEE, 0x78, 0x3C, 0x7E,
  0xE7, 0xE7, 0xE0, 0x78, 0x3E, 0x1F, 0x07, 0xE7, 0xE7, 0xFF, 0x3E, 0xFF,
  0xFF, 0xF1, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x00, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F,
  0xC7, 0xE3, 0xF3, 0xB9, 0xCF, 0xE3, 0xE0, 0xF1, 0xDC, 0x77, 0x1D, 0xCE,
  0x73, 0x8E, 0xE3, 0xB8, 0xEC, 0x3F, 0x07, 0xC1, 0xF0, 0x78, 0x1E, 0x00,
  0xE7, 0x3B, 0x39, 0xDD, 0xCE, 0xEF, 0x67, 0x7F, 0x3F, 0xF9, 0xFF, 0xC7,
  0xFE, 0x3D, 0xF1, 0xEF, 0x0F, 0x78, 0x7B, 0xC3, 0xCE, 0x00, 0xF3, 0xDC,
  0xE7, 0x38, 0xFC, 0x3F, 0x07, 0x81, 0xE0, 0x7C, 0x3F, 0x0F, 0xC7, 0x39,
  0xCE, 0xF3, 0xC0, 0xE3, 0xDC, 0xE7, 0x38, 0xCC, 0x3F, 0x0F, 0xC1, 0xE0,
  0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x00, 0xFF, 0xFF, 0x07, 0x0E,
  0x0E, 0x1C, 0x38, 0x38, 0x70, 0x70, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xE1, 0xC1, 0xC3, 0x87, 0x07, 0x0E, 0x1C, 0x1C,
  0x38, 0x70, 0x70, 0xE1, 0xC0, 0xFF, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77,
  0x77, 0xFF, 0x38, 0x70, 0xF3, 0x66, 0xCC, 0xC0, 0xFF, 0xFC, 0x71, 0x86,
  0x3C, 0x7E, 0x77, 0x07, 0x3F, 0x7F, 0x67, 0xE7, 0x7F, 0x77, 0xE1, 0xC3,
  0x87, 0x0F, 0xDF, 0xFB, 0xF3, 0xE7, 0xCF, 0x9F, 0x7F, 0xFB, 0x80, 0x3C,
  0x7E, 0x77, 0x67, 0xE0, 0xE0, 0x67, 0x77, 0x7E, 0x3C, 0x07, 0x07, 0x07,
  0x07, 0x3F, 0x7F, 0x77, 0x67, 0xE7, 0xE7, 0x67, 0x77, 0x7F, 0x3F, 0x7D,
  0xFF, 0xBF, 0x7F, 0xFF, 0xF8, 0x72, 0xFE, 0x78, 0x1C, 0xF7, 0x9C, 0xFF,
  0xF7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC0, 0x3B, 0x7F, 0x77, 0x67, 0xE7,
  0xE7, 0x67, 0x77, 0x7F, 0x3F, 0x07, 0x27, 0x7F, 0x3C, 0xE1, 0xC3, 0x87,
  0x0F, 0xDF, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xC0, 0xDF, 0x8F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x31, 0xCE, 0x03, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0xF7, 0x00, 0xE0, 0xE0, 0xE0, 0xE0, 0xEE, 0xEE, 0xFC, 0xF8,
  0xF8, 0xFC, 0xFC, 0xEE, 0xEE, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFD, 0xDF, 0xFF, 0xBB, 0xF7, 0x3E, 0xE7, 0xDC, 0xFB, 0x9F, 0x73, 0xEE,
  0x7D, 0xCC, 0xDD, 0xFF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDC, 0x3C,
  0x7F, 0x77, 0x67, 0xE7, 0x67, 0x67, 0x77, 0x7F, 0x3E, 0xFD, 0xFF, 0xBF,
  0x3E, 0x7C, 0xF9, 0xF7, 0xFF, 0xFB, 0x87, 0x0E, 0x1C, 0x00, 0x3B, 0x7F,
  0x77, 0x67, 0xE7, 0xE7, 0x67, 0x77, 0x7F, 0x3F, 0x07, 0x07, 0x07, 0x07,
  0xFF, 0xFF, 0xCE, 0x73, 0x9C, 0xE7, 0x00, 0x3C, 0x7E, 0x67, 0x70, 0x7C,
  0x3E, 0x0F, 0xE7, 0x7E, 0x3C, 0x73, 0xBF, 0xF7, 0x39, 0xCE, 0x73, 0x9E,
  0x70, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xFE, 0xFC, 0xE7, 0x67,
  0x76, 0x7E, 0x7E, 0x3E, 0x3C, 0x3C, 0x3C, 0x1C, 0xE6, 0xED, 0xDD, 0xBB,
  0xB7, 0x67, 0xFC, 0xF7, 0x9E, 0xF1, 0xDE, 0x3B, 0x87, 0x30, 0x67, 0x76,
  0x7E, 0x3E, 0x3C, 0x3C, 0x3E, 0x7E, 0x77, 0xE7, 0xE7, 0xE7, 0x77, 0x7E,
  0x7E, 0x3E, 0x3C, 0x3C, 0x3C, 0x1C, 0x18, 0x38, 0x78, 0x70, 0xFF, 0xFC,
  0x71, 0xC3, 0x8E, 0x1C, 0x70, 0xFF, 0xFC, 0x11, 0xCC, 0x67, 0x39, 0xDC,
  0xE3, 0x9C, 0xE7, 0x18, 0xC7, 0x10, 0xFF, 0xFE, 0x8C, 0xEE, 0xEE, 0xE7,
  0x76, 0xEE, 0xEE, 0xEC, 0x80, 0x73, 0xFB, 0xDE, 0xCE,
};

const GFXglyph RobotoCondensed_Black18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 3, 13, 5, 1, -13 },
  { 6, 5, 5, 6, 0, -14 },
  { 10, 9, 13, 9, 0, -13 },
  { 25, 7, 17, 9, 1, -15 },
  { 40, 10, 13, 12, 1, -13 },
  { 57, 10, 13, 11, 0, -13 },
  { 74, 3, 5, 3, 0, -14 },
  { 76, 4, 18, 6, 1, -14 },
  { 85, 5, 18, 6, 0, -14 },
  { 97, 8, 8, 8, 0, -13 },
  { 105, 8, 9, 8, 0, -11 },
  { 114, 4, 6, 5, 0, -2 },
  { 117, 5, 2, 8, 1, -6 },
  { 119, 3, 3, 5, 1, -3 },
  { 121, 5, 14, 6, 0, -13 },
  { 130, 7, 13, 9, 1, -13 },
  { 142, 6, 13, 9, 1, -13 },
  { 152, 7, 13, 9, 1, -13 },
  { 164, 8, 13, 9, 0, -13 },
  { 177, 8, 13, 9, 1, -13 },
  { 190, 7, 13, 9, 1, -13 },
  { 202, 8, 13, 9, 1, -13 },
  { 215, 7, 13, 9, 1, -13 },
  { 227, 7, 13, 9, 1, -13 },
  { 239, 7, 13, 9, 1, -13 },
  { 251, 3, 10, 5, 1, -10 },
  { 255, 3, 14, 5, 1, -10 },
  { 261, 7, 9, 8, 0, -10 },
  { 269, 7, 5, 9, 1, -8 },
  { 274, 7, 9, 8, 1, -10 },
  { 282, 8, 13, 8, 0, -13 },
  { 295, 12, 16, 14, 1, -12 },
  { 319, 11, 13, 11, 0, -13 },
  { 337, 8, 13, 10, 1, -13 },
  { 350, 9, 13, 10, 1, -13 },
  { 365, 8, 13, 10, 1, -13 },
  { 378, 7, 13, 9, 1, -13 },
  { 390, 7, 13, 9, 1, -13 },
  { 402, 9, 13, 11, 1, -13 },
  { 417, 9, 13, 11, 1, -13 },
  { 432, 3, 13, 5, 1, -13 },
  { 437, 8, 13, 9, 0, -13 },
  { 450, 9, 13, 10, 1, -13 },
  { 465, 7, 13, 9, 1, -13 },
  { 477, 12, 13, 14, 1, -13 },
  { 497, 9, 13, 11, 1, -13 },
  { 512, 9, 13, 11, 1, -13 },
  { 527, 9, 13, 10, 1, -13 },
  { 542, 9, 15, 11, 1, -13 },
  { 559, 9, 13, 10, 1, -13 },
  { 574, 8, 13, 10, 1, -13 },
  { 587, 10, 13, 10, 0, -13 },
  { 604, 9, 13, 10, 1, -13 },
  { 619, 10, 13, 11, 0, -13 },
  { 636, 13, 13, 13, 0, -13 },
  { 658, 10, 13, 10, 0, -13 },
  { 675, 10, 13, 10, 0, -13 },
  { 692, 8, 13, 10, 1, -13 },
  { 705, 3, 18, 5, 1, -15 },
  { 712, 7, 14, 7, 0, -13 },
  { 725, 4, 18, 5, 0, -15 },
  { 734, 7, 6, 7, 0, -13 },
  { 740, 7, 2, 7, 0, 0 },
  { 742, 5, 3, 6, 0, -14 },
  { 744, 8, 10, 8, 0, -10 },
  { 754, 7, 14, 9, 1, -14 },
  { 767, 8, 10, 8, 0, -10 },
  { 777, 8, 14, 9, 0, -14 },
  { 791, 7, 10, 9, 1, -10 },
  { 800, 6, 14, 6, 0, -14 },
  { 811, 8, 14, 9, 0, -10 },
  { 825, 7, 14, 9, 1, -14 },
  { 838, 3, 14, 5, 1, -14 },
  { 844, 5, 18, 5, -1, -14 },
  { 856, 8, 14, 9, 1, -14 },
  { 870, 3, 14, 5, 1, -14 },
  { 876, 11, 10, 13, 1, -10 },
  { 890, 7, 10, 9, 1, -10 },
  { 899, 8, 10, 9, 0, -10 },
  { 909, 7, 14, 9, 1, -10 },
  { 922, 8, 14, 9, 0, -10 },
  { 936, 5, 10, 6, 1, -10 },
  { 943, 8, 10, 8, 0, -10 },
  { 953, 5, 12, 6, 0, -12 },
  { 961, 7, 10, 9, 1, -10 },
  { 970, 8, 10, 8, 0, -10 },
  { 980, 11, 10, 11, 0, -10 },
  { 994, 8, 10, 8, 0, -10 },
  { 1004, 8, 14, 8, 0, -10 },
  { 1018, 7, 10, 8, 1, -10 },
  { 1027, 5, 17, 5, 0, -14 },
  { 1038, 1, 15, 5, 2, -13 },
  { 1040, 4, 17, 5, 1, -14 },
  { 1049, 8, 4, 10, 1, -7 },
};

const GFXfont RobotoCondensed_Black18pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Black18pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Black18pt7bGlyphs,
  0x20, 0x7E, 21
};

#endif // _ROBOTOCONDENSED_BLACK18PT7B_H_
