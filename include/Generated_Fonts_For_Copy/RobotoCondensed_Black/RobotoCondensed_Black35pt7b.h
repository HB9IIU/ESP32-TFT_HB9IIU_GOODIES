#ifndef _ROBOTOCONDENSED_BLACK35PT7B_H_
#define _ROBOTOCONDENSED_BLACK35PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Black.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Black35pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF,
  0xBE, 0x78, 0x00, 0x1E, 0xFB, 0xFF, 0xFE, 0x78, 0xF3, 0xFC, 0xFF, 0x3F,
  0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xF0, 0x07, 0x38, 0x07,
  0x38, 0x07, 0x38, 0x07, 0x38, 0x07, 0x38, 0x0F, 0x78, 0x0F, 0x78, 0x7F,
  0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x0E, 0x70, 0x0E, 0x70, 0x1E, 0x70, 0x1E,
  0xF0, 0x1E, 0xF0, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x1C, 0xE0, 0x1C,
  0xE0, 0x3D, 0xE0, 0x3D, 0xE0, 0x39, 0xC0, 0x39, 0xC0, 0x39, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x07, 0xE0, 0x0F, 0xF8, 0x1F,
  0xFC, 0x3F, 0xFC, 0x3F, 0x7E, 0x7E, 0x3E, 0x7E, 0x3E, 0x7E, 0x3E, 0x7E,
  0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x0F, 0xF8, 0x07, 0xFC, 0x01,
  0xFC, 0x00, 0x7E, 0x00, 0x7E, 0xFC, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7F,
  0x7E, 0x7F, 0xFE, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xE0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x3E, 0x00, 0x0F, 0xE0, 0x03, 0xFE, 0x00, 0x7B, 0xC3,
  0x0E, 0x38, 0xE1, 0xC7, 0x3C, 0x38, 0xE7, 0x07, 0x1D, 0xE0, 0xF7, 0xB8,
  0x1F, 0xFF, 0x01, 0xFD, 0xC0, 0x1F, 0x78, 0x00, 0x0E, 0x00, 0x03, 0x9E,
  0x00, 0x77, 0xF0, 0x1D, 0xFE, 0x07, 0xB9, 0xE0, 0xEF, 0x3C, 0x3D, 0xE7,
  0x87, 0x3C, 0xF1, 0xE7, 0x9E, 0x38, 0x73, 0xC1, 0x0F, 0xF0, 0x00, 0xFE,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0xFC,
  0x03, 0xFF, 0xC0, 0x7C, 0xF8, 0x0F, 0x9F, 0x01, 0xF3, 0xE0, 0x3E, 0xF8,
  0x07, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x01, 0xFC, 0x7C, 0x7F, 0xCF,
  0x9F, 0xFD, 0xF7, 0xFF, 0xBC, 0xFD, 0xFF, 0x9F, 0xBF, 0xF3, 0xF3, 0xFE,
  0x7E, 0x3F, 0x8F, 0xEF, 0xF0, 0xFF, 0xFF, 0x1F, 0xFF, 0xE1, 0xFF, 0xFE,
  0x0F, 0xCF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFE, 0xEE, 0x01, 0x07, 0x0F, 0x0F,
  0x1E, 0x3E, 0x3C, 0x3C, 0x78, 0x78, 0x78, 0xF8, 0xF8, 0xF8, 0xF8, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF8, 0xF8, 0xF8, 0xF8, 0x78, 0x78, 0x78, 0x3C,
  0x3C, 0x3E, 0x1E, 0x0F, 0x0F, 0x07, 0x03, 0x40, 0x70, 0x3C, 0x0F, 0x07,
  0xC1, 0xE0, 0xF8, 0x3C, 0x1E, 0x0F, 0x87, 0xC1, 0xE0, 0xF0, 0x7C, 0x3E,
  0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3C, 0x1E, 0x1F, 0x0F,
  0x87, 0x83, 0xC3, 0xE1, 0xE1, 0xF0, 0xF0, 0xF0, 0x70, 0x10, 0x00, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x71, 0xC6, 0x7D, 0xDF, 0x7F,
  0xFF, 0x1F, 0xFE, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0xF0, 0x1E, 0x78, 0x1E,
  0x3C, 0x1C, 0x3C, 0x00, 0x10, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x00, 0x3C, 0xF3, 0xCF, 0x3D, 0xF7, 0xDE, 0xFB, 0xC2, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3B, 0xFF, 0xFF, 0xFD, 0xE0, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x00,
  0x07, 0xE0, 0x1F, 0xE0, 0x7F, 0xE1, 0xFF, 0xE7, 0xFF, 0xCF, 0xCF, 0xDF,
  0x0F, 0xBE, 0x1F, 0x7C, 0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE1, 0xFF, 0xC3,
  0xFF, 0x87, 0xFF, 0x0F, 0xFE, 0x1F, 0x7C, 0x3E, 0xF8, 0x7D, 0xF0, 0xFB,
  0xF3, 0xF7, 0xFF, 0xC7, 0xFF, 0x87, 0xFE, 0x07, 0xF8, 0x07, 0xE0, 0x00,
  0xC0, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC0, 0x07, 0xE0, 0x3F, 0xF0, 0xFF,
  0xF3, 0xFF, 0xE7, 0xFF, 0xFF, 0x8F, 0xFF, 0x1F, 0xFE, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xF0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xE0, 0x3F, 0xF0, 0xFF, 0xF3,
  0xFF, 0xE7, 0xEF, 0xFF, 0x8F, 0xFF, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x01,
  0xF8, 0x1F, 0xF0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x80, 0x1F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7F, 0xF0, 0xFF, 0xE3, 0xFF, 0xEF, 0xEF, 0xFF, 0x9F,
  0xFF, 0x0F, 0xFC, 0x0F, 0xE0, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x03,
  0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xFC, 0x0F,
  0xFC, 0x1E, 0xFC, 0x1E, 0xFC, 0x3E, 0xFC, 0x3C, 0xFC, 0x7C, 0xFC, 0x78,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x3F, 0xFE, 0x7F, 0xFC, 0xFF,
  0xF9, 0xFF, 0xF7, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7D, 0xE0,
  0xFF, 0xF1, 0xFF, 0xF3, 0xFF, 0xE3, 0xC7, 0xE0, 0x0F, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7F, 0xF0, 0xFF, 0xE3, 0xF7, 0xFF, 0xEF, 0xFF,
  0x8F, 0xFE, 0x0F, 0xF8, 0x07, 0xE0, 0x00, 0xF0, 0x03, 0xF0, 0x07, 0xF0,
  0x0F, 0xF0, 0x1F, 0xF0, 0x3F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0xF0,
  0x7F, 0xFC, 0x7F, 0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0x7C, 0x3F, 0x7C, 0x3F, 0x7E, 0x3E, 0x7F, 0xFE,
  0x3F, 0xFE, 0x1F, 0xFC, 0x0F, 0xF8, 0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x00, 0xFC,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x0F, 0xC0, 0xFF, 0xC7, 0xFF,
  0x9F, 0xFE, 0xFF, 0xFF, 0xF3, 0xFF, 0xCF, 0xFF, 0x3F, 0xFC, 0xFD, 0xFF,
  0xE7, 0xFF, 0x8F, 0xFC, 0x3F, 0xF1, 0xFF, 0xEF, 0xCF, 0xFE, 0x3F, 0xF8,
  0x7F, 0xE1, 0xFF, 0x87, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0x8F,
  0xFC, 0x0F, 0xC0, 0x07, 0xC0, 0x1F, 0xE0, 0x7F, 0xE1, 0xFF, 0xE7, 0xFF,
  0xCF, 0xCF, 0xDF, 0x1F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x7D, 0xF0, 0xFB,
  0xE1, 0xF7, 0xE7, 0xEF, 0xFF, 0xCF, 0xFF, 0x8F, 0xFF, 0x0F, 0xFE, 0x00,
  0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0xFF, 0x81, 0xFE, 0x03, 0xF8, 0x07, 0xE0,
  0x0E, 0x00, 0x39, 0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x9F, 0xFF, 0xFF, 0xDE, 0x1C, 0xFD, 0xFB, 0xF7, 0xE7, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0x8F, 0x3E, 0x79, 0xF0, 0xC0, 0x00, 0x08, 0x01, 0xC0, 0x3E, 0x0F, 0xF1,
  0xFF, 0xBF, 0xFB, 0xFF, 0x1F, 0xE0, 0xF8, 0x07, 0xF8, 0x3F, 0xF0, 0xFF,
  0xE1, 0xFF, 0x83, 0xFC, 0x03, 0xE0, 0x07, 0x00, 0x08, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x07, 0x00, 0x3E, 0x01, 0xFC, 0x0F,
  0xF8, 0x7F, 0xF0, 0x7F, 0xE0, 0xFF, 0x01, 0xF8, 0x3F, 0xC7, 0xFF, 0xFF,
  0xCF, 0xF8, 0x7F, 0x03, 0xE0, 0x1C, 0x00, 0x80, 0x00, 0x0F, 0xC0, 0xFF,
  0xC7, 0xFF, 0xBF, 0xFE, 0xFF, 0xFF, 0xF3, 0xFF, 0x8F, 0xC0, 0x3F, 0x00,
  0xFC, 0x07, 0xE0, 0x3F, 0x81, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x0F, 0x80, 0x3F, 0x00,
  0xFC, 0x03, 0xE0, 0x07, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0xFC, 0x00, 0xF8, 0x1F, 0x00, 0xF0, 0x03, 0xC0, 0xF0, 0x00, 0xF0,
  0x78, 0x00, 0x38, 0x78, 0x3E, 0x1E, 0x38, 0x3F, 0xCF, 0x3C, 0x3F, 0xE3,
  0x9E, 0x3E, 0xF1, 0xCE, 0x1E, 0x78, 0xE7, 0x1E, 0x3C, 0x77, 0x8F, 0x1E,
  0x3F, 0xC7, 0x8F, 0x1F, 0xE7, 0xC7, 0x8E, 0xF3, 0xE3, 0xC7, 0x79, 0xE1,
  0xE3, 0xBC, 0xF8, 0xE1, 0xDE, 0x7C, 0xF1, 0xEF, 0x1E, 0x7C, 0xE7, 0x8F,
  0xFF, 0xF1, 0xC3, 0xF7, 0xF0, 0xF0, 0xF1, 0xE0, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xFC, 0x38, 0x00,
  0x7F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x01,
  0xF7, 0xE0, 0x1F, 0x9F, 0x00, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x7E, 0x3F,
  0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xC3, 0xF0, 0x3F, 0x3F, 0x01, 0xF9, 0xF8, 0x0F, 0xCF, 0xC0, 0x7F,
  0xFE, 0x01, 0xF8, 0xFF, 0xE0, 0xFF, 0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x7F, 0xFF,
  0xFE, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFE, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x1F, 0xFC, 0x1F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFC, 0xFF, 0xF0, 0x03, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xF0,
  0xFF, 0xFE, 0x3F, 0xFF, 0x9F, 0x83, 0xF7, 0xE0, 0xFD, 0xF0, 0x3F, 0xFC,
  0x0F, 0xFF, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xDF, 0x03, 0xF7, 0xE0, 0xFD,
  0xF8, 0x7F, 0x3F, 0xFF, 0x8F, 0xFF, 0xE1, 0xFF, 0xF0, 0x3F, 0xF8, 0x03,
  0xF8, 0x00, 0xFF, 0xC0, 0xFF, 0xF0, 0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE,
  0xFC, 0x7E, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x7E, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8,
  0xFF, 0xF0, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xFF, 0xBF,
  0xFE, 0xFF, 0xFB, 0xFF, 0xEF, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xFF, 0xBF, 0xFE, 0xFF, 0xFB, 0xFF,
  0xEF, 0xFF, 0xBF, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x03, 0xFF,
  0x81, 0xFF, 0xF0, 0xFF, 0xFE, 0x3F, 0xFF, 0xDF, 0x83, 0xF7, 0xE0, 0xFD,
  0xF8, 0x1F, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x7F, 0xFF, 0x1F, 0xFF, 0xC7, 0xFF, 0xF1, 0xFF, 0x7C, 0x0F, 0xDF, 0x83,
  0xF7, 0xE0, 0xFD, 0xFC, 0x3F, 0x3F, 0xFF, 0xCF, 0xFF, 0xF1, 0xFF, 0xF8,
  0x3F, 0xFC, 0x03, 0xFC, 0x00, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF,
  0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC,
  0x0F, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF,
  0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC,
  0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7F, 0xF8, 0xFF, 0xF1, 0xF7, 0xE7, 0xEF, 0xFF,
  0xCF, 0xFF, 0x1F, 0xFE, 0x1F, 0xF8, 0x0F, 0xC0, 0xFC, 0x3F, 0xFF, 0x0F,
  0xEF, 0xC7, 0xF3, 0xF1, 0xFC, 0xFC, 0x7E, 0x3F, 0x3F, 0x0F, 0xCF, 0xC3,
  0xF7, 0xE0, 0xFD, 0xF8, 0x3F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF,
  0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0x3F,
  0x0F, 0xCF, 0xE3, 0xF1, 0xF8, 0xFC, 0x7F, 0x3F, 0x1F, 0xCF, 0xC3, 0xFB,
  0xF0, 0xFE, 0xFC, 0x1F, 0xC0, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xDE, 0x3F, 0xFF,
  0xBC, 0xFF, 0xFF, 0x79, 0xEF, 0xFE, 0xFB, 0xDF, 0xFC, 0xF7, 0xBF, 0xF9,
  0xFE, 0x7F, 0xF3, 0xFC, 0xFF, 0xF3, 0xF9, 0xFF, 0xE7, 0xF3, 0xFF, 0xCF,
  0xC7, 0xFF, 0x9F, 0x8F, 0xFF, 0x1F, 0x1F, 0xFE, 0x3E, 0x3F, 0xFC, 0x78,
  0x7E, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F,
  0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xFE, 0x3F, 0xFF, 0x8F, 0xFF, 0xE3, 0xFF,
  0xFC, 0xFF, 0xFF, 0x3F, 0xFD, 0xEF, 0xFF, 0x7B, 0xFF, 0xCE, 0xFF, 0xF3,
  0xFF, 0xFC, 0xFF, 0xFF, 0x1F, 0xFF, 0xC7, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F,
  0xFF, 0x0F, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xC0, 0x03, 0xF8,
  0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0xFC, 0x1F,
  0x9F, 0x83, 0xF3, 0xF0, 0x3E, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F,
  0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F,
  0xFC, 0x07, 0xEF, 0xC0, 0xF9, 0xF8, 0x3F, 0x3F, 0x07, 0xE3, 0xFF, 0xF8,
  0x7F, 0xFF, 0x07, 0xFF, 0xC0, 0x7F, 0xF0, 0x03, 0xF8, 0x00, 0xFF, 0xE0,
  0x7F, 0xFC, 0x3F, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xF7, 0xE1, 0xFB, 0xF0,
  0xFD, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x87, 0xEF,
  0xFF, 0xF7, 0xFF, 0xF3, 0xFF, 0xF9, 0xFF, 0xF8, 0xFF, 0xF0, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F,
  0xFF, 0xC3, 0xFF, 0xF8, 0xFE, 0x1F, 0x9F, 0x83, 0xF3, 0xF0, 0x3F, 0xFC,
  0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8,
  0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xEF, 0xC0, 0xFD, 0xF8,
  0x3F, 0x3F, 0x87, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0x07, 0xFF, 0xC0, 0x7F,
  0xF8, 0x03, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xE0, 0x00,
  0x38, 0x00, 0x02, 0x00, 0xFF, 0xF0, 0x7F, 0xFE, 0x3F, 0xFF, 0x9F, 0xFF,
  0xCF, 0xFF, 0xF7, 0xE1, 0xFB, 0xF0, 0xFD, 0xF8, 0x7E, 0xFC, 0x3F, 0x7E,
  0x1F, 0xBF, 0x0F, 0xDF, 0xFF, 0xEF, 0xFF, 0xE7, 0xFF, 0xE3, 0xFF, 0xE1,
  0xFF, 0xF0, 0xFD, 0xFC, 0x7E, 0x7E, 0x3F, 0x3F, 0x1F, 0x8F, 0xCF, 0xC7,
  0xE7, 0xE3, 0xFB, 0xF0, 0xFD, 0xF8, 0x7E, 0xFC, 0x1F, 0x80, 0x03, 0xF0,
  0x07, 0xFE, 0x0F, 0xFF, 0x87, 0xFF, 0xE7, 0xFF, 0xF3, 0xF0, 0xFD, 0xF8,
  0x7E, 0xFC, 0x3F, 0x7E, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x03, 0xFF, 0x00,
  0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xFE, 0x0F,
  0xFF, 0x07, 0xFF, 0xC3, 0xF7, 0xFF, 0xFB, 0xFF, 0xF8, 0xFF, 0xFC, 0x1F,
  0xF8, 0x03, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF,
  0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07,
  0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC,
  0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xDF, 0x87, 0xEF, 0xFF, 0xF3, 0xFF, 0xF1,
  0xFF, 0xF8, 0x7F, 0xF8, 0x07, 0xF0, 0x00, 0xFE, 0x03, 0xF7, 0xE0, 0x7F,
  0x7E, 0x07, 0xF7, 0xE0, 0x7E, 0x7F, 0x07, 0xE3, 0xF0, 0x7E, 0x3F, 0x0F,
  0xE3, 0xF0, 0xFC, 0x1F, 0x0F, 0xC1, 0xF8, 0xFC, 0x1F, 0x8F, 0x81, 0xF9,
  0xF8, 0x0F, 0x9F, 0x80, 0xF9, 0xF8, 0x0F, 0xDF, 0x00, 0xFD, 0xF0, 0x07,
  0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00,
  0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0xF8, 0x7E,
  0x1F, 0xFC, 0x7E, 0x3F, 0xFC, 0x7E, 0x3F, 0xFC, 0x7E, 0x3F, 0xFC, 0x7E,
  0x3F, 0xFC, 0xFE, 0x3E, 0x7C, 0xFF, 0x3E, 0x7C, 0xFF, 0x3E, 0x7E, 0xFF,
  0x7E, 0x7E, 0xFF, 0x7E, 0x7E, 0xFF, 0x7E, 0x7F, 0xFF, 0x7C, 0x3F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xE7,
  0xFC, 0x3F, 0xE7, 0xF8, 0x1F, 0xE7, 0xF8, 0x1F, 0xE7, 0xF8, 0x1F, 0xE7,
  0xF8, 0x1F, 0xC7, 0xF8, 0x1F, 0xC3, 0xF8, 0x0F, 0xC3, 0xF0, 0x0F, 0xC3,
  0xF0, 0x7E, 0x0F, 0xEF, 0xE1, 0xFC, 0xFC, 0x3F, 0x1F, 0x8F, 0xE3, 0xF9,
  0xF8, 0x3F, 0x3F, 0x07, 0xEF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFE, 0x00, 0xFF,
  0xC0, 0x1F, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x7E, 0x7C, 0x0F, 0xCF,
  0xC3, 0xF9, 0xF8, 0x7E, 0x1F, 0x9F, 0xC3, 0xF3, 0xF8, 0x7F, 0xFE, 0x07,
  0xE0, 0xFE, 0x07, 0xEF, 0xC1, 0xFD, 0xF8, 0x3F, 0x1F, 0x07, 0xE3, 0xF0,
  0xF8, 0x7E, 0x3F, 0x07, 0xC7, 0xE0, 0xFC, 0xF8, 0x0F, 0xBF, 0x01, 0xF7,
  0xC0, 0x3F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x01, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F,
  0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F,
  0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7F, 0xFF,
  0xFF, 0xF8, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xF8,
  0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xE0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB,
  0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E,
  0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x01, 0xF8,
  0x1F, 0x81, 0xF8, 0x3F, 0xC3, 0xFC, 0x3D, 0xC7, 0x9E, 0x79, 0xE7, 0x8F,
  0xF0, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xE0, 0xF8, 0x0F, 0xC0, 0x7F, 0xE1, 0xFF, 0xE3, 0xFF, 0xEF,
  0xCF, 0xDF, 0x9F, 0x80, 0x3F, 0x07, 0xFE, 0x3F, 0xFC, 0xFF, 0xFB, 0xF3,
  0xF7, 0xE7, 0xEF, 0xCF, 0xDF, 0x9F, 0xBF, 0xFF, 0x7F, 0xFE, 0x7F, 0xFC,
  0x3C, 0xFC, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xFB, 0xE3, 0xFF, 0xCF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFF, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE,
  0x1F, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFB, 0xEF, 0x80,
  0x0F, 0xC0, 0xFF, 0xC7, 0xFF, 0x9F, 0xFF, 0xFE, 0xFF, 0xF1, 0xFF, 0xC7,
  0xFF, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x1F, 0xFC, 0x7F, 0xFB,
  0xF7, 0xFF, 0x9F, 0xFE, 0x3F, 0xF0, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x1F,
  0x7E, 0x7F, 0xFD, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0x8F, 0xFF, 0x1F,
  0xFE, 0x3F, 0xFC, 0x7F, 0xF8, 0xFF, 0xF1, 0xFF, 0xE3, 0xFF, 0xC7, 0xFF,
  0xDF, 0xDF, 0xFF, 0xBF, 0xFF, 0x3F, 0xBE, 0x3E, 0x7C, 0x07, 0xE0, 0x3F,
  0xF0, 0xFF, 0xF3, 0xFF, 0xE7, 0xEF, 0xFF, 0x8F, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xC0, 0x8F, 0xEF, 0x1F,
  0xFF, 0x1F, 0xFF, 0x1F, 0xFC, 0x0F, 0xE0, 0x03, 0xE1, 0xFC, 0x3F, 0x8F,
  0xF1, 0xFC, 0x3E, 0x07, 0xC0, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x0F, 0xBE, 0x7F, 0xFD, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F,
  0xF8, 0x7F, 0xF0, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0xFF, 0xDF, 0xFF, 0xBF,
  0xFF, 0x3F, 0xFE, 0x1E, 0x7C, 0x00, 0xF8, 0x03, 0xF1, 0xCF, 0xE7, 0xFF,
  0x8F, 0xFF, 0x1F, 0xFC, 0x0F, 0xE0, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0xF1, 0xFF,
  0xF3, 0xFF, 0xF7, 0xFF, 0xEF, 0xEF, 0xFF, 0x8F, 0xFF, 0x1F, 0xFE, 0x3F,
  0xFC, 0x7F, 0xF8, 0xFF, 0xF1, 0xFF, 0xE3, 0xFF, 0xC7, 0xFF, 0x8F, 0xFF,
  0x1F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF8, 0xFC, 0x10, 0xF9, 0xFF, 0xF7, 0xC7,
  0x00, 0x00, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3,
  0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF8, 0x04, 0x0F, 0x87, 0xE3, 0xF1, 0xF0,
  0x70, 0x00, 0x00, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F,
  0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7,
  0xE3, 0xEF, 0xF7, 0xFB, 0xF9, 0xFC, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0xFF, 0xF1, 0xFB, 0xE7, 0xE7, 0xDF, 0xCF, 0xBF, 0x1F, 0xFC, 0x3F, 0xF0,
  0x7F, 0xE0, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0xC7, 0xFF, 0x8F, 0x9F, 0x9F,
  0x3F, 0x3E, 0x3F, 0x7C, 0x7E, 0xF8, 0xFF, 0xF0, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xF9, 0xE1, 0xF3, 0xEF, 0xCF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xE3, 0xF3, 0xFF, 0x8F, 0xC7, 0xFE, 0x3F, 0x1F,
  0xF8, 0xFC, 0x7F, 0xE3, 0xF1, 0xFF, 0x8F, 0xC7, 0xFE, 0x3F, 0x1F, 0xF8,
  0xFC, 0x7F, 0xE3, 0xF1, 0xFF, 0x8F, 0xC7, 0xFE, 0x3F, 0x1F, 0xF8, 0xFC,
  0x7F, 0xE3, 0xF1, 0xF0, 0xFC, 0xF1, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xFF,
  0xEF, 0xFF, 0x8F, 0xFF, 0x1F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF8, 0xFF, 0xF1,
  0xFF, 0xE3, 0xFF, 0xC7, 0xFF, 0x8F, 0xFF, 0x1F, 0xFE, 0x3F, 0xFC, 0x7F,
  0xF8, 0xFC, 0x07, 0xE0, 0x3F, 0xF0, 0xFF, 0xF3, 0xFF, 0xE7, 0xEF, 0xFF,
  0x8F, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE1,
  0xFF, 0xC7, 0xEF, 0xDF, 0xDF, 0xFF, 0x1F, 0xFE, 0x1F, 0xF8, 0x1F, 0xC0,
  0xFB, 0xE3, 0xFF, 0xCF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0x87,
  0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xF3, 0xEF, 0x8F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x00, 0x1F, 0x3E, 0x7F, 0x7D,
  0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0x8F, 0xFF, 0x1F, 0xFE, 0x3F, 0xFC,
  0x7F, 0xF8, 0xFF, 0xF1, 0xFF, 0xE3, 0xFF, 0xC7, 0xFF, 0xDF, 0xDF, 0xFF,
  0xBF, 0xFF, 0x3F, 0xFE, 0x3E, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0xF9, 0xFD, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1,
  0xF0, 0xF8, 0x7C, 0x00, 0x0F, 0xC0, 0xFF, 0xC7, 0xFF, 0xBF, 0xFE, 0xFC,
  0xFF, 0xF3, 0xFF, 0xE0, 0x1F, 0xE0, 0x7F, 0xE0, 0x7F, 0xC0, 0x7F, 0x80,
  0x7F, 0xF8, 0xFF, 0xE3, 0xFF, 0xFF, 0x9F, 0xFE, 0x3F, 0xF0, 0x3F, 0x00,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xFC,
  0xFF, 0x1F, 0xC7, 0xF0, 0x7C, 0xFC, 0x7F, 0xF8, 0xFF, 0xF1, 0xFF, 0xE3,
  0xFF, 0xC7, 0xFF, 0x8F, 0xFF, 0x1F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF8, 0xFF,
  0xF1, 0xFF, 0xE3, 0xFF, 0xC7, 0xEF, 0xDF, 0xDF, 0xFF, 0xBF, 0xFF, 0x3F,
  0xBE, 0x3E, 0x7C, 0xFC, 0x3F, 0x7C, 0x3E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x3E, 0x7C, 0x3E, 0x7C, 0x3F, 0x7C, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07,
  0xE0, 0x07, 0xE0, 0x7C, 0x78, 0xFB, 0xE3, 0xC7, 0xDF, 0x3E, 0x3E, 0xF9,
  0xF9, 0xF7, 0xCF, 0xDF, 0x1F, 0x7E, 0xF8, 0xFB, 0xF7, 0xC7, 0xFF, 0xBE,
  0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x87, 0xF7, 0xF8, 0x3F, 0x9F, 0xC1, 0xFC,
  0xFE, 0x0F, 0xE7, 0xF0, 0x7F, 0x3F, 0x81, 0xF0, 0xF8, 0x0F, 0x87, 0xC0,
  0x7C, 0x3E, 0x00, 0x7E, 0x3E, 0x7E, 0x7E, 0x3E, 0x7E, 0x3F, 0x7C, 0x1F,
  0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xFC, 0x3E, 0x7C, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7C, 0x3F, 0xFC, 0x3F, 0x7C, 0x3F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x3E, 0x7C, 0x3E, 0xFC, 0x3F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x1F, 0xC0, 0x3F, 0xC0, 0x3F,
  0x80, 0x3F, 0x00, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x01, 0xF8, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x02, 0x0F, 0x1F, 0x1F, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E,
  0x3E, 0x3E, 0x7C, 0xFC, 0xF8, 0xF8, 0xFC, 0x7C, 0x3E, 0x3E, 0x3E, 0x3E,
  0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x1F, 0x1F, 0x0F, 0x02, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x40, 0x70,
  0xF8, 0x7C, 0x7C, 0x7C, 0x7C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3E, 0x3E,
  0x1F, 0x1F, 0x0F, 0x1F, 0x3E, 0x3E, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x7C,
  0x7C, 0x7C, 0x7C, 0x78, 0xF8, 0x70, 0x40, 0x3C, 0x00, 0xFE, 0x3F, 0xFE,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xB8, 0x7F, 0x00, 0x78,
};

const GFXglyph RobotoCondensed_Black35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 6, 25, 9, 2, -25 },
  { 20, 10, 10, 11, 0, -26 },
  { 33, 16, 25, 18, 1, -25 },
  { 83, 16, 32, 18, 1, -29 },
  { 147, 19, 25, 23, 2, -25 },
  { 207, 19, 25, 21, 1, -25 },
  { 267, 4, 10, 5, 1, -26 },
  { 272, 8, 35, 11, 2, -27 },
  { 307, 9, 35, 11, 1, -27 },
  { 347, 16, 15, 16, 0, -25 },
  { 377, 14, 19, 16, 1, -21 },
  { 411, 6, 11, 9, 1, -4 },
  { 420, 9, 4, 15, 3, -13 },
  { 425, 6, 6, 11, 2, -6 },
  { 430, 11, 27, 11, 0, -25 },
  { 468, 15, 25, 18, 1, -25 },
  { 515, 10, 25, 18, 3, -25 },
  { 547, 15, 25, 18, 1, -25 },
  { 594, 15, 25, 18, 1, -25 },
  { 641, 16, 25, 18, 1, -25 },
  { 691, 15, 25, 18, 1, -25 },
  { 738, 16, 25, 18, 1, -25 },
  { 788, 15, 25, 18, 1, -25 },
  { 835, 14, 25, 18, 2, -25 },
  { 879, 15, 25, 18, 1, -25 },
  { 926, 6, 20, 10, 2, -20 },
  { 941, 7, 27, 10, 1, -20 },
  { 965, 13, 17, 16, 1, -19 },
  { 993, 14, 11, 18, 2, -16 },
  { 1013, 13, 17, 16, 2, -19 },
  { 1041, 14, 25, 16, 1, -25 },
  { 1085, 25, 32, 27, 1, -24 },
  { 1185, 21, 25, 21, 0, -25 },
  { 1251, 16, 25, 20, 2, -25 },
  { 1301, 18, 25, 20, 1, -25 },
  { 1358, 16, 25, 20, 2, -25 },
  { 1408, 14, 25, 17, 2, -25 },
  { 1452, 14, 25, 17, 2, -25 },
  { 1496, 18, 25, 21, 1, -25 },
  { 1553, 18, 25, 21, 2, -25 },
  { 1610, 6, 25, 10, 2, -25 },
  { 1629, 15, 25, 17, 1, -25 },
  { 1676, 18, 25, 20, 2, -25 },
  { 1733, 14, 25, 17, 2, -25 },
  { 1777, 23, 25, 27, 2, -25 },
  { 1849, 18, 25, 21, 2, -25 },
  { 1906, 19, 25, 21, 1, -25 },
  { 1966, 17, 25, 20, 2, -25 },
  { 2020, 19, 30, 21, 1, -25 },
  { 2092, 17, 25, 20, 2, -25 },
  { 2146, 17, 25, 19, 1, -25 },
  { 2200, 18, 25, 19, 1, -25 },
  { 2257, 17, 25, 20, 2, -25 },
  { 2311, 20, 25, 20, 0, -25 },
  { 2374, 24, 25, 26, 1, -25 },
  { 2449, 19, 25, 20, 0, -25 },
  { 2509, 19, 25, 19, 0, -25 },
  { 2569, 17, 25, 19, 1, -25 },
  { 2623, 7, 35, 9, 2, -29 },
  { 2654, 14, 27, 14, 0, -25 },
  { 2702, 7, 35, 9, 1, -29 },
  { 2733, 12, 12, 14, 1, -25 },
  { 2751, 13, 4, 14, 0, 0 },
  { 2758, 9, 5, 12, 1, -26 },
  { 2764, 15, 18, 16, 1, -18 },
  { 2798, 14, 26, 17, 2, -26 },
  { 2844, 14, 18, 16, 1, -18 },
  { 2876, 15, 26, 17, 1, -26 },
  { 2925, 15, 18, 17, 1, -18 },
  { 2959, 11, 26, 12, 0, -26 },
  { 2995, 15, 25, 18, 1, -18 },
  { 3042, 15, 26, 17, 1, -26 },
  { 3091, 7, 26, 9, 1, -26 },
  { 3114, 9, 33, 9, -1, -26 },
  { 3152, 15, 26, 17, 2, -26 },
  { 3201, 5, 26, 9, 2, -26 },
  { 3218, 22, 18, 26, 2, -18 },
  { 3268, 15, 18, 17, 1, -18 },
  { 3302, 15, 18, 17, 1, -18 },
  { 3336, 14, 25, 17, 2, -18 },
  { 3380, 15, 25, 17, 1, -18 },
  { 3427, 9, 18, 12, 2, -18 },
  { 3448, 14, 18, 16, 1, -18 },
  { 3480, 10, 23, 11, 0, -23 },
  { 3509, 15, 18, 17, 1, -18 },
  { 3543, 16, 18, 16, 0, -18 },
  { 3579, 21, 18, 22, 0, -18 },
  { 3627, 16, 18, 16, 0, -18 },
  { 3663, 16, 25, 16, 0, -18 },
  { 3713, 14, 18, 16, 1, -18 },
  { 3745, 8, 33, 10, 1, -27 },
  { 3778, 3, 30, 9, 3, -25 },
  { 3790, 8, 33, 10, 1, -27 },
  { 3823, 15, 8, 19, 2, -14 },
};

const GFXfont RobotoCondensed_Black35pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Black35pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Black35pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _ROBOTOCONDENSED_BLACK35PT7B_H_
