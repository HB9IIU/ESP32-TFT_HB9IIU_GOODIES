#ifndef _ROBOTOCONDENSED_BLACK28PT7B_H_
#define _ROBOTOCONDENSED_BLACK28PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Black.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Black28pt7bBitmaps[] PROGMEM = {
  0x00, 0xFB, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0x80, 0x0E, 0x7F,
  0xDE, 0xE0, 0xF7, 0xF7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0x0C, 0xE0,
  0xCC, 0x0C, 0xC1, 0xDC, 0x1D, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0x19, 0x81,
  0x98, 0x19, 0x83, 0xB8, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0x30, 0x33, 0x03,
  0x30, 0x77, 0x07, 0x70, 0x03, 0x00, 0x30, 0x03, 0x00, 0xF8, 0x3F, 0xE3,
  0xFE, 0x7F, 0xF7, 0x9F, 0x78, 0xF7, 0x80, 0x7C, 0x03, 0xF0, 0x3F, 0x80,
  0xFE, 0x07, 0xE0, 0x1F, 0xF9, 0xFF, 0x8F, 0xF9, 0xF7, 0xFF, 0x7F, 0xE3,
  0xFE, 0x0F, 0x80, 0x60, 0x06, 0x00, 0x60, 0x3C, 0x00, 0x7E, 0x00, 0xFF,
  0x10, 0xE7, 0x38, 0xE7, 0x30, 0xE7, 0x70, 0xFF, 0x60, 0x7E, 0xE0, 0x3C,
  0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0xBC, 0x07, 0x7E, 0x06, 0xFF, 0x0E,
  0xE7, 0x0C, 0xE7, 0x1C, 0xE7, 0x18, 0xFF, 0x00, 0x7E, 0x00, 0x3C, 0x0F,
  0x00, 0x3F, 0x80, 0xFF, 0x03, 0xFF, 0x07, 0x9E, 0x0F, 0x3C, 0x1E, 0x70,
  0x1F, 0xE0, 0x3F, 0x80, 0x3E, 0x00, 0xFC, 0xF3, 0xFD, 0xEF, 0x7F, 0xDE,
  0xFF, 0xBC, 0xFE, 0x7C, 0xFC, 0xFF, 0xF8, 0xFF, 0xF1, 0xFF, 0xF0, 0xF9,
  0xF0, 0xFF, 0xFF, 0xFE, 0x04, 0x31, 0xCE, 0x79, 0xC7, 0x3C, 0xF3, 0x8E,
  0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x3C, 0xF1, 0xC7, 0x0E, 0x38, 0x70,
  0xC1, 0x81, 0xC3, 0x83, 0x87, 0x87, 0x0F, 0x1E, 0x1C, 0x38, 0x78, 0xF1,
  0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x70, 0xE3, 0xC7, 0x8E, 0x3C, 0x71, 0xE3,
  0x84, 0x00, 0x07, 0x00, 0x38, 0x01, 0xC0, 0xC6, 0x27, 0xB7, 0xFF, 0xFC,
  0x3F, 0x01, 0xF0, 0x1D, 0xC1, 0xE7, 0x0E, 0x38, 0x20, 0x80, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x00, 0x7B, 0xDE, 0xF7, 0xBB, 0xDC, 0x40,
  0xFF, 0xFF, 0xFF, 0xF0, 0x67, 0xBF, 0xFF, 0x00, 0x07, 0x07, 0x07, 0x0F,
  0x0E, 0x0E, 0x0E, 0x1E, 0x1C, 0x1C, 0x1C, 0x3C, 0x38, 0x38, 0x38, 0x78,
  0x70, 0x70, 0x70, 0xF0, 0xE0, 0xE0, 0x0F, 0x83, 0xFC, 0x7F, 0xE7, 0xFE,
  0x79, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F,
  0xF8, 0xFF, 0x8F, 0xF9, 0xF7, 0x9F, 0x7F, 0xE3, 0xFE, 0x3F, 0xC0, 0xF8,
  0x01, 0x0F, 0x7F, 0xFF, 0xFF, 0xEF, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x83, 0xFC, 0x7F,
  0xE7, 0xFF, 0xF9, 0xFF, 0x1F, 0xF1, 0xF0, 0x1F, 0x01, 0xE0, 0x3E, 0x07,
  0xC0, 0x78, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x1F, 0x83, 0xFC, 0x7F, 0xEF, 0xFF, 0xF9, 0xF0, 0x1F, 0x01,
  0xF0, 0x3E, 0x0F, 0xC0, 0xFC, 0x0F, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0xF0,
  0xFF, 0x9F, 0xFF, 0xF7, 0xFE, 0x3F, 0xC1, 0xF8, 0x03, 0xE0, 0x3E, 0x07,
  0xE0, 0x7E, 0x0F, 0xE0, 0xFE, 0x1F, 0xE1, 0xFE, 0x3F, 0xE3, 0xBE, 0x7B,
  0xE7, 0x3E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x3E, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7, 0xFE, 0x78, 0x07, 0x80, 0x78,
  0x07, 0xF8, 0xFF, 0xEF, 0xFE, 0x79, 0xF0, 0x1F, 0x00, 0xF0, 0x0F, 0xF9,
  0xFF, 0x9F, 0xFF, 0xE7, 0xFE, 0x3F, 0xC0, 0xF8, 0x03, 0xC0, 0x7E, 0x07,
  0xF0, 0x7F, 0x83, 0xE0, 0x3E, 0x01, 0xE0, 0x1F, 0x78, 0xFF, 0xE7, 0xFF,
  0xBF, 0xFD, 0xF1, 0xEF, 0x8F, 0x7C, 0x7F, 0xE3, 0xCF, 0x1E, 0x7F, 0xF1,
  0xFF, 0x0F, 0xF0, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01,
  0xE0, 0x1E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0xF8, 0x0F,
  0x80, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x0F,
  0x83, 0xFC, 0x7F, 0xE7, 0xFE, 0x79, 0xF7, 0x9F, 0x79, 0xF7, 0x9E, 0x7F,
  0xE3, 0xFC, 0x3F, 0xC7, 0xFE, 0x79, 0xFF, 0x8F, 0xF8, 0xFF, 0x9F, 0xFF,
  0xF7, 0xFE, 0x3F, 0xE1, 0xF8, 0x0F, 0x03, 0xFC, 0x3F, 0xE7, 0xFE, 0x79,
  0xFF, 0x9F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0x7D, 0xF7, 0xFF, 0x3F,
  0xF1, 0xFF, 0x01, 0xE0, 0x3E, 0x1F, 0xC1, 0xF8, 0x1F, 0x01, 0xC0, 0x67,
  0xBF, 0xF7, 0x00, 0x00, 0x00, 0x00, 0xCF, 0x7F, 0xEE, 0x31, 0xE7, 0xDE,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE7, 0x9E, 0x79, 0xE7, 0x9C,
  0xF1, 0x80, 0x00, 0x40, 0x70, 0x7C, 0xFF, 0xFF, 0xBF, 0x8F, 0x03, 0xF8,
  0xFF, 0x8F, 0xF0, 0x7C, 0x07, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x80,
  0x38, 0x0F, 0x83, 0xF8, 0x7F, 0x87, 0xF0, 0x7C, 0x7F, 0x7F, 0xBF, 0x8F,
  0x83, 0x80, 0x80, 0x00, 0x0F, 0x83, 0xFC, 0x7F, 0xE7, 0xFF, 0x79, 0xFF,
  0x9F, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x7C, 0x07, 0x80, 0xF0, 0x0F, 0x00,
  0xF0, 0x00, 0x00, 0x60, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x01, 0xF8,
  0x00, 0xFF, 0xC0, 0x3E, 0x7E, 0x0F, 0x01, 0xC3, 0xC0, 0x1C, 0x70, 0x01,
  0x9C, 0x1E, 0x3B, 0x8F, 0xE7, 0x63, 0xFC, 0x7C, 0x73, 0x8F, 0x9E, 0x71,
  0xF3, 0x8E, 0x3E, 0x71, 0xC7, 0xCE, 0x38, 0xF9, 0xC7, 0x3F, 0x39, 0xE7,
  0xE7, 0xFD, 0xDC, 0x7F, 0xF1, 0xC7, 0x3C, 0x38, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x03, 0xF0, 0x00, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3D,
  0xE0, 0x1E, 0xF0, 0x0F, 0x78, 0x0F, 0xBE, 0x07, 0x8F, 0x03, 0xC7, 0x83,
  0xFF, 0xC1, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0xFC, 0x7C, 0x1F, 0x3E, 0x0F,
  0x9F, 0x07, 0xDF, 0x01, 0xF0, 0xFF, 0xC3, 0xFF, 0xCF, 0xFF, 0xBF, 0xFE,
  0xF8, 0xFB, 0xE1, 0xEF, 0x87, 0xBE, 0x3E, 0xFF, 0xF3, 0xFF, 0x8F, 0xFF,
  0xBE, 0x1E, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xFF, 0xFB, 0xFF,
  0xEF, 0xFF, 0x3F, 0xF0, 0x0F, 0xC0, 0x7F, 0xC3, 0xFF, 0x9F, 0xFF, 0x78,
  0x7F, 0xE0, 0xFF, 0x83, 0xFE, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0xFF, 0x83, 0xDE, 0x1F, 0x7F, 0xFC, 0xFF, 0xE1,
  0xFF, 0x03, 0xF0, 0xFF, 0x83, 0xFF, 0x8F, 0xFF, 0x3F, 0xFC, 0xF8, 0xFB,
  0xE1, 0xEF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F,
  0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xBE, 0x3E, 0xFF, 0xF3, 0xFF, 0xCF, 0xFE,
  0x3F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0xFE, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xFF, 0xEF, 0xFE, 0xFF,
  0xEF, 0xFE, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0x0F, 0xE0, 0x7F, 0xC3, 0xFF, 0x9F, 0xFF, 0x7C, 0x7F, 0xE0,
  0xFF, 0x83, 0xFE, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x9F, 0xFE, 0x7F, 0xF9,
  0xFF, 0xE0, 0xFF, 0x83, 0xDF, 0x0F, 0x7F, 0xFC, 0xFF, 0xF1, 0xFF, 0x83,
  0xF8, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07,
  0xFE, 0x0F, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0,
  0xFF, 0xC1, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xFC, 0x7F, 0x9F, 0xFF,
  0xFF, 0xF9, 0xFE, 0x0F, 0x80, 0xF8, 0x7F, 0xF1, 0xFB, 0xE3, 0xE7, 0xCF,
  0xCF, 0x9F, 0x1F, 0x3E, 0x3E, 0xF8, 0x7D, 0xE0, 0xFF, 0xC1, 0xFF, 0x83,
  0xFF, 0x07, 0xFF, 0x0F, 0xFE, 0x1F, 0xBE, 0x3E, 0x7C, 0x7C, 0xFC, 0xF8,
  0xF9, 0xF1, 0xFB, 0xE1, 0xF7, 0xC3, 0xF0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0,
  0xFF, 0xFE, 0x3F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFF, 0xFF, 0x1F, 0xFF, 0xF3,
  0xFF, 0xEE, 0xFF, 0xFD, 0xDD, 0xFF, 0xBB, 0xBF, 0xF7, 0xF7, 0xFE, 0x7E,
  0xFF, 0xCF, 0x9F, 0xF9, 0xF3, 0xFF, 0x3E, 0x7F, 0xE3, 0xCF, 0xFC, 0x71,
  0xF0, 0xF8, 0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE1, 0xFF, 0xE3, 0xFF, 0xC7,
  0xFF, 0xCF, 0xFF, 0x9F, 0xFF, 0x3F, 0xF7, 0x7F, 0xEE, 0xFF, 0xCF, 0xFF,
  0x9F, 0xFF, 0x3F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE1,
  0xFF, 0xC1, 0xF0, 0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xFF, 0xE7, 0xC7,
  0xDF, 0x07, 0xBE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF,
  0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0x3E, 0x3E, 0x7F, 0xFC, 0x7F,
  0xF0, 0x7F, 0xC0, 0x7E, 0x00, 0xFF, 0xC3, 0xFF, 0xCF, 0xFF, 0xBF, 0xFE,
  0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xFF, 0xEF, 0xFF,
  0xBF, 0xFC, 0xFF, 0xC3, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xFF, 0xE7,
  0xC7, 0xDF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0,
  0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xBE, 0x3E, 0x7F, 0xFC,
  0x7F, 0xF0, 0x7F, 0xC0, 0x3F, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x00,
  0x08, 0xFF, 0xC3, 0xFF, 0xCF, 0xFF, 0xBF, 0xFE, 0xF8, 0x7F, 0xE1, 0xFF,
  0x87, 0xFE, 0x1F, 0xF8, 0x7B, 0xFF, 0xEF, 0xFF, 0x3F, 0xF8, 0xFF, 0xE3,
  0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF8, 0xFB, 0xE3, 0xEF, 0x87, 0xFE, 0x1F,
  0x0F, 0xC1, 0xFF, 0x1F, 0xFC, 0xFF, 0xF7, 0x8F, 0xFC, 0x3D, 0xE0, 0x0F,
  0xC0, 0x7F, 0x81, 0xFF, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xFC, 0x3F, 0xE1,
  0xFF, 0x0F, 0x7F, 0xFB, 0xFF, 0xCF, 0xFC, 0x1F, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0xF8, 0x7F, 0xE1, 0xFF,
  0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F,
  0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xDE, 0x1F,
  0x7F, 0xF9, 0xFF, 0xE3, 0xFF, 0x03, 0xF0, 0xF8, 0x1F, 0x7C, 0x1F, 0x7C,
  0x3F, 0x7C, 0x3E, 0x7C, 0x3E, 0x3C, 0x3E, 0x3E, 0x3C, 0x3E, 0x7C, 0x3E,
  0x7C, 0x1E, 0x7C, 0x1E, 0x78, 0x1F, 0x78, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x78,
  0xF0, 0xF7, 0x8F, 0x9F, 0x78, 0xF9, 0xF7, 0xCF, 0x9F, 0x7C, 0xF9, 0xF7,
  0xDF, 0x9E, 0x3D, 0xFD, 0xE3, 0xDF, 0xDE, 0x3D, 0xFF, 0xE3, 0xDF, 0xFE,
  0x3F, 0xFF, 0xE3, 0xFF, 0xFC, 0x1F, 0xDF, 0xC1, 0xFD, 0xFC, 0x1F, 0xDF,
  0xC1, 0xFD, 0xFC, 0x1F, 0x9F, 0xC1, 0xF8, 0xF8, 0x0F, 0x8F, 0x80, 0xF8,
  0xF8, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x7C, 0x3E, 0x7C, 0x3E, 0x78, 0x1F,
  0xF8, 0x1F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x1F, 0xF8, 0x1E, 0xF8, 0x3E, 0x7C, 0x3E, 0x7C, 0x7C,
  0x7C, 0x7C, 0x3E, 0xFC, 0x3E, 0xF8, 0x3E, 0xF8, 0x7D, 0xF0, 0xF1, 0xE3,
  0xE3, 0xC7, 0xC7, 0xCF, 0x07, 0xBE, 0x0F, 0x78, 0x0F, 0xF0, 0x1F, 0xC0,
  0x3F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x3C, 0x03,
  0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF,
  0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xFF,
  0xFF, 0xF8, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x7C, 0x03, 0xC0, 0x3E, 0x03,
  0xE0, 0x1E, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0x78, 0x07, 0xC0, 0x7C, 0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x1E, 0xFF, 0xFF,
  0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3,
  0xCF, 0x3C, 0xF3, 0xCF, 0x3F, 0xFF, 0xFF, 0x1C, 0x0F, 0x83, 0xE0, 0xFC,
  0x77, 0x1D, 0xC7, 0x7B, 0xCE, 0xE3, 0xB8, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xF8, 0xF8, 0xF0, 0xF0, 0x1F, 0x0F, 0xF9, 0xFF, 0x7D, 0xFF, 0x3E,
  0x07, 0xC7, 0xFB, 0xFF, 0xFF, 0xFE, 0x7F, 0xCF, 0xF9, 0xFF, 0xFE, 0xFB,
  0xCF, 0x78, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xFB,
  0xCF, 0xFE, 0xFF, 0xEF, 0xFF, 0xF9, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8,
  0xFF, 0x8F, 0xF9, 0xFF, 0xFF, 0xFF, 0xEF, 0x7E, 0xF7, 0xC0, 0x1F, 0x0F,
  0xF9, 0xFF, 0x7F, 0xFF, 0x1F, 0xE3, 0xFC, 0x07, 0x80, 0xF0, 0x1E, 0x3F,
  0xC7, 0xFF, 0xF7, 0xFC, 0xFF, 0x87, 0xC0, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x3D, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF,
  0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFF, 0x3C, 0xF0, 0x1F, 0x83, 0xFC, 0x7F, 0xEF, 0xFE, 0xF9, 0xFF, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x4F, 0xFE, 0x7F, 0xE3, 0xFE,
  0x1F, 0x80, 0x07, 0x8F, 0xC7, 0xE7, 0xF3, 0xE1, 0xF3, 0xFF, 0xFF, 0xFF,
  0x9F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87,
  0xC3, 0xE0, 0x1E, 0xF7, 0xFF, 0x7F, 0xFF, 0xFF, 0xF9, 0xFF, 0x1F, 0xF1,
  0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF9, 0xFF, 0xFF, 0x7F, 0xF7, 0xFF, 0x1F,
  0xF0, 0x1F, 0x01, 0xF3, 0xBF, 0x7F, 0xE7, 0xFC, 0x1F, 0x00, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xFB, 0xCF, 0xFE, 0xFF, 0xEF,
  0xFE, 0xF9, 0xFF, 0x9F, 0xF9, 0xFF, 0x9F, 0xF9, 0xFF, 0x9F, 0xF9, 0xFF,
  0x9F, 0xF9, 0xFF, 0x9F, 0xF9, 0xF0, 0x7F, 0xFE, 0xE0, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1E, 0x7C, 0xF8, 0xE0,
  0x00, 0x07, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C,
  0x78, 0xF1, 0xE7, 0xCF, 0xFF, 0xFD, 0xFB, 0xC0, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE7, 0xDF, 0x7E, 0xFB, 0xE7, 0xFE,
  0x3F, 0xF1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFF, 0x1F, 0xF8, 0xFB, 0xE7,
  0xDF, 0x3E, 0x7D, 0xF3, 0xEF, 0x8F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFB, 0xCF, 0x3F,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF9, 0xF3, 0xFE, 0x7C, 0xFF, 0x9F,
  0x3F, 0xE7, 0xCF, 0xF9, 0xF3, 0xFE, 0x7C, 0xFF, 0x9F, 0x3F, 0xE7, 0xCF,
  0xF9, 0xF3, 0xFE, 0x7C, 0xFF, 0x9F, 0x3C, 0xF3, 0xCF, 0x7E, 0xFF, 0xEF,
  0xFF, 0xF9, 0xFF, 0x9F, 0xF9, 0xFF, 0x9F, 0xF9, 0xFF, 0x9F, 0xF9, 0xFF,
  0x9F, 0xF9, 0xFF, 0x9F, 0xF9, 0xF0, 0x1F, 0x83, 0xFC, 0x7F, 0xEF, 0xFE,
  0xF9, 0xFF, 0x1F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x1F, 0xF9, 0xFF, 0xFE,
  0x7F, 0xE3, 0xFC, 0x1F, 0x80, 0xF3, 0xCF, 0xFE, 0xFF, 0xEF, 0xFF, 0xF9,
  0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF9, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFE, 0xFF, 0xCF, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x00, 0x3C, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF,
  0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0x3D, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0xF3, 0xFF, 0xFF,
  0xFF, 0xFC, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0x1F, 0x0F, 0xFB, 0xFF, 0x79, 0xFF, 0x3F, 0xF0, 0x3F, 0x83, 0xFC, 0x1F,
  0xC0, 0xFF, 0xCF, 0xF9, 0xFF, 0xFC, 0xFF, 0x8F, 0xC0, 0x3C, 0x3C, 0x3C,
  0xFF, 0xFF, 0xFF, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3F,
  0x3F, 0x3F, 0x0F, 0xF9, 0xFF, 0x9F, 0xF9, 0xFF, 0x9F, 0xF9, 0xFF, 0x9F,
  0xF9, 0xFF, 0x9F, 0xF9, 0xFF, 0x9F, 0xF9, 0xFF, 0xFF, 0x7F, 0xF7, 0xFF,
  0x3C, 0xF0, 0xF8, 0xFB, 0xC7, 0x9E, 0x7C, 0xFB, 0xE7, 0xDE, 0x1E, 0xF0,
  0xF7, 0x87, 0xBC, 0x3F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x07,
  0xC0, 0x3E, 0x00, 0xF9, 0xC7, 0xBC, 0xF3, 0xDE, 0x7B, 0xEF, 0x7D, 0xE7,
  0xBE, 0xF3, 0xDF, 0x78, 0xEF, 0xFC, 0x7F, 0xFE, 0x3F, 0x7F, 0x1F, 0xBF,
  0x0F, 0xCF, 0x83, 0xE7, 0xC1, 0xF3, 0xE0, 0xF1, 0xF0, 0x78, 0xF0, 0x78,
  0xF3, 0xEF, 0x8F, 0x78, 0x7B, 0xC3, 0xFE, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x0F, 0xF8, 0x7B, 0xC7, 0xDF, 0x3E, 0xF9, 0xE3, 0xC0,
  0xF8, 0xFB, 0xC7, 0x9E, 0x7C, 0xFB, 0xE7, 0xDF, 0x1E, 0xF0, 0xF7, 0x87,
  0xFC, 0x3F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x80, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xE0, 0x0F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x78, 0x1F, 0x03, 0xC0, 0xF8, 0x3E, 0x07,
  0x81, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0C, 0x73, 0xCF, 0x39,
  0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0xF3, 0x8F, 0x1E, 0x79, 0xE7, 0x9E, 0x79,
  0xE3, 0x8F, 0x3C, 0x70, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC1, 0xC3, 0xC3, 0x87, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3,
  0xE3, 0xE3, 0xCF, 0xBC, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x38, 0xF1,
  0xC3, 0x00, 0x3C, 0x3B, 0xF3, 0xDF, 0xFF, 0xFF, 0xEE, 0x3F, 0x00, 0xF0,
};

const GFXglyph RobotoCondensed_Black28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 5, 20, 7, 1, -20 },
  { 14, 8, 8, 9, 0, -21 },
  { 22, 12, 20, 14, 1, -20 },
  { 52, 12, 26, 14, 1, -23 },
  { 91, 16, 20, 18, 1, -20 },
  { 131, 15, 20, 17, 1, -20 },
  { 169, 3, 8, 4, 1, -21 },
  { 172, 6, 28, 9, 2, -22 },
  { 193, 7, 28, 9, 1, -22 },
  { 218, 13, 12, 13, 0, -20 },
  { 238, 11, 14, 13, 1, -16 },
  { 258, 5, 9, 8, 1, -3 },
  { 264, 7, 4, 12, 2, -11 },
  { 268, 5, 5, 8, 2, -5 },
  { 272, 8, 22, 9, 0, -20 },
  { 294, 12, 20, 14, 1, -20 },
  { 324, 8, 20, 14, 2, -20 },
  { 344, 12, 20, 14, 1, -20 },
  { 374, 12, 20, 14, 1, -20 },
  { 404, 12, 20, 14, 1, -20 },
  { 434, 12, 20, 14, 1, -20 },
  { 464, 13, 20, 14, 1, -20 },
  { 497, 12, 20, 14, 1, -20 },
  { 527, 12, 20, 14, 1, -20 },
  { 557, 12, 20, 14, 1, -20 },
  { 587, 5, 16, 8, 2, -16 },
  { 597, 6, 22, 8, 1, -16 },
  { 614, 10, 13, 13, 1, -15 },
  { 631, 11, 11, 14, 2, -14 },
  { 647, 10, 13, 13, 2, -15 },
  { 664, 12, 20, 13, 0, -20 },
  { 694, 19, 25, 21, 1, -19 },
  { 754, 17, 20, 17, 0, -20 },
  { 797, 14, 20, 16, 1, -20 },
  { 832, 14, 20, 16, 1, -20 },
  { 867, 14, 20, 16, 1, -20 },
  { 902, 12, 20, 14, 1, -20 },
  { 932, 12, 20, 13, 1, -20 },
  { 962, 14, 20, 17, 1, -20 },
  { 997, 15, 20, 17, 1, -20 },
  { 1035, 4, 20, 8, 2, -20 },
  { 1045, 11, 20, 14, 1, -20 },
  { 1073, 15, 20, 16, 1, -20 },
  { 1111, 12, 20, 13, 1, -20 },
  { 1141, 19, 20, 21, 1, -20 },
  { 1189, 15, 20, 17, 1, -20 },
  { 1227, 15, 20, 17, 1, -20 },
  { 1265, 14, 20, 16, 1, -20 },
  { 1300, 15, 24, 17, 1, -20 },
  { 1345, 14, 20, 16, 1, -20 },
  { 1380, 13, 20, 15, 1, -20 },
  { 1413, 14, 20, 16, 1, -20 },
  { 1448, 14, 20, 16, 1, -20 },
  { 1483, 16, 20, 16, 0, -20 },
  { 1523, 20, 20, 21, 0, -20 },
  { 1573, 16, 20, 16, 0, -20 },
  { 1613, 15, 20, 15, 0, -20 },
  { 1651, 13, 20, 15, 1, -20 },
  { 1684, 6, 28, 8, 1, -23 },
  { 1705, 12, 22, 11, 0, -20 },
  { 1738, 6, 28, 8, 0, -23 },
  { 1759, 10, 10, 11, 1, -20 },
  { 1772, 11, 3, 11, 0, 0 },
  { 1777, 7, 4, 10, 1, -21 },
  { 1781, 11, 15, 13, 1, -15 },
  { 1802, 12, 21, 14, 1, -21 },
  { 1834, 11, 15, 13, 1, -15 },
  { 1855, 12, 21, 14, 1, -21 },
  { 1887, 12, 15, 14, 1, -15 },
  { 1910, 9, 21, 9, 0, -21 },
  { 1934, 12, 21, 14, 1, -15 },
  { 1966, 12, 21, 14, 1, -21 },
  { 1998, 5, 21, 7, 1, -21 },
  { 2012, 7, 27, 7, -1, -21 },
  { 2036, 13, 21, 14, 1, -21 },
  { 2071, 5, 21, 7, 1, -21 },
  { 2085, 18, 15, 21, 1, -15 },
  { 2119, 12, 15, 14, 1, -15 },
  { 2142, 12, 15, 14, 1, -15 },
  { 2165, 12, 21, 14, 1, -15 },
  { 2197, 12, 21, 14, 1, -15 },
  { 2229, 8, 15, 10, 1, -15 },
  { 2244, 11, 15, 13, 1, -15 },
  { 2265, 8, 18, 9, 0, -18 },
  { 2283, 12, 15, 14, 1, -15 },
  { 2306, 13, 15, 13, 0, -15 },
  { 2331, 17, 15, 17, 0, -15 },
  { 2363, 13, 15, 13, 0, -15 },
  { 2388, 13, 21, 13, 0, -15 },
  { 2423, 11, 15, 13, 1, -15 },
  { 2444, 6, 27, 8, 1, -22 },
  { 2465, 3, 24, 7, 2, -20 },
  { 2474, 7, 27, 8, 1, -22 },
  { 2498, 13, 6, 15, 1, -11 },
};

const GFXfont RobotoCondensed_Black28pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Black28pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Black28pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _ROBOTOCONDENSED_BLACK28PT7B_H_
