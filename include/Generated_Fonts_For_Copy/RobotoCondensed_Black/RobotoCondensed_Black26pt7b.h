#ifndef _ROBOTOCONDENSED_BLACK26PT7B_H_
#define _ROBOTOCONDENSED_BLACK26PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Black.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Black26pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xF7, 0xBD, 0xEF, 0x73, 0x9C, 0xE7, 0x00, 0x0E, 0xFF,
  0xDC, 0xE7, 0xE7, 0xE7, 0xE7, 0xE6, 0xE6, 0xE6, 0x0D, 0xC3, 0xB8, 0x76,
  0x0E, 0xC1, 0x98, 0x33, 0x3F, 0xFF, 0xFF, 0x3B, 0x87, 0x70, 0xEC, 0x7F,
  0xFF, 0xFE, 0x66, 0x0D, 0xC1, 0xB8, 0x77, 0x0E, 0xC1, 0xD8, 0x00, 0x06,
  0x00, 0xC0, 0x18, 0x0F, 0x83, 0xFC, 0xFF, 0x9E, 0xFB, 0xCF, 0x79, 0xEF,
  0x01, 0xF0, 0x1F, 0x81, 0xF8, 0x1F, 0x80, 0xF8, 0x0F, 0xF1, 0xFE, 0x3F,
  0xE7, 0xBF, 0xF3, 0xFC, 0x3E, 0x01, 0x80, 0x30, 0x06, 0x00, 0x3C, 0x00,
  0xFC, 0x03, 0xB8, 0x87, 0x33, 0x8E, 0x66, 0x1C, 0xDC, 0x3B, 0xB0, 0x3F,
  0xE0, 0x3D, 0x80, 0x07, 0x00, 0x0D, 0xE0, 0x3F, 0xE0, 0x6F, 0xC1, 0xF9,
  0xC3, 0x73, 0x8C, 0xE7, 0x18, 0xFC, 0x01, 0xF8, 0x01, 0xE0, 0x1F, 0x00,
  0xFE, 0x03, 0xFC, 0x1E, 0xF0, 0x79, 0xC1, 0xE7, 0x07, 0xBC, 0x0F, 0xE0,
  0x3F, 0x00, 0xF9, 0xE7, 0xF7, 0xBF, 0xFE, 0xF7, 0xFB, 0xDF, 0xCF, 0x3F,
  0x3E, 0xF8, 0xFF, 0xF1, 0xFF, 0xE3, 0xE7, 0xC0, 0xFF, 0xED, 0xB0, 0x04,
  0x1C, 0x70, 0xE3, 0x87, 0x1C, 0x38, 0x70, 0xE1, 0xC7, 0x8F, 0x1E, 0x1C,
  0x38, 0x70, 0xE1, 0xC3, 0x83, 0x87, 0x07, 0x0E, 0x0E, 0x08, 0x83, 0x0E,
  0x1C, 0x70, 0xE3, 0x8F, 0x3C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x3C, 0xF3,
  0xCE, 0x39, 0xC7, 0x38, 0xC2, 0x00, 0x07, 0x00, 0x70, 0x06, 0x06, 0x66,
  0x7F, 0xF3, 0xFE, 0x0F, 0x01, 0xF8, 0x39, 0xC3, 0x9E, 0x10, 0x80, 0x1E,
  0x07, 0x81, 0xE0, 0x78, 0x1E, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0x81,
  0xE0, 0x78, 0x1E, 0x07, 0x80, 0x77, 0x77, 0x7F, 0xE4, 0xFF, 0xFF, 0xF8,
  0x7F, 0xDE, 0xE0, 0x07, 0x06, 0x0E, 0x0E, 0x0E, 0x0C, 0x1C, 0x1C, 0x1C,
  0x1C, 0x38, 0x38, 0x38, 0x38, 0x70, 0x70, 0x70, 0x70, 0xE0, 0xE0, 0xE0,
  0x1F, 0x07, 0xF1, 0xFF, 0x3D, 0xFF, 0x9F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1,
  0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFE, 0x7B, 0xDF, 0x7F, 0xC7,
  0xF0, 0x7C, 0x00, 0x03, 0x1F, 0x7F, 0xFF, 0xFF, 0xDF, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x07,
  0xF9, 0xFF, 0x7D, 0xFF, 0x1F, 0xE3, 0xC0, 0x78, 0x1F, 0x03, 0xC0, 0xF8,
  0x1E, 0x07, 0x81, 0xE0, 0x7C, 0x1F, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0x0F, 0xF9, 0xFF, 0x7D, 0xFF, 0x1E, 0x03, 0xC0, 0x78, 0x1E,
  0x1F, 0xC3, 0xF0, 0x7F, 0x00, 0xF0, 0x1E, 0x03, 0xFC, 0x7F, 0xDF, 0xFF,
  0xCF, 0xF8, 0x7C, 0x00, 0x03, 0xC0, 0xF8, 0x1F, 0x07, 0xE0, 0xFC, 0x3F,
  0x87, 0xF1, 0xDE, 0x3B, 0xCF, 0x79, 0xCF, 0x79, 0xEF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0x7F, 0xEF, 0xFD, 0xFF, 0xBC,
  0x07, 0x00, 0xE0, 0x3D, 0xC7, 0xFE, 0xFF, 0xC6, 0x7C, 0x07, 0x80, 0xF0,
  0x1F, 0xE3, 0xFC, 0x7F, 0xDF, 0x7F, 0xC7, 0xF0, 0x7C, 0x00, 0x03, 0x80,
  0xF8, 0x1F, 0x83, 0xF0, 0x7C, 0x07, 0x80, 0xFF, 0x8F, 0xFC, 0xFF, 0xEF,
  0xBE, 0xF1, 0xEF, 0x1E, 0xF1, 0xFF, 0x1E, 0xF1, 0xE7, 0xBE, 0x7F, 0xC3,
  0xFC, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x3C, 0x07, 0x80,
  0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x81, 0xF0, 0x3C, 0x07, 0x81,
  0xF0, 0x3C, 0x07, 0x81, 0xF0, 0x00, 0x1F, 0x07, 0xF9, 0xFF, 0x3D, 0xFF,
  0x9F, 0xF3, 0xDE, 0x7B, 0xDE, 0x3F, 0xC7, 0xF1, 0xFF, 0x3C, 0xFF, 0x1F,
  0xE3, 0xFC, 0x7F, 0xDF, 0x7F, 0xE7, 0xF8, 0x7C, 0x00, 0x1F, 0x07, 0xF1,
  0xFF, 0x3D, 0xEF, 0x9F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFF, 0x3D, 0xFF,
  0xBF, 0xF1, 0xDE, 0x07, 0x80, 0xF0, 0xFC, 0x3F, 0x87, 0xE0, 0xF0, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x7F, 0xFE, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0xF7, 0xBD, 0xEE, 0x77, 0x18, 0x00, 0x81, 0xC3, 0xE7, 0xFF,
  0xE7, 0xC3, 0xE1, 0xFC, 0x3F, 0x87, 0xC0, 0xE0, 0x10, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x38, 0x0F, 0x83, 0xF8,
  0x7F, 0x83, 0xF0, 0x3C, 0x3F, 0x7F, 0xBF, 0x8F, 0x83, 0x80, 0x80, 0x00,
  0x1F, 0x07, 0xF9, 0xFF, 0x3D, 0xFF, 0x9E, 0x03, 0xC0, 0x78, 0x1E, 0x07,
  0xC1, 0xF0, 0x3C, 0x07, 0x80, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x1F, 0x03,
  0xE0, 0x38, 0x00, 0x01, 0xF0, 0x01, 0xFF, 0x01, 0xF1, 0xE0, 0x70, 0x1C,
  0x38, 0x03, 0x9C, 0x3C, 0x67, 0x1F, 0x99, 0x8F, 0xE7, 0xE7, 0x39, 0xF9,
  0xCE, 0x7E, 0x73, 0x9F, 0x9C, 0xE7, 0xEF, 0x39, 0xF3, 0xCE, 0x7E, 0x73,
  0x9B, 0x9F, 0xEE, 0xE7, 0xFF, 0x38, 0xE7, 0x87, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x0F, 0xCC, 0x00, 0xFF, 0x80, 0x1F, 0x80, 0x03, 0xC0, 0x07,
  0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0E,
  0xF0, 0x1E, 0x70, 0x1E, 0x78, 0x1E, 0x78, 0x3E, 0x78, 0x3F, 0xFC, 0x3F,
  0xFC, 0x7F, 0xFC, 0x7C, 0x3E, 0x78, 0x3E, 0x78, 0x1E, 0xF8, 0x1E, 0xFF,
  0x87, 0xFF, 0x3F, 0xFD, 0xF7, 0xEF, 0x8F, 0x7C, 0x7B, 0xE3, 0xDF, 0x1E,
  0xFF, 0xE7, 0xFE, 0x3F, 0xFD, 0xF1, 0xEF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF,
  0x3E, 0xFF, 0xF7, 0xFF, 0x3F, 0xF0, 0x0F, 0x81, 0xFF, 0x1F, 0xFC, 0xFB,
  0xFF, 0x87, 0xFC, 0x3F, 0xC1, 0xFE, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x07, 0xFC, 0x3F, 0xE3, 0xEF, 0xFF, 0x7F, 0xF1, 0xFF, 0x03,
  0xE0, 0xFF, 0x07, 0xFE, 0x3F, 0xF9, 0xF7, 0xEF, 0x8F, 0x7C, 0x7B, 0xE3,
  0xFF, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7B,
  0xE3, 0xDF, 0x7E, 0xFF, 0xE7, 0xFE, 0x3F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xFF, 0xDF, 0xFB, 0xFF, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xFF, 0xDF,
  0xFB, 0xFF, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x00, 0x0F, 0xC1, 0xFF, 0x9F, 0xFC, 0xFF, 0xF7, 0x87, 0xFC, 0x3F,
  0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF, 0x87, 0xFC,
  0x3D, 0xE1, 0xEF, 0xDF, 0x7F, 0xF9, 0xFF, 0x83, 0xF0, 0xF8, 0x7F, 0xE1,
  0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE,
  0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3F, 0xE7, 0xFC, 0xF7, 0xFE, 0xFF, 0xCF, 0xF0, 0x78, 0x00, 0xF8, 0xFB,
  0xE3, 0xEF, 0x9F, 0x3E, 0x7C, 0xFB, 0xE3, 0xEF, 0x0F, 0xFC, 0x3F, 0xE0,
  0xFF, 0x83, 0xFE, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xE3, 0xEF, 0x8F, 0x9F,
  0x3E, 0x7C, 0xF8, 0xFB, 0xE3, 0xEF, 0x8F, 0x80, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFC,
  0x0F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xF0, 0xFF,
  0xF8, 0xFF, 0xFE, 0x7F, 0xF7, 0x3F, 0xFB, 0x9F, 0xFD, 0xDF, 0xFE, 0xEE,
  0xFF, 0xBF, 0x7F, 0xDF, 0xBF, 0xEF, 0x9F, 0xF7, 0xCF, 0xF9, 0xE7, 0xFC,
  0xF3, 0xFE, 0x71, 0xE0, 0xF8, 0x7F, 0xE1, 0xFF, 0xC7, 0xFF, 0x1F, 0xFC,
  0x7F, 0xF9, 0xFF, 0xE7, 0xFF, 0xDF, 0xFF, 0x7F, 0xED, 0xFF, 0xBF, 0xFE,
  0xFF, 0xF9, 0xFF, 0xE7, 0xFF, 0x9F, 0xFE, 0x3F, 0xF8, 0xFF, 0xE1, 0xFF,
  0x87, 0xC0, 0x0F, 0xC0, 0xFF, 0x83, 0xFF, 0x1F, 0xFE, 0x78, 0x7B, 0xE1,
  0xEF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0,
  0x7F, 0xE1, 0xE7, 0x87, 0x9F, 0xFE, 0x7F, 0xF0, 0xFF, 0x80, 0xFC, 0x00,
  0xFF, 0x87, 0xFF, 0x3F, 0xFD, 0xF3, 0xEF, 0x8F, 0xFC, 0x7F, 0xE1, 0xFF,
  0x1F, 0xF8, 0xFF, 0xCF, 0xBF, 0xFD, 0xFF, 0xCF, 0xF8, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0x0F, 0xC0, 0xFF, 0x83, 0xFF,
  0x1F, 0xFE, 0x78, 0x7B, 0xE1, 0xEF, 0x87, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1,
  0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xE1, 0xE7, 0x87, 0x9F, 0xFE, 0x3F,
  0xF0, 0xFF, 0x80, 0xFF, 0x00, 0x3F, 0x00, 0x78, 0x00, 0xC0, 0xFF, 0x87,
  0xFF, 0x3F, 0xFD, 0xF3, 0xEF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF, 0x1E, 0xF9,
  0xF7, 0xFF, 0xBF, 0xF9, 0xFF, 0x8F, 0xBE, 0x7D, 0xF3, 0xE7, 0x9F, 0x3E,
  0xF8, 0xF7, 0xC7, 0xFE, 0x3E, 0x0F, 0x83, 0xFE, 0x7F, 0xE7, 0xDF, 0xF8,
  0xFF, 0x8F, 0xF8, 0x07, 0xE0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x3F, 0x00,
  0xFF, 0x0F, 0xF0, 0xFF, 0x9F, 0x7F, 0xF3, 0xFE, 0x0F, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF,
  0x8F, 0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1,
  0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xEF, 0xBE, 0x7F, 0xF1, 0xFF, 0x07, 0xE0,
  0xF8, 0x3E, 0xF0, 0x7D, 0xE0, 0xF3, 0xE3, 0xE7, 0xC7, 0xC7, 0x8F, 0x8F,
  0x1E, 0x1E, 0x3C, 0x3E, 0x78, 0x3D, 0xF0, 0x7B, 0xC0, 0xF7, 0x81, 0xEF,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00,
  0xF8, 0xF1, 0xEF, 0x1E, 0x7D, 0xE7, 0xCF, 0x3C, 0xF9, 0xE7, 0x9F, 0x3C,
  0xFB, 0xE7, 0x9F, 0x7E, 0xF1, 0xFF, 0xDE, 0x3F, 0xFF, 0x87, 0xFF, 0xF0,
  0xFF, 0xFE, 0x1F, 0xDF, 0xC3, 0xFB, 0xF8, 0x3F, 0x7F, 0x07, 0xEF, 0xE0,
  0xFC, 0xF8, 0x1F, 0x9F, 0x03, 0xE3, 0xE0, 0x7C, 0x7C, 0x00, 0x78, 0x7D,
  0xF1, 0xF7, 0xC7, 0x8F, 0x3E, 0x3E, 0xF0, 0x7B, 0xC1, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x00, 0xFE, 0x07, 0xF8, 0x1F, 0xF0, 0x7B, 0xC3, 0xEF,
  0x0F, 0x3E, 0x7C, 0x79, 0xF1, 0xFF, 0x87, 0xC0, 0xF8, 0x7D, 0xE1, 0xF7,
  0xC7, 0x8F, 0x1E, 0x3C, 0xF0, 0xF3, 0xC1, 0xEF, 0x07, 0xF8, 0x0F, 0xE0,
  0x3F, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x78, 0x0F, 0x80, 0xF0, 0x1F, 0x01, 0xE0,
  0x3E, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF,
  0x7B, 0xDF, 0xFF, 0xC0, 0xF0, 0x1F, 0x01, 0xE0, 0x3C, 0x07, 0xC0, 0x78,
  0x0F, 0x01, 0xF0, 0x3E, 0x03, 0xC0, 0x78, 0x0F, 0x80, 0xF0, 0x1E, 0x03,
  0xE0, 0x3C, 0x07, 0x80, 0xF8, 0x0F, 0x01, 0xE0, 0x3E, 0xFF, 0xFF, 0xCF,
  0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF,
  0x3C, 0xF3, 0xFF, 0xFF, 0xF0, 0x1C, 0x1E, 0x0F, 0x8F, 0xC7, 0x63, 0xBB,
  0x9D, 0xCE, 0xE3, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0xF0, 0xF0, 0xE0,
  0x1F, 0x0F, 0xF3, 0xFF, 0x79, 0xE0, 0x3C, 0x7F, 0x9F, 0xF7, 0xDE, 0xF3,
  0xDE, 0x7B, 0xCF, 0x7F, 0xEF, 0xFC, 0x77, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3D, 0xE7, 0xFE, 0xFF, 0xFF, 0x7F, 0xC7, 0xF8,
  0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xFB, 0xFF, 0xFF, 0xFF, 0x7B, 0xC0,
  0x1F, 0x1F, 0xEF, 0xFF, 0xCF, 0xF3, 0xFC, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0xFF, 0x3F, 0xFF, 0x7F, 0x87, 0xC0, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xCF, 0x7B, 0xFF, 0xFF, 0xFF, 0x7F, 0xC7, 0xF8, 0xFF, 0x1F,
  0xE3, 0xFC, 0x7F, 0x8F, 0xF3, 0xFF, 0xFD, 0xFF, 0x9E, 0xF0, 0x1F, 0x0F,
  0xF9, 0xFF, 0x7D, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1E, 0x03,
  0xE7, 0x3F, 0xE7, 0xFC, 0x3F, 0x00, 0x0F, 0x1F, 0x3F, 0x3E, 0x3C, 0x3C,
  0xFF, 0xFF, 0xFF, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3D, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F,
  0x8F, 0xF1, 0xFE, 0x3F, 0xEF, 0xFF, 0xF7, 0xFE, 0x7B, 0xC0, 0x79, 0x1F,
  0x7F, 0xCF, 0xF8, 0xFC, 0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3D, 0xE7, 0xFE, 0xFF, 0xDF, 0x7F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3,
  0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xF0, 0x77, 0xFE, 0xE0,
  0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBC, 0x1C, 0x7C, 0xF8,
  0xE0, 0x07, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E,
  0x7C, 0xF9, 0xF3, 0xDF, 0xBF, 0x78, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF3, 0xEF, 0x3E, 0xF7, 0xCF, 0x78, 0xFF, 0x8F, 0xF0,
  0xFF, 0x0F, 0xF8, 0xFF, 0x8F, 0xFC, 0xF3, 0xCF, 0x3E, 0xF1, 0xEF, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0x9E,
  0x7F, 0xFF, 0xBF, 0xFF, 0xFF, 0x7D, 0xFF, 0x3E, 0x7F, 0x9F, 0x3F, 0xCF,
  0x9F, 0xE7, 0xCF, 0xF3, 0xE7, 0xF9, 0xF3, 0xFC, 0xF9, 0xFE, 0x7C, 0xFF,
  0x3E, 0x7F, 0x9F, 0x3C, 0xF7, 0x9F, 0xFB, 0xFF, 0x7D, 0xFF, 0x1F, 0xE3,
  0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xC0,
  0x1F, 0x0F, 0xF1, 0xFF, 0x7D, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1,
  0xFE, 0x3F, 0xEF, 0xBF, 0xE7, 0xF8, 0x3E, 0x00, 0xF7, 0x9F, 0xFB, 0xFF,
  0xFD, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xEF, 0xFF,
  0xFF, 0xFD, 0xEF, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x00, 0x3D,
  0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE,
  0x3F, 0xEF, 0xFF, 0xF7, 0xFE, 0x7B, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF7, 0xFF, 0xFE, 0xFE, 0xF8, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0x3F, 0x1F, 0xEF, 0xFF, 0xCF, 0xF0, 0x3E, 0x07,
  0xF0, 0xFE, 0x0F, 0xF8, 0xFF, 0x3F, 0xFF, 0x7F, 0x8F, 0xC0, 0x3C, 0x3C,
  0x3C, 0xFF, 0xFF, 0xFF, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3F, 0x3F, 0x1F, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC,
  0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xEF, 0xFF, 0xF7, 0xFE, 0x7B, 0xC0, 0xF9,
  0xF7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE3, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F,
  0xC1, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x80, 0xF0, 0xF1, 0xCF, 0x7B, 0xCF,
  0x7B, 0xCE, 0x7B, 0xDE, 0x7B, 0xDE, 0x7B, 0xFE, 0x3F, 0xFE, 0x3F, 0xFC,
  0x3F, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x1E, 0x7C, 0x1E, 0x7C, 0x1E, 0x38,
  0x79, 0xE7, 0x9E, 0x7F, 0xE3, 0xFC, 0x3F, 0xC1, 0xF8, 0x1F, 0x81, 0xF8,
  0x1F, 0x83, 0xFC, 0x3F, 0xC7, 0x9E, 0x79, 0xEF, 0x9F, 0xF9, 0xF7, 0x9E,
  0x79, 0xE7, 0x9E, 0x7B, 0xE3, 0xFC, 0x3F, 0xC3, 0xFC, 0x1F, 0x81, 0xF8,
  0x1F, 0x81, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xE0, 0x3E, 0x03, 0xC0,
  0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x1E, 0x0F, 0x83, 0xC1, 0xE0, 0xF8,
  0x3C, 0x1F, 0x07, 0x83, 0xFF, 0xFF, 0xFF, 0xF0, 0x08, 0x73, 0xDE, 0x79,
  0xE7, 0x9E, 0x79, 0xE7, 0x3C, 0xE3, 0xC7, 0x1E, 0x79, 0xE7, 0x9E, 0x79,
  0xE3, 0xC7, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xC3, 0x8F, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xE7, 0x8F, 0x1C, 0xF7, 0x9E,
  0x71, 0xC7, 0x1C, 0x71, 0xCF, 0x38, 0xC0, 0x38, 0x77, 0xE7, 0x7E, 0xFF,
  0x7E, 0xE3, 0xEE, 0x1C,
};

const GFXglyph RobotoCondensed_Black26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 5, 19, 7, 1, -19 },
  { 13, 8, 7, 8, 0, -20 },
  { 20, 11, 19, 13, 1, -19 },
  { 47, 11, 25, 13, 1, -22 },
  { 82, 15, 19, 17, 1, -19 },
  { 118, 14, 19, 16, 1, -19 },
  { 152, 3, 7, 4, 1, -20 },
  { 155, 7, 26, 8, 1, -20 },
  { 178, 6, 26, 8, 1, -20 },
  { 198, 12, 11, 12, 0, -19 },
  { 215, 10, 14, 12, 1, -16 },
  { 233, 4, 8, 7, 1, -3 },
  { 237, 7, 3, 11, 2, -9 },
  { 240, 5, 4, 8, 1, -4 },
  { 243, 8, 21, 8, 0, -19 },
  { 264, 11, 19, 13, 1, -19 },
  { 291, 8, 19, 13, 2, -19 },
  { 310, 11, 19, 13, 1, -19 },
  { 337, 11, 19, 13, 1, -19 },
  { 364, 11, 19, 13, 1, -19 },
  { 391, 11, 19, 13, 1, -19 },
  { 418, 12, 19, 13, 1, -19 },
  { 447, 11, 19, 13, 1, -19 },
  { 474, 11, 19, 13, 1, -19 },
  { 501, 11, 19, 13, 1, -19 },
  { 528, 4, 14, 8, 2, -14 },
  { 535, 5, 19, 7, 1, -14 },
  { 547, 9, 12, 12, 1, -14 },
  { 561, 10, 8, 13, 2, -12 },
  { 571, 10, 13, 12, 1, -14 },
  { 588, 11, 19, 12, 0, -19 },
  { 615, 18, 24, 20, 1, -18 },
  { 669, 16, 19, 16, 0, -19 },
  { 707, 13, 19, 15, 1, -19 },
  { 738, 13, 19, 15, 1, -19 },
  { 769, 13, 19, 15, 1, -19 },
  { 800, 11, 19, 13, 1, -19 },
  { 827, 11, 19, 12, 1, -19 },
  { 854, 13, 19, 15, 1, -19 },
  { 885, 14, 19, 16, 1, -19 },
  { 919, 5, 19, 7, 1, -19 },
  { 931, 11, 19, 13, 1, -19 },
  { 958, 14, 19, 15, 1, -19 },
  { 992, 11, 19, 12, 1, -19 },
  { 1019, 17, 19, 20, 1, -19 },
  { 1060, 14, 19, 16, 1, -19 },
  { 1094, 14, 19, 16, 1, -19 },
  { 1128, 13, 19, 15, 1, -19 },
  { 1159, 14, 22, 16, 1, -19 },
  { 1198, 13, 19, 15, 1, -19 },
  { 1229, 12, 19, 14, 1, -19 },
  { 1258, 13, 19, 14, 1, -19 },
  { 1289, 13, 19, 15, 1, -19 },
  { 1320, 15, 19, 15, 0, -19 },
  { 1356, 19, 19, 19, 0, -19 },
  { 1402, 14, 19, 15, 0, -19 },
  { 1436, 14, 19, 14, 0, -19 },
  { 1470, 12, 19, 14, 1, -19 },
  { 1499, 5, 26, 7, 1, -22 },
  { 1516, 11, 21, 10, 0, -19 },
  { 1545, 6, 26, 7, 0, -22 },
  { 1565, 9, 9, 10, 1, -19 },
  { 1576, 10, 3, 10, 0, 0 },
  { 1580, 7, 4, 9, 1, -20 },
  { 1584, 11, 14, 12, 1, -14 },
  { 1604, 11, 20, 13, 1, -20 },
  { 1632, 10, 14, 12, 1, -14 },
  { 1650, 11, 20, 13, 1, -20 },
  { 1678, 11, 14, 13, 1, -14 },
  { 1698, 8, 20, 9, 0, -20 },
  { 1718, 11, 19, 13, 1, -14 },
  { 1745, 11, 20, 13, 1, -20 },
  { 1773, 5, 19, 7, 1, -19 },
  { 1785, 7, 24, 7, -1, -19 },
  { 1806, 12, 20, 13, 1, -20 },
  { 1836, 4, 20, 7, 1, -20 },
  { 1846, 17, 14, 19, 1, -14 },
  { 1876, 11, 14, 13, 1, -14 },
  { 1896, 11, 14, 13, 1, -14 },
  { 1916, 11, 19, 13, 1, -14 },
  { 1943, 11, 19, 13, 1, -14 },
  { 1970, 8, 14, 9, 1, -14 },
  { 1984, 10, 14, 12, 1, -14 },
  { 2002, 8, 17, 8, 0, -17 },
  { 2019, 11, 14, 13, 1, -14 },
  { 2039, 12, 14, 12, 0, -14 },
  { 2060, 16, 14, 16, 0, -14 },
  { 2088, 12, 14, 12, 0, -14 },
  { 2109, 12, 19, 12, 0, -14 },
  { 2138, 10, 14, 12, 1, -14 },
  { 2156, 6, 25, 8, 1, -20 },
  { 2175, 3, 22, 7, 2, -19 },
  { 2184, 6, 25, 8, 1, -20 },
  { 2203, 12, 6, 14, 1, -11 },
};

const GFXfont RobotoCondensed_Black26pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Black26pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Black26pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _ROBOTOCONDENSED_BLACK26PT7B_H_
