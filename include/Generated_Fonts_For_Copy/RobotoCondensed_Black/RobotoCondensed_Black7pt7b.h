#ifndef _ROBOTOCONDENSED_BLACK7PT7B_H_
#define _ROBOTOCONDENSED_BLACK7PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Black.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Black7pt7bBitmaps[] PROGMEM = {
  0x00, 0xF8, 0xC0, 0xF0, 0x7D, 0xFC, 0x0F, 0xBA, 0xC0, 0xCE, 0x27, 0x70,
  0x66, 0x4B, 0xF0, 0xC0, 0x6A, 0x90, 0x95, 0x60, 0x5E, 0x80, 0x5D, 0x20,
  0x40, 0x80, 0xC0, 0x56, 0x80, 0x76, 0xD6, 0xFF, 0xC0, 0x74, 0xAE, 0xE5,
  0x9E, 0x2D, 0xF2, 0x73, 0x96, 0x7B, 0xD6, 0xE4, 0xA4, 0x7D, 0xD6, 0x77,
  0x94, 0xC3, 0xC1, 0x80, 0x3B, 0x80, 0xFC, 0x8F, 0xC0, 0xE5, 0x04, 0x32,
  0x6F, 0xBB, 0xA0, 0x80, 0x66, 0x6F, 0x90, 0xEF, 0xED, 0xE0, 0x69, 0x89,
  0x60, 0xEF, 0xFF, 0xE0, 0xFB, 0xEE, 0xFB, 0xEC, 0x6D, 0xBD, 0x70, 0xDD,
  0xFD, 0xD0, 0xFF, 0xC0, 0x24, 0xDE, 0xFE, 0xEE, 0xF0, 0xDB, 0x6E, 0xDE,
  0xEF, 0x5E, 0x80, 0xDD, 0xDF, 0xD0, 0x6D, 0x9D, 0x60, 0xED, 0xFC, 0xC0,
  0x6D, 0x9D, 0x61, 0xEF, 0xEE, 0xF0, 0x6F, 0x6B, 0x60, 0xF6, 0x66, 0x60,
  0xDD, 0xDD, 0x60, 0x9F, 0x66, 0x60, 0xAD, 0x5E, 0xA5, 0x00, 0xF6, 0x66,
  0xF0, 0xB6, 0x66, 0x60, 0xF2, 0x64, 0xF0, 0xEA, 0xAC, 0x99, 0x26, 0xFF,
  0xFC, 0x5A, 0x80, 0xE0, 0x40, 0x66, 0xF0, 0x9E, 0xDE, 0x76, 0x70, 0x2E,
  0xDE, 0x77, 0xB0, 0x7F, 0xC0, 0x76, 0xF6, 0x9E, 0xDA, 0xAA, 0x80, 0xBF,
  0xE0, 0x97, 0xFA, 0xF8, 0xBD, 0x6B, 0x50, 0xB6, 0xD0, 0x76, 0xF0, 0xF6,
  0xF8, 0x76, 0xF2, 0xEA, 0x71, 0xF0, 0xFF, 0x40, 0xB6, 0xF0, 0xB5, 0xA0,
  0xBB, 0x75, 0xAD, 0xD0, 0xB5, 0xA4, 0x00, 0xED, 0x70, 0x5A, 0x50, 0x78,
  0xA5, 0xA0, 0x54,
};

const GFXglyph RobotoCondensed_Black7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 5, 2, 0, -5 },
  { 3, 2, 2, 2, 0, -5 },
  { 4, 3, 5, 4, 0, -5 },
  { 6, 3, 7, 4, 0, -6 },
  { 9, 4, 5, 5, 0, -5 },
  { 12, 4, 5, 4, 0, -5 },
  { 15, 1, 2, 1, 0, -5 },
  { 16, 2, 7, 2, 0, -5 },
  { 18, 2, 7, 2, 0, -5 },
  { 20, 3, 3, 3, 0, -5 },
  { 22, 3, 4, 3, 0, -4 },
  { 24, 1, 2, 2, 0, -1 },
  { 25, 1, 1, 3, 1, -3 },
  { 26, 2, 1, 2, 0, -1 },
  { 27, 2, 5, 2, 0, -5 },
  { 29, 3, 5, 4, 0, -5 },
  { 31, 2, 5, 4, 1, -5 },
  { 33, 3, 5, 4, 0, -5 },
  { 35, 3, 5, 4, 0, -5 },
  { 37, 3, 5, 4, 0, -5 },
  { 39, 3, 5, 4, 0, -5 },
  { 41, 3, 5, 4, 0, -5 },
  { 43, 3, 5, 4, 0, -5 },
  { 45, 3, 5, 4, 0, -5 },
  { 47, 3, 5, 4, 0, -5 },
  { 49, 2, 4, 2, 0, -4 },
  { 50, 2, 5, 2, 0, -4 },
  { 52, 3, 4, 3, 0, -4 },
  { 54, 3, 2, 4, 0, -3 },
  { 55, 3, 4, 3, 0, -4 },
  { 57, 3, 5, 3, 0, -5 },
  { 59, 5, 7, 5, 0, -5 },
  { 64, 4, 5, 4, 0, -5 },
  { 67, 4, 5, 4, 0, -5 },
  { 70, 4, 5, 4, 0, -5 },
  { 73, 4, 5, 4, 0, -5 },
  { 76, 3, 5, 3, 0, -5 },
  { 78, 3, 5, 3, 0, -5 },
  { 80, 4, 5, 4, 0, -5 },
  { 83, 4, 5, 4, 0, -5 },
  { 86, 2, 5, 2, 0, -5 },
  { 88, 3, 5, 3, 0, -5 },
  { 90, 4, 5, 4, 0, -5 },
  { 93, 3, 5, 3, 0, -5 },
  { 95, 5, 5, 5, 0, -5 },
  { 99, 4, 5, 4, 0, -5 },
  { 102, 4, 5, 4, 0, -5 },
  { 105, 4, 5, 4, 0, -5 },
  { 108, 4, 6, 4, 0, -5 },
  { 111, 4, 5, 4, 0, -5 },
  { 114, 4, 5, 4, 0, -5 },
  { 117, 4, 5, 4, 0, -5 },
  { 120, 4, 5, 4, 0, -5 },
  { 123, 4, 5, 4, 0, -5 },
  { 126, 5, 5, 5, 0, -5 },
  { 130, 4, 5, 4, 0, -5 },
  { 133, 4, 5, 4, 0, -5 },
  { 136, 4, 5, 4, 0, -5 },
  { 139, 2, 7, 2, 0, -6 },
  { 141, 3, 5, 3, 0, -5 },
  { 143, 2, 7, 2, 0, -6 },
  { 145, 3, 3, 3, 0, -5 },
  { 147, 3, 1, 3, 0, 0 },
  { 148, 2, 1, 2, 0, -5 },
  { 149, 3, 4, 3, 0, -4 },
  { 151, 3, 5, 3, 0, -5 },
  { 153, 3, 4, 3, 0, -4 },
  { 155, 3, 5, 3, 0, -5 },
  { 157, 3, 4, 3, 0, -4 },
  { 159, 2, 5, 2, 0, -5 },
  { 161, 3, 5, 4, 0, -4 },
  { 163, 3, 5, 3, 0, -5 },
  { 165, 2, 5, 2, 0, -5 },
  { 167, 2, 7, 2, 0, -5 },
  { 169, 3, 5, 3, 0, -5 },
  { 171, 1, 5, 2, 0, -5 },
  { 172, 5, 4, 5, 0, -4 },
  { 175, 3, 4, 3, 0, -4 },
  { 177, 3, 4, 3, 0, -4 },
  { 179, 3, 5, 3, 0, -4 },
  { 181, 3, 5, 3, 0, -4 },
  { 183, 2, 4, 2, 0, -4 },
  { 184, 3, 4, 3, 0, -4 },
  { 186, 2, 5, 2, 0, -5 },
  { 188, 3, 4, 3, 0, -4 },
  { 190, 3, 4, 3, 0, -4 },
  { 192, 4, 4, 4, 0, -4 },
  { 194, 3, 4, 3, 0, -4 },
  { 196, 3, 6, 3, 0, -4 },
  { 199, 3, 4, 3, 0, -4 },
  { 201, 2, 6, 2, 0, -5 },
  { 203, 1, 6, 2, 0, -5 },
  { 204, 2, 6, 2, 0, -5 },
  { 206, 3, 2, 4, 0, -3 },
};

const GFXfont RobotoCondensed_Black7pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Black7pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Black7pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _ROBOTOCONDENSED_BLACK7PT7B_H_
