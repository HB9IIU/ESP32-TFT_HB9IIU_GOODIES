#ifndef _ROBOTOCONDENSED_BLACK42PT7B_H_
#define _ROBOTOCONDENSED_BLACK42PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Black.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Black42pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7,
  0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF0, 0x00, 0x00, 0x1E, 0x7F, 0xFF,
  0xFF, 0xF7, 0xE7, 0x80, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3,
  0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0xF0, 0xF0, 0x03, 0xCF, 0x00,
  0x79, 0xE0, 0x0F, 0x3C, 0x01, 0xE7, 0x80, 0x3C, 0xF0, 0x07, 0x9E, 0x00,
  0xE3, 0x80, 0x3C, 0xF0, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF,
  0xFF, 0xF0, 0x79, 0xE0, 0x0F, 0x3C, 0x03, 0xCF, 0x00, 0x79, 0xE0, 0x0F,
  0x3C, 0x01, 0xE7, 0x83, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF,
  0xFF, 0x87, 0x9E, 0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x03, 0xCF, 0x00, 0x79,
  0xE0, 0x0F, 0x3C, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF,
  0xE0, 0xFF, 0xFC, 0x7F, 0xFF, 0x9F, 0xCF, 0xE7, 0xF1, 0xF9, 0xF8, 0x7F,
  0x7E, 0x1F, 0xDF, 0xC7, 0xF7, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F,
  0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0xFC, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7E,
  0xFF, 0x3F, 0x9F, 0xFF, 0xE7, 0xFF, 0xF0, 0xFF, 0xFC, 0x0F, 0xFC, 0x00,
  0xFC, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1F,
  0x00, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0x04, 0x0F, 0x9E,
  0x1E, 0x1E, 0x3C, 0x3C, 0x3C, 0x78, 0xF0, 0x78, 0xF1, 0xE0, 0xF1, 0xE7,
  0x81, 0xF3, 0xCF, 0x03, 0xFF, 0xBC, 0x03, 0xFE, 0xF0, 0x03, 0xFD, 0xE0,
  0x03, 0xE7, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x79, 0xF0,
  0x01, 0xEF, 0xF0, 0x03, 0xDF, 0xF0, 0x0F, 0x7F, 0xF0, 0x1E, 0xF3, 0xE0,
  0x79, 0xE3, 0xC0, 0xF3, 0xC7, 0x83, 0xC7, 0x8F, 0x0F, 0x0F, 0x1E, 0x1E,
  0x1E, 0x3C, 0x18, 0x3F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x00,
  0x3E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xF7, 0xF0, 0x0F, 0xC7, 0xE0, 0x1F, 0x8F,
  0xC0, 0x3F, 0x1F, 0x80, 0x3F, 0x3E, 0x00, 0x7E, 0xFC, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xFC, 0x7C,
  0x3F, 0xF8, 0xF8, 0xFF, 0xF9, 0xF1, 0xFF, 0xFF, 0xE7, 0xF7, 0xFF, 0xCF,
  0xE7, 0xFF, 0x9F, 0xC7, 0xFF, 0x3F, 0x8F, 0xFC, 0x7F, 0x0F, 0xF8, 0x7F,
  0xBF, 0xE0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC1, 0xFF,
  0xDF, 0xC0, 0xFE, 0x3F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xBD,
  0xE0, 0x00, 0x80, 0x38, 0x0F, 0x03, 0xE0, 0x7C, 0x1F, 0x07, 0xC0, 0xF8,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0x7C, 0x0F, 0x80, 0xF8, 0x0F, 0x81, 0xF0, 0x1E, 0x01, 0xC0, 0x10, 0x40,
  0x0E, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x1F, 0x01,
  0xF0, 0x3E, 0x07, 0xC0, 0xFC, 0x1F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xF8, 0x1F,
  0x03, 0xE0, 0xFC, 0x1F, 0x83, 0xE0, 0x7C, 0x0F, 0x83, 0xE0, 0x7C, 0x1F,
  0x03, 0xE0, 0xF8, 0x3F, 0x07, 0xC0, 0x70, 0x08, 0x00, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x3C, 0x78, 0x6F, 0xDE,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0x80, 0x3F, 0x00, 0x1F, 0xE0,
  0x0F, 0xFC, 0x07, 0xCF, 0x03, 0xE3, 0xE0, 0xF8, 0x7C, 0x1C, 0x0E, 0x00,
  0x02, 0x00, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3E, 0x3E, 0x7E, 0x7C, 0xFC,
  0xF8, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3C, 0x7E, 0x7F,
  0xFF, 0x7F, 0x7E, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x00, 0x03, 0xF0,
  0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x7F, 0xFF, 0x1F, 0xDF, 0xE7,
  0xE3, 0xFB, 0xF8, 0x7E, 0xFE, 0x1F, 0xBF, 0x87, 0xFF, 0xE1, 0xFF, 0xF0,
  0x7F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F,
  0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xEF,
  0xE1, 0xF9, 0xF8, 0xFE, 0x7F, 0x7F, 0x9F, 0xFF, 0xC3, 0xFF, 0xF0, 0x7F,
  0xF8, 0x0F, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x10, 0x0F, 0x07, 0xF1, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xF8, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF,
  0xC3, 0xFF, 0xF8, 0xFF, 0x7F, 0x9F, 0xC7, 0xF7, 0xF0, 0xFE, 0xFE, 0x1F,
  0xDF, 0xC3, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x0F, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFE,
  0xFF, 0xFF, 0xC0, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF,
  0xC7, 0xFF, 0xFC, 0xFF, 0x7F, 0x9F, 0xC7, 0xF7, 0xF0, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x3F, 0xF8, 0x07, 0xFE,
  0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xF0, 0x00, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0xFF,
  0x7F, 0xBF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0xE0,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x7F,
  0xC0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x03, 0xFF,
  0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x07, 0xDF, 0xC0, 0xFB, 0xF8, 0x3F, 0x7F,
  0x07, 0xCF, 0xE1, 0xF9, 0xFC, 0x3E, 0x3F, 0x8F, 0xC7, 0xF1, 0xF8, 0xFE,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x3F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFF, 0xFF, 0x1F, 0xFF,
  0xE3, 0xFF, 0xFC, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x0F, 0xE0, 0x01, 0xFD, 0xF0, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xFF,
  0x1F, 0xFF, 0xF0, 0xF0, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFF, 0xFC, 0x1F, 0x9F, 0x83, 0xF3, 0xF8, 0xFE,
  0x7F, 0xBF, 0xC7, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0xE0,
  0x07, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x3F, 0xF0,
  0x1F, 0xFC, 0x07, 0xFE, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x1F,
  0x80, 0x0F, 0xE7, 0xC3, 0xFF, 0xF8, 0xFF, 0xFF, 0x3F, 0xFF, 0xEF, 0xFF,
  0xFB, 0xFD, 0xFF, 0xFE, 0x1F, 0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F,
  0xFC, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFD, 0xF8, 0x7F, 0x7F, 0x7F, 0x9F,
  0xFF, 0xE3, 0xFF, 0xF0, 0x7F, 0xF8, 0x0F, 0xFC, 0x00, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x07, 0xFF, 0x03, 0xFF, 0xE1, 0xFF, 0xFC, 0x7F, 0xFF, 0x1F, 0xDF,
  0xEF, 0xE3, 0xFB, 0xF8, 0xFE, 0xFE, 0x3F, 0xBF, 0x8F, 0xE7, 0xE3, 0xF9,
  0xFD, 0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xF8, 0x7F,
  0xFF, 0x1F, 0xCF, 0xEF, 0xE1, 0xFB, 0xF8, 0x7E, 0xFE, 0x1F, 0xFF, 0x87,
  0xFF, 0xE1, 0xFF, 0xF8, 0xFE, 0xFF, 0x7F, 0x9F, 0xFF, 0xE7, 0xFF, 0xF0,
  0xFF, 0xF8, 0x1F, 0xFC, 0x01, 0xFC, 0x00, 0x03, 0xE0, 0x03, 0xFE, 0x01,
  0xFF, 0xC0, 0xFF, 0xF8, 0x7F, 0xFF, 0x1F, 0xDF, 0xCF, 0xE3, 0xFB, 0xF8,
  0x7E, 0xFE, 0x1F, 0xBF, 0x87, 0xEF, 0xC1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F,
  0xFF, 0x87, 0xFF, 0xF3, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xCF, 0xFF, 0xE1,
  0xFF, 0xF8, 0x3E, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x03,
  0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xC0,
  0x03, 0xC0, 0x00, 0x3C, 0x7E, 0x7F, 0xFF, 0x7F, 0x7F, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x7E, 0x7F, 0x7F, 0x7F,
  0x7F, 0x3C, 0x1E, 0x1F, 0x9F, 0xEF, 0xF7, 0xF9, 0xF8, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x3F, 0x1F, 0x8F, 0x8F, 0xC7, 0xC3, 0xC0,
  0x60, 0x00, 0x02, 0x00, 0x1C, 0x00, 0xF8, 0x07, 0xF0, 0x3F, 0xE1, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xE1, 0xFF, 0x03, 0xF8, 0x07, 0xFC, 0x0F,
  0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0x03, 0xFE, 0x01, 0xFC, 0x00,
  0xF8, 0x00, 0x70, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xE0,
  0x00, 0xF8, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F,
  0xFE, 0x07, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0x01, 0xFF, 0x07, 0xFF, 0x3F,
  0xFE, 0xFF, 0xF8, 0xFF, 0xE0, 0xFF, 0x80, 0xFE, 0x00, 0xF8, 0x00, 0xE0,
  0x00, 0x80, 0x00, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xE7,
  0xFF, 0xF7, 0xFB, 0xFB, 0xF8, 0xFF, 0xFC, 0x7F, 0xFE, 0x3F, 0x80, 0x1F,
  0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07,
  0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x03, 0xFC,
  0x00, 0xFE, 0x00, 0x7E, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xF0,
  0x0F, 0xC0, 0x1F, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x1E, 0x07, 0xC0, 0x00,
  0x7C, 0x1F, 0x00, 0x00, 0xF0, 0xF8, 0x0F, 0x83, 0xE3, 0xE0, 0xFF, 0x87,
  0x8F, 0x07, 0xFF, 0x1E, 0x7C, 0x3F, 0xFC, 0x79, 0xF0, 0xF9, 0xF1, 0xE7,
  0x87, 0xC7, 0xC3, 0xDE, 0x1F, 0x1F, 0x0F, 0x78, 0x78, 0x7C, 0x3F, 0xE3,
  0xE1, 0xF0, 0xFF, 0x8F, 0x87, 0x83, 0xFE, 0x3E, 0x1E, 0x0E, 0xF8, 0xF8,
  0x78, 0x7B, 0xE3, 0xE1, 0xE1, 0xEF, 0x8F, 0x87, 0x87, 0xBE, 0x3E, 0x3E,
  0x1E, 0x78, 0xFC, 0xF8, 0xF1, 0xE3, 0xFF, 0xFF, 0xC7, 0x87, 0xFF, 0xFE,
  0x1F, 0x0F, 0xEF, 0xF0, 0x7C, 0x1E, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x60, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x01, 0xFF,
  0xF0, 0x00, 0xFD, 0xF8, 0x00, 0x7E, 0xFE, 0x00, 0x3F, 0x3F, 0x00, 0x3F,
  0x9F, 0x80, 0x1F, 0x8F, 0xC0, 0x0F, 0xC7, 0xF0, 0x0F, 0xE3, 0xF8, 0x07,
  0xF0, 0xFC, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x3F, 0x80, 0xFF,
  0x1F, 0xC0, 0x3F, 0x9F, 0xE0, 0x1F, 0xCF, 0xE0, 0x0F, 0xE7, 0xF0, 0x07,
  0xFF, 0xF8, 0x01, 0xFC, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F,
  0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xEF, 0xE0, 0xFE, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xE0,
  0xFE, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xF8,
  0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0xFF, 0xF9, 0xFC,
  0x1F, 0xDF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x07, 0xFF,
  0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xEF, 0xE0, 0xFE, 0x7F, 0xFF,
  0xF1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0xFF, 0xF0, 0x00,
  0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFE, 0x1F, 0xEF, 0xE0, 0xFE, 0xFE, 0x0F,
  0xEF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xEF,
  0xE1, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0,
  0xFF, 0xFE, 0x0F, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0xFF, 0x3F, 0xFF,
  0xCF, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF,
  0xFF, 0x7F, 0xFF, 0xBF, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xFC, 0x07, 0xFF,
  0xF0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xFC, 0x1F, 0xFF,
  0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE,
  0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F,
  0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xEF, 0xE0, 0x7F, 0x7F, 0xFF, 0xF9, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0xFF, 0x00,
  0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE,
  0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01,
  0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xFF, 0x87, 0xFF, 0xE3, 0xFF, 0xF8, 0xFE, 0xFF, 0xFF, 0x9F, 0xFF,
  0xC7, 0xFF, 0xF0, 0xFF, 0xF8, 0x1F, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x07,
  0xFF, 0xF8, 0x3F, 0xEF, 0xE0, 0xFF, 0x3F, 0x83, 0xFC, 0xFE, 0x1F, 0xE3,
  0xF8, 0x7F, 0x0F, 0xE3, 0xFC, 0x3F, 0x8F, 0xE0, 0xFE, 0x7F, 0x83, 0xF9,
  0xFC, 0x0F, 0xEF, 0xE0, 0x3F, 0xBF, 0x80, 0xFF, 0xFC, 0x03, 0xFF, 0xF0,
  0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0xFF, 0x3F, 0x83, 0xFC, 0xFF, 0x0F, 0xE3,
  0xFC, 0x3F, 0x87, 0xF8, 0xFE, 0x1F, 0xE3, 0xF8, 0x3F, 0xCF, 0xE0, 0xFF,
  0x3F, 0x83, 0xFE, 0xFE, 0x07, 0xFB, 0xF8, 0x1F, 0xE0, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xDF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xF1, 0xF7, 0xFF, 0xEF, 0x9F, 0x7F, 0xFE, 0xF9, 0xF7,
  0xFF, 0xEF, 0x9F, 0x7F, 0xFE, 0xFB, 0xE7, 0xFF, 0xE7, 0xFE, 0x7F, 0xFE,
  0x7F, 0xE7, 0xFF, 0xE7, 0xFE, 0x7F, 0xFE, 0x3F, 0xC7, 0xFF, 0xE3, 0xFC,
  0x7F, 0xFE, 0x3F, 0xC7, 0xFF, 0xE3, 0xF8, 0x7F, 0xFE, 0x1F, 0x87, 0xFF,
  0xE1, 0xF8, 0x7F, 0xFE, 0x1F, 0x87, 0xFF, 0xE1, 0xF0, 0x7F, 0xFE, 0x01,
  0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x81, 0xFF,
  0xFE, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF,
  0x87, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x7F, 0xFE, 0xF1, 0xFF, 0xFB, 0xC7,
  0xFF, 0xEF, 0x9F, 0xFF, 0x9E, 0x7F, 0xFE, 0x7D, 0xFF, 0xF8, 0xF7, 0xFF,
  0xE3, 0xDF, 0xFF, 0x8F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F,
  0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xF0, 0x01, 0xFC, 0x00,
  0x1F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFF,
  0xFF, 0xC7, 0xF0, 0x7F, 0xBF, 0xC0, 0xFE, 0xFE, 0x03, 0xFB, 0xF8, 0x0F,
  0xEF, 0xE0, 0x3F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFB, 0xF8, 0x0F, 0xEF, 0xF0, 0x3F,
  0x9F, 0xC1, 0xFE, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x07,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x0F, 0xFF, 0xC0, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF1, 0xFF, 0xFF, 0xC7, 0xF0, 0x7F, 0xBF, 0xC0, 0xFE, 0xFE, 0x03, 0xFB,
  0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xEF,
  0xF0, 0x3F, 0x9F, 0xC1, 0xFE, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFE, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x00, 0xFF,
  0x80, 0x00, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x04, 0x00,
  0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xF3, 0xF8, 0x3F, 0xDF, 0xC0, 0xFE, 0xFE, 0x07, 0xF7,
  0xF0, 0x3F, 0xBF, 0x81, 0xFD, 0xFC, 0x0F, 0xEF, 0xE0, 0xFF, 0x7F, 0xFF,
  0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xF8, 0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x3F,
  0xFF, 0xC1, 0xFC, 0xFF, 0x0F, 0xE3, 0xF8, 0x7F, 0x1F, 0xE3, 0xF8, 0xFF,
  0x1F, 0xC3, 0xF8, 0xFE, 0x1F, 0xE7, 0xF0, 0x7F, 0x3F, 0x83, 0xFD, 0xFC,
  0x1F, 0xEF, 0xE0, 0x7F, 0x7F, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0xFC,
  0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xC3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF9, 0xFE,
  0x1F, 0xCF, 0xE0, 0xFF, 0x7F, 0x03, 0xFB, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0xC0, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F,
  0xF8, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xEF,
  0xF0, 0x7F, 0x7F, 0x81, 0xFD, 0xFC, 0x1F, 0xEF, 0xE0, 0xFE, 0x7F, 0xDF,
  0xF1, 0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x7F, 0xF8, 0x00,
  0x7F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F,
  0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0x7F, 0x7F, 0xFF, 0xF7,
  0xFF, 0xFE, 0x3F, 0xFF, 0xE1, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0x3F, 0xC0,
  0xFF, 0x00, 0xFF, 0x7F, 0x00, 0xFF, 0x7F, 0x80, 0xFF, 0x7F, 0x80, 0xFE,
  0x7F, 0x80, 0xFE, 0x3F, 0x81, 0xFE, 0x3F, 0x81, 0xFE, 0x3F, 0xC1, 0xFC,
  0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC3, 0xF8, 0x1F, 0xC3, 0xF8,
  0x0F, 0xE3, 0xF8, 0x0F, 0xE3, 0xF8, 0x0F, 0xE3, 0xF0, 0x0F, 0xE7, 0xF0,
  0x07, 0xE7, 0xF0, 0x07, 0xF7, 0xF0, 0x07, 0xF7, 0xE0, 0x03, 0xF7, 0xE0,
  0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0,
  0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0xFE, 0x1F, 0xC3, 0xFF, 0xF0, 0xFE,
  0x1F, 0xFF, 0x87, 0xF0, 0xFF, 0xFC, 0x3F, 0x87, 0xFF, 0xE1, 0xFC, 0x3F,
  0xBF, 0x0F, 0xE1, 0xFD, 0xFC, 0xFF, 0x8F, 0xCF, 0xE7, 0xFC, 0xFE, 0x7F,
  0x3F, 0xE7, 0xF3, 0xF9, 0xFF, 0x3F, 0x9F, 0xCF, 0xF9, 0xFC, 0x7E, 0x7F,
  0xEF, 0xE3, 0xF7, 0xFF, 0x7E, 0x1F, 0xFF, 0xFB, 0xF0, 0xFF, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xFC, 0x3F, 0xFD, 0xFF, 0xE0, 0xFF, 0xEF, 0xFF, 0x07,
  0xFF, 0x7F, 0xF0, 0x3F, 0xFB, 0xFF, 0x81, 0xFF, 0xDF, 0xFC, 0x0F, 0xFE,
  0x7F, 0xE0, 0x7F, 0xE3, 0xFF, 0x01, 0xFF, 0x1F, 0xF8, 0x0F, 0xF8, 0xFF,
  0x80, 0x7F, 0xC7, 0xFC, 0x03, 0xFE, 0x1F, 0xE0, 0x1F, 0xE0, 0xFF, 0x00,
  0xFF, 0x07, 0xF8, 0x03, 0xF8, 0x3F, 0xC0, 0x7F, 0x81, 0xFE, 0xFF, 0x03,
  0xF8, 0xFE, 0x0F, 0xF1, 0xFE, 0x1F, 0xE3, 0xFC, 0x3F, 0x83, 0xF8, 0xFF,
  0x07, 0xF9, 0xFC, 0x07, 0xF3, 0xF8, 0x0F, 0xEF, 0xE0, 0x0F, 0xFF, 0xC0,
  0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x01, 0xFD, 0xFC, 0x03, 0xF9,
  0xFC, 0x0F, 0xF3, 0xF8, 0x1F, 0xC7, 0xF8, 0x7F, 0x87, 0xF0, 0xFF, 0x0F,
  0xF3, 0xFC, 0x1F, 0xE7, 0xF8, 0x1F, 0xEF, 0xF0, 0x3F, 0xC0, 0xFF, 0x01,
  0xFE, 0xFE, 0x03, 0xF9, 0xFC, 0x07, 0xF1, 0xFC, 0x1F, 0xE3, 0xF8, 0x3F,
  0x87, 0xF0, 0x7F, 0x07, 0xF0, 0xFC, 0x0F, 0xE3, 0xF8, 0x0F, 0xC7, 0xF0,
  0x1F, 0xCF, 0xC0, 0x3F, 0xBF, 0x80, 0x3F, 0x7E, 0x00, 0x7E, 0xFC, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0xFE,
  0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE,
  0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE,
  0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F,
  0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F,
  0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x7F, 0x01, 0xFF,
  0x03, 0xFE, 0x07, 0xBC, 0x1F, 0x7C, 0x3E, 0xF8, 0x78, 0xF1, 0xF1, 0xF3,
  0xE3, 0xE7, 0xC7, 0xDF, 0x07, 0xFE, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x03, 0xF0, 0x1F, 0x81, 0xFC,
  0x0F, 0xE0, 0x7E, 0x03, 0xF0, 0x03, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xFC,
  0x7F, 0xFF, 0x9F, 0x8F, 0xEF, 0xE3, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x81,
  0xFF, 0xE1, 0xFF, 0xF8, 0xFF, 0xFE, 0x7F, 0xFF, 0xBF, 0x8F, 0xEF, 0xE3,
  0xFB, 0xF8, 0xFE, 0xFE, 0x3F, 0xBF, 0xFF, 0xEF, 0xFF, 0xF9, 0xFF, 0xFE,
  0x3F, 0xFF, 0x83, 0xC7, 0xF0, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xEF, 0x83, 0xFF, 0xF8, 0xFF, 0xFF, 0x3F, 0xFF,
  0xEF, 0xFF, 0xFB, 0xFD, 0xFE, 0xFE, 0x1F, 0xBF, 0x87, 0xFF, 0xE1, 0xFF,
  0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE,
  0x1F, 0xFF, 0x87, 0xEF, 0xF3, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF,
  0xCF, 0xDF, 0xE3, 0xF3, 0xE0, 0x03, 0xF0, 0x07, 0xFE, 0x0F, 0xFF, 0x87,
  0xFF, 0xE7, 0xFF, 0xF3, 0xFB, 0xFF, 0xF8, 0x7F, 0xFC, 0x3F, 0xFE, 0x1F,
  0xFF, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x7F, 0xFC, 0x3F, 0x7F, 0x3F, 0xBF, 0xFF, 0xCF, 0xFF, 0xC7, 0xFF, 0xC0,
  0xFF, 0xC0, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x79, 0xFC, 0x7F, 0xFF, 0x3F, 0xFF, 0xDF, 0xFF, 0xF7,
  0xFF, 0xFD, 0xFC, 0xFF, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8,
  0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F,
  0xFF, 0x87, 0xF7, 0xF3, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xCF, 0xFF, 0xF1,
  0xFE, 0xFC, 0x1F, 0x3F, 0x03, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xFF,
  0xFE, 0x7F, 0xFF, 0x9F, 0xEF, 0xF7, 0xE0, 0xFD, 0xF8, 0x3F, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07,
  0xE0, 0x01, 0xFC, 0x0C, 0x7F, 0x8F, 0x1F, 0xFF, 0xE3, 0xFF, 0xF8, 0x7F,
  0xFE, 0x0F, 0xFF, 0x00, 0x7F, 0x00, 0x00, 0xF8, 0x0F, 0xE0, 0x7F, 0x83,
  0xFE, 0x0F, 0xFC, 0x7F, 0xD1, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x0F,
  0xFF, 0xBF, 0xFE, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0x87, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x07, 0xCF, 0xC7, 0xFF, 0xF3, 0xFF, 0xFD, 0xFF, 0xFF, 0x7F,
  0xFF, 0xDF, 0xEF, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x83,
  0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF,
  0xF8, 0x3F, 0x7F, 0x9F, 0xDF, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x1F,
  0xEF, 0xC1, 0xF3, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC3, 0x0F,
  0xF1, 0xFF, 0xFC, 0xFF, 0xFE, 0x3F, 0xFF, 0x07, 0xFF, 0x80, 0x3F, 0x80,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x1E, 0x1F,
  0xBF, 0xCF, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFC, 0x3F,
  0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xF0,
  0xFF, 0xF8, 0x7F, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF,
  0xC3, 0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0x38, 0xFB, 0xFF, 0xFF,
  0xFF, 0xDE, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x03, 0x80, 0xF8, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC1, 0xE0, 0x00, 0x00,
  0x01, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1,
  0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC,
  0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFE, 0xFF,
  0xFF, 0xEF, 0xFD, 0xFF, 0x3F, 0xC7, 0xF0, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0xFF, 0x7F, 0x1F, 0xCF,
  0xE7, 0xF9, 0xFD, 0xFE, 0x3F, 0xBF, 0x87, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F,
  0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF8, 0x3F,
  0xFF, 0x07, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xDF, 0xE3, 0xF9, 0xFC, 0x7F,
  0x3F, 0xCF, 0xE3, 0xF9, 0xFC, 0x7F, 0xBF, 0x87, 0xF7, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x7C, 0x1F, 0x1F, 0xBF, 0xCF, 0xF3, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xBF, 0xFF,
  0x8F, 0xE3, 0xFF, 0xF1, 0xFC, 0x7F, 0xFE, 0x3F, 0x8F, 0xFF, 0xC7, 0xF1,
  0xFF, 0xF8, 0xFE, 0x3F, 0xFF, 0x1F, 0xC7, 0xFF, 0xE3, 0xF8, 0xFF, 0xFC,
  0x7F, 0x1F, 0xFF, 0x8F, 0xE3, 0xFF, 0xF1, 0xFC, 0x7F, 0xFE, 0x3F, 0x8F,
  0xFF, 0xC7, 0xF1, 0xFF, 0xF8, 0xFE, 0x3F, 0xFF, 0x1F, 0xC7, 0xFF, 0xE3,
  0xF8, 0xFF, 0xFC, 0x7F, 0x1F, 0xC0, 0xFC, 0x7C, 0x7E, 0xFF, 0x3F, 0xFF,
  0xDF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0xFC,
  0x3F, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF,
  0xF0, 0xFF, 0xF8, 0x7F, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0x87,
  0xFF, 0xC3, 0xFF, 0xE1, 0xFC, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC,
  0x1F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFF, 0x7F, 0x9F, 0xC7, 0xF7, 0xF0, 0x7E,
  0xFE, 0x0F, 0xDF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF,
  0xFC, 0x1F, 0xBF, 0x83, 0xF3, 0xF0, 0xFE, 0x7F, 0xBF, 0xCF, 0xFF, 0xF0,
  0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0xE0, 0x07, 0xF0, 0x00, 0xFC, 0xF8,
  0x3F, 0x7F, 0x8F, 0xFF, 0xF3, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xCF, 0xEF,
  0xE1, 0xFB, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8,
  0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7E, 0xFF, 0x3F,
  0xBF, 0xFF, 0xEF, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFE, 0x3F, 0xBE, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x00, 0x0F, 0xCF, 0xC7, 0xFB,
  0xF3, 0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xDF, 0xCF, 0xFF, 0xE1, 0xFF,
  0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE,
  0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0x7F, 0x3F, 0xDF, 0xFF,
  0xF7, 0xFF, 0xFC, 0xFF, 0xFF, 0x1F, 0xFF, 0xC1, 0xF7, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0xFC, 0xFF, 0xDF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xE7,
  0xFF, 0xF7, 0xF1, 0xFF, 0xF8, 0xFF, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xF0,
  0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xF8, 0x01, 0xFF, 0xF8,
  0x7F, 0xFE, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xC7, 0xFF, 0xC1, 0xFF, 0xC0,
  0x3F, 0x80, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0xFF,
  0xEF, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xE3, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF8, 0x3F,
  0xD3, 0xFF, 0x3F, 0xF1, 0xFF, 0x1F, 0xF0, 0x7E, 0xFC, 0x3F, 0xFE, 0x1F,
  0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0xF8,
  0x7F, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF,
  0xE1, 0xFF, 0xF0, 0xFF, 0xFC, 0x7F, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xF3, 0xFD, 0xF8, 0xF8, 0xFC, 0xFF, 0x0F, 0xEF, 0xE1, 0xFD,
  0xFC, 0x7F, 0x3F, 0x8F, 0xE3, 0xF1, 0xFC, 0x7E, 0x3F, 0x0F, 0xE7, 0xE1,
  0xFD, 0xFC, 0x1F, 0xBF, 0x83, 0xF7, 0xE0, 0x7E, 0xFC, 0x0F, 0xDF, 0x80,
  0xFF, 0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFC, 0x3E, 0x3F, 0xFE, 0x3F, 0x1F, 0xBF, 0x1F, 0x8F, 0xDF, 0x8F, 0xC7,
  0xEF, 0xE7, 0xE3, 0xF3, 0xF3, 0xFB, 0xF9, 0xFB, 0xFD, 0xF8, 0xFD, 0xFE,
  0xFC, 0x7E, 0xFF, 0x7E, 0x3F, 0x7F, 0xBF, 0x0F, 0xBF, 0xFF, 0x87, 0xFF,
  0xFF, 0x83, 0xFF, 0x7F, 0xC1, 0xFF, 0x3F, 0xE0, 0xFF, 0x9F, 0xF0, 0x3F,
  0xCF, 0xF8, 0x1F, 0xE3, 0xF8, 0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0xFE, 0x03,
  0xF8, 0x7F, 0x00, 0xFC, 0x3F, 0x80, 0x7E, 0x0F, 0xC0, 0x7F, 0x0F, 0xEF,
  0xE3, 0xF8, 0xFE, 0x7F, 0x1F, 0xCF, 0xC1, 0xFB, 0xF8, 0x3F, 0xFE, 0x03,
  0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F,
  0xBF, 0x87, 0xF7, 0xF0, 0xFE, 0x7F, 0x1F, 0x8F, 0xE7, 0xF1, 0xFC, 0xFE,
  0x1F, 0xC0, 0xFE, 0x0F, 0xEF, 0xE1, 0xFD, 0xFC, 0x7F, 0xBF, 0x8F, 0xE7,
  0xF1, 0xFC, 0x7E, 0x3F, 0x8F, 0xEF, 0xE1, 0xFD, 0xFC, 0x1F, 0xBF, 0x83,
  0xF7, 0xF0, 0x7E, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFC, 0x03,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0x80, 0x07, 0xC0, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF,
  0xF7, 0xFF, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x01,
  0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x80, 0xE0, 0x7C, 0x3F, 0x1F, 0x87, 0xE1, 0xF8,
  0x7C, 0x1F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x3F, 0x8F, 0xE3, 0xE0, 0xFC, 0x3F, 0x87, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0x7C, 0x1F, 0x07, 0xE1, 0xF8, 0x7E,
  0x0F, 0xC1, 0xF0, 0x38, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x60, 0x1E, 0x07, 0xC3, 0xF0,
  0x7E, 0x0F, 0x83, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x1F, 0x87, 0xF0, 0xFC, 0x1F, 0x0F, 0xC7, 0xF1, 0xF8,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0x83, 0xE1, 0xF8, 0xFC, 0x1F, 0x07, 0x01, 0x80, 0x0F, 0x00, 0x07,
  0xF0, 0x7D, 0xFF, 0x0F, 0xBF, 0xF1, 0xFF, 0xFF, 0x7F, 0xFB, 0xFF, 0xBE,
  0x3F, 0xF7, 0xC3, 0xFC, 0xF8, 0x3F, 0x00, 0x03, 0xC0,
};

const GFXglyph RobotoCondensed_Black42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 7, 30, 11, 2, -30 },
  { 28, 11, 12, 13, 1, -32 },
  { 45, 19, 30, 22, 1, -30 },
  { 117, 18, 38, 21, 2, -34 },
  { 203, 23, 30, 27, 2, -30 },
  { 290, 23, 30, 25, 1, -30 },
  { 377, 5, 12, 6, 1, -32 },
  { 385, 11, 42, 14, 2, -33 },
  { 443, 11, 42, 14, 1, -33 },
  { 501, 18, 18, 20, 1, -30 },
  { 542, 17, 22, 19, 1, -25 },
  { 589, 8, 13, 11, 1, -5 },
  { 602, 11, 5, 18, 3, -15 },
  { 609, 8, 7, 13, 2, -7 },
  { 616, 13, 33, 13, 0, -30 },
  { 670, 18, 30, 21, 2, -30 },
  { 738, 12, 30, 21, 3, -30 },
  { 783, 19, 30, 21, 1, -30 },
  { 855, 19, 30, 21, 1, -30 },
  { 927, 19, 30, 21, 1, -30 },
  { 999, 19, 30, 21, 1, -30 },
  { 1071, 18, 30, 21, 2, -30 },
  { 1139, 19, 30, 21, 1, -30 },
  { 1211, 18, 30, 21, 2, -30 },
  { 1279, 18, 30, 21, 2, -30 },
  { 1347, 8, 23, 12, 2, -23 },
  { 1370, 9, 31, 12, 1, -23 },
  { 1405, 15, 21, 19, 1, -23 },
  { 1445, 16, 14, 22, 3, -20 },
  { 1473, 16, 21, 19, 2, -23 },
  { 1515, 17, 30, 19, 1, -30 },
  { 1579, 30, 38, 32, 1, -29 },
  { 1722, 25, 30, 25, 0, -30 },
  { 1816, 20, 30, 24, 2, -30 },
  { 1891, 21, 30, 24, 2, -30 },
  { 1970, 20, 30, 24, 2, -30 },
  { 2045, 18, 30, 21, 2, -30 },
  { 2113, 17, 30, 20, 2, -30 },
  { 2177, 21, 30, 25, 2, -30 },
  { 2256, 22, 30, 26, 2, -30 },
  { 2339, 7, 30, 12, 2, -30 },
  { 2366, 18, 30, 21, 1, -30 },
  { 2434, 22, 30, 23, 2, -30 },
  { 2517, 17, 30, 20, 2, -30 },
  { 2581, 28, 30, 32, 2, -30 },
  { 2686, 22, 30, 26, 2, -30 },
  { 2769, 22, 30, 25, 2, -30 },
  { 2852, 20, 30, 24, 2, -30 },
  { 2927, 22, 35, 25, 2, -30 },
  { 3024, 21, 30, 24, 2, -30 },
  { 3103, 21, 30, 23, 1, -30 },
  { 3182, 21, 30, 23, 1, -30 },
  { 3261, 20, 30, 24, 2, -30 },
  { 3336, 24, 30, 25, 0, -30 },
  { 3426, 29, 30, 31, 1, -30 },
  { 3535, 23, 30, 24, 0, -30 },
  { 3622, 23, 30, 23, 0, -30 },
  { 3709, 20, 30, 22, 1, -30 },
  { 3784, 8, 42, 11, 2, -35 },
  { 3826, 17, 33, 16, 0, -30 },
  { 3897, 8, 42, 11, 1, -35 },
  { 3939, 15, 15, 17, 1, -30 },
  { 3968, 16, 5, 17, 0, 0 },
  { 3978, 12, 6, 14, 1, -31 },
  { 3987, 18, 22, 20, 1, -22 },
  { 4037, 18, 32, 21, 2, -32 },
  { 4109, 17, 22, 19, 1, -22 },
  { 4156, 18, 32, 21, 1, -32 },
  { 4228, 18, 22, 20, 1, -22 },
  { 4278, 14, 32, 14, 0, -32 },
  { 4334, 18, 31, 21, 1, -22 },
  { 4404, 17, 32, 21, 2, -32 },
  { 4472, 7, 31, 11, 2, -31 },
  { 4500, 11, 40, 11, -2, -31 },
  { 4555, 19, 32, 21, 2, -32 },
  { 4631, 7, 32, 11, 2, -32 },
  { 4659, 27, 22, 31, 2, -22 },
  { 4734, 17, 22, 21, 2, -22 },
  { 4781, 19, 22, 21, 1, -22 },
  { 4834, 18, 31, 21, 2, -22 },
  { 4904, 18, 31, 21, 1, -22 },
  { 4974, 12, 22, 14, 2, -22 },
  { 5007, 17, 22, 19, 1, -22 },
  { 5054, 12, 28, 13, 1, -28 },
  { 5096, 17, 22, 21, 2, -22 },
  { 5143, 19, 22, 19, 0, -22 },
  { 5196, 25, 22, 26, 1, -22 },
  { 5265, 19, 22, 19, 0, -22 },
  { 5318, 19, 31, 19, 0, -22 },
  { 5392, 17, 22, 19, 1, -22 },
  { 5439, 10, 40, 12, 1, -33 },
  { 5489, 3, 36, 11, 4, -30 },
  { 5503, 10, 40, 12, 1, -33 },
  { 5553, 19, 10, 23, 2, -18 },
};

const GFXfont RobotoCondensed_Black42pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Black42pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Black42pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _ROBOTOCONDENSED_BLACK42PT7B_H_
