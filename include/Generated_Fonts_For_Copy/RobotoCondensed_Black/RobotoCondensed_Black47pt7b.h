#ifndef _ROBOTOCONDENSED_BLACK47PT7B_H_
#define _ROBOTOCONDENSED_BLACK47PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Black.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Black47pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xBF, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F,
  0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7,
  0xF3, 0xF8, 0x00, 0x00, 0x00, 0x1E, 0x1F, 0xCF, 0xEF, 0xF7, 0xF9, 0xFC,
  0xFE, 0x3E, 0x00, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC,
  0x7F, 0xE3, 0xFE, 0x1F, 0xF0, 0xF7, 0x87, 0xBC, 0x3D, 0xE1, 0xEF, 0x0F,
  0x00, 0x01, 0xF3, 0xC0, 0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80,
  0x1E, 0x7C, 0x00, 0xF3, 0xE0, 0x0F, 0x9F, 0x00, 0x7C, 0xF0, 0x03, 0xE7,
  0x80, 0x1E, 0x3C, 0x1F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFC, 0x1F, 0x3C, 0x00, 0xF9, 0xE0, 0x07, 0x8F, 0x00, 0x3C, 0x78,
  0x01, 0xE7, 0xC0, 0x0F, 0x3E, 0x0F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFE, 0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x03, 0xCF, 0x80,
  0x1E, 0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0x9E, 0x00, 0x7C, 0xF0, 0x03, 0xC7,
  0x80, 0x1E, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x1F, 0xC0, 0x07, 0xFF, 0x00, 0xFF, 0xF8,
  0x1F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE7, 0xF8, 0xFF, 0x7F, 0x8F,
  0xF7, 0xF8, 0xFF, 0x7F, 0x87, 0xF7, 0xF8, 0x7F, 0x7F, 0x80, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xF7, 0xF8, 0xFF,
  0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x07, 0xFF,
  0x00, 0x1F, 0xC0, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFD, 0xF8, 0x30, 0x3E, 0x3E, 0x1E, 0x0F,
  0x8F, 0x87, 0x83, 0xE3, 0xE3, 0xC0, 0xF8, 0xF9, 0xF0, 0x3E, 0x3E, 0x78,
  0x0F, 0x8F, 0xBE, 0x03, 0xF7, 0xEF, 0x00, 0x7F, 0xF7, 0xC0, 0x1F, 0xFD,
  0xE0, 0x03, 0xFE, 0xF8, 0x00, 0x3E, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x9F, 0x00, 0x03, 0xDF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x7B, 0xFF,
  0x80, 0x3E, 0xFB, 0xF0, 0x0F, 0x7C, 0x7C, 0x07, 0xDF, 0x1F, 0x01, 0xE7,
  0xC7, 0xC0, 0xF1, 0xF1, 0xF0, 0x7C, 0x7C, 0x7C, 0x1E, 0x1F, 0x1F, 0x07,
  0x83, 0xE7, 0xC0, 0x40, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x01,
  0xFC, 0xFE, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x07, 0xE1, 0xF8,
  0x01, 0xFC, 0xFC, 0x00, 0x7F, 0x7F, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF,
  0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x3F, 0x07,
  0xFF, 0x8F, 0xC3, 0xFF, 0xE3, 0xF0, 0xFF, 0xFD, 0xFC, 0x7F, 0x7F, 0xFF,
  0x1F, 0xDF, 0xFF, 0xCF, 0xF3, 0xFF, 0xE3, 0xFC, 0x7F, 0xF8, 0xFF, 0x1F,
  0xFE, 0x3F, 0xC3, 0xFF, 0x07, 0xF8, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE,
  0x03, 0xF8, 0x7F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF,
  0xBE, 0xF8, 0x00, 0x40, 0x38, 0x0F, 0x83, 0xF0, 0x7C, 0x1F, 0x87, 0xE0,
  0xF8, 0x3F, 0x07, 0xE0, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0x7C, 0x0F,
  0x81, 0xF8, 0x3F, 0x03, 0xE0, 0x7E, 0x0F, 0xC0, 0xF8, 0x1F, 0x81, 0xF8,
  0x1F, 0x03, 0xF0, 0x3E, 0x03, 0x80, 0x10, 0x60, 0x07, 0x00, 0x78, 0x0F,
  0xC0, 0x7E, 0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xC0,
  0xFC, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x03, 0xE0, 0x7E, 0x0F,
  0xC0, 0x78, 0x07, 0x00, 0x60, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x20, 0x78, 0x01, 0xC3, 0xC1,
  0xDF, 0xDE, 0x7E, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xC7, 0xFF, 0xF8, 0x07,
  0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xF8, 0x01, 0xF3, 0xE0,
  0x1F, 0x9F, 0x81, 0xF8, 0x7E, 0x0F, 0x81, 0xF0, 0x1C, 0x0E, 0x00, 0x40,
  0x20, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7E, 0x3F,
  0x1F, 0x9F, 0x8F, 0xCF, 0xC3, 0xC0, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3C,
  0x00, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F,
  0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F,
  0x80, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x81, 0xFF,
  0xF8, 0x3F, 0xFF, 0xC7, 0xFF, 0xFE, 0x7F, 0x9F, 0xE7, 0xF0, 0xFE, 0xFF,
  0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF,
  0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F,
  0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xF7, 0xF0, 0xFE, 0x7F, 0x9F, 0xE7, 0xFF,
  0xFE, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xE0, 0x01,
  0xF8, 0x00, 0x00, 0x18, 0x03, 0xC0, 0xFE, 0x1F, 0xF7, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81,
  0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F,
  0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x3F,
  0xFC, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xC3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF9,
  0xFE, 0x3F, 0xCF, 0xF0, 0xFE, 0x7F, 0x07, 0xF7, 0xF8, 0x3F, 0xFF, 0xC1,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE,
  0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF8, 0x01,
  0xFC, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF,
  0x3F, 0xFF, 0xF9, 0xFE, 0x3F, 0xCF, 0xE0, 0xFF, 0x7F, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x7F,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xFF,
  0xE0, 0x7F, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xDF, 0xE3, 0xFE, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x00, 0xFF, 0xF0, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC,
  0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xBF, 0xC1, 0xFB,
  0xFC, 0x1F, 0xBF, 0xC3, 0xF3, 0xFC, 0x3F, 0x3F, 0xC7, 0xF3, 0xFC, 0x7E,
  0x3F, 0xCF, 0xE3, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xC0, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x7F,
  0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF7, 0xC0, 0x7F, 0xFF, 0x0F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0xFF, 0x3F, 0xE0, 0xC1, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xE0,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFE, 0xFF, 0x1F, 0xE7, 0xFF, 0xFE, 0x7F,
  0xFF, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xE0, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0x80, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x7C, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xE3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF7, 0xF8, 0x7F, 0xBF,
  0xC3, 0xFD, 0xFC, 0x0F, 0xEF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xF3, 0xF8, 0x7F, 0x9F, 0xE3, 0xFC, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0xE0,
  0x01, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0xF0, 0x1F,
  0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7, 0xFF, 0xFE, 0x7F, 0x9F, 0xE7,
  0xF0, 0xFE, 0x7F, 0x0F, 0xE7, 0xF0, 0xFE, 0x7F, 0x0F, 0xE7, 0xF0, 0xFE,
  0x7F, 0x9F, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFF,
  0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7, 0xF9, 0xFE, 0x7F, 0x0F, 0xEF, 0xF0,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x9F, 0xF7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80,
  0xFF, 0xF0, 0x03, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0xE0, 0x0F, 0xFF,
  0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0x9F, 0xEF, 0xF0,
  0xFE, 0xFF, 0x0F, 0xEF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0xFF, 0x7F, 0xFF, 0xF7,
  0xFF, 0xFF, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x7C, 0xFE,
  0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xFC, 0x01, 0xFF,
  0x80, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0xFF,
  0x00, 0x0F, 0x80, 0x00, 0x1C, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x7E,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x3C, 0x1C, 0x1F, 0x9F, 0xEF, 0xF7, 0xFB,
  0xFD, 0xFC, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F,
  0xC7, 0xE3, 0xF3, 0xF1, 0xF9, 0xF8, 0xFC, 0x7C, 0x0C, 0x00, 0x00, 0x00,
  0x80, 0x01, 0xC0, 0x03, 0xE0, 0x07, 0xF0, 0x0F, 0xF8, 0x1F, 0xFC, 0x7F,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0x7F, 0xF0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xFE, 0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x03, 0xFF, 0x80, 0x7F,
  0xC0, 0x0F, 0xE0, 0x01, 0xF0, 0x00, 0x38, 0x00, 0x04, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x80, 0x00, 0x70, 0x00, 0x3E, 0x00, 0x1F, 0xC0, 0x0F, 0xF8, 0x07, 0xFF,
  0x03, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0x81, 0xFF, 0xC0, 0x3F, 0xE0,
  0x1F, 0xF0, 0x3F, 0xF8, 0xFF, 0xFD, 0xFF, 0xFD, 0xFF, 0xF0, 0xFF, 0xE0,
  0x7F, 0xC0, 0x3F, 0x80, 0x1F, 0x00, 0x0E, 0x00, 0x04, 0x00, 0x00, 0x03,
  0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0xFE, 0x1F, 0xFF, 0xC7, 0xFF, 0xFC, 0xFF,
  0xFF, 0xBF, 0xC7, 0xFF, 0xF8, 0xFF, 0xFF, 0x1F, 0xFF, 0xC3, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x0F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x1F, 0x80, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x1F,
  0xC0, 0x7F, 0x80, 0x1F, 0x80, 0x07, 0xE0, 0x1F, 0x80, 0x01, 0xF0, 0x0F,
  0x80, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x1E, 0x0F, 0xC0, 0x00, 0x0F, 0x87,
  0xC0, 0x3F, 0x03, 0xC7, 0xC0, 0x7F, 0xC1, 0xE3, 0xE0, 0x7F, 0xF8, 0xF9,
  0xF0, 0x7F, 0xFC, 0x7C, 0xF0, 0x7F, 0x3E, 0x1E, 0xF8, 0x3E, 0x3E, 0x0F,
  0x7C, 0x3F, 0x1F, 0x07, 0xBE, 0x1F, 0x0F, 0x83, 0xDF, 0x0F, 0x87, 0xC1,
  0xEF, 0x0F, 0xC3, 0xE0, 0xF7, 0x87, 0xE1, 0xF0, 0x7B, 0xC3, 0xE0, 0xF8,
  0x3F, 0xE1, 0xF0, 0x7C, 0x1E, 0xF0, 0xF8, 0x3E, 0x1F, 0x78, 0x7C, 0x1F,
  0x0F, 0x3C, 0x3F, 0x1F, 0x87, 0x9F, 0x1F, 0x8F, 0xC7, 0xCF, 0x8F, 0xEF,
  0xE7, 0xC7, 0xC3, 0xFF, 0xFF, 0xE3, 0xE1, 0xFF, 0x7F, 0xE1, 0xF0, 0x7F,
  0x3F, 0xE0, 0x7C, 0x0F, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x20, 0x00, 0x3F, 0xF1, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x01,
  0xFF, 0xF8, 0x00, 0x1F, 0xDF, 0x80, 0x01, 0xFD, 0xFC, 0x00, 0x3F, 0x9F,
  0xC0, 0x03, 0xF9, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x07, 0xF8, 0xFE, 0x00,
  0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0xFF, 0x00, 0xFF, 0x07, 0xF0, 0x0F, 0xF0,
  0x7F, 0x00, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC3, 0xFC,
  0x03, 0xFC, 0x3F, 0xC0, 0x1F, 0xE7, 0xFC, 0x01, 0xFE, 0x7F, 0x80, 0x1F,
  0xE7, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xF0, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xBF, 0xC3, 0xFF, 0x7F, 0x81, 0xFE, 0xFF, 0x03, 0xFD, 0xFE, 0x07,
  0xFB, 0xFC, 0x0F, 0xF7, 0xF8, 0x1F, 0xEF, 0xF0, 0x3F, 0xDF, 0xE1, 0xFF,
  0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xE7, 0xF8, 0x1F, 0xEF, 0xF0, 0x3F, 0xDF, 0xE0, 0x3F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xFC,
  0x1F, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFC, 0x7F, 0xE7, 0xFE, 0x7F, 0x81, 0xFE, 0xFF, 0x00, 0xFE, 0xFF, 0x00,
  0xFE, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFE, 0x7F, 0x81,
  0xFE, 0x7F, 0xE7, 0xFE, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0xFF, 0xFC,
  0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFE, 0x3F, 0xC7, 0xFE, 0x7F, 0x83, 0xFC, 0xFF, 0x03, 0xFD,
  0xFE, 0x07, 0xFB, 0xFC, 0x0F, 0xF7, 0xF8, 0x1F, 0xEF, 0xF0, 0x1F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFE,
  0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0,
  0x7F, 0xBF, 0xC0, 0xFF, 0x7F, 0x81, 0xFE, 0xFF, 0x03, 0xFD, 0xFE, 0x0F,
  0xF3, 0xFC, 0x3F, 0xE7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x7F, 0xE3, 0xFE,
  0x7F, 0x81, 0xFE, 0x7F, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0x7F, 0x80, 0xFF, 0x7F, 0x80, 0xFF, 0x7F, 0xE1, 0xFF,
  0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC,
  0x03, 0xFF, 0xF0, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0x7F, 0x9F, 0xE7, 0xFF, 0xFE,
  0x7F, 0xFF, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xE0, 0x03, 0xF8,
  0x00, 0xFF, 0x01, 0xFF, 0x7F, 0x81, 0xFF, 0xBF, 0xC0, 0xFF, 0x9F, 0xE0,
  0xFF, 0x8F, 0xF0, 0x7F, 0xC7, 0xF8, 0x7F, 0xC3, 0xFC, 0x3F, 0xE1, 0xFE,
  0x3F, 0xE0, 0xFF, 0x1F, 0xE0, 0x7F, 0x9F, 0xF0, 0x3F, 0xCF, 0xF0, 0x1F,
  0xEF, 0xF0, 0x0F, 0xF7, 0xF8, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x07, 0xFE, 0xFF, 0x03, 0xFF, 0x7F,
  0xC1, 0xFF, 0x3F, 0xE0, 0xFF, 0x0F, 0xF0, 0x7F, 0x87, 0xFC, 0x3F, 0xC1,
  0xFE, 0x1F, 0xE0, 0xFF, 0x8F, 0xF0, 0x7F, 0xC7, 0xF8, 0x1F, 0xF3, 0xFC,
  0x0F, 0xF9, 0xFE, 0x03, 0xFE, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xEF, 0x83, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF,
  0x0F, 0xBF, 0xFF, 0xFE, 0x1F, 0x7F, 0xFF, 0x7C, 0x7E, 0xFF, 0xFE, 0xFC,
  0xFD, 0xFF, 0xFD, 0xF9, 0xF3, 0xFF, 0xF9, 0xF3, 0xE7, 0xFF, 0xF3, 0xEF,
  0xCF, 0xFF, 0xE7, 0xDF, 0x9F, 0xFF, 0xCF, 0xFE, 0x3F, 0xFF, 0x8F, 0xFC,
  0x7F, 0xFF, 0x1F, 0xF8, 0xFF, 0xFE, 0x3F, 0xE3, 0xFF, 0xFC, 0x7F, 0xC7,
  0xFF, 0xF8, 0x7F, 0x8F, 0xFF, 0xF0, 0xFF, 0x1F, 0xFF, 0xE1, 0xFC, 0x3F,
  0xFF, 0xC1, 0xF8, 0x7F, 0xFF, 0x83, 0xF0, 0xFF, 0xFF, 0x07, 0xE1, 0xFE,
  0xFF, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0x7C, 0xFF, 0xFF, 0x7C, 0xFF, 0xFF, 0x7C, 0xFF,
  0xFF, 0x3E, 0xFF, 0xFF, 0x3E, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF1, 0xFF, 0x9F,
  0xF8, 0xFF, 0x03, 0xFC, 0xFF, 0x80, 0xFF, 0x7F, 0x80, 0x7F, 0xBF, 0xC0,
  0x3F, 0xDF, 0xE0, 0x1F, 0xEF, 0xF0, 0x07, 0xF7, 0xF8, 0x03, 0xFF, 0xFC,
  0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x07, 0xFB,
  0xFC, 0x03, 0xFD, 0xFE, 0x01, 0xFE, 0xFF, 0x80, 0xFF, 0x3F, 0xC0, 0xFF,
  0x1F, 0xF9, 0xFF, 0x87, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xBF, 0xC1, 0xFF, 0x7F, 0x81, 0xFF, 0xFF, 0x01,
  0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x83, 0xFE, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xE0, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xF1, 0xFF, 0x9F, 0xF8, 0xFF, 0x03, 0xFE, 0x7F,
  0x80, 0xFF, 0x7F, 0x80, 0x7F, 0xBF, 0xC0, 0x3F, 0xDF, 0xE0, 0x0F, 0xEF,
  0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFD, 0xFE, 0x01,
  0xFE, 0x7F, 0x80, 0xFF, 0x3F, 0xC0, 0xFF, 0x9F, 0xF9, 0xFF, 0x87, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x07,
  0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x40,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0x07, 0xFC, 0xFF, 0x03, 0xFC,
  0xFF, 0x03, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x01, 0xFE,
  0xFF, 0x03, 0xFC, 0xFF, 0x03, 0xFC, 0xFF, 0x07, 0xFC, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xE0, 0xFF, 0x1F, 0xE0, 0xFF, 0x1F, 0xE0, 0xFF, 0x1F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xF8,
  0xFF, 0x07, 0xFC, 0xFF, 0x03, 0xFC, 0xFF, 0x03, 0xFE, 0xFF, 0x03, 0xFE,
  0xFF, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE7, 0xFC, 0x7F, 0xDF, 0xE0,
  0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xF7, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x07,
  0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF8, 0x7F, 0xDF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF,
  0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF,
  0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x01,
  0xFE, 0xFF, 0x07, 0xFD, 0xFF, 0x1F, 0xF3, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x3F, 0xEF, 0xF0, 0x07, 0xFD, 0xFF, 0x00, 0xFF, 0xBF, 0xE0,
  0x1F, 0xE7, 0xFC, 0x03, 0xFC, 0x7F, 0x80, 0xFF, 0x8F, 0xF0, 0x1F, 0xE1,
  0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x83, 0xFC, 0x1F, 0xF0, 0x7F, 0x83,
  0xFC, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x0F, 0xF0, 0x1F, 0xE1, 0xFC, 0x03,
  0xFC, 0x7F, 0x80, 0x3F, 0x8F, 0xF0, 0x07, 0xF1, 0xFE, 0x00, 0xFF, 0x3F,
  0x80, 0x1F, 0xE7, 0xF0, 0x01, 0xFD, 0xFE, 0x00, 0x3F, 0xBF, 0xC0, 0x07,
  0xF7, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0,
  0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F,
  0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x07, 0xF0, 0x7F, 0xFF, 0x83, 0xF8, 0x3F,
  0xFF, 0xC1, 0xFC, 0x1F, 0xFF, 0xE1, 0xFE, 0x0F, 0xF7, 0xF0, 0xFF, 0x87,
  0xF3, 0xF8, 0x7F, 0xC3, 0xF9, 0xFC, 0x3F, 0xE3, 0xFC, 0xFF, 0x1F, 0xF1,
  0xFE, 0x7F, 0x8F, 0xF8, 0xFF, 0x3F, 0xCF, 0xFC, 0x7F, 0x8F, 0xE7, 0xFF,
  0x3F, 0x87, 0xF3, 0xFF, 0x9F, 0xC3, 0xF9, 0xFF, 0xDF, 0xE1, 0xFE, 0xFF,
  0xEF, 0xF0, 0xFF, 0xFF, 0xF7, 0xF8, 0x7F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xDF, 0xFF, 0x03, 0xFF,
  0xEF, 0xFF, 0x81, 0xFF, 0xF7, 0xFF, 0xC0, 0xFF, 0xFB, 0xFF, 0xC0, 0x3F,
  0xFD, 0xFF, 0xE0, 0x1F, 0xFC, 0xFF, 0xF0, 0x0F, 0xFE, 0x3F, 0xF8, 0x07,
  0xFF, 0x1F, 0xFC, 0x03, 0xFF, 0x8F, 0xFE, 0x01, 0xFF, 0xC7, 0xFE, 0x00,
  0x7F, 0xC3, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xC0,
  0x0F, 0xF8, 0x3F, 0xE0, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x7F,
  0xDF, 0xF0, 0x3F, 0xE3, 0xFC, 0x0F, 0xF8, 0xFF, 0x83, 0xFC, 0x1F, 0xE1,
  0xFF, 0x07, 0xF8, 0x7F, 0x80, 0xFF, 0x1F, 0xE0, 0x3F, 0xCF, 0xF0, 0x0F,
  0xF3, 0xFC, 0x01, 0xFE, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0,
  0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07,
  0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80,
  0x1F, 0xEF, 0xF0, 0x0F, 0xF3, 0xFC, 0x03, 0xFC, 0xFF, 0x81, 0xFF, 0x1F,
  0xE0, 0x7F, 0x87, 0xFC, 0x3F, 0xE0, 0xFF, 0x0F, 0xF8, 0x3F, 0xC7, 0xFC,
  0x0F, 0xF9, 0xFF, 0x01, 0xFE, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF, 0x80, 0x7F,
  0xDF, 0xE0, 0x1F, 0xE7, 0xF8, 0x07, 0xF8, 0xFF, 0x03, 0xFC, 0x3F, 0xC0,
  0xFF, 0x07, 0xF0, 0x3F, 0x81, 0xFE, 0x1F, 0xE0, 0x7F, 0x87, 0xF8, 0x0F,
  0xE1, 0xFC, 0x03, 0xFC, 0xFF, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xCF, 0xE0,
  0x07, 0xF3, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF,
  0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF,
  0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF,
  0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC,
  0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x00, 0x1F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9,
  0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F,
  0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF,
  0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x03, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x7D, 0xE0, 0x3E, 0xF8, 0x1F, 0x7C, 0x1F, 0xBE, 0x0F,
  0x8F, 0x87, 0xC7, 0xC7, 0xE3, 0xE3, 0xF1, 0xF9, 0xF0, 0x7D, 0xF8, 0x3F,
  0xFC, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0x81, 0xFC, 0x07, 0xF0, 0x3F, 0xC0,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF,
  0x83, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xFF, 0xFE, 0x7F, 0x1F, 0xE7, 0xF1,
  0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x03, 0xFF, 0xE0, 0xFF, 0xFE, 0x3F,
  0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0x9F, 0xEF, 0xF1, 0xFE, 0xFF, 0x1F, 0xEF,
  0xF1, 0xFE, 0xFF, 0x1F, 0xEF, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE,
  0x3F, 0xEF, 0xE1, 0xFE, 0xFF, 0x0F, 0xCF, 0xF0, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x7E, 0x0F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE,
  0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xEF, 0xF8, 0xFE, 0x7E, 0x00,
  0x01, 0xFC, 0x01, 0xFF, 0xE0, 0x7F, 0xFE, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC,
  0xFF, 0xFF, 0xDF, 0xE3, 0xFB, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x0F, 0xEF, 0xE1, 0xFD, 0xFE, 0x3F, 0xBF, 0xFF, 0xF3,
  0xFF, 0xFC, 0x7F, 0xFF, 0x87, 0xFF, 0xE0, 0x7F, 0xF8, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x07, 0xE7, 0xF1, 0xFF, 0x7F, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x7F,
  0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0x8F, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF,
  0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F,
  0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0x7F, 0x8F,
  0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF0, 0xFF,
  0x7F, 0x07, 0xE7, 0xF0, 0x03, 0xF8, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0x83,
  0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0xFF, 0xFE, 0xFF, 0x1F, 0xEF, 0xE0, 0xFE,
  0xFE, 0x0F, 0xEF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x83, 0x87, 0xFF, 0xFC, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F,
  0xFF, 0xC0, 0xFF, 0xF8, 0x03, 0xFC, 0x00, 0x00, 0x7E, 0x03, 0xFC, 0x1F,
  0xF8, 0x3F, 0xF0, 0xFF, 0xE1, 0xFF, 0xC3, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0x03, 0xF3, 0xF8, 0x7F, 0xDF, 0xC7, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFE, 0x1F, 0xEF, 0xE0, 0xFF, 0xFF, 0x07,
  0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF,
  0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFB, 0xF8, 0x3F,
  0xDF, 0xE1, 0xFE, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0x7F,
  0xFF, 0xE1, 0xFF, 0xFF, 0x03, 0xE7, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0xC0, 0xFF, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0x83, 0xFF,
  0xFC, 0x3F, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0xF8, 0x7F,
  0x7F, 0xCF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC,
  0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8,
  0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0,
  0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0x80, 0x00, 0x7E, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7E, 0x3C, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7E,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x07, 0xF0, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xEF, 0xFC, 0xFF, 0x8F, 0xE0, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC3, 0xFF, 0xFE,
  0x3F, 0xEF, 0xF1, 0xFE, 0x7F, 0x9F, 0xF3, 0xFD, 0xFF, 0x1F, 0xEF, 0xF0,
  0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07,
  0xFF, 0xFC, 0x3F, 0xFF, 0xE1, 0xFE, 0x7F, 0x8F, 0xF3, 0xFC, 0x7F, 0x9F,
  0xF3, 0xFC, 0x7F, 0x9F, 0xE3, 0xFE, 0xFF, 0x0F, 0xF7, 0xF8, 0x7F, 0xFF,
  0xC1, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x3F, 0x07, 0xE1, 0xFC, 0xFF, 0x1F, 0xE3, 0xFB, 0xFF, 0x7F,
  0xE7, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xC7, 0xFC, 0xFF, 0x7F, 0x8F, 0xF0, 0xFE, 0xFF, 0x1F, 0xE1, 0xFD,
  0xFE, 0x1F, 0xC3, 0xFF, 0xFC, 0x3F, 0x87, 0xFF, 0xF8, 0x7F, 0x0F, 0xFF,
  0xF0, 0xFE, 0x1F, 0xFF, 0xE1, 0xFC, 0x3F, 0xFF, 0xC3, 0xF8, 0x7F, 0xFF,
  0x87, 0xF0, 0xFF, 0xFF, 0x0F, 0xE1, 0xFF, 0xFE, 0x1F, 0xC3, 0xFF, 0xFC,
  0x3F, 0x87, 0xFF, 0xF8, 0x7F, 0x0F, 0xFF, 0xF0, 0xFE, 0x1F, 0xFF, 0xE1,
  0xFC, 0x3F, 0xFF, 0xC3, 0xF8, 0x7F, 0xFF, 0x87, 0xF0, 0xFF, 0xFF, 0x0F,
  0xE1, 0xFE, 0xFE, 0x3E, 0x1F, 0xDF, 0xF3, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF,
  0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF,
  0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF,
  0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC3, 0xFF, 0xFE, 0x3F, 0xFF, 0xF9, 0xFE, 0x3F, 0xCF, 0xE0, 0xFE, 0x7F,
  0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F,
  0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0x7F, 0x07, 0xFB, 0xF8,
  0x3F, 0x9F, 0xE3, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0,
  0x7F, 0xFF, 0x00, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0xFE, 0x7E, 0x0F, 0xEF,
  0xF8, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF,
  0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0x7E, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xE3, 0xF1, 0xFF, 0x7F, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x7F, 0xFF,
  0xF7, 0xFF, 0xFF, 0x7F, 0x8F, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0,
  0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF,
  0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0x7F, 0x8F, 0xF7,
  0xFF, 0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0x7F,
  0x07, 0xE7, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0xFE, 0x3F, 0xF7, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F,
  0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE,
  0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x00, 0x03, 0xF8, 0x01,
  0xFF, 0xE0, 0x7F, 0xFE, 0x1F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFE, 0x3F, 0xDF,
  0xC7, 0xFB, 0xF8, 0xFF, 0x7F, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F,
  0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00,
  0x3F, 0xFF, 0xC3, 0xFF, 0xF8, 0x3F, 0xFF, 0x8F, 0xF7, 0xFF, 0xFC, 0x7F,
  0xFF, 0x8F, 0xFF, 0xE0, 0x7F, 0xF8, 0x03, 0xF8, 0x00, 0x3F, 0xC1, 0xFE,
  0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F,
  0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8,
  0x3F, 0xC1, 0xFF, 0xCF, 0xFE, 0x3F, 0xF1, 0xFF, 0x87, 0xFC, 0x0F, 0xE0,
  0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF,
  0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF,
  0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF,
  0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xF9, 0xFF, 0x7F, 0x0F, 0x8F, 0xE0,
  0x7F, 0x07, 0xFB, 0xFC, 0x3F, 0xDF, 0xE1, 0xFE, 0xFF, 0x0F, 0xE3, 0xF8,
  0xFF, 0x1F, 0xC7, 0xF8, 0xFE, 0x3F, 0xC7, 0xF9, 0xFC, 0x1F, 0xCF, 0xE0,
  0xFE, 0x7F, 0x07, 0xF7, 0xF0, 0x3F, 0xBF, 0x80, 0xFD, 0xFC, 0x07, 0xFF,
  0xE0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0xFE, 0x1F, 0x0F, 0xFF, 0xE1, 0xF8,
  0xFE, 0xFE, 0x1F, 0x8F, 0xEF, 0xE3, 0xF8, 0xFE, 0x7E, 0x3F, 0x8F, 0xE7,
  0xE3, 0xF8, 0xFE, 0x7F, 0x3F, 0xCF, 0xC7, 0xF7, 0xFC, 0xFC, 0x7F, 0x7F,
  0xDF, 0xC7, 0xF7, 0xFD, 0xFC, 0x3F, 0x7F, 0xDF, 0xC3, 0xF7, 0xFF, 0xF8,
  0x3F, 0xFB, 0xFF, 0x83, 0xFF, 0xBF, 0xF8, 0x3F, 0xFB, 0xFF, 0x81, 0xFF,
  0x9F, 0xF8, 0x1F, 0xF9, 0xFF, 0x81, 0xFF, 0x1F, 0xF0, 0x1F, 0xF1, 0xFF,
  0x01, 0xFF, 0x1F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFE, 0x0F, 0xF0, 0x0F,
  0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0xFF, 0x0F,
  0xFF, 0xF0, 0xFE, 0x7F, 0x1F, 0xE7, 0xF9, 0xFE, 0x3F, 0x9F, 0xC3, 0xFB,
  0xFC, 0x1F, 0xFF, 0x81, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F,
  0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0xFF, 0xF0, 0x1F, 0xFF, 0x81, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3, 0xF9, 0xFC,
  0x7F, 0x9F, 0xC7, 0xF9, 0xFE, 0x7F, 0x0F, 0xEF, 0xF0, 0xFF, 0xFF, 0x0F,
  0xF0, 0xFF, 0x07, 0xF9, 0xFE, 0x1F, 0xE7, 0xF8, 0x7F, 0x9F, 0xE1, 0xFE,
  0x7F, 0x8F, 0xF0, 0xFE, 0x3F, 0xC3, 0xFC, 0xFF, 0x0F, 0xF3, 0xF8, 0x1F,
  0xDF, 0xE0, 0x7F, 0x7F, 0x81, 0xFD, 0xFE, 0x07, 0xF7, 0xF0, 0x0F, 0xFF,
  0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80,
  0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x40, 0x3C, 0x0F, 0x83, 0xF0, 0xFE, 0x1F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0xFE, 0x3F, 0x8F, 0xF1, 0xFC, 0x3F, 0x07, 0xF0, 0xFF, 0x07, 0xF0, 0xFE,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x87, 0xF0, 0x7E, 0x0F, 0xE0, 0xFC, 0x0F, 0x80, 0xF0,
  0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x20, 0x07, 0x80,
  0x7C, 0x07, 0xE0, 0x7F, 0x03, 0xF0, 0x3F, 0x03, 0xF8, 0x3F, 0x83, 0xF8,
  0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x81, 0xF8,
  0x1F, 0x81, 0xFE, 0x0F, 0xF0, 0x7F, 0x03, 0xF0, 0x7F, 0x0F, 0xF1, 0xFC,
  0x1F, 0x81, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8,
  0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x03, 0xF0, 0x7E, 0x07, 0xE0,
  0x7C, 0x07, 0x80, 0x20, 0x00, 0x0F, 0x80, 0x00, 0xFE, 0x07, 0xCF, 0xF8,
  0x3E, 0xFF, 0xE1, 0xF7, 0xFF, 0x9F, 0xBF, 0xFF, 0xFF, 0xF3, 0xFF, 0xDF,
  0x8F, 0xFE, 0xFC, 0x3F, 0xE7, 0xC0, 0xFF, 0x00, 0x03, 0xE0,
};

const GFXglyph RobotoCondensed_Black47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 9, 33, 12, 2, -33 },
  { 39, 13, 13, 15, 1, -35 },
  { 61, 21, 33, 24, 1, -33 },
  { 148, 20, 43, 24, 2, -38 },
  { 256, 26, 33, 30, 2, -33 },
  { 364, 26, 33, 28, 1, -33 },
  { 472, 6, 13, 7, 1, -35 },
  { 482, 11, 47, 15, 3, -37 },
  { 547, 12, 47, 15, 1, -37 },
  { 618, 21, 21, 22, 1, -33 },
  { 674, 19, 25, 22, 1, -28 },
  { 734, 9, 15, 13, 1, -6 },
  { 751, 12, 6, 20, 4, -17 },
  { 760, 8, 8, 14, 3, -8 },
  { 768, 14, 36, 15, 0, -33 },
  { 831, 20, 33, 24, 2, -33 },
  { 914, 13, 33, 24, 4, -33 },
  { 968, 21, 33, 24, 1, -33 },
  { 1055, 21, 33, 24, 1, -33 },
  { 1142, 20, 33, 24, 2, -33 },
  { 1225, 20, 33, 24, 2, -33 },
  { 1308, 21, 33, 24, 2, -33 },
  { 1395, 21, 33, 24, 1, -33 },
  { 1482, 20, 33, 24, 2, -33 },
  { 1565, 20, 33, 24, 2, -33 },
  { 1648, 8, 26, 14, 3, -26 },
  { 1674, 9, 35, 13, 2, -26 },
  { 1714, 17, 22, 21, 1, -25 },
  { 1761, 18, 17, 24, 3, -23 },
  { 1800, 17, 22, 21, 3, -25 },
  { 1847, 19, 33, 22, 1, -33 },
  { 1926, 33, 42, 36, 1, -32 },
  { 2100, 28, 33, 28, 0, -33 },
  { 2216, 23, 33, 27, 2, -33 },
  { 2311, 24, 33, 27, 2, -33 },
  { 2410, 23, 33, 26, 2, -33 },
  { 2505, 20, 33, 23, 2, -33 },
  { 2588, 19, 33, 22, 2, -33 },
  { 2667, 24, 33, 28, 2, -33 },
  { 2766, 24, 33, 29, 2, -33 },
  { 2865, 7, 33, 13, 3, -33 },
  { 2894, 20, 33, 23, 1, -33 },
  { 2977, 25, 33, 26, 2, -33 },
  { 3081, 19, 33, 23, 2, -33 },
  { 3160, 31, 33, 36, 2, -33 },
  { 3288, 24, 33, 29, 2, -33 },
  { 3387, 25, 33, 28, 2, -33 },
  { 3491, 23, 33, 27, 2, -33 },
  { 3586, 25, 39, 28, 2, -33 },
  { 3708, 24, 33, 27, 2, -33 },
  { 3807, 22, 33, 26, 2, -33 },
  { 3898, 24, 33, 26, 1, -33 },
  { 3997, 23, 33, 27, 2, -33 },
  { 4092, 27, 33, 28, 0, -33 },
  { 4204, 33, 33, 35, 1, -33 },
  { 4341, 26, 33, 26, 0, -33 },
  { 4449, 26, 33, 26, 0, -33 },
  { 4557, 23, 33, 25, 1, -33 },
  { 4652, 10, 47, 13, 2, -39 },
  { 4711, 19, 36, 18, 0, -33 },
  { 4797, 9, 47, 13, 1, -39 },
  { 4850, 17, 17, 19, 1, -33 },
  { 4887, 18, 6, 19, 0, 0 },
  { 4901, 13, 7, 16, 1, -35 },
  { 4913, 20, 25, 22, 1, -25 },
  { 4976, 20, 35, 23, 2, -35 },
  { 5064, 19, 25, 22, 1, -25 },
  { 5124, 20, 35, 23, 1, -35 },
  { 5212, 20, 25, 23, 2, -25 },
  { 5275, 15, 35, 16, 0, -35 },
  { 5341, 21, 35, 24, 1, -25 },
  { 5433, 19, 35, 23, 2, -35 },
  { 5517, 8, 36, 12, 2, -36 },
  { 5553, 12, 46, 12, -2, -36 },
  { 5622, 21, 35, 23, 2, -35 },
  { 5714, 8, 35, 12, 2, -35 },
  { 5749, 31, 25, 35, 2, -25 },
  { 5846, 19, 25, 23, 2, -25 },
  { 5906, 21, 25, 23, 1, -25 },
  { 5972, 20, 35, 23, 2, -25 },
  { 6060, 20, 35, 23, 1, -25 },
  { 6148, 13, 25, 16, 2, -25 },
  { 6189, 19, 25, 21, 1, -25 },
  { 6249, 13, 31, 15, 1, -31 },
  { 6300, 19, 25, 23, 2, -25 },
  { 6360, 21, 25, 22, 0, -25 },
  { 6426, 28, 25, 29, 1, -25 },
  { 6514, 20, 25, 22, 1, -25 },
  { 6577, 22, 35, 22, 0, -25 },
  { 6674, 18, 25, 22, 2, -25 },
  { 6731, 11, 45, 14, 1, -37 },
  { 6793, 4, 39, 12, 4, -33 },
  { 6813, 12, 45, 14, 1, -37 },
  { 6881, 21, 11, 25, 2, -19 },
};

const GFXfont RobotoCondensed_Black47pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Black47pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Black47pt7bGlyphs,
  0x20, 0x7E, 55
};

#endif // _ROBOTOCONDENSED_BLACK47PT7B_H_
