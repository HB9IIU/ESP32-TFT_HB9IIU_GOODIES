#ifndef _ROBOTOCONDENSED_BLACK50PT7B_H_
#define _ROBOTOCONDENSED_BLACK50PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Black.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Black50pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0xBF,
  0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0xBF, 0x9F, 0xCF, 0xE7,
  0xF3, 0xF8, 0xFC, 0x7E, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xE3, 0xF9, 0xFF,
  0xFF, 0xFF, 0xBF, 0xDF, 0xC3, 0xC0, 0xF8, 0xFF, 0xE3, 0xFF, 0x8F, 0xFE,
  0x3F, 0xF8, 0xFF, 0xE3, 0xFF, 0x8F, 0xFE, 0x3E, 0xF8, 0xFB, 0xE3, 0xEF,
  0x8F, 0xBC, 0x3E, 0xF0, 0xFB, 0xC3, 0xE0, 0x00, 0xF1, 0xF0, 0x01, 0xE3,
  0xC0, 0x03, 0xC7, 0x80, 0x0F, 0x8F, 0x00, 0x1F, 0x3E, 0x00, 0x3E, 0x7C,
  0x00, 0x7C, 0xF8, 0x00, 0xF9, 0xF0, 0x01, 0xE3, 0xE0, 0x03, 0xC7, 0x80,
  0x0F, 0x8F, 0x01, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0x81, 0xE3, 0xE0, 0x03, 0xC7, 0x80, 0x0F, 0x8F, 0x00, 0x1F,
  0x1E, 0x00, 0x3E, 0x7C, 0x00, 0x7C, 0xF8, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0x1F, 0x1E, 0x00, 0x3E, 0x7C,
  0x00, 0x7C, 0xF8, 0x00, 0xF9, 0xF0, 0x01, 0xF3, 0xE0, 0x03, 0xC7, 0xC0,
  0x07, 0x8F, 0x00, 0x1F, 0x1E, 0x00, 0x3E, 0x3C, 0x00, 0x7C, 0xF8, 0x00,
  0xF9, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xF8, 0x03, 0xFF,
  0xF0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xF3, 0xFE,
  0x7F, 0xC7, 0xF9, 0xFE, 0x1F, 0xE7, 0xF8, 0x7F, 0xDF, 0xE0, 0xFF, 0x7F,
  0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0,
  0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFB, 0xFC,
  0x1F, 0xEF, 0xF0, 0x7F, 0xBF, 0xC1, 0xFE, 0xFF, 0x87, 0xF9, 0xFE, 0x1F,
  0xE7, 0xFC, 0xFF, 0x9F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0x80,
  0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x7F, 0xFC, 0x18, 0x0F, 0xCF, 0xC3, 0xE0, 0xF8, 0x7C, 0x3E, 0x0F, 0x87,
  0xC7, 0xC0, 0xF8, 0x7C, 0x7C, 0x0F, 0x87, 0xCF, 0x80, 0xF8, 0x7C, 0xF8,
  0x0F, 0xCF, 0xDF, 0x00, 0x7F, 0xFD, 0xE0, 0x07, 0xFF, 0xBE, 0x00, 0x3F,
  0xFB, 0xC0, 0x01, 0xFF, 0x7C, 0x00, 0x0F, 0xC7, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x3E, 0x7F, 0xC0,
  0x03, 0xEF, 0xFC, 0x00, 0x7D, 0xFF, 0xE0, 0x07, 0xDF, 0xFE, 0x00, 0xFB,
  0xF3, 0xF0, 0x0F, 0xBE, 0x1F, 0x01, 0xF3, 0xE1, 0xF0, 0x1E, 0x3E, 0x1F,
  0x03, 0xE3, 0xE1, 0xF0, 0x3C, 0x3E, 0x1F, 0x07, 0xC3, 0xF1, 0xF0, 0x38,
  0x1F, 0xFE, 0x00, 0x81, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0x00, 0x1F, 0xEF, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x1F, 0xC3, 0xF0, 0x01,
  0xFC, 0x3F, 0x00, 0x1F, 0xC3, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x1F, 0xEF,
  0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x1F, 0xC1, 0xFF,
  0xF1, 0xFC, 0x3F, 0xFF, 0x1F, 0xC3, 0xFF, 0xF9, 0xFC, 0x7F, 0xFF, 0xDF,
  0x87, 0xFB, 0xFF, 0xF8, 0x7F, 0xBF, 0xFF, 0x8F, 0xF1, 0xFF, 0xF8, 0xFF,
  0x0F, 0xFF, 0x0F, 0xF8, 0x7F, 0xF0, 0x7F, 0x87, 0xFF, 0x07, 0xFC, 0x7F,
  0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xBF, 0xE0, 0x3F, 0xE3, 0xFE, 0x00, 0x20,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xBE, 0xFB,
  0xE0, 0x00, 0x60, 0x0E, 0x01, 0xE0, 0x3F, 0x07, 0xE0, 0x7E, 0x0F, 0xC0,
  0xF8, 0x1F, 0x81, 0xF0, 0x3F, 0x03, 0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xF0, 0x3F, 0x03,
  0xF0, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x7E, 0x03, 0xF0,
  0x1E, 0x00, 0xE0, 0x06, 0x20, 0x03, 0x80, 0x1E, 0x00, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x1F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0xC0, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0xFE, 0x07,
  0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF0, 0x3F, 0x81,
  0xFC, 0x0F, 0xE0, 0x7E, 0x03, 0xF0, 0x3F, 0x81, 0xF8, 0x0F, 0xC0, 0xFC,
  0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x3F, 0x01, 0xF0, 0x0F, 0x00, 0x70, 0x01,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x07, 0x07, 0x81, 0x9F, 0x1E, 0x3E,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xC1, 0xFF, 0xF0, 0x01,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xF0, 0x01, 0xF7, 0xC0, 0x0F, 0xCF,
  0x80, 0x7E, 0x3F, 0x03, 0xF0, 0x7E, 0x07, 0xC0, 0xF8, 0x0E, 0x03, 0x80,
  0x00, 0x04, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x3F, 0x9F, 0xCF,
  0xCF, 0xE7, 0xE7, 0xE1, 0xF0, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x3E, 0x3F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFC,
  0x7C, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F,
  0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0xFF, 0xF9, 0xFF, 0x7F, 0xCF, 0xF1, 0xFE,
  0x7F, 0x87, 0xFB, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0,
  0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF,
  0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83,
  0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xDF,
  0xC1, 0xFE, 0xFF, 0x0F, 0xF7, 0xF8, 0xFF, 0x3F, 0xEF, 0xF8, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0x7F, 0xFC, 0x01, 0xFF, 0xC0, 0x03,
  0xF8, 0x00, 0x00, 0x0C, 0x00, 0xF0, 0x1F, 0xC1, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xE0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x7F,
  0xFE, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xFE, 0xFF,
  0x9F, 0xF1, 0xFF, 0x7F, 0x83, 0xFD, 0xFE, 0x0F, 0xF7, 0xF8, 0x3F, 0xFF,
  0xE0, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFD,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x00, 0xFE, 0x00, 0x0F,
  0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0x1F, 0xFB, 0xFF, 0x3F, 0xC3, 0xFE, 0x7F, 0x83, 0xFC, 0xFF, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFC, 0x1F, 0xEF, 0xF8, 0x3F, 0xCF, 0xFD, 0xFF, 0x9F, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x01, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x3F, 0x7F, 0x80, 0xFD, 0xFE, 0x07, 0xE7, 0xF8,
  0x1F, 0x9F, 0xE0, 0xFE, 0x7F, 0x83, 0xF1, 0xFE, 0x1F, 0xC7, 0xF8, 0x7F,
  0x1F, 0xE3, 0xF8, 0x7F, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF9, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF3, 0xE0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x8F, 0x83, 0xFE, 0x04, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0xFF, 0xBF,
  0xEF, 0xF9, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0x7F, 0xFE,
  0x01, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x01, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF,
  0xF8, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x9F, 0x01, 0xFD, 0xFF, 0x0F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFD, 0xFF, 0xBF, 0xE1,
  0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xDF, 0xE1, 0xFF, 0x7F,
  0x87, 0xF9, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xFF,
  0xE0, 0x3F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xC3, 0xFF,
  0xFE, 0x1F, 0xFF, 0xF9, 0xFF, 0x7F, 0xCF, 0xF1, 0xFF, 0x7F, 0x87, 0xFB,
  0xFC, 0x3F, 0xDF, 0xE1, 0xFE, 0xFF, 0x0F, 0xF7, 0xF8, 0x7F, 0x3F, 0xC7,
  0xF8, 0xFF, 0x7F, 0xC7, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC3, 0xFF, 0xFF, 0x3F, 0xC7, 0xF9, 0xFE, 0x1F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF8, 0x7F, 0xBF, 0xE7, 0xFD, 0xFF, 0xFF, 0xE7, 0xFF, 0xFE,
  0x3F, 0xFF, 0xE0, 0xFF, 0xFE, 0x01, 0xFF, 0xE0, 0x03, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFE,
  0x1F, 0xFF, 0xF1, 0xFF, 0x7F, 0xCF, 0xF1, 0xFE, 0x7F, 0x87, 0xFF, 0xF8,
  0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF,
  0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x87, 0xFB, 0xFE, 0x7F, 0xDF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0,
  0x7C, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x07, 0xFE, 0x03, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x07,
  0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x3F,
  0xBF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFC, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC7, 0xF7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xBF, 0x8F, 0x80, 0x1F, 0x1F, 0xE7, 0xFD, 0xFF, 0x7F, 0xDF,
  0xE3, 0xF8, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE3, 0xF8, 0xFE, 0x3F,
  0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xC3, 0xF1, 0xFC, 0x7E, 0x3F, 0x8F,
  0xC1, 0xE0, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x3C, 0x00, 0x1F, 0x80,
  0x0F, 0xF0, 0x07, 0xFE, 0x03, 0xFF, 0xC1, 0xFF, 0xF8, 0xFF, 0xFF, 0x7F,
  0xFF, 0x1F, 0xFF, 0x83, 0xFF, 0xC0, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF,
  0xE0, 0x3F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0xFC, 0x07,
  0xFF, 0x80, 0x3F, 0xF0, 0x01, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x78, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x80, 0x00, 0x38, 0x00, 0x0F, 0x80,
  0x03, 0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0xFF, 0x83, 0xFF, 0xF8,
  0x3F, 0xFF, 0x83, 0xFF, 0xF0, 0x1F, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x7F, 0xF0, 0xFF, 0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0x3F, 0xFE, 0x0F, 0xFE,
  0x03, 0xFE, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0x0E, 0x00, 0x02, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF,
  0xE7, 0xFF, 0xFE, 0xFF, 0xDF, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFE, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x3F,
  0xC0, 0x03, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0xFC,
  0x00, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x07, 0xC1, 0xF0, 0x1F, 0xF8, 0x7C,
  0x1F, 0x03, 0xFF, 0xC3, 0xE3, 0xF0, 0x7F, 0xFC, 0x3E, 0x3E, 0x0F, 0xFF,
  0xC3, 0xE3, 0xE0, 0xFC, 0x7C, 0x3E, 0x7E, 0x1F, 0x87, 0xC1, 0xE7, 0xC1,
  0xF8, 0x7C, 0x1E, 0x7C, 0x1F, 0x07, 0xC1, 0xE7, 0xC3, 0xF0, 0x7C, 0x1E,
  0x7C, 0x3F, 0x0F, 0xC1, 0xE7, 0xC3, 0xF0, 0xFC, 0x1E, 0x7C, 0x3F, 0x0F,
  0xC1, 0xE7, 0xC3, 0xE0, 0xFC, 0x1E, 0x7C, 0x7E, 0x0F, 0x83, 0xE7, 0xC7,
  0xE0, 0xF8, 0x3E, 0x7C, 0x7E, 0x0F, 0x83, 0xE7, 0xC3, 0xF0, 0xF8, 0x3C,
  0x7C, 0x3F, 0x1F, 0x87, 0xC7, 0xC3, 0xFB, 0xFC, 0xF8, 0x7C, 0x3F, 0xFF,
  0xFF, 0x87, 0xE1, 0xFF, 0xFF, 0xF0, 0x3E, 0x0F, 0xF3, 0xFE, 0x03, 0xE0,
  0x7E, 0x1F, 0xC0, 0x3F, 0x01, 0x00, 0x60, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x18, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0x80, 0x01, 0xFE, 0xFE, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x1F, 0xCF,
  0xE0, 0x00, 0xFF, 0x3F, 0xC0, 0x03, 0xFC, 0xFF, 0x00, 0x0F, 0xF1, 0xFC,
  0x00, 0x3F, 0x87, 0xF8, 0x01, 0xFE, 0x1F, 0xE0, 0x07, 0xF8, 0x7F, 0x80,
  0x1F, 0xE0, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0x80, 0x3F, 0xC3, 0xFE, 0x00,
  0xFF, 0x0F, 0xF0, 0x03, 0xFE, 0x7F, 0xC0, 0x0F, 0xF9, 0xFF, 0x00, 0x3F,
  0xE7, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0x83, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0x81, 0xFE, 0xFF, 0x83, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0xFF,
  0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x01,
  0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0xFF, 0x81, 0xFE, 0x7F, 0x80, 0xFF,
  0xBF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x07,
  0xFF, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xDF, 0xE0, 0x1F, 0xEF, 0xF0, 0x1F, 0xF7,
  0xFC, 0x1F, 0xF1, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0x87,
  0xFE, 0xFF, 0x83, 0xFE, 0xFF, 0x81, 0xFE, 0xFF, 0x81, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFE, 0xFF, 0x83,
  0xFE, 0xFF, 0x87, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xC0, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0,
  0x03, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0xC1, 0xFF,
  0x7F, 0xC0, 0x7F, 0xBF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xDF, 0xE0, 0x1F, 0xEF,
  0xF8, 0x0F, 0xF7, 0xFE, 0x07, 0xF9, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF8, 0xFF, 0xBF, 0xFF, 0xF9, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFC, 0x3F, 0xFF, 0xC0, 0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0x03, 0xF8, 0x00,
  0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x7F, 0xEF, 0xF8, 0x1F, 0xFB, 0xFE, 0x0F,
  0xFC, 0xFF, 0x83, 0xFF, 0x3F, 0xE0, 0xFF, 0x8F, 0xF8, 0x7F, 0xC3, 0xFE,
  0x1F, 0xF0, 0xFF, 0x8F, 0xF8, 0x3F, 0xE3, 0xFE, 0x0F, 0xF9, 0xFF, 0x03,
  0xFE, 0x7F, 0x80, 0xFF, 0xBF, 0xE0, 0x3F, 0xEF, 0xF0, 0x0F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xCF, 0xF8, 0x3F, 0xF3, 0xFE,
  0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFE, 0x3F, 0xE0,
  0xFF, 0x8F, 0xF8, 0x3F, 0xF3, 0xFE, 0x07, 0xFC, 0xFF, 0x81, 0xFF, 0xBF,
  0xE0, 0x7F, 0xEF, 0xF8, 0x0F, 0xFB, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0,
  0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF8, 0x7E, 0xFF, 0xFE, 0xFC,
  0x3F, 0x7F, 0xFF, 0x7E, 0x1F, 0xBF, 0xFF, 0xBF, 0x0F, 0xDF, 0xFF, 0xCF,
  0x8F, 0xCF, 0xFF, 0xE7, 0xE7, 0xEF, 0xFF, 0xF3, 0xF3, 0xF7, 0xFF, 0xF9,
  0xF9, 0xFB, 0xFF, 0xFE, 0x7C, 0xF9, 0xFF, 0xFF, 0x3F, 0xFC, 0xFF, 0xFF,
  0x9F, 0xFE, 0x7F, 0xFF, 0xCF, 0xFF, 0x3F, 0xFF, 0xE3, 0xFF, 0x1F, 0xFF,
  0xF1, 0xFF, 0x8F, 0xFF, 0xF8, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0xC3, 0xFF,
  0xFE, 0x1F, 0xE1, 0xFF, 0xFF, 0x0F, 0xF0, 0xFF, 0xFF, 0x87, 0xF8, 0x7F,
  0xFF, 0xC1, 0xF8, 0x3F, 0xFF, 0xE0, 0xFC, 0x1F, 0xFF, 0xF0, 0x7E, 0x0F,
  0xF0, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFE, 0xF8, 0xFF, 0xFF, 0xBE, 0x3F, 0xFF, 0xEF, 0xCF, 0xFF,
  0xF9, 0xF3, 0xFF, 0xFE, 0x7E, 0xFF, 0xFF, 0x8F, 0xBF, 0xFF, 0xE3, 0xEF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF1, 0xFF, 0x03, 0xFE,
  0x7F, 0xC0, 0xFF, 0x9F, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xF7, 0xF8,
  0x07, 0xFD, 0xFF, 0x03, 0xFE, 0x7F, 0xC0, 0xFF, 0x8F, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFD, 0xFF, 0x03, 0xFE, 0xFF, 0x80, 0xFF, 0x7F,
  0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xFE, 0xFF, 0x81, 0xFF,
  0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF1, 0xFF,
  0x83, 0xFE, 0x7F, 0xC0, 0x7F, 0x9F, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x1F,
  0xF7, 0xF8, 0x07, 0xFD, 0xFF, 0x01, 0xFE, 0x7F, 0xE0, 0xFF, 0x8F, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFD, 0xFF, 0x03, 0xFE, 0xFF, 0x81, 0xFF,
  0x7F, 0xC0, 0x7F, 0xBF, 0xE0, 0x3F, 0xDF, 0xF0, 0x1F, 0xEF, 0xF8, 0x0F,
  0xF7, 0xFC, 0x07, 0xFB, 0xFE, 0x07, 0xFD, 0xFF, 0x03, 0xFE, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC1, 0xFF, 0x3F, 0xE0, 0xFF,
  0x8F, 0xF8, 0x7F, 0xC7, 0xFC, 0x3F, 0xE3, 0xFE, 0x1F, 0xF0, 0xFF, 0x8F,
  0xF8, 0x7F, 0xC7, 0xFC, 0x1F, 0xF3, 0xFE, 0x0F, 0xF9, 0xFF, 0x07, 0xFC,
  0xFF, 0x81, 0xFF, 0x7F, 0xC0, 0xFF, 0xBF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F,
  0xF0, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x7F, 0xC3,
  0xFE, 0x7F, 0x81, 0xFF, 0x7F, 0x81, 0xFF, 0x7F, 0x81, 0xFF, 0x7F, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFF,
  0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x01, 0xFF,
  0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFE, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x81, 0xFE, 0x7F, 0xF7, 0xFE, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x00, 0x7F,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0x80,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0x7F, 0x80, 0xFF, 0x7F, 0xC1,
  0xFF, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0xFF, 0xC0,
  0x0F, 0xFB, 0xFE, 0x00, 0xFF, 0xDF, 0xF0, 0x07, 0xFC, 0xFF, 0x80, 0x3F,
  0xE7, 0xFC, 0x01, 0xFF, 0x1F, 0xF0, 0x0F, 0xF8, 0xFF, 0x80, 0xFF, 0x87,
  0xFC, 0x07, 0xFC, 0x1F, 0xE0, 0x3F, 0xE0, 0xFF, 0x01, 0xFE, 0x07, 0xFC,
  0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0x80, 0xFF, 0x07, 0xFC, 0x07, 0xF8, 0x3F,
  0xC0, 0x3F, 0xC1, 0xFE, 0x01, 0xFF, 0x0F, 0xF0, 0x07, 0xF8, 0xFF, 0x00,
  0x3F, 0xC7, 0xF8, 0x01, 0xFE, 0x3F, 0xC0, 0x07, 0xF1, 0xFE, 0x00, 0x3F,
  0xCF, 0xE0, 0x01, 0xFE, 0xFF, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x3F, 0xBF,
  0xC0, 0x01, 0xFD, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x03, 0xF8,
  0x1F, 0xFF, 0xE0, 0x7F, 0x03, 0xFF, 0xFC, 0x0F, 0xE0, 0x7F, 0xFF, 0xC3,
  0xFE, 0x0F, 0xF7, 0xF8, 0x7F, 0xC3, 0xFE, 0xFF, 0x0F, 0xF8, 0x7F, 0x9F,
  0xE1, 0xFF, 0x0F, 0xF3, 0xFC, 0x3F, 0xE1, 0xFE, 0x7F, 0x8F, 0xFE, 0x3F,
  0xCF, 0xF1, 0xFF, 0xC7, 0xF8, 0xFF, 0x3F, 0xF8, 0xFF, 0x1F, 0xE7, 0xFF,
  0x3F, 0xC3, 0xFC, 0xFF, 0xE7, 0xF8, 0x7F, 0x9F, 0xFC, 0xFF, 0x0F, 0xF7,
  0xFF, 0xDF, 0xE1, 0xFE, 0xFF, 0xFB, 0xFC, 0x1F, 0xDF, 0xFF, 0x7F, 0x83,
  0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xFB, 0xFF, 0xF0, 0x3F, 0xFF, 0x7F, 0xFE, 0x03, 0xFF, 0xEF,
  0xFF, 0xC0, 0x7F, 0xFD, 0xFF, 0xF0, 0x0F, 0xFF, 0xBF, 0xFE, 0x01, 0xFF,
  0xE3, 0xFF, 0xC0, 0x3F, 0xFC, 0x7F, 0xF8, 0x07, 0xFF, 0x8F, 0xFF, 0x00,
  0x7F, 0xF1, 0xFF, 0xE0, 0x0F, 0xFE, 0x3F, 0xF8, 0x01, 0xFF, 0x83, 0xFF,
  0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0xC1,
  0xFF, 0x80, 0x0F, 0xF8, 0x3F, 0xF0, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x7F,
  0xC0, 0x3F, 0xE7, 0xFE, 0x03, 0xFE, 0x3F, 0xE0, 0x7F, 0xC3, 0xFE, 0x07,
  0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x0F, 0xF8, 0x1F, 0xF0, 0xFF, 0x80,
  0xFF, 0x8F, 0xF0, 0x0F, 0xF9, 0xFF, 0x00, 0x7F, 0x9F, 0xE0, 0x07, 0xFD,
  0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0,
  0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x03,
  0xFF, 0xFE, 0x00, 0x7F, 0xDF, 0xE0, 0x07, 0xF9, 0xFE, 0x00, 0xFF, 0x9F,
  0xF0, 0x0F, 0xF8, 0xFF, 0x01, 0xFF, 0x0F, 0xF8, 0x1F, 0xF0, 0xFF, 0x83,
  0xFF, 0x07, 0xFC, 0x3F, 0xE0, 0x7F, 0xC7, 0xFE, 0x07, 0xFE, 0x7F, 0xE0,
  0x3F, 0xE7, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xEF, 0xF8, 0x07, 0xFD,
  0xFF, 0x00, 0xFF, 0x1F, 0xE0, 0x3F, 0xE3, 0xFE, 0x07, 0xFC, 0x7F, 0xC0,
  0xFF, 0x07, 0xF8, 0x3F, 0xE0, 0xFF, 0x07, 0xF8, 0x0F, 0xF0, 0xFF, 0x01,
  0xFE, 0x1F, 0xE0, 0x3F, 0xC7, 0xF8, 0x03, 0xFC, 0xFF, 0x00, 0x7F, 0x9F,
  0xC0, 0x07, 0xF7, 0xF8, 0x00, 0xFE, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x01,
  0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFE, 0xFF, 0xBF, 0xEF, 0xFB, 0xFE, 0xFF, 0xBF,
  0xEF, 0xFB, 0xFE, 0xFF, 0xBF, 0xEF, 0xFB, 0xFE, 0xFF, 0xBF, 0xEF, 0xFB,
  0xFE, 0xFF, 0xBF, 0xEF, 0xFB, 0xFE, 0xFF, 0xBF, 0xEF, 0xFB, 0xFE, 0xFF,
  0xBF, 0xEF, 0xFB, 0xFE, 0xFF, 0xBF, 0xEF, 0xFB, 0xFE, 0xFF, 0xBF, 0xEF,
  0xFB, 0xFE, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3,
  0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF,
  0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF,
  0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xF0,
  0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xFC, 0x03, 0xFF, 0x00,
  0xFF, 0xC0, 0x3F, 0xF8, 0x1F, 0xBE, 0x07, 0xCF, 0x81, 0xF3, 0xF0, 0xFC,
  0xFC, 0x3F, 0x1F, 0x0F, 0x87, 0xE7, 0xE1, 0xF9, 0xF8, 0x3E, 0xFC, 0x0F,
  0xFF, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0x80, 0xFF, 0x03, 0xFE, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x01, 0xFE, 0x00, 0x3F,
  0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9,
  0xFE, 0x3F, 0xCF, 0xF1, 0xFE, 0x7F, 0x8F, 0xF0, 0x00, 0x7F, 0x80, 0x7F,
  0xFC, 0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x1F, 0xFF, 0xF9, 0xFF, 0xBF, 0xCF,
  0xF1, 0xFE, 0xFF, 0x0F, 0xF7, 0xF8, 0x7F, 0xBF, 0xC3, 0xFD, 0xFF, 0x1F,
  0xEF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xC7, 0xFE, 0xFF, 0x1F,
  0xE7, 0xF8, 0x3E, 0x3F, 0xC0, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF3, 0xF0, 0x7F, 0xBF, 0xE3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F,
  0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8,
  0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xCF, 0xF7, 0xFC, 0x7F, 0x1F, 0x80, 0x01, 0xFC, 0x00,
  0x3F, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0xFF,
  0xF9, 0xFF, 0x7F, 0xCF, 0xF0, 0xFE, 0x7F, 0x87, 0xF7, 0xF8, 0x3F, 0xFF,
  0xC1, 0xFF, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x07, 0xFB, 0xFC, 0x3F, 0xDF, 0xE1, 0xFC, 0xFF,
  0x9F, 0xE7, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xF8,
  0x07, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0x03, 0xE7, 0xFC, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFC, 0xFF, 0xDF, 0xE1,
  0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF,
  0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF,
  0x07, 0xFF, 0xFE, 0x1F, 0xF7, 0xF8, 0x7F, 0xDF, 0xF3, 0xFF, 0x7F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x0F, 0xFB, 0xFC,
  0x0F, 0x8F, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x7F,
  0xFF, 0xC7, 0xFF, 0xFF, 0x3F, 0xFF, 0xFB, 0xFF, 0x3F, 0xDF, 0xE0, 0xFF,
  0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xE0, 0x31, 0xFF, 0xCF, 0x87, 0xFF, 0xFE, 0x3F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x0F, 0xF8, 0x3F, 0xF0, 0xFF, 0xE3, 0xFF, 0xC7,
  0xFF, 0x8F, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x00, 0x03, 0xF1, 0xFC, 0x3F, 0xF7, 0xF1, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFE, 0xFF, 0xDF, 0xE0, 0xFF,
  0x7F, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x83,
  0xFD, 0xFE, 0x0F, 0xF7, 0xF8, 0x3F, 0xDF, 0xF9, 0xFF, 0x7F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x0F, 0xFB, 0xFC, 0x0F,
  0xCF, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x04, 0x07, 0xFC, 0x3C, 0x3F,
  0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x80,
  0xFF, 0xF8, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF1, 0xF0, 0x7F, 0xBF, 0xE3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xE7, 0xFD, 0xFE, 0x1F, 0xFF, 0xF0, 0x7F,
  0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8,
  0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF,
  0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFC, 0x3E, 0x3F, 0xBF,
  0xFF, 0xFF, 0xFF, 0xFD, 0xFC, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0xF7, 0xFB,
  0xFD, 0xFE, 0xFF, 0x7F, 0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF,
  0x7F, 0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0xBF, 0xDF,
  0xEF, 0xF7, 0xF8, 0x03, 0xE0, 0x3F, 0x83, 0xFE, 0x1F, 0xF0, 0xFF, 0x87,
  0xFC, 0x1F, 0xC0, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x7F,
  0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0,
  0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F,
  0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE,
  0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE1, 0xFF, 0xBF, 0xF7, 0xFF, 0xBF,
  0xFD, 0xFF, 0xCF, 0xFC, 0x7F, 0xC3, 0xF8, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0xDF, 0xE1, 0xFF,
  0x3F, 0xC7, 0xFE, 0x7F, 0x8F, 0xF8, 0xFF, 0x3F, 0xE1, 0xFE, 0x7F, 0xC3,
  0xFD, 0xFF, 0x07, 0xFB, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F,
  0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF,
  0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xF7, 0xFC, 0x3F, 0xC7,
  0xF8, 0x7F, 0x8F, 0xF8, 0xFF, 0x1F, 0xF1, 0xFE, 0x1F, 0xF3, 0xFC, 0x3F,
  0xE7, 0xF8, 0x3F, 0xEF, 0xF0, 0x7F, 0xDF, 0xE0, 0x7F, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x1F, 0x81, 0xF0, 0x7F, 0x9F, 0xE3, 0xFE, 0x3F, 0xFF, 0xFB, 0xFF,
  0x9F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0x7F, 0xF7, 0xFD, 0xFF, 0x1F, 0xF1, 0xFE, 0xFF, 0x0F, 0xF0,
  0xFF, 0xFF, 0x87, 0xF8, 0x3F, 0xFF, 0xC3, 0xFC, 0x1F, 0xFF, 0xE1, 0xFE,
  0x0F, 0xFF, 0xF0, 0xFF, 0x07, 0xFF, 0xF8, 0x7F, 0x83, 0xFF, 0xFC, 0x3F,
  0xC1, 0xFF, 0xFE, 0x1F, 0xE0, 0xFF, 0xFF, 0x0F, 0xF0, 0x7F, 0xFF, 0x87,
  0xF8, 0x3F, 0xFF, 0xC3, 0xFC, 0x1F, 0xFF, 0xE1, 0xFE, 0x0F, 0xFF, 0xF0,
  0xFF, 0x07, 0xFF, 0xF8, 0x7F, 0x83, 0xFF, 0xFC, 0x3F, 0xC1, 0xFF, 0xFE,
  0x1F, 0xE0, 0xFF, 0xFF, 0x0F, 0xF0, 0x7F, 0xFF, 0x87, 0xF8, 0x3F, 0xC0,
  0xFF, 0x1F, 0x87, 0xFB, 0xFE, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFB, 0xFE, 0x7F, 0xDF, 0xE1, 0xFF, 0xFF, 0x07, 0xFF,
  0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83,
  0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF,
  0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xC0, 0x00, 0xFE, 0x00,
  0x1F, 0xFE, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xE7, 0xFE, 0xFF, 0x9F, 0xE1, 0xFF, 0x7F, 0x83, 0xFD, 0xFE, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0x7F, 0x83, 0xFD, 0xFE, 0x0F, 0xF7, 0xF8,
  0x3F, 0xDF, 0xFB, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0x03, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0xFF, 0x3F, 0x07,
  0xFB, 0xFE, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF,
  0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFC,
  0xFF, 0x7F, 0xC7, 0xF9, 0xF8, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xE1, 0xFC, 0x3F,
  0xEF, 0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFD, 0xFF, 0xFF,
  0xF7, 0xFC, 0xFF, 0xDF, 0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x1F, 0xF7, 0xF8, 0x7F,
  0xDF, 0xF3, 0xFF, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x0F, 0x9F, 0xF0, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xFF,
  0x3F, 0xFD, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x83, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0xFF, 0xF0, 0x1F, 0xFF, 0xC3, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFF,
  0x7F, 0x0F, 0xF7, 0xF0, 0xFF, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0x7F,
  0xDF, 0xF7, 0xFF, 0xFE, 0x3F, 0xFF, 0xE1, 0xFF, 0xFC, 0x0F, 0xFF, 0x80,
  0x3F, 0xC0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFF, 0x4F, 0xFF, 0x1F, 0xFC, 0x7F, 0xF0, 0xFF, 0xC1, 0xFF, 0x03, 0xF8,
  0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0,
  0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF,
  0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83,
  0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF,
  0xC3, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0x1F, 0xF7, 0xF8, 0x7E, 0x3F, 0xC0, 0x7F, 0x83, 0xFC,
  0xFF, 0x07, 0xF9, 0xFE, 0x0F, 0xF3, 0xFC, 0x3F, 0xE3, 0xFC, 0x7F, 0x87,
  0xF8, 0xFF, 0x0F, 0xF1, 0xFE, 0x1F, 0xE3, 0xFC, 0x1F, 0xC7, 0xF0, 0x3F,
  0xDF, 0xE0, 0x7F, 0xBF, 0xC0, 0xFF, 0x7F, 0x00, 0xFE, 0xFE, 0x01, 0xFD,
  0xFC, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF,
  0x80, 0x1F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0xFE, 0x0F, 0x83, 0xFF, 0xF8, 0xFE, 0x1F, 0xFF, 0xC7, 0xF0, 0xFF, 0xFE,
  0x3F, 0x8F, 0xF7, 0xF1, 0xFC, 0x7F, 0xBF, 0x8F, 0xF3, 0xF9, 0xFC, 0xFF,
  0x9F, 0xCF, 0xE7, 0xFC, 0xFE, 0x7F, 0x3F, 0xE7, 0xF1, 0xF9, 0xFF, 0x3F,
  0x8F, 0xEF, 0xFD, 0xF8, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xDF, 0xFE, 0x1F,
  0xFE, 0xFF, 0xF0, 0x7F, 0xF7, 0xFF, 0x83, 0xFF, 0xBF, 0xFC, 0x1F, 0xFC,
  0xFF, 0xC0, 0xFF, 0xC7, 0xFE, 0x07, 0xFE, 0x3F, 0xF0, 0x3F, 0xF1, 0xFF,
  0x80, 0xFF, 0x87, 0xFC, 0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0xC1, 0xFE, 0x01,
  0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0x81, 0xFC, 0x00, 0xFF,
  0x07, 0xF9, 0xFE, 0x1F, 0xE7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x3F, 0xCF,
  0xE0, 0xFF, 0x7F, 0x81, 0xFD, 0xFE, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0,
  0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x01, 0xFF, 0xFC, 0x0F, 0xF7, 0xF8, 0x3F, 0xDF, 0xE1, 0xFE, 0x3F, 0xC7,
  0xF8, 0xFF, 0x1F, 0xE3, 0xFE, 0xFF, 0x07, 0xFB, 0xFC, 0x1F, 0xE0, 0xFF,
  0x83, 0xFE, 0xFF, 0x07, 0xF9, 0xFE, 0x0F, 0xF3, 0xFC, 0x3F, 0xE3, 0xFC,
  0x7F, 0xC7, 0xF8, 0xFF, 0x0F, 0xF1, 0xFE, 0x1F, 0xE3, 0xFC, 0x1F, 0xCF,
  0xF0, 0x3F, 0xDF, 0xE0, 0x7F, 0xBF, 0xC0, 0x7F, 0x7F, 0x00, 0xFF, 0xFE,
  0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0,
  0x0F, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00,
  0x7F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF,
  0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0x80, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00,
  0x7F, 0xC0, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x60, 0x0E,
  0x03, 0xF0, 0x7F, 0x07, 0xF0, 0xFE, 0x0F, 0xE0, 0xFC, 0x1F, 0xC1, 0xFC,
  0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC,
  0x1F, 0xC1, 0xFC, 0x3F, 0x8F, 0xF8, 0xFF, 0x0F, 0xE0, 0xFE, 0x0F, 0xF0,
  0xFF, 0x83, 0xF8, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC,
  0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x0F, 0xC0, 0xFE,
  0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0x00, 0xE0, 0x06, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x20, 0x03, 0xC0, 0x1F, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0xFE, 0x07,
  0xF0, 0x3F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xFC, 0x0F, 0xE0, 0x7F,
  0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x07, 0xFC,
  0x1F, 0xE0, 0x7F, 0x03, 0xF8, 0x3F, 0xC3, 0xFE, 0x3F, 0xC1, 0xFC, 0x0F,
  0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xC0, 0xFE, 0x07,
  0xE0, 0x3E, 0x01, 0xE0, 0x04, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xC0, 0xFC,
  0xFF, 0xC1, 0xF9, 0xFF, 0xC3, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF,
  0xBF, 0xFF, 0x7E, 0x1F, 0xFC, 0xFC, 0x1F, 0xF9, 0xF8, 0x1F, 0xE0, 0x00,
  0x1F, 0x00,
};

const GFXglyph RobotoCondensed_Black50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 9, 36, 13, 2, -36 },
  { 42, 14, 14, 16, 1, -38 },
  { 67, 23, 36, 26, 1, -36 },
  { 171, 22, 46, 26, 2, -41 },
  { 298, 28, 36, 32, 2, -36 },
  { 424, 28, 37, 30, 1, -36 },
  { 554, 6, 14, 8, 1, -38 },
  { 565, 12, 50, 16, 3, -39 },
  { 640, 13, 50, 16, 1, -39 },
  { 722, 22, 22, 23, 1, -36 },
  { 783, 21, 26, 23, 1, -29 },
  { 852, 9, 16, 13, 1, -6 },
  { 870, 13, 6, 21, 4, -18 },
  { 880, 9, 8, 15, 3, -8 },
  { 889, 15, 39, 15, 0, -36 },
  { 963, 21, 36, 26, 2, -36 },
  { 1058, 14, 36, 26, 4, -36 },
  { 1121, 22, 36, 26, 1, -36 },
  { 1220, 23, 36, 26, 1, -36 },
  { 1324, 22, 36, 26, 2, -36 },
  { 1423, 21, 36, 26, 2, -36 },
  { 1518, 22, 36, 26, 2, -36 },
  { 1617, 22, 36, 26, 1, -36 },
  { 1716, 21, 36, 26, 2, -36 },
  { 1811, 21, 36, 26, 2, -36 },
  { 1906, 9, 27, 15, 3, -27 },
  { 1937, 10, 37, 14, 2, -27 },
  { 1984, 19, 24, 22, 1, -27 },
  { 2041, 19, 17, 26, 3, -24 },
  { 2082, 18, 24, 23, 3, -27 },
  { 2136, 20, 36, 23, 1, -36 },
  { 2226, 36, 45, 38, 1, -34 },
  { 2429, 30, 36, 30, 0, -36 },
  { 2564, 24, 36, 28, 2, -36 },
  { 2672, 25, 36, 29, 2, -36 },
  { 2785, 24, 36, 28, 2, -36 },
  { 2893, 21, 36, 24, 2, -36 },
  { 2988, 21, 36, 24, 2, -36 },
  { 3083, 25, 36, 30, 2, -36 },
  { 3196, 26, 36, 30, 2, -36 },
  { 3313, 8, 36, 14, 3, -36 },
  { 3349, 21, 36, 25, 1, -36 },
  { 3444, 26, 36, 28, 2, -36 },
  { 3561, 21, 36, 24, 2, -36 },
  { 3656, 33, 36, 38, 2, -36 },
  { 3805, 26, 36, 30, 2, -36 },
  { 3922, 26, 36, 30, 2, -36 },
  { 4039, 25, 36, 29, 2, -36 },
  { 4152, 26, 43, 30, 2, -36 },
  { 4292, 25, 36, 28, 2, -36 },
  { 4405, 24, 36, 28, 2, -36 },
  { 4513, 26, 36, 28, 1, -36 },
  { 4630, 24, 36, 29, 2, -36 },
  { 4738, 29, 36, 29, 0, -36 },
  { 4869, 35, 36, 37, 1, -36 },
  { 5027, 28, 36, 28, 0, -36 },
  { 5153, 27, 36, 28, 0, -36 },
  { 5275, 24, 36, 27, 1, -36 },
  { 5383, 10, 51, 13, 2, -42 },
  { 5447, 21, 39, 19, 0, -36 },
  { 5550, 10, 51, 13, 1, -42 },
  { 5614, 18, 18, 20, 1, -36 },
  { 5655, 19, 6, 20, 0, 0 },
  { 5670, 14, 8, 17, 1, -38 },
  { 5684, 21, 26, 23, 1, -26 },
  { 5753, 21, 38, 25, 2, -38 },
  { 5853, 21, 26, 23, 1, -26 },
  { 5922, 22, 38, 25, 1, -38 },
  { 6027, 21, 26, 24, 2, -26 },
  { 6096, 15, 39, 17, 1, -39 },
  { 6170, 22, 36, 25, 1, -26 },
  { 6269, 21, 38, 25, 2, -38 },
  { 6369, 9, 37, 13, 2, -37 },
  { 6411, 13, 47, 13, -2, -37 },
  { 6488, 23, 38, 25, 2, -38 },
  { 6598, 8, 38, 13, 3, -38 },
  { 6636, 33, 26, 37, 2, -26 },
  { 6744, 21, 26, 25, 2, -26 },
  { 6813, 22, 26, 25, 1, -26 },
  { 6885, 21, 36, 25, 2, -26 },
  { 6980, 22, 36, 25, 1, -26 },
  { 7079, 14, 26, 17, 2, -26 },
  { 7125, 20, 26, 23, 1, -26 },
  { 7190, 14, 33, 16, 1, -33 },
  { 7248, 21, 26, 25, 2, -26 },
  { 7317, 23, 26, 23, 0, -26 },
  { 7392, 29, 26, 31, 1, -26 },
  { 7487, 22, 26, 23, 1, -26 },
  { 7559, 23, 36, 23, 0, -26 },
  { 7663, 19, 26, 23, 2, -26 },
  { 7725, 12, 48, 15, 1, -39 },
  { 7797, 5, 43, 13, 4, -36 },
  { 7824, 13, 48, 15, 1, -39 },
  { 7902, 23, 11, 27, 2, -20 },
};

const GFXfont RobotoCondensed_Black50pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Black50pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Black50pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _ROBOTOCONDENSED_BLACK50PT7B_H_
