#ifndef _ROBOTOCONDENSED_BLACK39PT7B_H_
#define _ROBOTOCONDENSED_BLACK39PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Black.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Black39pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0xFD, 0xFB, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF0, 0x00, 0x00, 0x1E, 0x7E, 0xFF, 0xFF,
  0xF3, 0xC0, 0xF9, 0xFF, 0x9F, 0xF9, 0xFF, 0x9E, 0xF9, 0xEF, 0x9E, 0xF9,
  0xEF, 0x1E, 0xF1, 0xEF, 0x1E, 0xF1, 0xE0, 0x03, 0x9E, 0x00, 0xE7, 0x80,
  0x39, 0xE0, 0x1E, 0x78, 0x07, 0x9E, 0x01, 0xE7, 0x00, 0x79, 0xC0, 0x1E,
  0xF0, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF, 0x0F, 0x38,
  0x03, 0xCE, 0x00, 0xF3, 0x80, 0x39, 0xE0, 0x0E, 0x78, 0x3F, 0xFF, 0xCF,
  0xFF, 0xF3, 0xFF, 0xFC, 0x1E, 0x70, 0x07, 0x9C, 0x01, 0xEF, 0x00, 0x73,
  0xC0, 0x1C, 0xF0, 0x0F, 0x3C, 0x03, 0xCF, 0x00, 0xF3, 0x80, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC,
  0x3F, 0xFE, 0x7F, 0xFF, 0x7E, 0x7F, 0x7E, 0x3F, 0xFE, 0x3F, 0xFE, 0x3F,
  0x7E, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFC,
  0x03, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFE, 0x7F, 0xFF, 0xFF, 0x7F, 0xFE, 0x3F, 0xFC, 0x1F, 0xF8,
  0x07, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x1F, 0x00,
  0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x86, 0x0F, 0x3C, 0x3C, 0x79,
  0xE3, 0xC3, 0xCF, 0x1C, 0x1E, 0x79, 0xE0, 0xF3, 0xCE, 0x07, 0xFE, 0xF0,
  0x1F, 0xF7, 0x00, 0xFF, 0x78, 0x01, 0xF3, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xC0, 0x00, 0x1E, 0x78, 0x01, 0xEF, 0xF0, 0x0F, 0xFF, 0xC0, 0xF7, 0xFE,
  0x07, 0xBC, 0xF0, 0x79, 0xE7, 0x83, 0x8F, 0x3C, 0x3C, 0x79, 0xE1, 0xC3,
  0xCF, 0x0E, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFF,
  0xE0, 0x1F, 0x9F, 0x00, 0xFC, 0xF8, 0x07, 0xE7, 0xC0, 0x3F, 0x3E, 0x01,
  0xFB, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0xC7, 0xC7, 0xFE, 0x3E, 0x7F, 0xFB, 0xF3, 0xFF, 0xFF, 0xBF,
  0x3F, 0xF9, 0xF9, 0xFF, 0xCF, 0xC7, 0xFE, 0x7F, 0x1F, 0xE3, 0xF8, 0xFF,
  0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x0F,
  0xC7, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x80, 0xE0, 0x78,
  0x1E, 0x0F, 0x87, 0xC1, 0xE0, 0xF8, 0x3E, 0x0F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F,
  0x83, 0xE0, 0xF8, 0x1E, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x03, 0xC0, 0xF8,
  0x3E, 0x07, 0x81, 0xF0, 0x3E, 0x07, 0x81, 0xE0, 0x38, 0x02, 0x40, 0x18,
  0x0F, 0x03, 0xE0, 0x7C, 0x0F, 0x03, 0xE0, 0x78, 0x1F, 0x07, 0xC0, 0xF8,
  0x3E, 0x0F, 0x83, 0xE0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xF8, 0x3E, 0x0F, 0x83, 0xE1,
  0xF0, 0x7C, 0x1E, 0x0F, 0x83, 0xC1, 0xF0, 0xF8, 0x3C, 0x06, 0x01, 0x00,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x07, 0x8E,
  0x3B, 0xF7, 0x7F, 0xFF, 0xFF, 0x3F, 0xFE, 0x01, 0xF8, 0x01, 0xF8, 0x01,
  0xFE, 0x01, 0xE7, 0x81, 0xF3, 0xE0, 0xF0, 0xF8, 0x38, 0x38, 0x08, 0x10,
  0x00, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0xBE,
  0x7D, 0xF3, 0xE1, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7D,
  0xFF, 0xFF, 0xF7, 0xE7, 0x80, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x3E, 0x03,
  0xE0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0xF8, 0x0F,
  0x80, 0xF0, 0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3E,
  0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF0,
  0x0F, 0x00, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFE,
  0x7E, 0x7E, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0x7E, 0x7E,
  0x7F, 0xFE, 0x7F, 0xFC, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xE0, 0x00, 0x60,
  0x3C, 0x3F, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x03, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x87, 0xFF, 0xE7, 0xFF, 0xF3,
  0xF1, 0xFF, 0xF8, 0xFF, 0xFC, 0x3F, 0xFC, 0x1F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x03,
  0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFE, 0x00,
  0xFE, 0x00, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF,
  0xF0, 0x07, 0xF0, 0x07, 0xFE, 0x0F, 0xFF, 0x87, 0xFF, 0xE7, 0xFF, 0xF3,
  0xF1, 0xFF, 0xF8, 0x7F, 0xFC, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F,
  0xC0, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xC0, 0x0F, 0xF8, 0x07, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0xFF,
  0xF8, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0x1F, 0xFF, 0x07, 0xFF, 0x00, 0xFE,
  0x00, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0xFF, 0xE0, 0x3D, 0xF8, 0x1F, 0x7E, 0x07, 0x9F, 0x83, 0xE7, 0xE0, 0xF9,
  0xF8, 0x7C, 0x7E, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xF0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x3F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF,
  0xE3, 0xFF, 0xF1, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x7C, 0x1F, 0xFF, 0x0F, 0xFF, 0xC7, 0xFF, 0xF3, 0xFF, 0xF8, 0x30, 0xFE,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xFF, 0xE1,
  0xFF, 0xF0, 0xFD, 0xFC, 0xFE, 0xFF, 0xFE, 0x3F, 0xFF, 0x0F, 0xFF, 0x03,
  0xFF, 0x00, 0x7E, 0x00, 0x00, 0x78, 0x01, 0xFC, 0x01, 0xFE, 0x01, 0xFF,
  0x01, 0xFF, 0x81, 0xFE, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E,
  0x7C, 0x3F, 0xFF, 0x1F, 0xFF, 0xCF, 0xFF, 0xF7, 0xFF, 0xFB, 0xF9, 0xFD,
  0xF8, 0x7F, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0xC3,
  0xFF, 0xE1, 0xF9, 0xF9, 0xFC, 0xFF, 0xFE, 0x3F, 0xFE, 0x1F, 0xFE, 0x03,
  0xFE, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0,
  0x03, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07,
  0xE0, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE,
  0x7F, 0xFE, 0xFE, 0x7F, 0xFE, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFE, 0x7F,
  0x7E, 0x7E, 0x7F, 0xFE, 0x3F, 0xFC, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE,
  0xFE, 0x7E, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFE, 0x7F, 0xFF, 0xFF, 0x7F, 0xFE, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xE0,
  0x07, 0xE0, 0x1F, 0xF0, 0x3F, 0xF8, 0x7F, 0xFC, 0x7F, 0xFE, 0xFE, 0x7E,
  0xFC, 0x7F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFE, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x3F, 0xFF,
  0x0F, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xFC, 0x1F, 0xF8,
  0x1F, 0xF0, 0x1F, 0xE0, 0x1F, 0xC0, 0x1E, 0x00, 0x7C, 0xFF, 0xFF, 0xF7,
  0xE7, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x7F, 0xFF,
  0xFB, 0xF3, 0xC0, 0x3E, 0x7F, 0x7F, 0x7F, 0x3F, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x3F, 0x3F, 0x3F, 0x3E,
  0x3E, 0x3E, 0x3E, 0x7C, 0x7C, 0xF8, 0x30, 0x00, 0x04, 0x00, 0x70, 0x07,
  0xC0, 0x7F, 0x07, 0xFC, 0x7F, 0xF7, 0xFF, 0xBF, 0xF8, 0xFF, 0x03, 0xF0,
  0x0F, 0xF0, 0x3F, 0xF8, 0x7F, 0xF8, 0x7F, 0xF0, 0x7F, 0xC0, 0x7F, 0x00,
  0x7C, 0x00, 0x70, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x03, 0x80, 0x0F,
  0x80, 0x3F, 0x80, 0xFF, 0x83, 0xFF, 0x83, 0xFF, 0xC3, 0xFF, 0x03, 0xFC,
  0x03, 0xF0, 0x3F, 0xC3, 0xFF, 0x7F, 0xFB, 0xFF, 0x8F, 0xF8, 0x3F, 0x80,
  0xF8, 0x03, 0x80, 0x08, 0x00, 0x00, 0x0F, 0xE0, 0x7F, 0xF1, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0x1F, 0xFE, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x03, 0xF0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x3C, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0x87,
  0xE0, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x00, 0x78, 0x0F, 0x00, 0x07, 0xC1,
  0xE0, 0x00, 0x3C, 0x3E, 0x07, 0xC1, 0xC3, 0xC1, 0xFF, 0x1E, 0x3C, 0x3F,
  0xF1, 0xE7, 0x87, 0xFF, 0x1E, 0x78, 0x78, 0xF0, 0xE7, 0x8F, 0x8F, 0x0E,
  0x78, 0xF0, 0xF0, 0xEF, 0x8F, 0x0F, 0x0E, 0xF0, 0xF0, 0xF0, 0xEF, 0x1F,
  0x0F, 0x0E, 0xF1, 0xF0, 0xF0, 0xEF, 0x1F, 0x1F, 0x1E, 0xF1, 0xF1, 0xF1,
  0xEF, 0x1F, 0x1E, 0x1E, 0xF1, 0xF1, 0xF3, 0xCF, 0x8F, 0xFF, 0x7C, 0x78,
  0xFF, 0xFF, 0x87, 0x87, 0xE7, 0xF0, 0x78, 0x3C, 0x3E, 0x07, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xFC, 0x02, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x0F, 0xBF,
  0x00, 0x3F, 0x3E, 0x00, 0x7E, 0x7E, 0x00, 0xFC, 0xFC, 0x03, 0xF1, 0xF8,
  0x07, 0xE3, 0xF8, 0x0F, 0xC3, 0xF0, 0x3F, 0x87, 0xE0, 0x7F, 0xFF, 0xE0,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F,
  0x80, 0xFE, 0x7F, 0x00, 0xFC, 0xFE, 0x01, 0xFD, 0xFC, 0x03, 0xFF, 0xF0,
  0x07, 0xF0, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF,
  0xFF, 0xFD, 0xF8, 0x7F, 0xBF, 0x07, 0xF7, 0xE0, 0x7E, 0xFC, 0x0F, 0xDF,
  0x81, 0xFB, 0xF0, 0x7F, 0x7E, 0x3F, 0xCF, 0xFF, 0xF1, 0xFF, 0xFC, 0x3F,
  0xFF, 0xC7, 0xFF, 0xFC, 0xFC, 0x1F, 0xDF, 0x81, 0xFB, 0xF0, 0x3F, 0x7E,
  0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xBF, 0x07, 0xF7, 0xFF, 0xFE, 0xFF,
  0xFF, 0x9F, 0xFF, 0xF3, 0xFF, 0xFC, 0x7F, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x7F, 0xF0, 0x0F, 0xFF, 0x81, 0xFF, 0xFC, 0x3F, 0xFF, 0xE3, 0xF8, 0xFE,
  0x7F, 0x07, 0xF7, 0xE0, 0x3F, 0x7E, 0x03, 0xF7, 0xE0, 0x3F, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x03, 0xF7, 0xE0, 0x3F, 0x7E,
  0x03, 0xF7, 0xF0, 0x7F, 0x3F, 0x8F, 0xF3, 0xFF, 0xFE, 0x1F, 0xFF, 0xC0,
  0xFF, 0xFC, 0x07, 0xFF, 0x00, 0x1F, 0xC0, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F,
  0xFF, 0xE3, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0x1F, 0xEF, 0xC1, 0xFF, 0xF0,
  0x7F, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F,
  0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xC7, 0xFB, 0xFF,
  0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0x8F, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0x03, 0xFC, 0x01, 0xFF, 0xE0, 0x7F, 0xFE, 0x1F, 0xFF, 0xE7,
  0xFF, 0xFC, 0xFE, 0x1F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFF,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x7F, 0xFF,
  0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0x1F, 0xFE,
  0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xDF, 0xC3, 0xFB, 0xFF, 0xFF, 0x3F,
  0xFF, 0xE3, 0xFF, 0xF8, 0x3F, 0xFE, 0x01, 0xFE, 0x00, 0xFC, 0x07, 0xFF,
  0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F,
  0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC,
  0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF,
  0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFE, 0x3F, 0xFE, 0x7F, 0x7F, 0xFE, 0x7F, 0xFE, 0x3F, 0xFC,
  0x1F, 0xF8, 0x07, 0xE0, 0xFC, 0x0F, 0xFF, 0xC1, 0xFE, 0xFC, 0x1F, 0xEF,
  0xC3, 0xFC, 0xFC, 0x3F, 0x8F, 0xC3, 0xF8, 0xFC, 0x7F, 0x0F, 0xC7, 0xF0,
  0xFC, 0xFE, 0x0F, 0xCF, 0xC0, 0xFD, 0xFC, 0x0F, 0xDF, 0x80, 0xFF, 0xF8,
  0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x0F, 0xE7, 0xF0, 0xFE, 0x7F, 0x8F, 0xC3, 0xF8, 0xFC,
  0x3F, 0x8F, 0xC3, 0xFC, 0xFC, 0x1F, 0xCF, 0xC1, 0xFE, 0xFC, 0x0F, 0xEF,
  0xC0, 0xFF, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x87,
  0xBF, 0xFF, 0xE3, 0xEF, 0xFF, 0x78, 0xFB, 0xFF, 0xDF, 0x3F, 0xFF, 0xF7,
  0xCF, 0x7F, 0xFC, 0xF7, 0xDF, 0xFF, 0x3D, 0xF7, 0xFF, 0xCF, 0xF9, 0xFF,
  0xF3, 0xFE, 0x7F, 0xFC, 0x7F, 0x9F, 0xFF, 0x1F, 0xE7, 0xFF, 0xC7, 0xF1,
  0xFF, 0xF1, 0xFC, 0x7F, 0xFC, 0x3F, 0x1F, 0xFF, 0x0F, 0xC7, 0xFF, 0xC3,
  0xE1, 0xFF, 0xF0, 0xF8, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07,
  0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0x87, 0xFF, 0xF8,
  0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0xE7, 0xFF, 0xDE, 0x7F, 0xFD,
  0xE7, 0xFF, 0xCF, 0x7F, 0xFC, 0xF7, 0xFF, 0xCF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF,
  0xFC, 0x1F, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x07,
  0xFF, 0xC0, 0x7F, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xF0, 0x3F,
  0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xE7, 0xF9, 0xFC, 0x1F, 0xCF, 0xE0, 0x7E,
  0x7E, 0x03, 0xFB, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0,
  0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF,
  0xF0, 0x1F, 0xDF, 0x80, 0xFE, 0xFC, 0x07, 0xF7, 0xF0, 0x3F, 0xBF, 0x83,
  0xF8, 0xFF, 0x3F, 0xC7, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x7F, 0xFE, 0x01,
  0xFF, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC,
  0x7F, 0xFF, 0xCF, 0xFF, 0xFD, 0xF8, 0x3F, 0xBF, 0x03, 0xFF, 0xE0, 0x7F,
  0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC1, 0xFD,
  0xFF, 0xFF, 0xBF, 0xFF, 0xE7, 0xFF, 0xF8, 0xFF, 0xFE, 0x1F, 0xFF, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xC3, 0xFF,
  0xFE, 0x1F, 0xE7, 0xF9, 0xFC, 0x1F, 0xCF, 0xE0, 0x7F, 0x7E, 0x03, 0xFB,
  0xF0, 0x1F, 0xDF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01,
  0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFB, 0xF0, 0x1F, 0xDF,
  0x80, 0xFE, 0xFC, 0x07, 0xF7, 0xF0, 0x3F, 0xBF, 0x83, 0xF8, 0xFF, 0x3F,
  0xC7, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x7F, 0xFE, 0x01, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x3C,
  0x00, 0x00, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF,
  0xCF, 0xFF, 0xFD, 0xF8, 0x7F, 0xBF, 0x07, 0xF7, 0xE0, 0x7E, 0xFC, 0x0F,
  0xDF, 0x81, 0xFB, 0xF0, 0x3F, 0x7E, 0x0F, 0xEF, 0xC3, 0xFD, 0xFF, 0xFF,
  0x3F, 0xFF, 0xE7, 0xFF, 0xF8, 0xFF, 0xFE, 0x1F, 0xFF, 0xC3, 0xF3, 0xF8,
  0x7E, 0x3F, 0x8F, 0xC7, 0xF1, 0xF8, 0x7F, 0x3F, 0x0F, 0xE7, 0xE1, 0xFC,
  0xFC, 0x1F, 0xDF, 0x83, 0xFB, 0xF0, 0x3F, 0xFE, 0x07, 0xF0, 0x01, 0xF8,
  0x01, 0xFF, 0xC0, 0x7F, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0xFF, 0x3F,
  0xDF, 0xC3, 0xFB, 0xF8, 0x7F, 0x7F, 0x07, 0xEF, 0xE0, 0x00, 0xFF, 0x00,
  0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFE,
  0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFE,
  0xFC, 0x1F, 0xDF, 0xC3, 0xFB, 0xFF, 0xFE, 0x3F, 0xFF, 0xC3, 0xFF, 0xF0,
  0x3F, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x07,
  0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F,
  0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F,
  0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F,
  0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x1F, 0xBF, 0xC7, 0xF3, 0xFF, 0xFE,
  0x7F, 0xFF, 0x87, 0xFF, 0xE0, 0x7F, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x01,
  0xFC, 0xFE, 0x03, 0xF9, 0xFC, 0x07, 0xF3, 0xF8, 0x0F, 0xE7, 0xF0, 0x3F,
  0x87, 0xF0, 0x7F, 0x0F, 0xE0, 0xFE, 0x1F, 0xC1, 0xFC, 0x1F, 0x83, 0xF0,
  0x3F, 0x0F, 0xE0, 0x7F, 0x1F, 0xC0, 0xFE, 0x3F, 0x00, 0xFC, 0x7E, 0x01,
  0xF8, 0xFC, 0x03, 0xF3, 0xF8, 0x07, 0xF7, 0xE0, 0x07, 0xEF, 0xC0, 0x0F,
  0xDF, 0x80, 0x1F, 0xBF, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0xFC, 0x1F, 0x07, 0xFF, 0x87,
  0xE0, 0xFF, 0xF0, 0xFE, 0x3F, 0xFF, 0x1F, 0xC7, 0xFF, 0xE3, 0xF8, 0xFE,
  0xFC, 0x7F, 0x1F, 0x9F, 0x8F, 0xE3, 0xF3, 0xF3, 0xFE, 0x7E, 0x7E, 0x7F,
  0xCF, 0xCF, 0xCF, 0xFB, 0xF9, 0xFD, 0xFF, 0x7F, 0x1F, 0xBF, 0xEF, 0xC3,
  0xFF, 0xFD, 0xF8, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFB, 0xFF, 0x83, 0xFF, 0x7F, 0xE0, 0x7F, 0xEF, 0xFC, 0x0F,
  0xFD, 0xFF, 0x81, 0xFF, 0x3F, 0xF0, 0x3F, 0xE3, 0xFE, 0x07, 0xFC, 0x7F,
  0xC0, 0x7F, 0x8F, 0xF0, 0x0F, 0xF1, 0xFE, 0x01, 0xFE, 0x3F, 0xC0, 0x3F,
  0x83, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x03, 0xF9, 0xFC, 0x0F, 0xE3,
  0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xE0, 0x7F, 0x3F, 0x81, 0xFC,
  0xFE, 0x03, 0xF3, 0xF0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x03, 0xFF,
  0xF0, 0x0F, 0xCF, 0xC0, 0x7F, 0x3F, 0x81, 0xFC, 0xFE, 0x0F, 0xE1, 0xFC,
  0x3F, 0x87, 0xF1, 0xFE, 0x1F, 0xE7, 0xF0, 0x3F, 0xBF, 0xC0, 0xFE, 0xFE,
  0x03, 0xFB, 0xF8, 0x1F, 0xDF, 0xC0, 0xFC, 0x7E, 0x0F, 0xE3, 0xF8, 0x7F,
  0x1F, 0xC3, 0xF0, 0x7E, 0x3F, 0x83, 0xF1, 0xF8, 0x0F, 0xCF, 0xC0, 0x7E,
  0x7E, 0x03, 0xF7, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F,
  0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0,
  0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC,
  0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC,
  0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x03,
  0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x00,
  0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F,
  0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F,
  0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x0F, 0x80, 0x3F, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0xE0, 0x7F,
  0x83, 0xFE, 0x0F, 0x7C, 0x3C, 0xF1, 0xF3, 0xC7, 0x8F, 0x9E, 0x1E, 0xF8,
  0x7B, 0xE1, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0x07, 0xE0,
  0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0x7F, 0xFE, 0xFE, 0x7F, 0xFE, 0x7F,
  0x00, 0x7F, 0x07, 0xFF, 0x3F, 0xFF, 0x7F, 0xFF, 0x7F, 0x7F, 0xFE, 0x7F,
  0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0x3F, 0xBF, 0x1F, 0x3F, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFD, 0xF0, 0xFF, 0xFC,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0x7F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC,
  0xF9, 0xF0, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0x7F, 0xFE,
  0x7E, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x3F, 0xFC, 0x3F, 0x7E, 0x3F, 0x7F, 0xFE,
  0x7F, 0xFE, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x0F, 0xBF, 0x9F, 0xFF, 0xCF, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xF1, 0xFF, 0xF8, 0xFF, 0xF8, 0x7F, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0x0F,
  0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0xFC, 0x7F, 0x7F,
  0xFF, 0xBF, 0xFF, 0xCF, 0xFF, 0xE7, 0xFB, 0xF0, 0xF9, 0xF8, 0x07, 0xF0,
  0x0F, 0xFE, 0x0F, 0xFF, 0x87, 0xFF, 0xE7, 0xFF, 0xF3, 0xF1, 0xFD, 0xF8,
  0x7F, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x1C, 0x7F, 0xFE, 0x1F, 0xFF,
  0x8F, 0xFF, 0xC1, 0xFF, 0xC0, 0x3F, 0x80, 0x01, 0xF8, 0x3F, 0xC3, 0xFE,
  0x1F, 0xF1, 0xFF, 0x8F, 0xE0, 0x7E, 0x03, 0xF0, 0xFF, 0xF7, 0xFF, 0xBF,
  0xFD, 0xFF, 0xE1, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x00, 0x0F, 0xDF, 0x8F, 0xFF, 0xCF,
  0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF1, 0xFF, 0xF8, 0x7F, 0xF8, 0x3F,
  0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0,
  0xFF, 0xF8, 0x7E, 0xFC, 0x3F, 0x7F, 0xFF, 0xBF, 0xFF, 0xCF, 0xFF, 0xE3,
  0xFF, 0xF0, 0xF9, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x30, 0x7F, 0x1F, 0xFF,
  0x1F, 0xFF, 0x8F, 0xFF, 0x83, 0xFF, 0x80, 0x7F, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0xF0, 0xFF, 0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFC,
  0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC,
  0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC,
  0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0x7B, 0xFF, 0xFF, 0xFD, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0x0F, 0xC7, 0xE3, 0xF1, 0xF8, 0x78,
  0x00, 0x00, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F,
  0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3,
  0xF1, 0xF8, 0xFC, 0x7E, 0x7F, 0xFF, 0xFF, 0xFF, 0xDF, 0xCF, 0x80, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x7F, 0xFE, 0x3F, 0xBF, 0x3F, 0x9F, 0x9F,
  0xCF, 0xDF, 0xC7, 0xEF, 0xC3, 0xFF, 0xE1, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F,
  0xF8, 0x3F, 0xFC, 0x1F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0xE3, 0xF3, 0xF1,
  0xF9, 0xFC, 0xFC, 0xFE, 0x7E, 0x3F, 0xBF, 0x1F, 0xDF, 0x87, 0xFF, 0xC3,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC,
  0xF8, 0x7C, 0x7E, 0xFE, 0x7F, 0x3F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xF3, 0xF9, 0xFF, 0xF1, 0xF8, 0x7F, 0xF8, 0xFE, 0x3F,
  0xFC, 0x7F, 0x1F, 0xFE, 0x3F, 0x8F, 0xFF, 0x1F, 0xC7, 0xFF, 0x8F, 0xE3,
  0xFF, 0xC7, 0xF1, 0xFF, 0xE3, 0xF8, 0xFF, 0xF1, 0xFC, 0x7F, 0xF8, 0xFE,
  0x3F, 0xFC, 0x7F, 0x1F, 0xFE, 0x3F, 0x8F, 0xFF, 0x1F, 0xC7, 0xFF, 0x8F,
  0xE3, 0xFF, 0xC7, 0xF1, 0xF8, 0xF8, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC,
  0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC,
  0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0x07,
  0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x87, 0xFF, 0xE7, 0xFF, 0xF3, 0xF1, 0xFF,
  0xF8, 0x7F, 0xFC, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83,
  0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF8, 0x7E, 0xFC, 0x7F, 0x7F, 0xFF, 0x1F,
  0xFF, 0x8F, 0xFF, 0x83, 0xFF, 0x80, 0x7F, 0x00, 0xFD, 0xF0, 0xFF, 0xFC,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0x7F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC,
  0xFD, 0xF0, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x0F, 0x9F, 0x9F, 0xEF, 0xCF, 0xFF,
  0xEF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF1, 0xFF, 0xF8, 0xFF, 0xF8, 0x7F, 0xFC,
  0x3F, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF,
  0xF8, 0xFF, 0xFC, 0x7F, 0x7F, 0xFF, 0xBF, 0xFF, 0xCF, 0xFF, 0xE7, 0xFF,
  0xF0, 0xFB, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0xFC, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC0, 0x0F, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0x7E, 0x7E, 0xFC,
  0x7E, 0xFC, 0x7F, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0xF0, 0x3F, 0xF8, 0x0F,
  0xFC, 0x03, 0xFE, 0x00, 0xFE, 0xFC, 0x7E, 0xFC, 0x7E, 0xFE, 0x7E, 0x7F,
  0xFE, 0x7F, 0xFC, 0x1F, 0xF8, 0x0F, 0xE0, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F,
  0x87, 0xF1, 0xFF, 0xBF, 0xF7, 0xFE, 0xFF, 0xCF, 0xE1, 0xFC, 0x3F, 0x87,
  0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x83, 0xF0,
  0x7F, 0xCF, 0xF9, 0xFF, 0x1F, 0xE0, 0xF8, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC,
  0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC,
  0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC,
  0x7F, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0x7F, 0xBF, 0x1F,
  0x3F, 0xFE, 0x1F, 0x9F, 0x87, 0xE7, 0xE1, 0xF9, 0xF8, 0xFE, 0x7F, 0x3F,
  0x0F, 0xCF, 0xC3, 0xF3, 0xF0, 0xFC, 0xFC, 0x1F, 0x3E, 0x07, 0xDF, 0x81,
  0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F,
  0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xF0,
  0x00, 0xFC, 0x78, 0x7F, 0xF8, 0xF8, 0xFF, 0xF3, 0xF3, 0xF7, 0xE7, 0xE7,
  0xEF, 0xCF, 0xCF, 0xCF, 0x9F, 0x9F, 0x9F, 0x3F, 0xBF, 0x3E, 0xFF, 0x7C,
  0x7D, 0xFE, 0xF8, 0xFF, 0xFD, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0x7F, 0xC3,
  0xFE, 0xFF, 0x07, 0xF9, 0xFE, 0x0F, 0xF3, 0xFC, 0x1F, 0xE7, 0xF8, 0x1F,
  0xC7, 0xF0, 0x3F, 0x0F, 0xE0, 0x7E, 0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF8,
  0x7E, 0x00, 0x7E, 0x1F, 0x9F, 0xCF, 0xE3, 0xF3, 0xF0, 0xFC, 0xFC, 0x1F,
  0xFF, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xF0, 0x0F, 0xFC, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x81, 0xFF, 0xE0,
  0x7F, 0xF8, 0x3F, 0x3F, 0x0F, 0xCF, 0xC7, 0xF3, 0xF9, 0xF8, 0x7E, 0x7E,
  0x1F, 0x80, 0xFE, 0x1F, 0xDF, 0x87, 0xE7, 0xE1, 0xF9, 0xFC, 0xFE, 0x7F,
  0x3F, 0x8F, 0xCF, 0xC3, 0xF3, 0xF0, 0xFD, 0xFC, 0x1F, 0xFE, 0x07, 0xFF,
  0x81, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0,
  0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x1F, 0xE0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0xFE, 0xFF, 0xFD,
  0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xFC, 0x03,
  0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xE0,
  0x1F, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x01, 0x03, 0xC3, 0xE3, 0xF1, 0xF0, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F,
  0xC7, 0xE3, 0xF1, 0xF8, 0xF8, 0x7C, 0x7E, 0x7E, 0x3E, 0x1F, 0x8F, 0xC3,
  0xF0, 0xF8, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x3E,
  0x1F, 0x0F, 0xC3, 0xE0, 0xF0, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x60,
  0x1C, 0x0F, 0x83, 0xF0, 0x7C, 0x1F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xFC, 0x1F, 0x87, 0xF0, 0xFC, 0x3F,
  0x1F, 0xCF, 0xC3, 0xF0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F,
  0x83, 0xE0, 0xF8, 0x7C, 0x3F, 0x0F, 0x81, 0xC0, 0x60, 0x00, 0x1E, 0x00,
  0x1F, 0xC3, 0xDF, 0xE1, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xC3,
  0xFD, 0xE0, 0xFC, 0x00, 0x3C, 0x00,
};

const GFXglyph RobotoCondensed_Black39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 7, 28, 10, 2, -28 },
  { 26, 12, 11, 12, 0, -29 },
  { 43, 18, 28, 20, 1, -28 },
  { 106, 16, 36, 20, 2, -32 },
  { 178, 21, 28, 25, 2, -28 },
  { 252, 21, 28, 23, 1, -28 },
  { 326, 4, 11, 6, 1, -29 },
  { 332, 10, 40, 13, 2, -31 },
  { 382, 10, 40, 13, 1, -31 },
  { 432, 17, 17, 18, 1, -28 },
  { 469, 16, 20, 18, 1, -23 },
  { 509, 7, 12, 11, 1, -5 },
  { 520, 10, 5, 16, 3, -14 },
  { 527, 7, 6, 12, 2, -6 },
  { 533, 12, 30, 12, 0, -28 },
  { 578, 16, 28, 20, 2, -28 },
  { 634, 11, 28, 20, 3, -28 },
  { 673, 17, 28, 20, 1, -28 },
  { 733, 17, 28, 20, 1, -28 },
  { 793, 18, 28, 20, 1, -28 },
  { 856, 17, 28, 20, 1, -28 },
  { 916, 17, 28, 20, 2, -28 },
  { 976, 17, 28, 20, 1, -28 },
  { 1036, 16, 28, 20, 2, -28 },
  { 1092, 16, 28, 20, 2, -28 },
  { 1148, 7, 21, 11, 2, -21 },
  { 1167, 8, 28, 11, 1, -21 },
  { 1195, 14, 19, 17, 1, -21 },
  { 1229, 15, 14, 20, 2, -19 },
  { 1256, 14, 19, 18, 2, -21 },
  { 1290, 15, 28, 18, 1, -28 },
  { 1343, 28, 36, 30, 1, -27 },
  { 1469, 23, 28, 24, 0, -28 },
  { 1550, 19, 28, 22, 2, -28 },
  { 1617, 20, 28, 22, 1, -28 },
  { 1687, 18, 28, 22, 2, -28 },
  { 1750, 16, 28, 19, 2, -28 },
  { 1806, 16, 28, 19, 2, -28 },
  { 1862, 19, 28, 23, 2, -28 },
  { 1929, 20, 28, 24, 2, -28 },
  { 1999, 7, 28, 11, 2, -28 },
  { 2024, 16, 28, 19, 1, -28 },
  { 2080, 20, 28, 22, 2, -28 },
  { 2150, 16, 28, 19, 2, -28 },
  { 2206, 26, 28, 30, 2, -28 },
  { 2297, 20, 28, 24, 2, -28 },
  { 2367, 21, 28, 24, 1, -28 },
  { 2441, 19, 28, 22, 2, -28 },
  { 2508, 21, 33, 24, 1, -28 },
  { 2595, 19, 28, 22, 2, -28 },
  { 2662, 19, 28, 21, 1, -28 },
  { 2729, 20, 28, 22, 1, -28 },
  { 2799, 19, 28, 23, 2, -28 },
  { 2866, 23, 28, 23, 0, -28 },
  { 2947, 27, 28, 29, 1, -28 },
  { 3042, 22, 28, 22, 0, -28 },
  { 3119, 21, 28, 22, 0, -28 },
  { 3193, 19, 28, 21, 1, -28 },
  { 3260, 8, 39, 10, 2, -32 },
  { 3299, 16, 30, 15, 0, -28 },
  { 3359, 8, 39, 10, 1, -32 },
  { 3398, 14, 14, 16, 1, -28 },
  { 3423, 15, 5, 15, 0, 0 },
  { 3433, 11, 6, 13, 1, -29 },
  { 3442, 16, 21, 18, 1, -21 },
  { 3484, 16, 29, 19, 2, -29 },
  { 3542, 16, 21, 18, 1, -21 },
  { 3584, 17, 29, 19, 1, -29 },
  { 3646, 17, 21, 19, 1, -21 },
  { 3691, 13, 29, 13, 0, -29 },
  { 3739, 17, 29, 20, 1, -21 },
  { 3801, 16, 29, 19, 2, -29 },
  { 3859, 6, 29, 10, 2, -29 },
  { 3881, 9, 37, 10, -1, -29 },
  { 3923, 17, 29, 19, 2, -29 },
  { 3985, 6, 29, 10, 2, -29 },
  { 4007, 25, 21, 29, 2, -21 },
  { 4073, 16, 21, 19, 2, -21 },
  { 4115, 17, 21, 19, 1, -21 },
  { 4160, 16, 29, 19, 2, -21 },
  { 4218, 17, 29, 19, 1, -21 },
  { 4280, 11, 21, 13, 2, -21 },
  { 4309, 16, 21, 18, 1, -21 },
  { 4351, 11, 26, 12, 1, -26 },
  { 4387, 16, 21, 19, 2, -21 },
  { 4429, 18, 21, 18, 0, -21 },
  { 4477, 23, 21, 24, 1, -21 },
  { 4538, 18, 21, 18, 0, -21 },
  { 4586, 18, 29, 18, 0, -21 },
  { 4652, 15, 21, 18, 1, -21 },
  { 4692, 9, 37, 11, 1, -30 },
  { 4734, 4, 33, 10, 3, -28 },
  { 4751, 10, 37, 11, 1, -30 },
  { 4798, 17, 9, 21, 2, -16 },
};

const GFXfont RobotoCondensed_Black39pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Black39pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Black39pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _ROBOTOCONDENSED_BLACK39PT7B_H_
