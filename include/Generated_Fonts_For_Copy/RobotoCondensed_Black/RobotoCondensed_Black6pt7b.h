#ifndef _ROBOTOCONDENSED_BLACK6PT7B_H_
#define _ROBOTOCONDENSED_BLACK6PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Black.ttf
// Size: 6pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Black6pt7bBitmaps[] PROGMEM = {
  0x00, 0xF0, 0xF0, 0x4B, 0xA0, 0x55, 0x1E, 0x80, 0xE4, 0x63, 0xEB, 0xF0,
  0xC0, 0x6A, 0x90, 0xA5, 0x60, 0xE8, 0x49, 0x20, 0xC0, 0xC0, 0x80, 0x5A,
  0xF6, 0xB0, 0xD5, 0xE5, 0x70, 0xEC, 0xF0, 0x6F, 0x90, 0xF8, 0xF0, 0x5E,
  0xB0, 0xE9, 0x20, 0xEE, 0xF0, 0xF5, 0xA0, 0xA0, 0x90, 0x70, 0xFC, 0xCE,
  0x00, 0xC9, 0x20, 0x7B, 0xFF, 0xE0, 0x66, 0xEA, 0xFE, 0xF0, 0xF2, 0x30,
  0xF6, 0xF0, 0xFE, 0x70, 0xF2, 0x40, 0xF2, 0xB0, 0xBE, 0xD0, 0xF0, 0x24,
  0xE0, 0xBB, 0xD0, 0x92, 0x70, 0xDD, 0xBB, 0xFE, 0xD0, 0xF6, 0xB0, 0xF7,
  0x40, 0xF6, 0xB2, 0xF7, 0xD0, 0xF8, 0xF0, 0xE9, 0x20, 0xB6, 0xF0, 0xAD,
  0xA0, 0xBF, 0x77, 0xAD, 0xD0, 0xAD, 0x20, 0xE9, 0x70, 0xEA, 0xB0, 0x95,
  0xFC, 0x70, 0xC0, 0x80, 0xFF, 0x80, 0x93, 0xDE, 0xF3, 0x00, 0x27, 0xDE,
  0xFF, 0x80, 0x6E, 0x80, 0xF7, 0xB0, 0x93, 0xDA, 0x70, 0x78, 0x93, 0x6A,
  0xF8, 0xFB, 0xB0, 0xF6, 0x80, 0xF7, 0x80, 0xF7, 0xC0, 0xF7, 0x90, 0xE8,
  0xEB, 0x00, 0xBB, 0xB7, 0x80, 0xB9, 0x00, 0xDE, 0x60, 0xCA, 0x80, 0xA9,
  0x20, 0xCB, 0x80, 0x2A, 0x90, 0xF8, 0xA9, 0xA0, 0xE0,
};

const GFXglyph RobotoCondensed_Black6pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 1, 0, -1 },
  { 1, 1, 4, 2, 0, -4 },
  { 2, 2, 2, 2, 0, -5 },
  { 3, 3, 4, 3, 0, -4 },
  { 5, 3, 6, 3, 0, -5 },
  { 8, 4, 4, 4, 0, -4 },
  { 10, 3, 4, 4, 0, -4 },
  { 12, 1, 2, 1, 0, -5 },
  { 13, 2, 6, 2, 0, -5 },
  { 15, 2, 6, 2, 0, -5 },
  { 17, 3, 2, 3, 0, -4 },
  { 18, 3, 4, 3, 0, -4 },
  { 20, 1, 2, 2, 0, -1 },
  { 21, 2, 1, 3, 0, -2 },
  { 22, 1, 1, 2, 0, -1 },
  { 23, 2, 4, 2, 0, -4 },
  { 24, 3, 4, 3, 0, -4 },
  { 26, 2, 4, 3, 0, -4 },
  { 27, 3, 4, 3, 0, -4 },
  { 29, 3, 4, 3, 0, -4 },
  { 31, 3, 4, 3, 0, -4 },
  { 33, 3, 4, 3, 0, -4 },
  { 35, 3, 4, 3, 0, -4 },
  { 37, 3, 4, 3, 0, -4 },
  { 39, 3, 4, 3, 0, -4 },
  { 41, 3, 4, 3, 0, -4 },
  { 43, 1, 3, 2, 0, -3 },
  { 44, 1, 4, 2, 0, -3 },
  { 45, 2, 3, 3, 0, -3 },
  { 46, 3, 2, 3, 0, -3 },
  { 47, 3, 3, 3, 0, -3 },
  { 49, 3, 4, 3, 0, -4 },
  { 51, 4, 5, 5, 0, -4 },
  { 54, 4, 4, 4, 0, -4 },
  { 56, 3, 4, 3, 0, -4 },
  { 58, 3, 4, 3, 0, -4 },
  { 60, 3, 4, 3, 0, -4 },
  { 62, 3, 4, 3, 0, -4 },
  { 64, 3, 4, 3, 0, -4 },
  { 66, 3, 4, 4, 0, -4 },
  { 68, 3, 4, 4, 0, -4 },
  { 70, 1, 4, 2, 0, -4 },
  { 71, 3, 4, 3, 0, -4 },
  { 73, 3, 4, 3, 0, -4 },
  { 75, 3, 4, 3, 0, -4 },
  { 77, 4, 4, 5, 0, -4 },
  { 79, 3, 4, 4, 0, -4 },
  { 81, 3, 4, 4, 0, -4 },
  { 83, 3, 4, 3, 0, -4 },
  { 85, 3, 5, 4, 0, -4 },
  { 87, 3, 4, 3, 0, -4 },
  { 89, 3, 4, 3, 0, -4 },
  { 91, 3, 4, 3, 0, -4 },
  { 93, 3, 4, 3, 0, -4 },
  { 95, 3, 4, 4, 0, -4 },
  { 97, 4, 4, 4, 0, -4 },
  { 99, 3, 4, 3, 0, -4 },
  { 101, 3, 4, 3, 0, -4 },
  { 103, 3, 4, 3, 0, -4 },
  { 105, 2, 6, 2, 0, -5 },
  { 107, 2, 4, 2, 0, -4 },
  { 108, 1, 6, 2, 0, -5 },
  { 109, 2, 2, 2, 0, -4 },
  { 110, 2, 1, 2, 0, 0 },
  { 111, 2, 1, 2, 0, -5 },
  { 112, 3, 3, 3, 0, -3 },
  { 114, 3, 5, 3, 0, -5 },
  { 116, 3, 3, 3, 0, -3 },
  { 118, 3, 5, 3, 0, -5 },
  { 120, 3, 3, 3, 0, -3 },
  { 122, 2, 5, 2, 0, -5 },
  { 124, 3, 4, 3, 0, -3 },
  { 126, 3, 5, 3, 0, -5 },
  { 128, 1, 4, 2, 0, -4 },
  { 129, 1, 5, 2, 0, -4 },
  { 130, 3, 5, 3, 0, -5 },
  { 132, 1, 5, 2, 0, -5 },
  { 133, 4, 3, 4, 0, -3 },
  { 135, 3, 3, 3, 0, -3 },
  { 137, 3, 3, 3, 0, -3 },
  { 139, 3, 4, 3, 0, -3 },
  { 141, 3, 4, 3, 0, -3 },
  { 143, 2, 3, 2, 0, -3 },
  { 144, 3, 3, 3, 0, -3 },
  { 146, 2, 4, 2, 0, -4 },
  { 147, 3, 3, 3, 0, -3 },
  { 149, 3, 3, 3, 0, -3 },
  { 151, 4, 3, 4, 0, -3 },
  { 153, 3, 3, 3, 0, -3 },
  { 155, 3, 4, 3, 0, -3 },
  { 157, 3, 3, 3, 0, -3 },
  { 159, 2, 6, 2, 0, -5 },
  { 161, 1, 5, 2, 0, -4 },
  { 162, 2, 6, 2, 0, -5 },
  { 164, 3, 1, 3, 0, -2 },
};

const GFXfont RobotoCondensed_Black6pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Black6pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Black6pt7bGlyphs,
  0x20, 0x7E, 7
};

#endif // _ROBOTOCONDENSED_BLACK6PT7B_H_
