#ifndef _ROBOTOCONDENSED_BLACK10PT7B_H_
#define _ROBOTOCONDENSED_BLACK10PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Black.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Black10pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x14, 0xB6, 0x80, 0x31, 0x9E, 0xAF, 0x31, 0x80, 0x23, 0x96,
  0x87, 0x0F, 0x6E, 0x20, 0x62, 0xA7, 0x04, 0x3C, 0xD1, 0xC0, 0x71, 0x45,
  0x1A, 0xFB, 0x67, 0x80, 0xE0, 0x6A, 0xAA, 0x90, 0x89, 0x36, 0xDA, 0x50,
  0x27, 0x98, 0xA0, 0x22, 0xF2, 0x20, 0x5C, 0xC0, 0xC0, 0x25, 0x24, 0xA4,
  0x72, 0xF7, 0xBD, 0xAD, 0xC0, 0x7D, 0xB6, 0xD8, 0x76, 0xC6, 0x62, 0x33,
  0xE0, 0x76, 0xC6, 0x61, 0xED, 0xC0, 0x31, 0x9C, 0xA5, 0x7C, 0x40, 0x72,
  0x1C, 0x31, 0xED, 0xC0, 0x33, 0x1D, 0xBD, 0xAD, 0xC0, 0xF8, 0x84, 0x62,
  0x31, 0x80, 0x72, 0xD4, 0xED, 0xED, 0xC0, 0x72, 0xB6, 0xB7, 0x99, 0x80,
  0xCC, 0x50, 0x17, 0x1E, 0xE1, 0xE3, 0x80, 0x9F, 0xC0, 0x7D, 0x13, 0x62,
  0x60, 0x3C, 0x85, 0x6D, 0xDA, 0xB5, 0x5F, 0xA0, 0x38, 0x30, 0xC7, 0x9E,
  0x49, 0xFC, 0xC0, 0xFE, 0xF7, 0xFC, 0xEF, 0xE0, 0x72, 0xF3, 0x8C, 0xAD,
  0xC0, 0xF6, 0xF3, 0x9C, 0xEF, 0xC0, 0xFE, 0x31, 0xEC, 0x63, 0xE0, 0xFE,
  0x31, 0xEC, 0x63, 0x00, 0x79, 0x2C, 0x37, 0xCD, 0xB7, 0x80, 0xCF, 0x3C,
  0xFF, 0xCF, 0x3C, 0xC0, 0xFE, 0x11, 0x11, 0x1D, 0x70, 0xDB, 0x6F, 0x3C,
  0xF3, 0x6D, 0x80, 0xC6, 0x31, 0x8C, 0x63, 0xE0, 0xE7, 0xCF, 0xBF, 0x5D,
  0xFB, 0xF5, 0x80, 0xCF, 0xBE, 0xF7, 0xDF, 0x7C, 0xC0, 0x79, 0x2C, 0xF3,
  0xCD, 0x27, 0x80, 0xF6, 0xF3, 0xBF, 0xE3, 0x00, 0x79, 0xAC, 0xF3, 0xCD,
  0x27, 0x82, 0xFE, 0xF3, 0xBF, 0x6F, 0x60, 0x72, 0xD0, 0xE1, 0xED, 0xE0,
  0xF9, 0x8C, 0x63, 0x18, 0xC0, 0xCE, 0x73, 0x9C, 0xAD, 0xE0, 0xCF, 0x25,
  0x9E, 0x78, 0xC3, 0x00, 0xD3, 0xBD, 0x7B, 0xF7, 0xCD, 0x9B, 0x00, 0xD9,
  0xE7, 0x0C, 0x71, 0xED, 0x80, 0xCA, 0xDC, 0x63, 0x18, 0xC0, 0xF8, 0xCC,
  0x66, 0x23, 0xE0, 0xFB, 0x6D, 0xB6, 0xDC, 0xCC, 0x46, 0x62, 0x33, 0xD5,
  0x55, 0x70, 0x66, 0x6D, 0xF0, 0x4C, 0x7D, 0x7D, 0x70, 0xC6, 0x31, 0xED,
  0xEF, 0x7E, 0x7D, 0xCD, 0x70, 0x18, 0xC6, 0xFD, 0xEF, 0x6F, 0x76, 0xFF,
  0x87, 0x00, 0x69, 0x74, 0x92, 0x7E, 0xF7, 0xB7, 0x8D, 0xC0, 0xC6, 0x31,
  0xED, 0xEF, 0x7B, 0x71, 0x55, 0x71, 0x55, 0xF0, 0xC6, 0x31, 0xBF, 0x7B,
  0xDB, 0xFF, 0xFF, 0xBF, 0x5E, 0xBD, 0x60, 0xF6, 0xF7, 0xBD, 0x80, 0x76,
  0xF7, 0xB7, 0x00, 0xF6, 0xF7, 0xBF, 0x63, 0x00, 0x7E, 0xF7, 0xB7, 0x8C,
  0x60, 0xFF, 0x6C, 0x7D, 0x7D, 0x70, 0x4B, 0xA4, 0x98, 0xDE, 0xF7, 0xB7,
  0x80, 0xD6, 0x9C, 0xE6, 0x00, 0xFF, 0xF7, 0xDE, 0x68, 0xD3, 0x98, 0xED,
  0x00, 0xD7, 0x9C, 0xE6, 0x31, 0x00, 0xF3, 0x64, 0xF0, 0x29, 0x25, 0x92,
  0x4C, 0xFF, 0x89, 0x24, 0xD2, 0x50, 0x6F, 0xC0,
};

const GFXglyph RobotoCondensed_Black10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 7, 3, 0, -7 },
  { 3, 3, 3, 3, 0, -8 },
  { 5, 5, 7, 5, 0, -7 },
  { 10, 5, 9, 5, 0, -8 },
  { 16, 6, 7, 6, 0, -7 },
  { 22, 6, 7, 6, 0, -7 },
  { 28, 1, 3, 2, 0, -8 },
  { 29, 2, 10, 3, 1, -8 },
  { 32, 3, 10, 3, 0, -8 },
  { 36, 5, 4, 5, 0, -7 },
  { 39, 4, 5, 5, 0, -6 },
  { 42, 2, 3, 3, 0, -1 },
  { 43, 2, 1, 4, 1, -3 },
  { 44, 1, 2, 3, 1, -2 },
  { 45, 3, 8, 3, 0, -7 },
  { 48, 5, 7, 5, 0, -7 },
  { 53, 3, 7, 5, 1, -7 },
  { 56, 5, 7, 5, 0, -7 },
  { 61, 5, 7, 5, 0, -7 },
  { 66, 5, 7, 5, 0, -7 },
  { 71, 5, 7, 5, 0, -7 },
  { 76, 5, 7, 5, 0, -7 },
  { 81, 5, 7, 5, 0, -7 },
  { 86, 5, 7, 5, 0, -7 },
  { 91, 5, 7, 5, 0, -7 },
  { 96, 1, 6, 3, 1, -6 },
  { 97, 2, 8, 3, 0, -6 },
  { 99, 4, 4, 4, 0, -5 },
  { 101, 3, 3, 5, 1, -5 },
  { 103, 3, 4, 5, 1, -5 },
  { 105, 4, 7, 5, 0, -7 },
  { 109, 7, 9, 8, 0, -7 },
  { 117, 6, 7, 6, 0, -7 },
  { 123, 5, 7, 6, 0, -7 },
  { 128, 5, 7, 6, 0, -7 },
  { 133, 5, 7, 6, 0, -7 },
  { 138, 5, 7, 5, 0, -7 },
  { 143, 5, 7, 5, 0, -7 },
  { 148, 6, 7, 6, 0, -7 },
  { 154, 6, 7, 6, 0, -7 },
  { 160, 1, 7, 3, 1, -7 },
  { 161, 4, 7, 5, 0, -7 },
  { 165, 6, 7, 6, 0, -7 },
  { 171, 5, 7, 5, 0, -7 },
  { 176, 7, 7, 8, 0, -7 },
  { 183, 6, 7, 6, 0, -7 },
  { 189, 6, 7, 6, 0, -7 },
  { 195, 5, 7, 6, 0, -7 },
  { 200, 6, 8, 6, 0, -7 },
  { 206, 5, 7, 6, 0, -7 },
  { 211, 5, 7, 6, 0, -7 },
  { 216, 5, 7, 6, 0, -7 },
  { 221, 5, 7, 6, 0, -7 },
  { 226, 6, 7, 6, 0, -7 },
  { 232, 7, 7, 7, 0, -7 },
  { 239, 6, 7, 6, 0, -7 },
  { 245, 5, 7, 6, 0, -7 },
  { 250, 5, 7, 5, 0, -7 },
  { 255, 3, 10, 3, 0, -8 },
  { 259, 4, 8, 4, 0, -7 },
  { 263, 2, 10, 3, 0, -8 },
  { 266, 4, 4, 4, 0, -7 },
  { 268, 4, 1, 4, 0, 0 },
  { 269, 3, 2, 3, 0, -8 },
  { 270, 4, 5, 5, 0, -5 },
  { 273, 5, 8, 5, 0, -8 },
  { 278, 4, 5, 5, 0, -5 },
  { 281, 5, 8, 5, 0, -8 },
  { 286, 5, 5, 5, 0, -5 },
  { 290, 3, 8, 3, 0, -8 },
  { 293, 5, 7, 5, 0, -5 },
  { 298, 5, 8, 5, 0, -8 },
  { 303, 2, 8, 3, 0, -8 },
  { 305, 2, 10, 3, 0, -8 },
  { 308, 5, 8, 5, 0, -8 },
  { 313, 1, 8, 3, 1, -8 },
  { 314, 7, 5, 7, 0, -5 },
  { 319, 5, 5, 5, 0, -5 },
  { 323, 5, 5, 5, 0, -5 },
  { 327, 5, 7, 5, 0, -5 },
  { 332, 5, 7, 5, 0, -5 },
  { 337, 3, 5, 3, 0, -5 },
  { 339, 4, 5, 5, 0, -5 },
  { 342, 3, 7, 3, 0, -7 },
  { 345, 5, 5, 5, 0, -5 },
  { 349, 5, 5, 5, 0, -5 },
  { 353, 6, 5, 6, 0, -5 },
  { 357, 5, 5, 5, 0, -5 },
  { 361, 5, 7, 5, 0, -5 },
  { 366, 4, 5, 5, 0, -5 },
  { 369, 3, 10, 3, 0, -8 },
  { 373, 1, 8, 3, 1, -7 },
  { 374, 3, 10, 3, 0, -8 },
  { 378, 5, 2, 5, 0, -4 },
};

const GFXfont RobotoCondensed_Black10pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Black10pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Black10pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _ROBOTOCONDENSED_BLACK10PT7B_H_
