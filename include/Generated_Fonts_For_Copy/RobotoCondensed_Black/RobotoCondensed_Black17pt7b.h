#ifndef _ROBOTOCONDENSED_BLACK17PT7B_H_
#define _ROBOTOCONDENSED_BLACK17PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Black.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Black17pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFE, 0x1B, 0xE0, 0xDE, 0xF7, 0xBD, 0x80, 0x1E, 0x16,
  0x16, 0x7F, 0x7F, 0x34, 0x34, 0xFF, 0xFF, 0x2C, 0x2C, 0x68, 0x10, 0x20,
  0xE3, 0xEE, 0xFD, 0xF8, 0x3C, 0x3C, 0x1F, 0x3F, 0x7F, 0xEF, 0x84, 0x08,
  0x70, 0x79, 0x24, 0x92, 0xCF, 0x43, 0xE0, 0x7C, 0x2F, 0x35, 0x92, 0xC9,
  0xE0, 0xE0, 0x1C, 0x0F, 0x87, 0x61, 0xD8, 0x3E, 0x0F, 0x07, 0xD9, 0xF6,
  0xEF, 0x9D, 0xC7, 0xF8, 0xFE, 0xFF, 0xC0, 0x13, 0x66, 0xEC, 0xCC, 0xCC,
  0xCC, 0xE6, 0x63, 0x10, 0x43, 0x18, 0x63, 0x18, 0xE7, 0x39, 0xCE, 0x63,
  0x19, 0x8C, 0x40, 0x18, 0x18, 0xFB, 0x7E, 0x3C, 0x24, 0x24, 0x18, 0x30,
  0x67, 0xFF, 0xE3, 0x06, 0x0C, 0x66, 0x66, 0x40, 0xFF, 0xC0, 0x7F, 0x80,
  0x18, 0xC4, 0x63, 0x18, 0x8C, 0x63, 0x11, 0x8C, 0x00, 0x38, 0xFB, 0xBE,
  0x7C, 0xF9, 0xF3, 0xE7, 0xEF, 0xDD, 0xF1, 0xC0, 0x0B, 0xFF, 0x73, 0x9C,
  0xE7, 0x39, 0xCE, 0x70, 0x3C, 0x7E, 0x77, 0x67, 0x07, 0x0E, 0x0E, 0x1C,
  0x38, 0x70, 0x7F, 0x7F, 0x3C, 0x7E, 0x67, 0x07, 0x07, 0x1E, 0x1E, 0x07,
  0xE7, 0x77, 0x7E, 0x3C, 0x1C, 0x38, 0xF1, 0xE7, 0xCF, 0xB7, 0x7F, 0xFE,
  0x38, 0x70, 0xE0, 0xFF, 0xFF, 0x87, 0x0F, 0xDF, 0x83, 0x87, 0xCF, 0xDF,
  0xF3, 0xC0, 0x1C, 0xF9, 0xC7, 0x0F, 0xDF, 0xFB, 0xE7, 0xCF, 0xDD, 0xF1,
  0xC0, 0xFF, 0xFF, 0x07, 0x06, 0x0E, 0x0E, 0x1C, 0x1C, 0x1C, 0x38, 0x38,
  0x30, 0x79, 0xFB, 0xBF, 0x7E, 0xEF, 0x9F, 0x77, 0xCF, 0xDF, 0xF3, 0xC0,
  0x39, 0xFB, 0xBE, 0x7C, 0xFD, 0xFF, 0xBF, 0x0C, 0x39, 0xE3, 0x80, 0x7F,
  0x80, 0x03, 0xFC, 0xDF, 0x80, 0x00, 0xFF, 0xEC, 0x02, 0x3D, 0xFF, 0x8F,
  0x0F, 0xC7, 0x81, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x83, 0x8F, 0x8F, 0x3F,
  0xEE, 0x20, 0x3C, 0xFF, 0xBF, 0x70, 0xE3, 0x86, 0x0C, 0x00, 0x30, 0xE0,
  0xC0, 0x07, 0x81, 0xCE, 0x30, 0x62, 0x3B, 0x67, 0x96, 0xD9, 0x4D, 0x94,
  0xD9, 0x4D, 0x94, 0xDB, 0x4F, 0xB6, 0x6E, 0x60, 0x03, 0x00, 0x3F, 0x80,
  0xF8, 0x0E, 0x07, 0x81, 0xE0, 0x7C, 0x3F, 0x0E, 0xC3, 0x31, 0xCE, 0x7F,
  0x9F, 0xE6, 0x1F, 0x87, 0xFC, 0xFE, 0xE7, 0xE7, 0xE7, 0xFE, 0xFE, 0xE7,
  0xE7, 0xE7, 0xFE, 0xFC, 0x3C, 0x7F, 0xE7, 0xE7, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE7, 0xE7, 0x7F, 0x3C, 0xF8, 0xFE, 0xEE, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7,
  0xE7, 0xEE, 0xFE, 0xF8, 0xFF, 0xFF, 0x87, 0x0E, 0x1F, 0xBF, 0x70, 0xE1,
  0xC3, 0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0x0E, 0x1F, 0xBF, 0x70, 0xE1, 0xC3,
  0x87, 0x00, 0x3C, 0x7F, 0xE7, 0xE3, 0xE0, 0xE0, 0xEF, 0xEF, 0xE3, 0xE7,
  0x7F, 0x3E, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0xFF, 0xFF, 0xC7, 0xE3,
  0xF1, 0xF8, 0xFC, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0xE7, 0x6E, 0x7E, 0x3C, 0xE7, 0x77, 0xBB,
  0x9F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xEE, 0x77, 0x39, 0xDC, 0xE0, 0xE1,
  0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0xFF, 0xF0, 0xF1, 0xFE,
  0x3F, 0xC7, 0xF8, 0xFF, 0xBF, 0xB7, 0xFE, 0xFF, 0xDF, 0xEE, 0xFD, 0xDF,
  0xBB, 0xF7, 0x70, 0xE3, 0xF1, 0xFC, 0xFE, 0x7F, 0x3F, 0xDF, 0xEF, 0xDF,
  0xEF, 0xF3, 0xF9, 0xFC, 0xF0, 0x3C, 0x3F, 0xB9, 0xDC, 0x6E, 0x3F, 0x1F,
  0x8F, 0xC7, 0xE3, 0x73, 0x9F, 0xC7, 0x80, 0xFC, 0xFE, 0xE7, 0xE7, 0xE7,
  0xE7, 0xFE, 0xFC, 0xE0, 0xE0, 0xE0, 0xE0, 0x3C, 0x3F, 0xB9, 0xDC, 0x6E,
  0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0x73, 0x9F, 0xC7, 0xE0, 0x78, 0x10, 0xFC,
  0xFE, 0xE7, 0xE7, 0xE7, 0xE7, 0xFE, 0xFC, 0xEE, 0xEE, 0xE7, 0xE7, 0x3C,
  0xFE, 0xE7, 0xE7, 0xF0, 0x7C, 0x3E, 0x0F, 0xC7, 0xE7, 0xFE, 0x3C, 0xFF,
  0xFF, 0xC7, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x80, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xFE,
  0x3C, 0xE1, 0xFC, 0xE7, 0x39, 0xCE, 0x73, 0x8C, 0xC3, 0xF0, 0xFC, 0x3E,
  0x07, 0x81, 0xE0, 0x78, 0xE7, 0x76, 0x77, 0x67, 0x77, 0xF7, 0x7F, 0x77,
  0xF6, 0x7F, 0xE3, 0xFE, 0x3D, 0xE3, 0xDE, 0x3D, 0xE3, 0x9C, 0xF3, 0xB9,
  0xDD, 0xC7, 0xE3, 0xE0, 0xF0, 0x78, 0x7C, 0x3F, 0x3B, 0x9C, 0xFE, 0x70,
  0xE3, 0xB9, 0xDD, 0xC6, 0xE3, 0x61, 0xF0, 0x78, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x80, 0xFF, 0xFF, 0xC1, 0xC0, 0xC0, 0xE0, 0xE0, 0x70, 0x70, 0x38,
  0x38, 0x1F, 0xEF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xE1,
  0xC1, 0xC3, 0x87, 0x07, 0x0E, 0x1C, 0x1C, 0x38, 0x70, 0x70, 0xE0, 0xFF,
  0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x7F, 0xF0, 0x38, 0x70, 0xA3, 0x66,
  0xCD, 0x80, 0xFF, 0xFC, 0x71, 0x8E, 0x3C, 0x7E, 0x6E, 0x0E, 0x3E, 0x7E,
  0xEE, 0x7E, 0x76, 0xC1, 0x83, 0x06, 0x0D, 0xDF, 0xFB, 0xE7, 0xCF, 0x9F,
  0xBF, 0xFD, 0xC0, 0x3C, 0xFD, 0x9F, 0x3E, 0x1C, 0x19, 0xBF, 0x3C, 0x07,
  0x07, 0x07, 0x07, 0x3F, 0x7F, 0x67, 0xE7, 0xE7, 0xE7, 0x67, 0x7F, 0x3F,
  0x79, 0xFB, 0x3F, 0xFF, 0xF8, 0x39, 0x7E, 0x7C, 0x39, 0xDC, 0xEF, 0xFD,
  0xCE, 0x73, 0x9C, 0xE7, 0x00, 0x3F, 0x7F, 0x77, 0xE7, 0xE7, 0xE7, 0x77,
  0x7F, 0x3F, 0x07, 0x7E, 0x3C, 0xC1, 0x83, 0x06, 0x0D, 0xDF, 0xB3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xE0, 0xDF, 0x0F, 0xFF, 0xFF, 0xFE, 0x31, 0xCC,
  0x03, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9F, 0xDC, 0xC1, 0x83, 0x06, 0x0C,
  0xFB, 0xB7, 0x7C, 0xF9, 0xFB, 0x76, 0x7C, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xDD, 0xDF, 0xFB, 0xBB, 0xE7, 0x7C, 0xEF, 0x9D, 0xF3, 0xBE, 0x77,
  0xCE, 0xE0, 0xDD, 0xFB, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCE, 0x3C, 0x7E,
  0x77, 0xE7, 0xE7, 0xE7, 0x77, 0x7E, 0x3C, 0xDD, 0xFF, 0xBE, 0x7C, 0xF9,
  0xFB, 0xFE, 0xDD, 0x83, 0x06, 0x00, 0x3F, 0x7F, 0x67, 0xE7, 0xE7, 0xE7,
  0x67, 0x7F, 0x3F, 0x07, 0x07, 0x07, 0xDF, 0xFF, 0x8C, 0x63, 0x18, 0xC0,
  0x3C, 0xFD, 0xBB, 0x87, 0xC3, 0xF9, 0xBF, 0x3C, 0x73, 0xBF, 0xF7, 0x39,
  0xCE, 0x73, 0xCE, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xFB, 0xFF, 0x7E, 0xE7,
  0x66, 0x6E, 0x7E, 0x7C, 0x3C, 0x3C, 0x3C, 0x38, 0xEC, 0xDB, 0xB6, 0xFD,
  0xBF, 0x7F, 0xDE, 0xE7, 0xB8, 0xEE, 0x33, 0x80, 0x66, 0x7E, 0x7E, 0x3C,
  0x3C, 0x3C, 0x7E, 0x7E, 0xE6, 0xE7, 0x6E, 0x6E, 0x7E, 0x7C, 0x3C, 0x3C,
  0x3C, 0x18, 0x38, 0x78, 0x70, 0xFF, 0xF1, 0x8E, 0x71, 0xCE, 0x3F, 0xFC,
  0x13, 0x37, 0x77, 0x7E, 0xE7, 0x77, 0x73, 0x31, 0xFF, 0xFF, 0xFF, 0xF0,
  0x43, 0x18, 0xE7, 0x39, 0xC7, 0x3B, 0x9C, 0xE7, 0x31, 0x88, 0x63, 0xEF,
  0x7E, 0x60,
};

const GFXglyph RobotoCondensed_Black17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 3, 12, 5, 1, -12 },
  { 6, 5, 5, 5, 0, -13 },
  { 10, 8, 12, 9, 0, -12 },
  { 22, 7, 16, 9, 1, -14 },
  { 36, 9, 12, 11, 1, -12 },
  { 50, 10, 12, 10, 0, -12 },
  { 65, 2, 5, 3, 0, -13 },
  { 67, 4, 17, 6, 1, -13 },
  { 76, 5, 17, 6, 0, -13 },
  { 87, 8, 7, 8, 0, -12 },
  { 94, 7, 8, 8, 0, -9 },
  { 101, 4, 5, 5, 0, -2 },
  { 104, 5, 2, 7, 1, -6 },
  { 106, 3, 3, 5, 1, -3 },
  { 108, 5, 13, 5, 0, -12 },
  { 117, 7, 12, 9, 1, -12 },
  { 128, 5, 12, 9, 1, -12 },
  { 136, 8, 12, 9, 0, -12 },
  { 148, 8, 12, 9, 0, -12 },
  { 160, 7, 12, 9, 1, -12 },
  { 171, 7, 12, 9, 1, -12 },
  { 182, 7, 12, 9, 1, -12 },
  { 193, 8, 12, 9, 0, -12 },
  { 205, 7, 12, 9, 1, -12 },
  { 216, 7, 12, 9, 1, -12 },
  { 227, 3, 10, 5, 1, -10 },
  { 231, 3, 13, 5, 1, -10 },
  { 236, 7, 8, 8, 0, -9 },
  { 243, 7, 5, 9, 1, -8 },
  { 248, 6, 8, 8, 1, -9 },
  { 254, 7, 12, 8, 0, -12 },
  { 265, 12, 16, 13, 0, -12 },
  { 289, 10, 12, 10, 0, -12 },
  { 304, 8, 12, 10, 1, -12 },
  { 316, 8, 12, 10, 1, -12 },
  { 328, 8, 12, 10, 1, -12 },
  { 340, 7, 12, 8, 1, -12 },
  { 351, 7, 12, 8, 1, -12 },
  { 362, 8, 12, 10, 1, -12 },
  { 374, 9, 12, 10, 1, -12 },
  { 388, 3, 12, 5, 1, -12 },
  { 393, 8, 12, 8, 0, -12 },
  { 405, 9, 12, 9, 1, -12 },
  { 419, 7, 12, 8, 1, -12 },
  { 430, 11, 12, 13, 1, -12 },
  { 447, 9, 12, 10, 1, -12 },
  { 461, 9, 12, 10, 1, -12 },
  { 475, 8, 12, 10, 1, -12 },
  { 487, 9, 14, 10, 1, -12 },
  { 503, 8, 12, 10, 1, -12 },
  { 515, 8, 12, 9, 1, -12 },
  { 527, 9, 12, 9, 0, -12 },
  { 541, 8, 12, 10, 1, -12 },
  { 553, 10, 12, 10, 0, -12 },
  { 568, 12, 12, 13, 0, -12 },
  { 586, 9, 12, 10, 0, -12 },
  { 600, 9, 12, 9, 0, -12 },
  { 614, 9, 12, 9, 0, -12 },
  { 628, 3, 17, 5, 1, -14 },
  { 635, 7, 13, 7, 0, -12 },
  { 647, 4, 17, 5, 0, -14 },
  { 656, 7, 6, 7, 0, -12 },
  { 662, 7, 2, 7, 0, 0 },
  { 664, 5, 3, 6, 0, -13 },
  { 666, 8, 9, 8, 0, -9 },
  { 675, 7, 13, 8, 1, -13 },
  { 687, 7, 9, 8, 0, -9 },
  { 695, 8, 13, 8, 0, -13 },
  { 708, 7, 9, 8, 1, -9 },
  { 716, 5, 13, 6, 0, -13 },
  { 725, 8, 12, 9, 0, -9 },
  { 737, 7, 13, 8, 1, -13 },
  { 749, 3, 13, 4, 1, -13 },
  { 754, 5, 16, 4, -1, -13 },
  { 764, 7, 13, 8, 1, -13 },
  { 776, 3, 13, 4, 1, -13 },
  { 781, 11, 9, 13, 1, -9 },
  { 794, 7, 9, 8, 1, -9 },
  { 802, 8, 9, 8, 0, -9 },
  { 811, 7, 12, 8, 1, -9 },
  { 822, 8, 12, 8, 0, -9 },
  { 834, 5, 9, 6, 1, -9 },
  { 840, 7, 9, 8, 0, -9 },
  { 848, 5, 11, 5, 0, -11 },
  { 855, 7, 9, 8, 1, -9 },
  { 863, 8, 9, 8, 0, -9 },
  { 872, 10, 9, 11, 0, -9 },
  { 884, 8, 9, 8, 0, -9 },
  { 893, 8, 12, 8, 0, -9 },
  { 905, 6, 9, 8, 1, -9 },
  { 912, 4, 16, 5, 0, -13 },
  { 920, 2, 14, 4, 1, -12 },
  { 924, 5, 16, 5, 0, -13 },
  { 934, 7, 4, 9, 1, -7 },
};

const GFXfont RobotoCondensed_Black17pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Black17pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Black17pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _ROBOTOCONDENSED_BLACK17PT7B_H_
