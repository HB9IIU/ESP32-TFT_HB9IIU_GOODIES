#ifndef _ROBOTOCONDENSED_BLACK16PT7B_H_
#define _ROBOTOCONDENSED_BLACK16PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Black.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Black16pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x6D, 0xB6, 0x1B, 0xE0, 0xDE, 0xF7, 0xA0, 0x16, 0x14, 0x14,
  0x34, 0x7F, 0x3C, 0x2C, 0xFE, 0x2C, 0x28, 0x68, 0x68, 0x10, 0x21, 0xE7,
  0xEE, 0xDD, 0xF8, 0x3C, 0x3C, 0x1B, 0x36, 0x6F, 0xCF, 0x04, 0x08, 0xE0,
  0x78, 0x2D, 0x9E, 0x8E, 0xC0, 0x40, 0x60, 0x2E, 0x3D, 0x16, 0xDB, 0x40,
  0xE0, 0x3C, 0x1E, 0x1D, 0x8E, 0xC3, 0xC1, 0xC1, 0xEE, 0xFE, 0xEF, 0x33,
  0x9F, 0xC7, 0xF0, 0xFF, 0xC0, 0x13, 0x66, 0xCC, 0xCC, 0xCC, 0xCC, 0xC6,
  0x63, 0x10, 0x46, 0x63, 0x33, 0x33, 0x33, 0x33, 0x33, 0x66, 0x40, 0x18,
  0x33, 0xFB, 0xF3, 0x8D, 0x89, 0x00, 0x18, 0x30, 0x67, 0xFF, 0xE3, 0x06,
  0x0C, 0x6D, 0xB4, 0xFF, 0x5F, 0x80, 0x18, 0x8C, 0x63, 0x11, 0x8C, 0x63,
  0x31, 0x8C, 0x00, 0x79, 0xFB, 0xB6, 0x6C, 0xF9, 0xF3, 0xE7, 0xCD, 0xDB,
  0xF3, 0xC0, 0x1B, 0xFF, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x70, 0x3C, 0x7E,
  0x66, 0x66, 0x06, 0x0E, 0x0C, 0x1C, 0x38, 0x70, 0x7F, 0x7F, 0x3C, 0x7E,
  0x66, 0x06, 0x06, 0x1E, 0x1E, 0x06, 0x07, 0xE6, 0x7E, 0x3C, 0x1C, 0x78,
  0xF3, 0xE7, 0xDB, 0xB7, 0x7F, 0xFE, 0x38, 0x70, 0xE0, 0xFF, 0xFC, 0x30,
  0xFB, 0xF0, 0xC3, 0x0F, 0x3F, 0xDE, 0x18, 0xF1, 0xC7, 0x0D, 0x9F, 0xB3,
  0xE7, 0xCF, 0x9B, 0xF1, 0xC0, 0xFF, 0xFE, 0x06, 0x0E, 0x0E, 0x0C, 0x1C,
  0x1C, 0x18, 0x38, 0x38, 0x30, 0x7B, 0xFE, 0xF3, 0xED, 0xE7, 0xF3, 0xCF,
  0x3F, 0xDE, 0x7B, 0xFE, 0xF3, 0xCF, 0x3F, 0xDF, 0x0C, 0x77, 0x9C, 0x5F,
  0x80, 0x17, 0xE0, 0x5F, 0x00, 0x07, 0xFB, 0x40, 0x04, 0x77, 0xFC, 0xF1,
  0xF1, 0xC1, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x83, 0x8F, 0x8F, 0x3F, 0xEE,
  0x20, 0x3C, 0xFB, 0xB8, 0x70, 0xC3, 0x8E, 0x1C, 0x00, 0x20, 0xE1, 0xC0,
  0x0F, 0x81, 0x8C, 0x30, 0x66, 0x72, 0x6F, 0xB4, 0xDB, 0x49, 0xB5, 0x93,
  0x59, 0x24, 0xFE, 0x4F, 0xC6, 0x00, 0x60, 0x03, 0xF0, 0x0F, 0x00, 0x1C,
  0x07, 0x81, 0xE0, 0x78, 0x3E, 0x0D, 0xC3, 0x71, 0xCC, 0x7F, 0x9F, 0xE6,
  0x3B, 0x86, 0xFD, 0xFF, 0x3E, 0x3C, 0xFF, 0xFF, 0xE3, 0xC7, 0x8F, 0xFF,
  0xE0, 0x3C, 0x7E, 0xE7, 0xC7, 0xC0, 0xC0, 0xC0, 0xC0, 0xC7, 0xE7, 0x7E,
  0x3C, 0xF9, 0xFB, 0x3E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x9F, 0xF7, 0xC0,
  0xFF, 0xFF, 0x06, 0x0C, 0x1F, 0xBF, 0x60, 0xC1, 0x83, 0xFF, 0xF0, 0xFF,
  0xFC, 0x30, 0xC3, 0xFF, 0xF0, 0xC3, 0x0C, 0x30, 0x3C, 0x7E, 0xE7, 0xC7,
  0xC0, 0xC0, 0xCF, 0xCF, 0xC7, 0xE7, 0x7F, 0x3C, 0xC7, 0xC7, 0xC7, 0xC7,
  0xC7, 0xFF, 0xFF, 0xC7, 0xC7, 0xC7, 0xC7, 0xC7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0xEE, 0xDD, 0xF1, 0xC0,
  0xC7, 0xCE, 0xCE, 0xDC, 0xD8, 0xF8, 0xFC, 0xFC, 0xEC, 0xCE, 0xCE, 0xC7,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0F, 0xFF, 0xE1, 0xFC, 0x7F,
  0x3F, 0xCF, 0xF3, 0xF4, 0xFD, 0xEF, 0x7B, 0xDE, 0xF3, 0xBC, 0xCF, 0x33,
  0xE7, 0xE7, 0xE7, 0xF7, 0xF7, 0xDF, 0xDF, 0xCF, 0xCF, 0xCF, 0xC7, 0xC7,
  0x3C, 0x7E, 0xE7, 0xC7, 0xC7, 0xC7, 0xC7, 0xC7, 0xC7, 0xE7, 0x7E, 0x3C,
  0xFC, 0xFE, 0xCE, 0xC7, 0xC7, 0xC6, 0xFE, 0xFC, 0xC0, 0xC0, 0xC0, 0xC0,
  0x3C, 0x7E, 0xE7, 0xC7, 0xC7, 0xC7, 0xC7, 0xC7, 0xC7, 0xE7, 0x7E, 0x3E,
  0x07, 0x02, 0xFC, 0xFE, 0xCE, 0xC6, 0xC6, 0xCE, 0xFE, 0xFC, 0xDC, 0xCE,
  0xCE, 0xC7, 0x7D, 0xFF, 0xBF, 0x3E, 0x0F, 0x0F, 0x87, 0xC7, 0xDF, 0xF9,
  0xE0, 0xFF, 0xFF, 0xC7, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x80, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0xCF,
  0xFB, 0xE0, 0xE3, 0xF1, 0xDC, 0xEE, 0x67, 0x71, 0xB8, 0xDC, 0x7C, 0x3E,
  0x0F, 0x07, 0x83, 0x80, 0xE6, 0x7E, 0x66, 0x6E, 0x66, 0xFE, 0x7F, 0xE7,
  0xFE, 0x7F, 0xE7, 0xFC, 0x3F, 0xC3, 0xBC, 0x39, 0xC3, 0x9C, 0xE3, 0xBB,
  0x9D, 0xC6, 0xC3, 0xE0, 0xE0, 0xF8, 0x7C, 0x36, 0x3B, 0x9D, 0xDC, 0x70,
  0xE3, 0xB3, 0x9D, 0xCE, 0xC3, 0x61, 0xF0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x80, 0xFF, 0xFF, 0x07, 0x0E, 0x0C, 0x1C, 0x18, 0x38, 0x30, 0x70,
  0x7F, 0x7F, 0xFF, 0x6D, 0xB6, 0xDB, 0x6D, 0xBF, 0xE1, 0xC1, 0x83, 0x87,
  0x06, 0x0E, 0x1C, 0x18, 0x38, 0x70, 0xE0, 0xC0, 0xFF, 0x77, 0x77, 0x77,
  0x77, 0x77, 0x77, 0xFF, 0x30, 0xE7, 0x9A, 0x6F, 0x30, 0xFF, 0xF0, 0x71,
  0x80, 0x3C, 0xFD, 0xB8, 0x73, 0xED, 0xFB, 0xBF, 0x7E, 0xC1, 0x83, 0x07,
  0xCF, 0xD9, 0xB3, 0x67, 0xCD, 0x9B, 0xF7, 0xC0, 0x3C, 0xFD, 0xBF, 0x0E,
  0x1C, 0x1B, 0xBF, 0x3C, 0x06, 0x0C, 0x19, 0xB7, 0xEC, 0xF9, 0xF3, 0xE6,
  0xCD, 0xF9, 0xB0, 0x7B, 0xFC, 0xFF, 0xFF, 0x0C, 0x3F, 0x78, 0x3B, 0xDD,
  0xFF, 0xB9, 0xCE, 0x73, 0x9C, 0xE0, 0x3E, 0xFD, 0x9F, 0x3E, 0x7C, 0xD9,
  0xBF, 0x3E, 0x0D, 0xF9, 0xE0, 0xC3, 0x0C, 0x36, 0xFF, 0x3C, 0xF3, 0xCF,
  0x3C, 0xF3, 0x7C, 0xFF, 0xFF, 0xC0, 0x13, 0x30, 0x33, 0x33, 0x33, 0x33,
  0x33, 0xFE, 0xC1, 0x83, 0x06, 0xED, 0xDF, 0x3E, 0x7C, 0xF9, 0xBB, 0x76,
  0x70, 0xFF, 0xFF, 0xFF, 0xDB, 0xBF, 0xFC, 0xDF, 0x37, 0xCD, 0xF3, 0x7C,
  0xDF, 0x37, 0xCD, 0xC0, 0xDB, 0xFC, 0xF3, 0xCF, 0x3C, 0xF3, 0xCC, 0x3C,
  0xFD, 0x9F, 0x3E, 0x7C, 0xD9, 0xBF, 0x3C, 0xF9, 0xFB, 0x36, 0x6C, 0xF9,
  0xB3, 0x7E, 0xD9, 0x83, 0x06, 0x00, 0x36, 0xFD, 0x9F, 0x3E, 0x7C, 0xD9,
  0xBF, 0x36, 0x0C, 0x18, 0x30, 0xDF, 0xEC, 0xCC, 0xCC, 0xC0, 0x3C, 0xFD,
  0xBB, 0x87, 0xC3, 0xFB, 0xBF, 0x3C, 0x73, 0xBF, 0xF7, 0x39, 0xCE, 0x73,
  0xCE, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xFF, 0x6C, 0xEF, 0xDD, 0xBB, 0x67,
  0xCF, 0x8F, 0x1C, 0x38, 0xED, 0xDB, 0x66, 0xD9, 0xFE, 0x7F, 0x9F, 0xE7,
  0xF8, 0xCC, 0x33, 0x00, 0xEE, 0xDD, 0xF1, 0xE3, 0x87, 0x9F, 0x37, 0xEE,
  0xEF, 0xDD, 0xBB, 0x67, 0xC7, 0x8E, 0x1C, 0x38, 0x71, 0xC3, 0x80, 0xFF,
  0xF3, 0x8C, 0x71, 0x8E, 0x3F, 0xFC, 0x13, 0x77, 0x76, 0xEE, 0x67, 0x77,
  0x73, 0x10, 0xFF, 0xFF, 0xFF, 0xF0, 0x46, 0x66, 0x66, 0x33, 0x76, 0x66,
  0x66, 0x40, 0x67, 0xEF, 0x7E, 0x60,
};

const GFXglyph RobotoCondensed_Black16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 3, 12, 4, 1, -12 },
  { 6, 5, 4, 5, 0, -12 },
  { 9, 8, 12, 8, 0, -12 },
  { 21, 7, 16, 8, 1, -14 },
  { 35, 9, 12, 10, 1, -12 },
  { 49, 9, 12, 10, 0, -12 },
  { 63, 2, 5, 2, 0, -12 },
  { 65, 4, 17, 5, 1, -13 },
  { 74, 4, 17, 5, 0, -13 },
  { 83, 7, 7, 7, 0, -12 },
  { 90, 7, 8, 7, 0, -9 },
  { 97, 3, 5, 4, 0, -2 },
  { 99, 4, 2, 7, 1, -6 },
  { 100, 3, 3, 5, 1, -3 },
  { 102, 5, 13, 5, 0, -12 },
  { 111, 7, 12, 8, 1, -12 },
  { 122, 5, 12, 8, 1, -12 },
  { 130, 8, 12, 8, 0, -12 },
  { 142, 8, 12, 8, 0, -12 },
  { 154, 7, 12, 8, 1, -12 },
  { 165, 6, 12, 8, 1, -12 },
  { 174, 7, 12, 8, 1, -12 },
  { 185, 8, 12, 8, 0, -12 },
  { 197, 6, 12, 8, 1, -12 },
  { 206, 6, 12, 8, 1, -12 },
  { 215, 3, 9, 5, 1, -9 },
  { 219, 3, 12, 4, 1, -9 },
  { 224, 6, 8, 7, 0, -9 },
  { 230, 6, 6, 8, 1, -8 },
  { 235, 6, 8, 7, 1, -9 },
  { 241, 7, 12, 7, 0, -12 },
  { 252, 12, 15, 12, 0, -11 },
  { 275, 10, 12, 10, 0, -12 },
  { 290, 7, 12, 9, 1, -12 },
  { 301, 8, 12, 9, 1, -12 },
  { 313, 7, 12, 9, 1, -12 },
  { 324, 7, 12, 8, 1, -12 },
  { 335, 6, 12, 8, 1, -12 },
  { 344, 8, 12, 9, 1, -12 },
  { 356, 8, 12, 10, 1, -12 },
  { 368, 3, 12, 4, 1, -12 },
  { 373, 7, 12, 8, 0, -12 },
  { 384, 8, 12, 9, 1, -12 },
  { 396, 6, 12, 8, 1, -12 },
  { 405, 10, 12, 12, 1, -12 },
  { 420, 8, 12, 10, 1, -12 },
  { 432, 8, 12, 10, 1, -12 },
  { 444, 8, 12, 9, 1, -12 },
  { 456, 8, 14, 10, 1, -12 },
  { 470, 8, 12, 9, 1, -12 },
  { 482, 7, 12, 9, 1, -12 },
  { 493, 9, 12, 9, 0, -12 },
  { 507, 7, 12, 9, 1, -12 },
  { 518, 9, 12, 9, 0, -12 },
  { 532, 12, 12, 12, 0, -12 },
  { 550, 9, 12, 9, 0, -12 },
  { 564, 9, 12, 9, 0, -12 },
  { 578, 8, 12, 9, 0, -12 },
  { 590, 3, 16, 4, 1, -13 },
  { 596, 7, 13, 6, 0, -12 },
  { 608, 4, 16, 4, 0, -13 },
  { 616, 6, 6, 6, 0, -12 },
  { 621, 6, 2, 6, 0, 0 },
  { 623, 5, 2, 5, 0, -12 },
  { 625, 7, 9, 7, 0, -9 },
  { 633, 7, 12, 8, 1, -12 },
  { 644, 7, 9, 7, 0, -9 },
  { 652, 7, 12, 8, 0, -12 },
  { 663, 6, 9, 8, 1, -9 },
  { 670, 5, 12, 5, 0, -12 },
  { 678, 7, 12, 8, 0, -9 },
  { 689, 6, 12, 8, 1, -12 },
  { 698, 2, 13, 4, 1, -13 },
  { 702, 4, 16, 4, -1, -13 },
  { 710, 7, 12, 8, 1, -12 },
  { 721, 2, 12, 4, 1, -12 },
  { 724, 10, 9, 12, 1, -9 },
  { 736, 6, 9, 8, 1, -9 },
  { 743, 7, 9, 8, 0, -9 },
  { 751, 7, 12, 8, 1, -9 },
  { 762, 7, 12, 8, 0, -9 },
  { 773, 4, 9, 6, 1, -9 },
  { 778, 7, 9, 7, 0, -9 },
  { 786, 5, 11, 5, 0, -11 },
  { 793, 6, 9, 8, 1, -9 },
  { 800, 7, 9, 7, 0, -9 },
  { 808, 10, 9, 10, 0, -9 },
  { 820, 7, 9, 7, 0, -9 },
  { 828, 7, 12, 7, 0, -9 },
  { 839, 6, 9, 7, 1, -9 },
  { 846, 4, 15, 5, 0, -12 },
  { 854, 2, 14, 4, 1, -12 },
  { 858, 4, 15, 5, 0, -12 },
  { 866, 7, 4, 9, 1, -7 },
};

const GFXfont RobotoCondensed_Black16pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Black16pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Black16pt7bGlyphs,
  0x20, 0x7E, 19
};

#endif // _ROBOTOCONDENSED_BLACK16PT7B_H_
