#ifndef _ROBOTOCONDENSED_BLACK54PT7B_H_
#define _ROBOTOCONDENSED_BLACK54PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Black.ttf
// Size: 54pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Black54pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7,
  0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x41, 0xF9,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xF0, 0x20, 0xFC, 0x7F, 0xF8,
  0xFF, 0xF1, 0xFF, 0xE3, 0xFF, 0xC7, 0xFF, 0x8F, 0xFE, 0x1F, 0xFC, 0x3F,
  0xF8, 0x7F, 0xF0, 0xFB, 0xE1, 0xF7, 0xC3, 0xEF, 0x87, 0xDF, 0x0F, 0xBE,
  0x1F, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x3E, 0x00,
  0x1F, 0x1F, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0xC7, 0xC0, 0x03, 0xE7, 0xC0,
  0x01, 0xF3, 0xE0, 0x01, 0xF1, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x7C, 0x7C,
  0x07, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0x03, 0xE3, 0xE0, 0x01, 0xF1, 0xF0, 0x00, 0xF8,
  0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x7E, 0x00, 0x1F, 0x3E, 0x00, 0x1F,
  0x9F, 0x01, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xC0, 0x7C, 0xF8, 0x00, 0x7E, 0x7C, 0x00,
  0x3E, 0x3E, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0xC7, 0xC0,
  0x03, 0xE3, 0xE0, 0x01, 0xF3, 0xE0, 0x00, 0xF9, 0xF0, 0x00, 0xF8, 0xF8,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xE3,
  0xFE, 0x7F, 0xE7, 0xFC, 0x7F, 0xDF, 0xF0, 0xFF, 0xBF, 0xE0, 0xFF, 0x7F,
  0xC1, 0xFE, 0xFF, 0x83, 0xFC, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x07, 0xFF,
  0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFB, 0xFC, 0x1F, 0xF7, 0xFC, 0x3F, 0xEF,
  0xFC, 0xFF, 0xCF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFB, 0xF8, 0x18, 0x07,
  0xC7, 0xE0, 0xF8, 0x3F, 0x0F, 0x83, 0xE0, 0xFC, 0x3E, 0x1F, 0x03, 0xF0,
  0xF8, 0x7C, 0x0F, 0xC3, 0xE3, 0xE0, 0x3F, 0x0F, 0x9F, 0x80, 0x7C, 0x7E,
  0x7C, 0x01, 0xFB, 0xFB, 0xE0, 0x07, 0xFF, 0xCF, 0x80, 0x0F, 0xFF, 0x7C,
  0x00, 0x1F, 0xF9, 0xF0, 0x00, 0x3F, 0xCF, 0x80, 0x00, 0x10, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF9, 0xFE, 0x00, 0x07, 0xCF, 0xFC, 0x00, 0x1F, 0x7F, 0xF8, 0x00,
  0xFB, 0xFF, 0xF0, 0x07, 0xEF, 0xDF, 0xC0, 0x1F, 0x3E, 0x3F, 0x00, 0xF8,
  0xF8, 0x7C, 0x03, 0xE7, 0xE1, 0xF0, 0x1F, 0x1F, 0x87, 0xC0, 0x7C, 0x7E,
  0x1F, 0x03, 0xE0, 0xF8, 0x7C, 0x0F, 0x83, 0xE1, 0xF0, 0x3C, 0x0F, 0xEF,
  0xC0, 0x30, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFD, 0xFF,
  0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x7F, 0x87, 0xF0, 0x01, 0xFE, 0x1F, 0xC0,
  0x07, 0xF8, 0x7F, 0x00, 0x1F, 0xE1, 0xF8, 0x00, 0x3F, 0xCF, 0xE0, 0x00,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x87, 0xF0, 0x7F, 0xFE, 0x1F, 0xC1, 0xFF, 0xFC, 0x7F, 0x0F, 0xFF, 0xFB,
  0xFC, 0x7F, 0xFF, 0xEF, 0xF1, 0xFE, 0x7F, 0xFF, 0x87, 0xF9, 0xFF, 0xFE,
  0x1F, 0xE3, 0xFF, 0xF8, 0xFF, 0x87, 0xFF, 0xE1, 0xFE, 0x1F, 0xFF, 0x07,
  0xFC, 0x3F, 0xFC, 0x1F, 0xF0, 0x7F, 0xE0, 0x7F, 0xE7, 0xFF, 0x81, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xF8, 0xFF, 0xC0, 0x0C, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x10, 0x03, 0x80, 0x3C, 0x03, 0xF0, 0x3F, 0x81, 0xF8, 0x1F,
  0x81, 0xFC, 0x0F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x1F, 0x80,
  0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xE0, 0x7F,
  0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xF0, 0x3F, 0x81, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xFC, 0x07, 0xE0, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0x7E,
  0x01, 0xE0, 0x07, 0x00, 0x08, 0x20, 0x00, 0xE0, 0x07, 0xC0, 0x1F, 0x80,
  0x7E, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0xFE,
  0x01, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x0F,
  0xE0, 0x3F, 0x80, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x81, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x03, 0xF8, 0x0F, 0xC0,
  0x7F, 0x01, 0xF8, 0x0F, 0xE0, 0x7F, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00,
  0x38, 0x00, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x60, 0x3C,
  0x00, 0x78, 0x3C, 0x1E, 0x7F, 0x3C, 0x7E, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x03, 0xEF, 0xC0, 0x07, 0xE7, 0xC0, 0x0F, 0xC7,
  0xE0, 0x1F, 0xC3, 0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0x01, 0xF0, 0x07, 0x00,
  0xE0, 0x02, 0x00, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F,
  0xCF, 0xE3, 0xF8, 0xFE, 0x7F, 0x1F, 0xCF, 0xE1, 0xF0, 0x08, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0x1F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xF8, 0xFC, 0x08, 0x00,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xF8,
  0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xF7, 0xFE, 0x7F, 0xC3, 0xFC,
  0xFF, 0x87, 0xFD, 0xFE, 0x0F, 0xFB, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x03,
  0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xF7, 0xF8, 0x3F, 0xEF, 0xF0, 0x7F,
  0xDF, 0xF0, 0xFF, 0xBF, 0xE1, 0xFE, 0x3F, 0xEF, 0xFC, 0x7F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00,
  0x7F, 0xE0, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x1F, 0x00, 0x7F, 0x03,
  0xFF, 0x1F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFD, 0xFF, 0xE1, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F, 0xF7, 0xFE, 0xFF, 0x87, 0xFD, 0xFF,
  0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x7F,
  0xF7, 0xFE, 0x7F, 0xC3, 0xFF, 0x7F, 0xC1, 0xFF, 0x7F, 0xC1, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0x7F, 0xC1, 0xFF, 0x7F,
  0xC1, 0xFF, 0x7F, 0xE7, 0xFF, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00,
  0x18, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x03,
  0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x07, 0xEF, 0xF8, 0x0F,
  0xEF, 0xF8, 0x0F, 0xCF, 0xF8, 0x1F, 0xCF, 0xF8, 0x1F, 0xCF, 0xF8, 0x3F,
  0x8F, 0xF8, 0x3F, 0x8F, 0xF8, 0x7F, 0x8F, 0xF8, 0x7F, 0x0F, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x3F, 0xFF, 0xFC, 0x7F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF3, 0xF0,
  0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xF7, 0xFC, 0x7F, 0xE0, 0x70, 0x7F, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0,
  0xFF, 0x3F, 0xF7, 0xFE, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x8F, 0xC0, 0x7F, 0xBF, 0xF0, 0x7F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xC3, 0xFE, 0xFF, 0x83, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0x7F, 0x81,
  0xFF, 0x7F, 0x81, 0xFF, 0x7F, 0x81, 0xFF, 0x7F, 0xC3, 0xFE, 0x3F, 0xF7,
  0xFE, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x07, 0xFF,
  0xF0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x08, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80,
  0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x81,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x3F, 0xF3, 0xFE, 0x7F,
  0xC7, 0xFC, 0xFF, 0x87, 0xF9, 0xFF, 0x0F, 0xFB, 0xFE, 0x1F, 0xF7, 0xFC,
  0x3F, 0xEF, 0xF8, 0x7F, 0x9F, 0xF0, 0xFF, 0x1F, 0xF3, 0xFE, 0x3F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x3F, 0xE3, 0xFE, 0x7F, 0xC3, 0xFE,
  0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xBF, 0xE1, 0xFF, 0x7F, 0xE7, 0xFE, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFE, 0x1F, 0xF7, 0xFE, 0x7F, 0xC7, 0xFC, 0xFF, 0x87, 0xF9,
  0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFD, 0xFF,
  0x07, 0xFB, 0xFE, 0x1F, 0xF7, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x07, 0xCF,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00,
  0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3F, 0x1F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xF8, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xC7, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFE, 0x3F,
  0x00, 0x00, 0x1F, 0x87, 0xF9, 0xFF, 0x3F, 0xF7, 0xFE, 0xFF, 0x8F, 0xF0,
  0xFC, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0xFE, 0x1F,
  0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x8F, 0xE1, 0xFC, 0x3F, 0x87,
  0xE1, 0xFC, 0x3F, 0x0F, 0xE0, 0xF8, 0x06, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x07, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x01,
  0xFF, 0xF0, 0x7F, 0xFF, 0x3F, 0xFF, 0xEF, 0xFF, 0xF8, 0xFF, 0xFE, 0x0F,
  0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x80, 0x00, 0x0E, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x3F, 0xF0,
  0x03, 0xFF, 0x00, 0xFF, 0xF0, 0x7F, 0xFF, 0x1F, 0xFF, 0xF7, 0xFF, 0xFC,
  0xFF, 0xFF, 0x0F, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0xFE, 0x00,
  0x0F, 0x80, 0x00, 0xE0, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xE1, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x0F,
  0xE0, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x00,
  0xF8, 0x3F, 0x00, 0xFE, 0x07, 0xE3, 0xF0, 0x0F, 0xFC, 0x1F, 0x1F, 0x81,
  0xFF, 0xF0, 0xF8, 0xF8, 0x1F, 0xFF, 0x87, 0xEF, 0xC0, 0xFF, 0xFC, 0x1F,
  0x7E, 0x0F, 0xE3, 0xE0, 0xFB, 0xE0, 0x7E, 0x1F, 0x07, 0xDF, 0x07, 0xE1,
  0xF8, 0x3F, 0xF8, 0x3F, 0x0F, 0xC1, 0xFF, 0xC3, 0xF0, 0x7E, 0x0F, 0xFE,
  0x1F, 0x83, 0xF0, 0x7F, 0xE0, 0xFC, 0x1F, 0x83, 0xFF, 0x07, 0xE0, 0xFC,
  0x1F, 0xF8, 0x3F, 0x07, 0xE0, 0xFF, 0xC3, 0xF8, 0x3F, 0x07, 0xFE, 0x1F,
  0xC1, 0xF8, 0x3F, 0xF0, 0xFE, 0x0F, 0xC1, 0xFF, 0x87, 0xF0, 0x7C, 0x0F,
  0xFC, 0x3F, 0x87, 0xE0, 0xFB, 0xE0, 0xFC, 0x3F, 0x07, 0xDF, 0x87, 0xF3,
  0xF8, 0x7C, 0xFC, 0x3F, 0xFF, 0xE7, 0xE7, 0xE1, 0xFF, 0xFF, 0xFE, 0x1F,
  0x07, 0xFE, 0xFF, 0xF0, 0xFC, 0x1F, 0xF7, 0xFF, 0x07, 0xE0, 0x7E, 0x0F,
  0xE0, 0x3F, 0x00, 0x00, 0x18, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x10, 0x00, 0x0F, 0xF8, 0x07, 0x80, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0x7F,
  0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0x7F, 0x80, 0x01, 0xFE, 0x7F,
  0x80, 0x01, 0xFE, 0x3F, 0xC0, 0x01, 0xFE, 0x3F, 0xC0, 0x03, 0xFE, 0x3F,
  0xC0, 0x03, 0xFC, 0x3F, 0xE0, 0x03, 0xFC, 0x1F, 0xE0, 0x07, 0xFC, 0x1F,
  0xE0, 0x07, 0xFC, 0x1F, 0xF0, 0x07, 0xF8, 0x1F, 0xF0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xFC, 0x3F, 0xF0, 0x07, 0xFC, 0x3F, 0xE0, 0x07, 0xFE, 0x3F, 0xE0, 0x03,
  0xFE, 0x7F, 0xE0, 0x03, 0xFE, 0x7F, 0xE0, 0x03, 0xFF, 0x7F, 0xC0, 0x03,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFD, 0xFF, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFE, 0x07, 0xFD, 0xFF, 0x07, 0xFE, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFB, 0xFE, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x3F, 0xE0, 0x7F, 0xC7,
  0xFC, 0x03, 0xFE, 0x7F, 0xC0, 0x3F, 0xE7, 0xFC, 0x03, 0xFE, 0xFF, 0x80,
  0x1F, 0xEF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x03, 0xFF, 0xFF,
  0x80, 0x3F, 0xEF, 0xF8, 0x03, 0xFE, 0x7F, 0xC0, 0x3F, 0xE7, 0xFC, 0x03,
  0xFE, 0x7F, 0xC0, 0x3F, 0xE7, 0xFE, 0x07, 0xFE, 0x3F, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x60, 0x00,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF9, 0xFF, 0x1F,
  0xFC, 0xFF, 0x83, 0xFF, 0x7F, 0xC0, 0xFF, 0xBF, 0xE0, 0x7F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xF7, 0xFC, 0x1F, 0xFB, 0xFE, 0x1F,
  0xF9, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F,
  0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x3F, 0xF0, 0x7F,
  0xE7, 0xFE, 0x03, 0xFE, 0x7F, 0xC0, 0x1F, 0xE7, 0xFC, 0x01, 0xFF, 0x7F,
  0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xC0, 0x1F, 0xF7, 0xFC, 0x01, 0xFF, 0x7F, 0xC0, 0x1F, 0xF7, 0xFC,
  0x01, 0xFF, 0x7F, 0xE0, 0x1F, 0xF3, 0xFF, 0x03, 0xFF, 0x3F, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x60,
  0x00, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x7F, 0xDF, 0xF1, 0xFF, 0x3F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x04, 0x00, 0x00, 0xFF, 0x80,
  0xFF, 0xEF, 0xF8, 0x0F, 0xFE, 0xFF, 0x81, 0xFF, 0xCF, 0xF8, 0x1F, 0xF8,
  0xFF, 0x83, 0xFF, 0x8F, 0xF8, 0x3F, 0xF0, 0xFF, 0x87, 0xFF, 0x0F, 0xF8,
  0x7F, 0xE0, 0xFF, 0x8F, 0xFC, 0x0F, 0xF8, 0xFF, 0xC0, 0xFF, 0x8F, 0xF8,
  0x0F, 0xF9, 0xFF, 0x00, 0xFF, 0x9F, 0xF0, 0x0F, 0xFB, 0xFE, 0x00, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFE, 0xFF, 0xC0, 0xFF, 0xCF, 0xFC, 0x0F, 0xF8, 0xFF, 0xC0,
  0xFF, 0x87, 0xFE, 0x0F, 0xF8, 0x7F, 0xE0, 0xFF, 0x83, 0xFF, 0x0F, 0xF8,
  0x3F, 0xF0, 0xFF, 0x81, 0xFF, 0x8F, 0xF8, 0x1F, 0xF8, 0xFF, 0x81, 0xFF,
  0xCF, 0xF8, 0x0F, 0xFC, 0xFF, 0x80, 0xFF, 0xEF, 0xF8, 0x07, 0xFE, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x7E, 0x0F, 0xDF, 0xFF, 0xEF,
  0xC3, 0xFB, 0xFF, 0xFD, 0xFC, 0x7F, 0x7F, 0xFF, 0xBF, 0x8F, 0xCF, 0xFF,
  0xF3, 0xF1, 0xF9, 0xFF, 0xFE, 0x7E, 0x3F, 0x3F, 0xFF, 0xCF, 0xEF, 0xE7,
  0xFF, 0xF8, 0xFD, 0xF8, 0xFF, 0xFF, 0x1F, 0xBF, 0x3F, 0xFF, 0xE3, 0xF7,
  0xE7, 0xFF, 0xFE, 0x7F, 0xFC, 0xFF, 0xFF, 0xC7, 0xFF, 0x1F, 0xFF, 0xF8,
  0xFF, 0xE3, 0xFF, 0xFF, 0x1F, 0xFC, 0x7F, 0xFF, 0xE3, 0xFF, 0x0F, 0xFF,
  0xFC, 0x3F, 0xE1, 0xFF, 0xFF, 0x87, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0x87,
  0xFF, 0xFE, 0x0F, 0xE0, 0xFF, 0xFF, 0xC1, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F,
  0x83, 0xFF, 0xFF, 0x07, 0xF0, 0x7F, 0xC0, 0xFF, 0x80, 0x3F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xF7, 0xE7, 0xFF, 0xFE, 0xFC, 0xFF, 0xFF,
  0xCF, 0xDF, 0xFF, 0xF9, 0xFB, 0xFF, 0xFF, 0x1F, 0x7F, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xF0, 0x7F,
  0xE3, 0xFF, 0x01, 0xFF, 0x1F, 0xF0, 0x0F, 0xFC, 0xFF, 0x80, 0x3F, 0xEF,
  0xFC, 0x01, 0xFF, 0x7F, 0xC0, 0x0F, 0xFB, 0xFE, 0x00, 0x7F, 0xDF, 0xF0,
  0x03, 0xFE, 0xFF, 0x80, 0x1F, 0xF7, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFE, 0xFF, 0x80, 0x1F, 0xF7, 0xFC,
  0x00, 0xFF, 0xBF, 0xE0, 0x07, 0xFD, 0xFF, 0x80, 0x3F, 0xE7, 0xFC, 0x01,
  0xFF, 0x3F, 0xE0, 0x1F, 0xF9, 0xFF, 0x80, 0xFF, 0x87, 0xFE, 0x0F, 0xFC,
  0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x40, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xF3, 0xFE, 0x07, 0xFE, 0xFF, 0x80, 0xFF, 0xBF, 0xE0,
  0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF,
  0xBF, 0xE0, 0x7F, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFC, 0x3F, 0xF0, 0x7F, 0xE3, 0xFF, 0x01, 0xFF, 0x1F, 0xF0, 0x0F,
  0xFC, 0xFF, 0x80, 0x3F, 0xEF, 0xFC, 0x01, 0xFF, 0x7F, 0xC0, 0x0F, 0xFB,
  0xFE, 0x00, 0x7F, 0xDF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xBF, 0xE0, 0x07, 0xFD, 0xFF,
  0x80, 0x3F, 0xE7, 0xFC, 0x01, 0xFF, 0x3F, 0xE0, 0x1F, 0xF9, 0xFF, 0x80,
  0xFF, 0x87, 0xFE, 0x0F, 0xFC, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x5F, 0xFC, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0x80, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFE, 0x0F, 0xFE, 0xFF, 0x81,
  0xFF, 0xBF, 0xE0, 0x3F, 0xEF, 0xF8, 0x0F, 0xFB, 0xFE, 0x03, 0xFE, 0xFF,
  0x80, 0xFF, 0xBF, 0xE0, 0x3F, 0xEF, 0xF8, 0x0F, 0xFB, 0xFE, 0x03, 0xFE,
  0xFF, 0x81, 0xFF, 0xBF, 0xE0, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x3F, 0xE7, 0xFE, 0x0F, 0xF8, 0xFF, 0xC3,
  0xFE, 0x3F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x8F, 0xF8, 0x3F,
  0xE3, 0xFE, 0x0F, 0xFC, 0xFF, 0x83, 0xFF, 0x3F, 0xE0, 0x7F, 0xEF, 0xF8,
  0x1F, 0xFB, 0xFE, 0x03, 0xFE, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xF0,
  0x00, 0x04, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFE, 0x7F, 0xE0, 0xFF, 0x9F, 0xF0, 0x3F, 0xF7, 0xFC, 0x07, 0xFD,
  0xFF, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80,
  0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x03, 0xFE, 0x7F, 0xFB, 0xFF, 0x9F,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x10, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0xFF,
  0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xBF, 0xE0, 0x3F,
  0xEF, 0xFC, 0x1F, 0xFB, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x80, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0xC0,
  0x0F, 0xFD, 0xFF, 0x80, 0x1F, 0xFB, 0xFF, 0x00, 0x7F, 0xE3, 0xFE, 0x00,
  0xFF, 0xC7, 0xFC, 0x01, 0xFF, 0x8F, 0xFC, 0x03, 0xFF, 0x1F, 0xF8, 0x07,
  0xFC, 0x1F, 0xF0, 0x1F, 0xF8, 0x3F, 0xE0, 0x3F, 0xF0, 0x7F, 0xC0, 0x7F,
  0xC0, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x81, 0xFF, 0x01, 0xFF, 0x07, 0xFE,
  0x03, 0xFE, 0x0F, 0xF8, 0x03, 0xFE, 0x1F, 0xF0, 0x07, 0xFC, 0x3F, 0xE0,
  0x0F, 0xF8, 0x7F, 0x80, 0x1F, 0xF1, 0xFF, 0x00, 0x1F, 0xE3, 0xFE, 0x00,
  0x3F, 0xE7, 0xFC, 0x00, 0x7F, 0xCF, 0xF0, 0x00, 0x7F, 0x9F, 0xE0, 0x00,
  0xFF, 0x7F, 0xC0, 0x01, 0xFE, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x81,
  0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xE0, 0x7F,
  0xFF, 0xE0, 0x7F, 0x81, 0xFF, 0x7F, 0x83, 0xFF, 0x07, 0xF9, 0xFF, 0x0F,
  0xFC, 0x3F, 0xE7, 0xFC, 0x3F, 0xF0, 0xFF, 0x9F, 0xF0, 0xFF, 0xC3, 0xFE,
  0x7F, 0xC3, 0xFF, 0x0F, 0xF9, 0xFF, 0x1F, 0xFE, 0x3F, 0xE3, 0xFC, 0x7F,
  0xF8, 0xFF, 0x0F, 0xF9, 0xFF, 0xE3, 0xFC, 0x3F, 0xE7, 0xFF, 0x9F, 0xF0,
  0xFF, 0x9F, 0xFE, 0x7F, 0xC3, 0xFE, 0x7F, 0xF9, 0xFF, 0x0F, 0xFB, 0xFF,
  0xF7, 0xFC, 0x1F, 0xEF, 0xFF, 0xDF, 0xE0, 0x7F, 0xBF, 0xFF, 0x7F, 0x81,
  0xFF, 0xFF, 0xFD, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xF3, 0xFF, 0xF0, 0x0F, 0xFF, 0xCF, 0xFF, 0xC0, 0x3F, 0xFF, 0x3F,
  0xFF, 0x00, 0xFF, 0xFC, 0xFF, 0xFC, 0x01, 0xFF, 0xF3, 0xFF, 0xF0, 0x07,
  0xFF, 0x87, 0xFF, 0x80, 0x1F, 0xFE, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x7F,
  0xF8, 0x01, 0xFF, 0xE1, 0xFF, 0xE0, 0x07, 0xFF, 0x87, 0xFF, 0x80, 0x0F,
  0xFE, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0xFF,
  0xC0, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x1F, 0xFD, 0xFF, 0x80, 0x7F, 0xE3, 0xFF, 0x01, 0xFF, 0x8F, 0xFC,
  0x0F, 0xFC, 0x1F, 0xF0, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0x80, 0xFF, 0x87,
  0xFE, 0x03, 0xFE, 0x1F, 0xF0, 0x0F, 0xFC, 0x7F, 0xC0, 0x1F, 0xF3, 0xFE,
  0x00, 0x7F, 0xCF, 0xF8, 0x00, 0xFF, 0xBF, 0xE0, 0x03, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x3F, 0xEF, 0xF8, 0x01, 0xFF, 0x3F, 0xE0, 0x07, 0xFC, 0xFF, 0xC0,
  0x3F, 0xF1, 0xFF, 0x00, 0xFF, 0x87, 0xFE, 0x07, 0xFE, 0x1F, 0xF8, 0x1F,
  0xF8, 0x3F, 0xE0, 0xFF, 0xC0, 0xFF, 0xC3, 0xFF, 0x03, 0xFF, 0x0F, 0xFC,
  0x07, 0xFE, 0x7F, 0xE0, 0x1F, 0xF9, 0xFF, 0x80, 0x7F, 0xF0, 0xFF, 0xC0,
  0x0F, 0xF9, 0xFF, 0x00, 0x7F, 0xE7, 0xFE, 0x01, 0xFF, 0x8F, 0xF8, 0x07,
  0xFC, 0x3F, 0xE0, 0x3F, 0xF0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE,
  0x07, 0xFC, 0x0F, 0xF0, 0x0F, 0xF8, 0x7F, 0xC0, 0x3F, 0xE1, 0xFF, 0x00,
  0x7F, 0x87, 0xF8, 0x01, 0xFE, 0x3F, 0xE0, 0x07, 0xFC, 0xFF, 0x00, 0x0F,
  0xF3, 0xFC, 0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF,
  0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF,
  0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC,
  0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F,
  0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF,
  0x9F, 0xF3, 0xFE, 0x7F, 0xCF, 0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F,
  0xF3, 0xFE, 0x7F, 0xCF, 0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3,
  0xFE, 0x7F, 0xCF, 0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE,
  0x7F, 0xCF, 0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F,
  0xCF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x01, 0xF9,
  0xF0, 0x1F, 0x9F, 0x81, 0xF9, 0xF8, 0x3F, 0x1F, 0x83, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC7, 0xF0, 0xFC, 0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0xFE, 0x07, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0x80,
  0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F, 0xE3, 0xFE, 0x7F, 0xC7, 0xFC, 0xFF,
  0x8F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x1F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0xFF, 0x8F,
  0xF9, 0xFF, 0x1F, 0xF3, 0xFC, 0x3F, 0xEF, 0xF8, 0x7F, 0xDF, 0xF0, 0xFF,
  0xBF, 0xE1, 0xFF, 0x7F, 0xC3, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xF1, 0xFF, 0xDF, 0xE1, 0xFF, 0xBF, 0xE1, 0xFE, 0x7F, 0xC0,
  0x20, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xF9, 0xFC, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xBF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0x3F, 0xDF, 0xFE, 0x7F, 0xBF, 0xF8, 0xFF, 0x1F,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xFE,
  0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xDF,
  0xFB, 0xFF, 0x7F, 0xC3, 0xFD, 0xFE, 0x0F, 0xF7, 0xF8, 0x3F, 0xDF, 0xE0,
  0xFF, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x83, 0xFD, 0xFE, 0x0F, 0xF7, 0xFC, 0x3F, 0xDF, 0xF9, 0xFF, 0x3F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x07, 0xFF, 0xE0,
  0x07, 0xFE, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x9F, 0xE1, 0xFF, 0xBF, 0xC7, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0x9F,
  0xFB, 0xFE, 0x1F, 0xF7, 0xF8, 0x1F, 0xEF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xBF,
  0xC0, 0xFF, 0x7F, 0x81, 0xFE, 0xFF, 0x87, 0xFD, 0xFF, 0x9F, 0xFB, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x87, 0xFE,
  0xFF, 0x07, 0xF9, 0xFE, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0x3F, 0xF7, 0xFE, 0xFF, 0x83, 0xFD, 0xFF, 0x07, 0xFB,
  0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0,
  0x18, 0x3F, 0xF8, 0xF8, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x0F, 0xFF, 0x0F,
  0xFF, 0x0F, 0xFF, 0x1F, 0xFC, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x00, 0x20, 0x00, 0x03, 0xFC, 0xFF, 0x0F, 0xFE, 0xFF, 0x1F, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x7F, 0xF7,
  0xFF, 0x7F, 0xC1, 0xFF, 0x7F, 0xC1, 0xFF, 0x7F, 0xC1, 0xFF, 0x7F, 0x81,
  0xFF, 0x7F, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0x7F, 0x81, 0xFF, 0x7F, 0x81,
  0xFF, 0x7F, 0x81, 0xFF, 0x7F, 0xC1, 0xFF, 0x7F, 0xC1, 0xFF, 0x7F, 0xF3,
  0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0x03, 0xFD, 0xFF, 0x00, 0x21, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0x06, 0x03, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x07, 0xFF,
  0xE0, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xFC, 0x10, 0x0F, 0xF9, 0xFC, 0x1F, 0xF7, 0xFE, 0x3F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0x3F, 0xF7, 0xFC,
  0x3F, 0xEF, 0xF8, 0x3F, 0xDF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0x83, 0xFE, 0x0C, 0x0F, 0xC7, 0xFB, 0xFF, 0xFF, 0xFF, 0xF7, 0xF9, 0xFE,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F,
  0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9,
  0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F,
  0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x80, 0x00, 0xC0, 0x0F, 0xC0, 0x7F, 0x83,
  0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0x7F, 0x81, 0xFE, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC,
  0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF,
  0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F,
  0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F,
  0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFE, 0x0F,
  0xFB, 0xFF, 0xEF, 0xFF, 0xBF, 0xFC, 0xFF, 0xF3, 0xFF, 0x8F, 0xF8, 0x3F,
  0x80, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF8, 0x3F, 0xF7, 0xFC, 0x3F, 0xF3, 0xFE, 0x1F, 0xF9,
  0xFF, 0x1F, 0xF8, 0xFF, 0x8F, 0xF8, 0x7F, 0xCF, 0xFC, 0x3F, 0xEF, 0xFC,
  0x1F, 0xF7, 0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFE,
  0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xC1, 0xFF, 0xBF, 0xE0, 0xFF, 0x9F, 0xF8, 0x7F, 0xC7, 0xFC, 0x3F,
  0xE3, 0xFF, 0x1F, 0xF0, 0xFF, 0x8F, 0xF8, 0x7F, 0xE7, 0xFC, 0x1F, 0xF3,
  0xFE, 0x0F, 0xFD, 0xFF, 0x07, 0xFE, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x01, 0x00, 0x00, 0x1F, 0xF3, 0xFC, 0x1F, 0xE3,
  0xFE, 0xFF, 0xC7, 0xFE, 0x7F, 0xFF, 0xFD, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFB, 0xFF, 0xFF, 0x87, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0x83, 0xFF, 0xFE,
  0x0F, 0xF0, 0x7F, 0xFF, 0xC1, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xC1, 0xFF,
  0xFF, 0x07, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xE0,
  0xFF, 0xFF, 0x83, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0x83, 0xFF, 0xFE, 0x0F,
  0xF0, 0x7F, 0xFF, 0xC1, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xC1, 0xFF, 0xFF,
  0x07, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xE0, 0xFF,
  0xFF, 0x83, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0x83, 0xFF, 0xFE, 0x0F, 0xF0,
  0x7F, 0xFF, 0xC1, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xC1, 0xFF, 0xFF, 0x07,
  0xF8, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x3F, 0xC3, 0xFC, 0xFF, 0xC7,
  0xFB, 0xFF, 0xCF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F,
  0xE7, 0xFE, 0xFF, 0x87, 0xFD, 0xFF, 0x07, 0xFB, 0xFE, 0x0F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xC0, 0x00, 0x08, 0x00, 0x01, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFE, 0x3F, 0xF7, 0xFE, 0x7F, 0xC3, 0xFE, 0x7F, 0xC1, 0xFF,
  0x7F, 0x81, 0xFF, 0x7F, 0x81, 0xFF, 0x7F, 0x81, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF,
  0x7F, 0x81, 0xFF, 0x7F, 0x81, 0xFF, 0x7F, 0x81, 0xFF, 0x7F, 0xC1, 0xFF,
  0x7F, 0xC1, 0xFE, 0x3F, 0xF7, 0xFE, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x3F, 0x83, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F,
  0xF7, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0x1F, 0xF3, 0xF8, 0x3F, 0xE1, 0x80, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF1, 0xFC, 0x3F, 0xF3, 0xF8, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xF3, 0xFF,
  0x7F, 0xC3, 0xFE, 0xFF, 0x03, 0xFD, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xF7, 0xF8,
  0x1F, 0xEF, 0xF0, 0x3F, 0xDF, 0xF0, 0x7F, 0xBF, 0xF3, 0xFF, 0x7F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xDF,
  0xE0, 0xFF, 0x3F, 0xC0, 0x10, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x1F, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x80, 0xFF,
  0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF,
  0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF,
  0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF0, 0xFF, 0xFF, 0xE7, 0xFE, 0xFF, 0x9F, 0xE1, 0xFF, 0x7F, 0x87, 0xFD,
  0xFE, 0x1F, 0xF7, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xF8, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x07, 0xFF,
  0xE0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xE1, 0xFF, 0x7F, 0xEF, 0xF9, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x03, 0x00,
  0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC,
  0x0F, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE7, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF,
  0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0,
  0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x03, 0xFF, 0x47, 0xFF, 0x8F,
  0xFF, 0x1F, 0xFE, 0x1F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF0, 0x02, 0x00, 0xFF,
  0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF3, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xDF, 0xF0, 0xFF, 0x3F, 0xE0, 0x10,
  0x00, 0x00, 0x7F, 0xC1, 0xFF, 0x7F, 0xC1, 0xFF, 0x7F, 0xC1, 0xFF, 0x7F,
  0xC1, 0xFE, 0x3F, 0xC3, 0xFE, 0x3F, 0xC3, 0xFE, 0x3F, 0xE3, 0xFE, 0x3F,
  0xE3, 0xFC, 0x1F, 0xE3, 0xFC, 0x1F, 0xE3, 0xFC, 0x1F, 0xE7, 0xFC, 0x1F,
  0xE7, 0xF8, 0x0F, 0xF7, 0xF8, 0x0F, 0xF7, 0xF8, 0x0F, 0xF7, 0xF8, 0x0F,
  0xF7, 0xF0, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x03,
  0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x01,
  0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0xFF, 0x07, 0xE0, 0xFF, 0xFF, 0x07, 0xE1,
  0xFF, 0xFF, 0x0F, 0xE1, 0xFE, 0xFF, 0x0F, 0xF1, 0xFE, 0x7F, 0x8F, 0xF1,
  0xFE, 0x7F, 0x8F, 0xF1, 0xFE, 0x7F, 0x9F, 0xF1, 0xFE, 0x7F, 0x9F, 0xF1,
  0xFE, 0x7F, 0x9F, 0xF9, 0xFC, 0x3F, 0x9F, 0xF9, 0xFC, 0x3F, 0x9F, 0xFB,
  0xFC, 0x3F, 0xBF, 0xFB, 0xFC, 0x3F, 0xBF, 0xFB, 0xFC, 0x3F, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFE, 0xFF, 0xF8, 0x1F, 0xFE, 0x7F,
  0xF8, 0x1F, 0xFE, 0x7F, 0xF8, 0x1F, 0xFE, 0x7F, 0xF0, 0x1F, 0xFE, 0x7F,
  0xF0, 0x0F, 0xFC, 0x7F, 0xF0, 0x0F, 0xFC, 0x3F, 0xF0, 0x0F, 0xFC, 0x3F,
  0xF0, 0x0F, 0xFC, 0x3F, 0xF0, 0x0F, 0xF8, 0x3F, 0xE0, 0x07, 0xF8, 0x3F,
  0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x1F,
  0xE0, 0xFF, 0x83, 0xFE, 0xFF, 0x07, 0xFD, 0xFF, 0x1F, 0xF3, 0xFE, 0x3F,
  0xE3, 0xFC, 0x7F, 0x87, 0xFD, 0xFF, 0x07, 0xFB, 0xFC, 0x0F, 0xF7, 0xF8,
  0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x3F, 0xFE, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x07,
  0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x01, 0xFF,
  0xFF, 0x03, 0xFD, 0xFE, 0x0F, 0xFB, 0xFE, 0x1F, 0xE3, 0xFC, 0x7F, 0xC7,
  0xFC, 0xFF, 0x8F, 0xF9, 0xFE, 0x0F, 0xF7, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F,
  0xE0, 0xFF, 0xC1, 0xFF, 0xBF, 0xE0, 0xFF, 0x9F, 0xF0, 0x7F, 0xCF, 0xF8,
  0x3F, 0xE7, 0xFC, 0x3F, 0xE1, 0xFF, 0x1F, 0xF0, 0xFF, 0x8F, 0xF8, 0x7F,
  0xC7, 0xFC, 0x1F, 0xE7, 0xFC, 0x0F, 0xF3, 0xFE, 0x07, 0xFD, 0xFF, 0x03,
  0xFE, 0xFF, 0x00, 0xFF, 0x7F, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xF8,
  0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF,
  0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03,
  0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFE,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x30, 0x07, 0x80, 0x7C, 0x07, 0xF0, 0x7F, 0x83, 0xF8, 0x3F, 0xC1, 0xFC,
  0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81,
  0xFC, 0x0F, 0xE0, 0x7F, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xE0, 0xFF,
  0x1F, 0xF0, 0xFF, 0x87, 0xF0, 0x3F, 0x81, 0xFF, 0x0F, 0xF8, 0x1F, 0xE0,
  0x7F, 0x03, 0xFC, 0x1F, 0xE0, 0xFF, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF8, 0x1F, 0xC0, 0xFF, 0x03, 0xF8, 0x0F, 0x80, 0x3C, 0x00, 0x60,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x60,
  0x03, 0x80, 0x3F, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x0F, 0xF0,
  0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xFC, 0x1F, 0xE0, 0x7F,
  0x83, 0xFF, 0x0F, 0xF8, 0x3F, 0xC1, 0xFE, 0x1F, 0xF1, 0xFF, 0x8F, 0xF0,
  0xFF, 0x07, 0xF8, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x07, 0xF8,
  0x3F, 0x81, 0xFC, 0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x1C, 0x00, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xF8, 0x0F, 0xC7, 0xFE, 0x07, 0xE7, 0xFF, 0x87,
  0xF3, 0xFF, 0xE3, 0xFB, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFC, 0xFC, 0x7F,
  0xFE, 0xFE, 0x1F, 0xFE, 0x7F, 0x07, 0xFE, 0x3F, 0x01, 0xFE, 0x00, 0x00,
  0x3E, 0x00,
};

const GFXglyph RobotoCondensed_Black54pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 9, 39, 14, 3, -38 },
  { 45, 15, 15, 17, 1, -41 },
  { 74, 25, 38, 28, 1, -38 },
  { 193, 23, 50, 28, 2, -44 },
  { 337, 30, 40, 35, 2, -39 },
  { 487, 30, 40, 32, 1, -39 },
  { 637, 6, 15, 8, 1, -41 },
  { 649, 13, 54, 18, 3, -42 },
  { 737, 14, 54, 17, 1, -42 },
  { 832, 24, 24, 25, 1, -38 },
  { 904, 23, 28, 25, 1, -32 },
  { 985, 10, 17, 15, 1, -7 },
  { 1007, 14, 7, 23, 4, -20 },
  { 1020, 10, 9, 16, 3, -8 },
  { 1032, 16, 41, 17, 0, -38 },
  { 1114, 23, 40, 28, 2, -39 },
  { 1229, 16, 38, 28, 4, -38 },
  { 1305, 23, 39, 28, 2, -39 },
  { 1418, 24, 40, 28, 1, -39 },
  { 1538, 24, 38, 28, 2, -38 },
  { 1652, 23, 39, 28, 2, -38 },
  { 1765, 24, 39, 28, 2, -38 },
  { 1882, 23, 38, 28, 2, -38 },
  { 1992, 23, 40, 28, 2, -39 },
  { 2107, 23, 39, 28, 2, -39 },
  { 2220, 10, 30, 16, 3, -29 },
  { 2258, 11, 39, 15, 2, -29 },
  { 2312, 20, 26, 24, 1, -29 },
  { 2377, 21, 19, 28, 3, -26 },
  { 2427, 20, 26, 24, 3, -29 },
  { 2492, 22, 40, 25, 1, -39 },
  { 2602, 37, 49, 41, 2, -37 },
  { 2829, 32, 38, 33, 0, -38 },
  { 2981, 25, 38, 31, 3, -38 },
  { 3100, 28, 40, 31, 2, -39 },
  { 3240, 25, 38, 30, 3, -38 },
  { 3359, 22, 38, 26, 3, -38 },
  { 3464, 22, 38, 26, 3, -38 },
  { 3569, 28, 40, 32, 2, -39 },
  { 3709, 27, 38, 33, 3, -38 },
  { 3838, 9, 38, 15, 3, -38 },
  { 3881, 23, 39, 27, 1, -38 },
  { 3994, 28, 38, 30, 3, -38 },
  { 4127, 22, 38, 26, 3, -38 },
  { 4232, 35, 38, 41, 3, -38 },
  { 4399, 27, 38, 33, 3, -38 },
  { 4528, 29, 40, 33, 2, -39 },
  { 4673, 26, 38, 31, 3, -38 },
  { 4797, 29, 46, 33, 2, -39 },
  { 4964, 26, 38, 31, 3, -38 },
  { 5088, 26, 40, 30, 2, -39 },
  { 5218, 28, 38, 30, 1, -38 },
  { 5351, 26, 39, 31, 3, -38 },
  { 5478, 31, 38, 32, 0, -38 },
  { 5626, 38, 38, 40, 1, -38 },
  { 5807, 30, 38, 30, 0, -38 },
  { 5950, 30, 38, 30, 0, -38 },
  { 6093, 25, 38, 29, 2, -38 },
  { 6212, 10, 54, 14, 3, -45 },
  { 6280, 22, 41, 21, 0, -38 },
  { 6393, 11, 54, 14, 1, -45 },
  { 6468, 20, 19, 22, 1, -38 },
  { 6516, 20, 7, 21, 1, 0 },
  { 6534, 15, 8, 18, 1, -40 },
  { 6549, 23, 31, 25, 1, -30 },
  { 6639, 23, 42, 27, 2, -41 },
  { 6760, 22, 31, 25, 1, -30 },
  { 6846, 23, 42, 27, 1, -41 },
  { 6967, 23, 31, 26, 2, -30 },
  { 7057, 16, 42, 18, 1, -42 },
  { 7141, 24, 41, 27, 1, -30 },
  { 7264, 23, 41, 27, 2, -41 },
  { 7382, 10, 41, 14, 2, -41 },
  { 7434, 14, 52, 14, -2, -41 },
  { 7525, 25, 41, 27, 2, -41 },
  { 7654, 8, 41, 14, 3, -41 },
  { 7695, 35, 30, 40, 2, -30 },
  { 7827, 23, 30, 27, 2, -30 },
  { 7914, 24, 31, 27, 1, -30 },
  { 8007, 23, 41, 27, 2, -30 },
  { 8125, 23, 41, 27, 1, -30 },
  { 8243, 16, 30, 19, 2, -30 },
  { 8303, 22, 31, 24, 1, -30 },
  { 8389, 15, 37, 17, 1, -36 },
  { 8459, 23, 30, 27, 2, -29 },
  { 8546, 24, 29, 25, 0, -29 },
  { 8633, 32, 29, 34, 1, -29 },
  { 8749, 23, 29, 25, 1, -29 },
  { 8833, 25, 40, 25, 0, -29 },
  { 8958, 21, 29, 25, 2, -29 },
  { 9035, 13, 52, 16, 1, -42 },
  { 9120, 4, 45, 14, 5, -38 },
  { 9143, 13, 52, 16, 2, -42 },
  { 9228, 25, 12, 29, 2, -22 },
};

const GFXfont RobotoCondensed_Black54pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Black54pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Black54pt7bGlyphs,
  0x20, 0x7E, 63
};

#endif // _ROBOTOCONDENSED_BLACK54PT7B_H_
