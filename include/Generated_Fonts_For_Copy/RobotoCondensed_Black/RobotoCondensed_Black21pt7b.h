#ifndef _ROBOTOCONDENSED_BLACK21PT7B_H_
#define _ROBOTOCONDENSED_BLACK21PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Black.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Black21pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFE, 0xEE, 0xEE, 0x60, 0xEF, 0xE0, 0xEF, 0xBE, 0xF3,
  0xCF, 0x30, 0x0D, 0x82, 0x41, 0xB0, 0x6C, 0x7F, 0xDF, 0xF1, 0xB0, 0x6C,
  0x1B, 0x3F, 0xEF, 0xF8, 0xD8, 0x36, 0x0D, 0x83, 0x60, 0x0C, 0x06, 0x0F,
  0x8F, 0xE7, 0xF7, 0xBF, 0xCF, 0xE0, 0x7C, 0x1F, 0x03, 0xC0, 0xFE, 0x7F,
  0x3F, 0xFE, 0xFE, 0x3E, 0x04, 0x02, 0x00, 0x78, 0x0F, 0x80, 0xDC, 0x8C,
  0xD8, 0xDF, 0x0F, 0xB0, 0x7E, 0x00, 0x60, 0x0D, 0xC0, 0xFE, 0x1B, 0x71,
  0xB7, 0x33, 0x71, 0x3E, 0x01, 0xC0, 0x3C, 0x0F, 0xC1, 0xFC, 0x3B, 0x87,
  0x70, 0xFC, 0x1F, 0x03, 0xEE, 0xFD, 0xDF, 0xFB, 0xBF, 0x73, 0xCF, 0xF9,
  0xFF, 0x8F, 0x78, 0xFF, 0xFF, 0xC0, 0x08, 0xCE, 0x67, 0x31, 0x9C, 0xE7,
  0x39, 0xCE, 0x71, 0x8C, 0x71, 0x8E, 0x30, 0x80, 0x86, 0x38, 0xC7, 0x38,
  0xC7, 0x39, 0xCE, 0x73, 0x9C, 0xCE, 0x73, 0x39, 0x88, 0x00, 0x0C, 0x03,
  0x04, 0xC3, 0xFE, 0x3F, 0x87, 0x83, 0xE0, 0xCC, 0x23, 0x00, 0x38, 0x38,
  0x38, 0x38, 0xFF, 0xFF, 0xFF, 0x38, 0x38, 0x38, 0x38, 0x33, 0x37, 0x76,
  0x60, 0xFF, 0xFE, 0xFF, 0x60, 0x0C, 0x31, 0xC6, 0x18, 0x63, 0x8C, 0x30,
  0xC7, 0x18, 0x63, 0x8E, 0x30, 0x3C, 0x3F, 0x9F, 0xDC, 0xFE, 0x7F, 0x3F,
  0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFE, 0xF7, 0xF3, 0xF8, 0xF0, 0x0C, 0xFF,
  0xFF, 0xBC, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xC0, 0x3E, 0x3F,
  0xBF, 0xDC, 0xFE, 0x78, 0x38, 0x1C, 0x1E, 0x1E, 0x1E, 0x0E, 0x0F, 0x0F,
  0xFF, 0xFF, 0xFE, 0x3C, 0x3F, 0xBF, 0xDC, 0xF0, 0x78, 0x3C, 0x7C, 0x3C,
  0x1F, 0x03, 0xC0, 0xFC, 0xFF, 0xFF, 0xF8, 0xF8, 0x0F, 0x07, 0x87, 0xC3,
  0xE3, 0xF1, 0xF9, 0xFC, 0xFE, 0xEF, 0x7F, 0xFF, 0xFF, 0xF0, 0xF0, 0x78,
  0x3C, 0x7F, 0x3F, 0xBF, 0xDC, 0x0E, 0x07, 0xF3, 0xFD, 0xCE, 0x07, 0x83,
  0xC1, 0xFC, 0xFF, 0xF3, 0xF8, 0xF0, 0x0E, 0x1F, 0x0F, 0x8F, 0x0F, 0x07,
  0x73, 0xFD, 0xFF, 0xE7, 0xF1, 0xF8, 0xFC, 0xF7, 0xFB, 0xF8, 0xF8, 0xFF,
  0xFF, 0xFF, 0xE0, 0xE0, 0x70, 0x78, 0x38, 0x1C, 0x1E, 0x0E, 0x0F, 0x07,
  0x83, 0x83, 0xC1, 0xE0, 0x3E, 0x3F, 0xBF, 0xDE, 0xFF, 0x7F, 0xB9, 0xFC,
  0x7C, 0x7F, 0x7B, 0xF9, 0xFC, 0xFF, 0xFB, 0xF8, 0xF8, 0x3C, 0x3F, 0x3F,
  0xDC, 0xEE, 0x7F, 0x3F, 0x9F, 0xFF, 0x7F, 0x9F, 0xC1, 0xC1, 0xE3, 0xE1,
  0xE0, 0xE0, 0xFF, 0x70, 0x00, 0x00, 0xFF, 0x70, 0xFF, 0x60, 0x00, 0x00,
  0x77, 0x76, 0xEE, 0xC0, 0x02, 0x1C, 0xFF, 0xEF, 0x1E, 0x3F, 0x1F, 0x0E,
  0x04, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0xF8, 0x7E,
  0x1F, 0x1F, 0x7E, 0xF8, 0xE0, 0x80, 0x3E, 0x3F, 0x9F, 0xFE, 0xF0, 0x78,
  0x3C, 0x3C, 0x3C, 0x1C, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0xE0, 0x70, 0x07,
  0xC0, 0x7F, 0xC3, 0x83, 0x9C, 0x06, 0x63, 0xCF, 0x9F, 0x3C, 0xEC, 0xF3,
  0x33, 0xCC, 0xCF, 0x73, 0x3D, 0xCC, 0xF3, 0x73, 0xCF, 0xFB, 0x19, 0xCE,
  0x00, 0x18, 0x00, 0x70, 0x00, 0xFF, 0x00, 0xF8, 0x00, 0x07, 0x00, 0x78,
  0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0E, 0xE0, 0x77, 0x07, 0xB8, 0x39, 0xE1,
  0xFF, 0x1F, 0xF8, 0xFF, 0xE7, 0x0F, 0x38, 0x7B, 0xC1, 0xC0, 0xFF, 0x3F,
  0xEF, 0xFF, 0xCF, 0xF3, 0xFC, 0xFF, 0x3B, 0xFC, 0xFF, 0xBC, 0xFF, 0x1F,
  0xCF, 0xFF, 0xFF, 0xEF, 0xF0, 0x1F, 0x0F, 0xF1, 0xFF, 0x78, 0xEE, 0x1D,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x87, 0x78, 0xE7, 0xFC, 0xFF,
  0x07, 0xC0, 0xFE, 0x3F, 0xCF, 0xFB, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF,
  0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xFF, 0xBF, 0xCF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFE, 0x0F, 0x07, 0x83, 0xFD, 0xFE, 0xFF, 0x78, 0x3C, 0x1E, 0x0F, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0x07, 0x83, 0xFD, 0xFE, 0xFF,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC0, 0x1F, 0x0F, 0xF1, 0xFF, 0x78,
  0xEF, 0x1F, 0xC0, 0x38, 0x07, 0x3F, 0xE7, 0xFC, 0x3F, 0xC7, 0xF8, 0xF7,
  0xFE, 0xFF, 0x87, 0xC0, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC,
  0x78, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xFC, 0xEE, 0x77, 0xFB,
  0xF8, 0x78, 0xF3, 0xFE, 0x7B, 0xDE, 0x7B, 0xCF, 0xF1, 0xFE, 0x3F, 0x87,
  0xF0, 0xFF, 0x1F, 0xE3, 0xDE, 0x7B, 0xCF, 0x3D, 0xE7, 0xBC, 0x78, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0xFF, 0xFF, 0xFE, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xFC,
  0xFF, 0xF3, 0xFE, 0xCD, 0xFB, 0x37, 0xEF, 0xDF, 0xBF, 0xFE, 0x7B, 0xFD,
  0xEF, 0xF7, 0xBF, 0xDE, 0xFF, 0x33, 0xC0, 0xF1, 0xFE, 0x3F, 0xE7, 0xFC,
  0xFF, 0x9F, 0xFB, 0xFF, 0x7F, 0xFF, 0xF7, 0xFE, 0xFF, 0xDF, 0xF9, 0xFF,
  0x3F, 0xE3, 0xFC, 0x78, 0x1F, 0x0F, 0xF1, 0xFF, 0x78, 0xEF, 0x1F, 0xC3,
  0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0xC7, 0xF8, 0xE7, 0xFC, 0xFF, 0x07,
  0xC0, 0xFF, 0x3F, 0xEF, 0xFF, 0xCF, 0xF1, 0xFC, 0x7F, 0x3F, 0xFF, 0xFF,
  0xBF, 0xCF, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x00, 0x1F, 0x0F, 0xF1, 0xFF,
  0x78, 0xEF, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0xC7, 0xF8,
  0xE7, 0xFC, 0xFF, 0x07, 0xE0, 0x1E, 0x01, 0xC0, 0x10, 0xFF, 0x3F, 0xEF,
  0xFF, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xFE, 0xFF, 0xBF, 0xCF, 0x7B, 0xDE,
  0xF3, 0xBC, 0xFF, 0x3C, 0x3E, 0x1F, 0xEF, 0xFB, 0xCF, 0xF3, 0xFC, 0x07,
  0xE0, 0xFC, 0x0F, 0x80, 0xFE, 0x3F, 0x8F, 0xFF, 0xDF, 0xE1, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0x87, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0xF1, 0xFC, 0x7F, 0x1F,
  0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xCF, 0xFF,
  0xDF, 0xE3, 0xF0, 0xF0, 0xF7, 0x0F, 0x78, 0xE7, 0x8E, 0x79, 0xE3, 0x9E,
  0x39, 0xC3, 0xDC, 0x3D, 0xC1, 0xFC, 0x1F, 0x81, 0xF8, 0x0F, 0x80, 0xF0,
  0x0F, 0x00, 0xF3, 0x8E, 0xE7, 0x9D, 0xCF, 0x7B, 0x9E, 0xF7, 0x7D, 0xCF,
  0xFB, 0x9F, 0xF7, 0x1F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF8, 0xFB, 0xE1, 0xF7,
  0xC3, 0xE7, 0x83, 0xCF, 0x07, 0x9E, 0x00, 0xF1, 0xE7, 0x9E, 0x79, 0xC3,
  0xBC, 0x3F, 0xC1, 0xF8, 0x1F, 0x80, 0xF0, 0x1F, 0x81, 0xF8, 0x3F, 0xC3,
  0xBC, 0x79, 0xE7, 0x9E, 0xF1, 0xE0, 0xF0, 0xEE, 0x3D, 0xE7, 0x1C, 0xE3,
  0xBC, 0x77, 0x07, 0xE0, 0xF8, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0x1E, 0x07, 0x03, 0xC0, 0xE0,
  0x70, 0x3C, 0x0E, 0x07, 0x81, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFE,
  0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEF, 0xFF, 0xF0, 0x78, 0x1C,
  0x0F, 0x07, 0x81, 0xC0, 0xF0, 0x78, 0x1C, 0x0F, 0x07, 0x81, 0xC0, 0xF0,
  0x78, 0x1C, 0x0E, 0xFF, 0xFE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD,
  0xEF, 0x7B, 0xDF, 0xFF, 0xFC, 0x1C, 0x3C, 0x3C, 0x36, 0x76, 0x66, 0x67,
  0xFF, 0xFF, 0xFF, 0xF3, 0x8E, 0x3C, 0xFE, 0xEF, 0xE7, 0x7F, 0xFF, 0xE7,
  0xE7, 0xEF, 0xFF, 0x77, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x73, 0xFD,
  0xFF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0xFF, 0xFD, 0xDC, 0x3C, 0x7E,
  0xFF, 0xE7, 0xE0, 0xE0, 0xE0, 0xE7, 0xFF, 0x7E, 0x3C, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x7F, 0xFF, 0xFF, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xFF, 0xFF,
  0x7F, 0x3E, 0x3F, 0xBF, 0xDC, 0xEE, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0x3F,
  0x8F, 0x80, 0x1E, 0x7C, 0xF9, 0xC3, 0x9F, 0xFF, 0x9C, 0x38, 0x70, 0xE1,
  0xC3, 0x87, 0x0E, 0x1C, 0x7B, 0xFF, 0xFF, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F,
  0xCF, 0xFF, 0xFF, 0xDF, 0xE0, 0xF7, 0xF3, 0xF8, 0xF0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x73, 0xFD, 0xFE, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F,
  0x3F, 0x9F, 0xCF, 0xEF, 0xE0, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xE0, 0x38,
  0xF3, 0x80, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCE, 0xFB,
  0xEF, 0x00, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x3F, 0xBD, 0xDC, 0xFE,
  0x7E, 0x3F, 0x9F, 0xCF, 0xF7, 0x3B, 0x9F, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xEE, 0x73, 0xFF, 0xEF, 0xFF, 0xB9, 0xCF, 0xE7, 0x3F, 0x9C,
  0xFE, 0x73, 0xF9, 0xCF, 0xE7, 0x3F, 0x9C, 0xFE, 0x73, 0xC0, 0xEE, 0x7F,
  0xBF, 0xDC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xE0, 0x3C,
  0x3F, 0xBF, 0xDC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xFF, 0x3F, 0x8F, 0x80,
  0xEE, 0x7F, 0xBF, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xFF, 0xFF, 0xBB,
  0x9C, 0x0E, 0x07, 0x03, 0x80, 0x7F, 0xFF, 0xFF, 0xE7, 0xE7, 0xE7, 0xE7,
  0xE7, 0xFF, 0xFF, 0x7F, 0x07, 0x07, 0x07, 0x07, 0xEF, 0xFF, 0xFC, 0xE3,
  0x8E, 0x38, 0xE3, 0x8E, 0x00, 0x3E, 0x3F, 0x9D, 0xEE, 0x77, 0xC1, 0xF8,
  0x3F, 0xEF, 0x77, 0xBF, 0x8F, 0x80, 0x79, 0xE7, 0xBF, 0xFD, 0xE7, 0x9E,
  0x79, 0xE7, 0x9F, 0x3C, 0x70, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F,
  0x9F, 0xCF, 0xFF, 0xFF, 0xDF, 0xE0, 0xF3, 0xB9, 0xDD, 0xEE, 0xF7, 0x71,
  0xF8, 0xFC, 0x7C, 0x3E, 0x0F, 0x07, 0x80, 0xF7, 0x3B, 0xBB, 0xDD, 0xDC,
  0xEE, 0xE7, 0xFF, 0x3E, 0xF8, 0xF7, 0xC7, 0xBC, 0x3D, 0xE1, 0xE7, 0x0E,
  0x38, 0x73, 0x9D, 0xE7, 0xF0, 0xFC, 0x3E, 0x07, 0x83, 0xF0, 0xFC, 0x7F,
  0x1D, 0xEF, 0x38, 0xF3, 0x9C, 0xE7, 0x79, 0xDE, 0x7F, 0x0F, 0xC3, 0xF0,
  0xF8, 0x1E, 0x07, 0x81, 0xC0, 0x70, 0x7C, 0x1E, 0x07, 0x80, 0xFF, 0xFF,
  0xFE, 0x1E, 0x1C, 0x38, 0x78, 0x70, 0xFF, 0xFF, 0xFF, 0x08, 0x63, 0x8E,
  0x38, 0xE3, 0x8E, 0x73, 0x8F, 0x1C, 0x38, 0xE3, 0x8E, 0x38, 0xE1, 0x82,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x87, 0x39, 0xCE, 0x73, 0x8C, 0x71, 0xDE,
  0xE6, 0x73, 0x9C, 0xE7, 0x31, 0x00, 0x71, 0xBC, 0xFF, 0xF9, 0xFC, 0x70,
};

const GFXglyph RobotoCondensed_Black21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 4, 15, 6, 1, -15 },
  { 9, 6, 6, 7, 0, -16 },
  { 14, 10, 15, 11, 0, -15 },
  { 33, 9, 19, 11, 1, -17 },
  { 55, 12, 15, 14, 1, -15 },
  { 78, 11, 15, 13, 1, -15 },
  { 99, 3, 6, 3, 0, -16 },
  { 102, 5, 21, 7, 1, -16 },
  { 116, 5, 21, 7, 1, -16 },
  { 130, 10, 9, 10, 0, -15 },
  { 142, 8, 11, 10, 1, -13 },
  { 153, 4, 7, 6, 0, -3 },
  { 157, 5, 3, 9, 2, -8 },
  { 159, 4, 3, 6, 1, -3 },
  { 161, 6, 16, 7, 0, -15 },
  { 173, 9, 15, 11, 1, -15 },
  { 190, 6, 15, 11, 2, -15 },
  { 202, 9, 15, 11, 1, -15 },
  { 219, 9, 15, 11, 1, -15 },
  { 236, 9, 15, 11, 1, -15 },
  { 253, 9, 15, 11, 1, -15 },
  { 270, 9, 15, 11, 1, -15 },
  { 287, 9, 15, 11, 1, -15 },
  { 304, 9, 15, 11, 1, -15 },
  { 321, 9, 15, 11, 1, -15 },
  { 338, 4, 11, 6, 1, -11 },
  { 344, 4, 15, 6, 1, -11 },
  { 352, 7, 10, 9, 1, -11 },
  { 361, 8, 7, 11, 1, -10 },
  { 368, 8, 10, 9, 1, -11 },
  { 378, 9, 15, 10, 0, -15 },
  { 395, 14, 19, 16, 1, -14 },
  { 429, 13, 15, 13, 0, -15 },
  { 454, 10, 15, 12, 1, -15 },
  { 473, 11, 15, 12, 1, -15 },
  { 494, 10, 15, 12, 1, -15 },
  { 513, 9, 15, 10, 1, -15 },
  { 530, 9, 15, 10, 1, -15 },
  { 547, 11, 15, 12, 1, -15 },
  { 568, 11, 15, 13, 1, -15 },
  { 589, 4, 15, 6, 1, -15 },
  { 597, 9, 15, 10, 0, -15 },
  { 614, 11, 15, 12, 1, -15 },
  { 635, 9, 15, 10, 1, -15 },
  { 652, 14, 15, 16, 1, -15 },
  { 679, 11, 15, 13, 1, -15 },
  { 700, 11, 15, 13, 1, -15 },
  { 721, 10, 15, 12, 1, -15 },
  { 740, 11, 18, 13, 1, -15 },
  { 765, 10, 15, 12, 1, -15 },
  { 784, 10, 15, 12, 1, -15 },
  { 803, 11, 15, 12, 0, -15 },
  { 824, 10, 15, 12, 1, -15 },
  { 843, 12, 15, 12, 0, -15 },
  { 866, 15, 15, 16, 0, -15 },
  { 895, 12, 15, 12, 0, -15 },
  { 918, 11, 15, 12, 0, -15 },
  { 939, 10, 15, 11, 1, -15 },
  { 958, 4, 22, 6, 1, -18 },
  { 969, 9, 16, 8, 0, -15 },
  { 987, 5, 22, 6, 0, -18 },
  { 1001, 8, 7, 8, 0, -15 },
  { 1008, 8, 3, 8, 0, 0 },
  { 1011, 5, 3, 7, 1, -16 },
  { 1013, 8, 11, 10, 1, -11 },
  { 1024, 9, 16, 10, 1, -16 },
  { 1042, 8, 11, 10, 1, -11 },
  { 1053, 8, 16, 10, 1, -16 },
  { 1069, 9, 11, 10, 1, -11 },
  { 1082, 7, 16, 7, 0, -16 },
  { 1096, 9, 15, 11, 1, -11 },
  { 1113, 9, 16, 10, 1, -16 },
  { 1131, 4, 15, 5, 1, -15 },
  { 1139, 6, 19, 5, -1, -15 },
  { 1154, 9, 16, 10, 1, -16 },
  { 1172, 3, 16, 5, 1, -16 },
  { 1178, 14, 11, 15, 1, -11 },
  { 1198, 9, 11, 10, 1, -11 },
  { 1211, 9, 11, 10, 1, -11 },
  { 1224, 9, 15, 10, 1, -11 },
  { 1241, 8, 15, 10, 1, -11 },
  { 1256, 6, 11, 7, 1, -11 },
  { 1265, 9, 11, 10, 0, -11 },
  { 1278, 6, 14, 7, 0, -14 },
  { 1289, 9, 11, 10, 1, -11 },
  { 1302, 9, 11, 10, 0, -11 },
  { 1315, 13, 11, 13, 0, -11 },
  { 1333, 10, 11, 10, 0, -11 },
  { 1347, 10, 15, 10, 0, -11 },
  { 1366, 8, 11, 10, 1, -11 },
  { 1377, 6, 20, 6, 0, -16 },
  { 1392, 2, 18, 5, 2, -15 },
  { 1397, 5, 20, 6, 1, -16 },
  { 1410, 9, 5, 11, 1, -9 },
};

const GFXfont RobotoCondensed_Black21pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Black21pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Black21pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _ROBOTOCONDENSED_BLACK21PT7B_H_
