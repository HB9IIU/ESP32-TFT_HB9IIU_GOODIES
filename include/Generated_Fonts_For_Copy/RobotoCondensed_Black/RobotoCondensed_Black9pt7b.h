#ifndef _ROBOTOCONDENSED_BLACK9PT7B_H_
#define _ROBOTOCONDENSED_BLACK9PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Black.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Black9pt7bBitmaps[] PROGMEM = {
  0x00, 0xD5, 0x4C, 0xB6, 0x80, 0x55, 0xF6, 0xF6, 0x60, 0x27, 0x54, 0x71,
  0xD7, 0x20, 0x65, 0x9C, 0x43, 0xAC, 0x60, 0x62, 0x9C, 0xCF, 0xED, 0xE0,
  0xE0, 0x6A, 0xAA, 0x40, 0x89, 0x26, 0x92, 0x80, 0x2F, 0x65, 0x66, 0xF6,
  0x60, 0x58, 0xC0, 0x80, 0x29, 0x25, 0x24, 0x75, 0xDD, 0xD5, 0x70, 0x75,
  0x54, 0x7D, 0x13, 0x64, 0xF0, 0x7D, 0x12, 0x1D, 0x70, 0x33, 0x77, 0x7F,
  0x30, 0x74, 0xF1, 0x1D, 0x60, 0x24, 0xFD, 0xD5, 0x70, 0xF1, 0x32, 0x26,
  0x40, 0x75, 0x56, 0xDD, 0x70, 0x65, 0xDD, 0x73, 0x60, 0x88, 0x40, 0x58,
  0x3E, 0xE3, 0xE3, 0x80, 0xC7, 0x7C, 0x6F, 0x32, 0x60, 0x60, 0x38, 0x89,
  0x6D, 0x5A, 0xB7, 0x90, 0x1C, 0x31, 0x9C, 0xA5, 0xFF, 0x20, 0xF6, 0xF7,
  0xED, 0xEF, 0xC0, 0x72, 0xF1, 0x8C, 0x2D, 0xC0, 0xF6, 0xB7, 0xBD, 0xEB,
  0xC0, 0xFC, 0xCF, 0xCC, 0xF0, 0xFC, 0xCF, 0xCC, 0xC0, 0x72, 0xF1, 0xBD,
  0xAD, 0xC0, 0xCE, 0x73, 0xFC, 0xE7, 0x20, 0xFE, 0x33, 0x33, 0x3F, 0x60,
  0xDE, 0xBD, 0xEF, 0x6B, 0x60, 0xCC, 0xCC, 0xCC, 0xF0, 0xEF, 0xBE, 0xFB,
  0xFF, 0x5D, 0x40, 0xCE, 0x7B, 0xDD, 0xEF, 0x60, 0x72, 0xF3, 0x9C, 0xAD,
  0xC0, 0xF6, 0xF7, 0xBF, 0x63, 0x00, 0x72, 0xF3, 0x9C, 0xAD, 0xC1, 0xF6,
  0xF7, 0xBF, 0x6B, 0x60, 0x72, 0xD0, 0xE1, 0xED, 0xC0, 0xF9, 0x08, 0x42,
  0x10, 0x80, 0xDE, 0xF7, 0xBD, 0xAD, 0xC0, 0xDE, 0xD6, 0xA7, 0x38, 0xC0,
  0xD5, 0xE9, 0xD3, 0xE7, 0xCD, 0x9B, 0x00, 0xDA, 0x9C, 0x67, 0x2B, 0x60,
  0xDA, 0x94, 0xE2, 0x10, 0x80, 0xF8, 0x8C, 0x46, 0x23, 0xE0, 0xFF, 0xFF,
  0xF0, 0xCC, 0x44, 0x66, 0x23, 0xD5, 0x55, 0x70, 0x6E, 0x80, 0xE0, 0x48,
  0x6F, 0x7F, 0xF0, 0xCC, 0xFD, 0xDD, 0xF0, 0x6D, 0xCD, 0x60, 0x11, 0x7D,
  0xDD, 0x70, 0x7D, 0xFC, 0x70, 0x6B, 0xA4, 0x90, 0x7D, 0xDD, 0x71, 0x70,
  0xCC, 0xFD, 0xDD, 0xD0, 0xCF, 0xFC, 0xCF, 0xFF, 0xC0, 0xCC, 0xFE, 0xEF,
  0xD0, 0xFF, 0xFC, 0xFF, 0x5D, 0x75, 0xD4, 0xFD, 0xDD, 0xD0, 0x7D, 0xDD,
  0x70, 0xFD, 0xDD, 0xFC, 0xC0, 0x7D, 0xDD, 0x71, 0x10, 0xFB, 0x6C, 0x6F,
  0x6F, 0x60, 0x5D, 0x24, 0xC0, 0xDD, 0xDD, 0x70, 0xFF, 0x66, 0x60, 0xEF,
  0xDE, 0xF5, 0x80, 0xF6, 0x66, 0xF0, 0xFF, 0x66, 0x66, 0x40, 0xF2, 0x64,
  0xF0, 0x55, 0x95, 0x40, 0xFF, 0x95, 0x55, 0x80, 0x7B,
};

const GFXglyph RobotoCondensed_Black9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 7, 2, 0, -7 },
  { 3, 3, 3, 3, 0, -7 },
  { 5, 4, 7, 5, 0, -7 },
  { 9, 4, 9, 5, 0, -8 },
  { 14, 5, 7, 6, 0, -7 },
  { 19, 5, 7, 5, 0, -7 },
  { 24, 1, 3, 1, 0, -7 },
  { 25, 2, 9, 3, 1, -7 },
  { 28, 3, 9, 3, 0, -7 },
  { 32, 4, 4, 4, 0, -7 },
  { 34, 4, 5, 4, 0, -5 },
  { 37, 2, 3, 2, 0, -1 },
  { 38, 2, 1, 4, 1, -3 },
  { 39, 1, 1, 3, 1, -1 },
  { 40, 3, 8, 3, 0, -7 },
  { 43, 4, 7, 5, 0, -7 },
  { 47, 2, 7, 5, 1, -7 },
  { 49, 4, 7, 5, 0, -7 },
  { 53, 4, 7, 5, 0, -7 },
  { 57, 4, 7, 5, 0, -7 },
  { 61, 4, 7, 5, 0, -7 },
  { 65, 4, 7, 5, 0, -7 },
  { 69, 4, 7, 5, 0, -7 },
  { 73, 4, 7, 5, 0, -7 },
  { 77, 4, 7, 5, 0, -7 },
  { 81, 1, 5, 3, 1, -5 },
  { 82, 2, 7, 3, 0, -5 },
  { 84, 4, 4, 4, 0, -5 },
  { 86, 3, 3, 5, 1, -4 },
  { 88, 4, 4, 4, 0, -5 },
  { 90, 4, 7, 4, 0, -7 },
  { 94, 7, 8, 7, 0, -6 },
  { 101, 5, 7, 5, 0, -7 },
  { 106, 5, 7, 5, 0, -7 },
  { 111, 5, 7, 5, 0, -7 },
  { 116, 5, 7, 5, 0, -7 },
  { 121, 4, 7, 4, 0, -7 },
  { 125, 4, 7, 4, 0, -7 },
  { 129, 5, 7, 5, 0, -7 },
  { 134, 5, 7, 5, 0, -7 },
  { 139, 1, 7, 3, 1, -7 },
  { 140, 4, 7, 4, 0, -7 },
  { 144, 5, 7, 5, 0, -7 },
  { 149, 4, 7, 4, 0, -7 },
  { 153, 6, 7, 7, 0, -7 },
  { 159, 5, 7, 5, 0, -7 },
  { 164, 5, 7, 5, 0, -7 },
  { 169, 5, 7, 5, 0, -7 },
  { 174, 5, 8, 5, 0, -7 },
  { 179, 5, 7, 5, 0, -7 },
  { 184, 5, 7, 5, 0, -7 },
  { 189, 5, 7, 5, 0, -7 },
  { 194, 5, 7, 5, 0, -7 },
  { 199, 5, 7, 5, 0, -7 },
  { 204, 7, 7, 7, 0, -7 },
  { 211, 5, 7, 5, 0, -7 },
  { 216, 5, 7, 5, 0, -7 },
  { 221, 5, 7, 5, 0, -7 },
  { 226, 2, 10, 2, 0, -8 },
  { 229, 4, 8, 3, 0, -7 },
  { 233, 2, 10, 2, 0, -8 },
  { 236, 3, 3, 4, 0, -7 },
  { 238, 3, 1, 4, 0, 0 },
  { 239, 3, 2, 3, 0, -7 },
  { 240, 4, 5, 4, 0, -5 },
  { 243, 4, 7, 4, 0, -7 },
  { 247, 4, 5, 4, 0, -5 },
  { 250, 4, 7, 4, 0, -7 },
  { 254, 4, 5, 4, 0, -5 },
  { 257, 3, 7, 3, 0, -7 },
  { 260, 4, 7, 5, 0, -5 },
  { 264, 4, 7, 4, 0, -7 },
  { 268, 2, 7, 2, 0, -7 },
  { 270, 2, 9, 2, 0, -7 },
  { 273, 4, 7, 4, 0, -7 },
  { 277, 2, 7, 2, 0, -7 },
  { 279, 6, 5, 7, 0, -5 },
  { 283, 4, 5, 4, 0, -5 },
  { 286, 4, 5, 4, 0, -5 },
  { 289, 4, 7, 4, 0, -5 },
  { 293, 4, 7, 4, 0, -5 },
  { 297, 3, 5, 3, 0, -5 },
  { 299, 4, 5, 4, 0, -5 },
  { 302, 3, 6, 3, 0, -6 },
  { 305, 4, 5, 4, 0, -5 },
  { 308, 4, 5, 4, 0, -5 },
  { 311, 5, 5, 6, 0, -5 },
  { 315, 4, 5, 4, 0, -5 },
  { 318, 4, 7, 4, 0, -5 },
  { 322, 4, 5, 4, 0, -5 },
  { 325, 2, 9, 3, 0, -7 },
  { 328, 1, 8, 2, 1, -7 },
  { 329, 2, 9, 3, 0, -7 },
  { 332, 4, 2, 5, 0, -4 },
};

const GFXfont RobotoCondensed_Black9pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Black9pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Black9pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _ROBOTOCONDENSED_BLACK9PT7B_H_
