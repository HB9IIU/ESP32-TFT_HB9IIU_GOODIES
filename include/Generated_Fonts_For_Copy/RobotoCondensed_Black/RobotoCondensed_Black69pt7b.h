#ifndef _ROBOTOCONDENSED_BLACK69PT7B_H_
#define _ROBOTOCONDENSED_BLACK69PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Black.ttf
// Size: 69pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Black69pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0xF7, 0xFF, 0x7F, 0xF7, 0xFF, 0x7F, 0xF7, 0xFF, 0x7F, 0xF7,
  0xFF, 0x7F, 0xF7, 0xFF, 0x7F, 0xF7, 0xFF, 0x7F, 0xF7, 0xFF, 0x7F, 0xF7,
  0xFF, 0x7F, 0xF7, 0xFF, 0x7F, 0xF7, 0xFF, 0x7F, 0xF7, 0xFF, 0x3F, 0xE3,
  0xFE, 0x3F, 0xE3, 0xFE, 0x3F, 0xE3, 0xFE, 0x3F, 0xE3, 0xFE, 0x3F, 0xE3,
  0xFE, 0x3F, 0xE3, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x3F, 0xE7, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xF7,
  0xFE, 0x3F, 0xC0, 0x70, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF,
  0x87, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE,
  0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC,
  0x1F, 0xFF, 0x83, 0xF7, 0xF0, 0x7E, 0xFC, 0x0F, 0xDF, 0x81, 0xFB, 0xF0,
  0x3F, 0x00, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x1F,
  0x87, 0xE0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x3F,
  0x8F, 0xE0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x3F,
  0x0F, 0xC0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3F,
  0x0F, 0xC0, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x7F, 0x1F, 0xC0, 0x1F, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFE,
  0x3F, 0x80, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0xFC,
  0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC,
  0x7F, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xF8,
  0xFE, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x03, 0xF0,
  0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF1,
  0xFC, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x07, 0xF1,
  0xF8, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x07, 0xE1,
  0xF8, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFC, 0x7F, 0xF8, 0xFF, 0xE1,
  0xFF, 0xE3, 0xFF, 0x83, 0xFF, 0x9F, 0xFE, 0x0F, 0xFE, 0x7F, 0xF0, 0x3F,
  0xF9, 0xFF, 0xC0, 0xFF, 0xE7, 0xFF, 0x83, 0xFF, 0xDF, 0xFE, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x3F, 0xFB, 0xFF, 0x80, 0xFF, 0xEF, 0xFE, 0x03, 0xFF, 0xBF,
  0xF8, 0x0F, 0xFE, 0xFF, 0xE0, 0x3F, 0xFB, 0xFF, 0x80, 0xFF, 0xEF, 0xFF,
  0x03, 0xFF, 0x9F, 0xFC, 0x0F, 0xFE, 0x7F, 0xF8, 0x7F, 0xF9, 0xFF, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x07, 0xFB, 0xFC, 0x03, 0x80, 0x3F, 0xC7, 0xF8, 0x0F, 0x80,
  0xFE, 0x0F, 0xE0, 0x7E, 0x03, 0xF8, 0x3F, 0x83, 0xF8, 0x0F, 0xE0, 0xFE,
  0x0F, 0xC0, 0x3F, 0x83, 0xF8, 0x7F, 0x00, 0xFE, 0x0F, 0xE1, 0xF8, 0x03,
  0xF8, 0x3F, 0x8F, 0xE0, 0x0F, 0xE0, 0xFE, 0x3F, 0x00, 0x3F, 0xC3, 0xF9,
  0xFC, 0x00, 0x7F, 0x1F, 0xE7, 0xE0, 0x01, 0xFF, 0xFF, 0x3F, 0x80, 0x07,
  0xFF, 0xFC, 0xFC, 0x00, 0x0F, 0xFF, 0xE7, 0xF0, 0x00, 0x1F, 0xFF, 0x9F,
  0x80, 0x00, 0x3F, 0xF8, 0xFE, 0x00, 0x00, 0x7F, 0xC3, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x7F, 0x80, 0x00, 0x0F, 0xC7, 0xFF, 0x80, 0x00, 0x7F, 0x3F,
  0xFF, 0x00, 0x01, 0xF9, 0xFF, 0xFE, 0x00, 0x0F, 0xE7, 0xFF, 0xF8, 0x00,
  0x3F, 0x3F, 0xFF, 0xF0, 0x01, 0xFC, 0xFE, 0x3F, 0xC0, 0x07, 0xE3, 0xF8,
  0x7F, 0x00, 0x3F, 0x9F, 0xC1, 0xFC, 0x00, 0xFC, 0x7F, 0x07, 0xF0, 0x07,
  0xF1, 0xFC, 0x1F, 0xC0, 0x1F, 0x87, 0xF0, 0x7F, 0x00, 0xFE, 0x1F, 0xC1,
  0xFC, 0x03, 0xF0, 0x7F, 0x07, 0xF0, 0x1F, 0xC1, 0xFE, 0x1F, 0xC0, 0x7E,
  0x03, 0xF8, 0x7F, 0x00, 0xF8, 0x0F, 0xF3, 0xFC, 0x00, 0xC0, 0x3F, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xF1, 0xFF, 0x80,
  0x00, 0xFF, 0xC3, 0xFE, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x00, 0xFF, 0x83, 0xFE, 0x00,
  0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x7F, 0xC0, 0x00, 0x3F, 0xF3,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x83, 0xFE, 0x03, 0xFF, 0xFE,
  0x0F, 0xF8, 0x1F, 0xFF, 0xFC, 0x3F, 0xE0, 0xFF, 0xFF, 0xF9, 0xFF, 0x87,
  0xFF, 0xFF, 0xF7, 0xFE, 0x1F, 0xFF, 0xFF, 0xDF, 0xF8, 0x7F, 0xE7, 0xFF,
  0xFF, 0xC3, 0xFF, 0x9F, 0xFF, 0xFF, 0x0F, 0xFE, 0x3F, 0xFF, 0xFC, 0x3F,
  0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0x83, 0xFF,
  0xFE, 0x0F, 0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF,
  0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0xE1, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFC, 0xFF, 0xF8, 0x07, 0xFF, 0xE1, 0xFF, 0xE0, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD,
  0xFE, 0xFF, 0x7F, 0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F,
  0xBF, 0x80, 0x00, 0x02, 0x00, 0x07, 0x00, 0x07, 0x80, 0x07, 0xE0, 0x07,
  0xF0, 0x07, 0xFC, 0x07, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFE, 0x01,
  0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0xC0,
  0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xFC, 0x03, 0xFE,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F,
  0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x07,
  0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xC0,
  0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07,
  0x80, 0x01, 0xC0, 0x00, 0x20, 0x20, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F,
  0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xE0,
  0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x1F,
  0xF0, 0x0F, 0xF8, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF,
  0xC0, 0x7F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x7F,
  0xE0, 0x3F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01,
  0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x3F, 0xE0,
  0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x07, 0xFC, 0x03, 0xFC,
  0x03, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x3F,
  0x00, 0x1F, 0x00, 0x0E, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x38, 0x07, 0xE0, 0x18, 0xFC, 0x0F, 0xC1, 0xF1, 0xFF,
  0x1F, 0x0F, 0xF3, 0xFF, 0xBE, 0x7F, 0xEF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0xFF, 0x1F,
  0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xF0, 0x3F, 0xC0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x3F, 0x80, 0x7F, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0x1C, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x0F,
  0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF,
  0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC7,
  0xFC, 0x3F, 0xE3, 0xFE, 0x1F, 0xE0, 0xFF, 0x01, 0xF0, 0x03, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x06, 0x03, 0xFC, 0x7F,
  0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFE, 0x3F,
  0xC0, 0x70, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xE1, 0xFF, 0xC7, 0xFF, 0x9F, 0xFC, 0x1F, 0xFC, 0xFF, 0xE0, 0xFF, 0xE7,
  0xFF, 0x03, 0xFF, 0x3F, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xBF, 0xF0, 0x1F, 0xFD, 0xFF, 0xC0,
  0xFF, 0xCF, 0xFE, 0x0F, 0xFE, 0x7F, 0xF0, 0x7F, 0xF1, 0xFF, 0xC7, 0xFF,
  0x8F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x1F, 0x00, 0x07, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0xF0, 0x7F, 0xFF,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xF8, 0x7F, 0xFC, 0x07,
  0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00,
  0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0,
  0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF,
  0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F,
  0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07,
  0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00,
  0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xF1,
  0xFF, 0xE7, 0xFF, 0x87, 0xFF, 0x9F, 0xFC, 0x0F, 0xFE, 0x7F, 0xF0, 0x3F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xF1, 0xFF,
  0xC0, 0xFF, 0xE7, 0xFF, 0x81, 0xFF, 0xEF, 0xFF, 0x01, 0xFF, 0xDF, 0xFC,
  0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0xFF, 0xEF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xBF,
  0xF8, 0x07, 0xFF, 0x7F, 0xF8, 0x0F, 0xFE, 0xFF, 0xF0, 0x3F, 0xFC, 0xFF,
  0xF0, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFD, 0xFF, 0xC0,
  0x07, 0xFB, 0xFF, 0x80, 0x1F, 0xF7, 0xFF, 0x00, 0x3F, 0xCF, 0xFE, 0x00,
  0xFF, 0x9F, 0xFC, 0x01, 0xFE, 0x3F, 0xF8, 0x07, 0xFC, 0x7F, 0xF0, 0x0F,
  0xF8, 0xFF, 0xE0, 0x3F, 0xE1, 0xFF, 0xC0, 0x7F, 0xC3, 0xFF, 0x81, 0xFF,
  0x87, 0xFF, 0x03, 0xFE, 0x0F, 0xFE, 0x0F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF8, 0x7F, 0xE0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC7, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xC1,
  0xFF, 0xE0, 0x3C, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFD, 0xFF, 0xC0, 0x7F, 0xF7, 0xFF,
  0x03, 0xFF, 0xDF, 0xFE, 0x0F, 0xFE, 0x7F, 0xFC, 0x7F, 0xF8, 0xFF, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF1, 0xFC, 0x01,
  0xFF, 0xDF, 0xFC, 0x07, 0xFE, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xC1, 0xFF, 0xEF, 0xFE, 0x03,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFD, 0xFF, 0x80, 0xFF, 0xF7, 0xFF, 0x03, 0xFF, 0x9F, 0xFC,
  0x1F, 0xFE, 0x3F, 0xF8, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xC7, 0xFF, 0x9F, 0xFE, 0x1F, 0xFC,
  0xFF, 0xE0, 0xFF, 0xE7, 0xFF, 0x07, 0xFF, 0x3F, 0xF8, 0x3F, 0xF9, 0xFF,
  0xC1, 0xFF, 0xCF, 0xFE, 0x0F, 0xFE, 0x7F, 0xF0, 0x7F, 0xF3, 0xFF, 0x83,
  0xFF, 0x8F, 0xFE, 0x1F, 0xFC, 0x7F, 0xF1, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x1F, 0xFC, 0x7F, 0xF9, 0xFF, 0xC1, 0xFF,
  0xCF, 0xFE, 0x07, 0xFE, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFB, 0xFF, 0xC7, 0xFF, 0xDF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE3, 0xFF, 0xC7,
  0xFF, 0x1F, 0xFC, 0x1F, 0xFC, 0xFF, 0xE0, 0xFF, 0xEF, 0xFF, 0x03, 0xFF,
  0x7F, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0x7F, 0xF8, 0x7F, 0xFB, 0xFF, 0xE7, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xBF,
  0xF0, 0x07, 0xF3, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x06, 0x01, 0xFE, 0x1F, 0xF8, 0xFF, 0xEF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xF3, 0xFF, 0x0F, 0xF0, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04,
  0x01, 0xFC, 0x3F, 0xF1, 0xFF, 0xDF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xE7, 0xFE, 0x1F, 0xE0, 0x1C, 0x00, 0x01, 0xC0, 0x3F, 0xC1, 0xFF,
  0x8F, 0xFF, 0x3F, 0xFC, 0xFF, 0xF3, 0xFF, 0xCF, 0xFF, 0x3F, 0xFC, 0x7F,
  0xE0, 0xFF, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8,
  0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xF8,
  0x3F, 0xE0, 0xFF, 0x07, 0xFC, 0x1F, 0xE0, 0x7F, 0x00, 0x7C, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xFE, 0x00,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x01,
  0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x80,
  0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0x00,
  0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0x80,
  0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0x8F,
  0xFF, 0x7F, 0xF0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFE, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFE,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x00, 0x01,
  0xFC, 0x0F, 0xF0, 0x01, 0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xFF, 0x80,
  0xFE, 0x1F, 0xE0, 0x0F, 0xFF, 0xC0, 0xFE, 0x1F, 0xC0, 0x1F, 0xFF, 0xE0,
  0xFE, 0x1F, 0xC0, 0x3F, 0xFF, 0xF0, 0x7E, 0x3F, 0xC0, 0x7F, 0xFF, 0xF0,
  0x7F, 0x3F, 0x80, 0xFF, 0xEF, 0xF0, 0x7F, 0x3F, 0x80, 0xFF, 0x0F, 0xE0,
  0x7F, 0x3F, 0x81, 0xFE, 0x0F, 0xE0, 0x7F, 0x7F, 0x01, 0xFE, 0x0F, 0xE0,
  0x3F, 0x7F, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x7F, 0x03, 0xFC, 0x0F, 0xE0,
  0x3F, 0x7F, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x7F, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0xFF, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0xFE, 0x07, 0xF8, 0x0F, 0xE0,
  0x3F, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0xFE, 0x07, 0xF8, 0x1F, 0xE0,
  0x3F, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0xFE, 0x07, 0xF8, 0x1F, 0xE0,
  0x7F, 0xFE, 0x0F, 0xF8, 0x1F, 0xE0, 0x7F, 0xFE, 0x0F, 0xF8, 0x1F, 0xC0,
  0x7F, 0xFE, 0x0F, 0xF8, 0x1F, 0xC0, 0x7E, 0xFE, 0x0F, 0xF8, 0x1F, 0xC0,
  0x7E, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0xFE, 0xFF, 0x07, 0xF8, 0x3F, 0xC0,
  0xFC, 0x7F, 0x07, 0xF8, 0x3F, 0xC0, 0xFC, 0x7F, 0x07, 0xFC, 0x7F, 0xC1,
  0xFC, 0x7F, 0x03, 0xFF, 0xFF, 0xE3, 0xF8, 0x7F, 0x03, 0xFF, 0xFF, 0xFF,
  0xF8, 0x7F, 0x83, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0x81, 0xFF, 0xF7, 0xFF,
  0xE0, 0x3F, 0x80, 0xFF, 0xE3, 0xFF, 0xC0, 0x3F, 0xC0, 0x7F, 0x81, 0xFF,
  0x00, 0x3F, 0xC0, 0x1E, 0x00, 0x7C, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xC0,
  0x00, 0x01, 0xFF, 0xFE, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x00, 0x1F,
  0xF9, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x7F,
  0xE0, 0x00, 0x07, 0xFE, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x0F, 0xFC, 0x00,
  0x01, 0xFF, 0x87, 0xFE, 0x00, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x00, 0xFF,
  0xE1, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x3F,
  0xF0, 0x00, 0x3F, 0xF8, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x0F, 0xFE, 0x00,
  0x1F, 0xFC, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFE, 0x00, 0x1F,
  0xFE, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x87,
  0xFF, 0x80, 0x01, 0xFF, 0xE3, 0xFF, 0xC0, 0x00, 0xFF, 0xF3, 0xFF, 0xE0,
  0x00, 0x7F, 0xF9, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xF8, 0x1F, 0xFF,
  0xBF, 0xFC, 0x03, 0xFF, 0xDF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0x7F, 0xF8, 0x03, 0xFF, 0xBF, 0xFC, 0x03,
  0xFF, 0xDF, 0xFE, 0x03, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0x00, 0xFF, 0xF7, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xF0, 0x1F, 0xFE, 0x3F, 0xFC, 0x01, 0xFF, 0xE7, 0xFF,
  0x00, 0x1F, 0xFC, 0xFF, 0xE0, 0x03, 0xFF, 0xBF, 0xFC, 0x00, 0x7F, 0xF7,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0x9F, 0xFC, 0x00, 0x7F, 0xF3, 0xFF, 0xC0, 0x1F,
  0xFE, 0x7F, 0xFC, 0x07, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFC, 0x7F, 0xF8, 0x7F, 0xFF, 0x3F, 0xFC, 0x07, 0xFF, 0x9F,
  0xFE, 0x03, 0xFF, 0xEF, 0xFF, 0x00, 0xFF, 0xF7, 0xFF, 0x80, 0x7F, 0xFB,
  0xFF, 0xC0, 0x1F, 0xFD, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xDF, 0xFE, 0x01, 0xFF, 0xEF, 0xFF, 0x00, 0xFF, 0xF7, 0xFF,
  0x80, 0xFF, 0xFB, 0xFF, 0xC0, 0x7F, 0xF9, 0xFF, 0xE0, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xF3, 0xFF, 0xF8, 0xFF,
  0xF0, 0x0F, 0xFF, 0x3F, 0xFC, 0x01, 0xFF, 0xE7, 0xFF, 0x80, 0x1F, 0xFC,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFE, 0xFF, 0xE0, 0x03,
  0xFF, 0xDF, 0xFE, 0x00, 0x7F, 0xFB, 0xFF, 0xE0, 0x0F, 0xFF, 0x3F, 0xFE,
  0x01, 0xFF, 0xE7, 0xFF, 0xF1, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0x7F, 0xF0, 0x3F, 0xFD, 0xFF, 0xC0, 0xFF, 0xE7, 0xFF,
  0x03, 0xFF, 0x9F, 0xFE, 0x1F, 0xFE, 0x7F, 0xFC, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFE, 0xFF, 0xF0, 0x07, 0xFF, 0xEF, 0xFF, 0x00,
  0xFF, 0xFC, 0xFF, 0xF0, 0x0F, 0xFF, 0x8F, 0xFF, 0x01, 0xFF, 0xF8, 0xFF,
  0xF0, 0x1F, 0xFF, 0x0F, 0xFF, 0x03, 0xFF, 0xF0, 0xFF, 0xF0, 0x3F, 0xFE,
  0x0F, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x07,
  0xFF, 0x80, 0xFF, 0xF0, 0xFF, 0xF0, 0x0F, 0xFF, 0x0F, 0xFF, 0x00, 0xFF,
  0xF1, 0xFF, 0xE0, 0x0F, 0xFF, 0x1F, 0xFE, 0x00, 0xFF, 0xF3, 0xFF, 0xC0,
  0x0F, 0xFF, 0x3F, 0xF8, 0x00, 0xFF, 0xF7, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0xFF, 0xF0,
  0x0F, 0xFF, 0xCF, 0xFF, 0x80, 0xFF, 0xF8, 0xFF, 0xF8, 0x0F, 0xFF, 0x07,
  0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF,
  0xF0, 0x3F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xFF,
  0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0xFF, 0xF0, 0x0F, 0xFF, 0x8F, 0xFF, 0x00,
  0xFF, 0xF8, 0xFF, 0xF0, 0x0F, 0xFF, 0xCF, 0xFF, 0x00, 0x7F, 0xFC, 0xFF,
  0xF0, 0x07, 0xFF, 0xEF, 0xFF, 0x00, 0x3F, 0xFE, 0xFF, 0xF0, 0x03, 0xFF,
  0xF0, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFF, 0xEF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xBF, 0xC0, 0xFF, 0x7F, 0xFF,
  0xFE, 0xFF, 0x83, 0xFD, 0xFF, 0xFF, 0xFB, 0xFE, 0x0F, 0xF7, 0xFF, 0xFF,
  0xE7, 0xF8, 0x7F, 0xDF, 0xFF, 0xFF, 0x9F, 0xE1, 0xFE, 0x7F, 0xFF, 0xFE,
  0x7F, 0x87, 0xF9, 0xFF, 0xFF, 0xF8, 0xFF, 0x1F, 0xE7, 0xFF, 0xFF, 0xE3,
  0xFC, 0xFF, 0x1F, 0xFF, 0xFF, 0x8F, 0xF3, 0xFC, 0x7F, 0xFF, 0xFF, 0x3F,
  0xCF, 0xF1, 0xFF, 0xFF, 0xFC, 0x7F, 0xBF, 0xC7, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xC7, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0x8F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F,
  0xFF, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0x83, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xF0, 0x3F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0xFF,
  0xFC, 0x07, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xE0, 0x3F, 0xFC, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF7, 0xF0, 0xFF, 0xFF, 0xFF, 0x7F,
  0x8F, 0xFF, 0xFF, 0xF7, 0xF8, 0xFF, 0xFF, 0xFF, 0x3F, 0x8F, 0xFF, 0xFF,
  0xF3, 0xFC, 0xFF, 0xFF, 0xFF, 0x1F, 0xCF, 0xFF, 0xFF, 0xF1, 0xFE, 0xFF,
  0xFF, 0xFF, 0x1F, 0xEF, 0xFF, 0xFF, 0xF0, 0xFE, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFC, 0x07, 0xFF, 0xC7, 0xFF, 0x80, 0x3F, 0xFC, 0x7F, 0xF8,
  0x01, 0xFF, 0xE7, 0xFF, 0x00, 0x1F, 0xFE, 0xFF, 0xF0, 0x00, 0xFF, 0xEF,
  0xFF, 0x00, 0x0F, 0xFE, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFE, 0xFF, 0xF0,
  0x01, 0xFF, 0xE7, 0xFF, 0x00, 0x1F, 0xFE, 0x7F, 0xF8, 0x01, 0xFF, 0xE7,
  0xFF, 0x80, 0x3F, 0xFC, 0x3F, 0xFC, 0x07, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFC, 0x07, 0xFF,
  0xEF, 0xFF, 0x00, 0x7F, 0xFB, 0xFF, 0xC0, 0x1F, 0xFE, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xBF,
  0xFC, 0x01, 0xFF, 0xEF, 0xFF, 0x01, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFC, 0x07, 0xFF,
  0xC7, 0xFF, 0x80, 0x3F, 0xFC, 0x7F, 0xF8, 0x01, 0xFF, 0xE7, 0xFF, 0x00,
  0x1F, 0xFE, 0xFF, 0xF0, 0x00, 0xFF, 0xEF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xE7, 0xFF, 0x00,
  0x1F, 0xFE, 0x7F, 0xF8, 0x01, 0xFF, 0xE7, 0xFF, 0x80, 0x3F, 0xFC, 0x3F,
  0xFC, 0x07, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x08,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFC, 0x07, 0xFF, 0xCF, 0xFF, 0x00, 0xFF, 0xFB,
  0xFF, 0xC0, 0x1F, 0xFE, 0xFF, 0xF0, 0x07, 0xFF, 0xBF, 0xFC, 0x01, 0xFF,
  0xEF, 0xFF, 0x00, 0x7F, 0xFB, 0xFF, 0xC0, 0x0F, 0xFE, 0xFF, 0xF0, 0x03,
  0xFF, 0xBF, 0xFC, 0x01, 0xFF, 0xEF, 0xFF, 0x00, 0x7F, 0xFB, 0xFF, 0xC0,
  0x1F, 0xFE, 0xFF, 0xF0, 0x07, 0xFF, 0xBF, 0xFC, 0x03, 0xFF, 0xCF, 0xFF,
  0x01, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xF1, 0xFF, 0xF0, 0x3F, 0xFC, 0x3F,
  0xFC, 0x0F, 0xFF, 0x0F, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0,
  0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFF, 0x0F, 0xFF, 0x03, 0xFF, 0xC3, 0xFF,
  0xC0, 0xFF, 0xF8, 0xFF, 0xF0, 0x1F, 0xFE, 0x3F, 0xFC, 0x07, 0xFF, 0xCF,
  0xFF, 0x01, 0xFF, 0xF3, 0xFF, 0xC0, 0x3F, 0xFC, 0xFF, 0xF0, 0x0F, 0xFF,
  0xBF, 0xFC, 0x01, 0xFF, 0xEF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xC7, 0xFF,
  0xE3, 0xFF, 0xC0, 0x7F, 0xF8, 0xFF, 0xF0, 0x1F, 0xFE, 0x3F, 0xF8, 0x03,
  0xFF, 0x8F, 0xFE, 0x00, 0xFF, 0xE3, 0xFF, 0x80, 0x3F, 0xFC, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xEF, 0xFF, 0x00, 0x3F, 0xFB, 0xFF,
  0xC0, 0x0F, 0xFE, 0xFF, 0xF0, 0x03, 0xFF, 0x9F, 0xFC, 0x00, 0xFF, 0xE7,
  0xFF, 0x00, 0x3F, 0xF9, 0xFF, 0xE0, 0x0F, 0xFE, 0x7F, 0xFC, 0x07, 0xFF,
  0x8F, 0xFF, 0x83, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFB, 0xFF,
  0xC0, 0x0F, 0xFE, 0xFF, 0xF0, 0x03, 0xFF, 0x9F, 0xFC, 0x00, 0xFF, 0xE7,
  0xFF, 0x80, 0x7F, 0xF9, 0xFF, 0xE0, 0x1F, 0xFE, 0x7F, 0xFE, 0x1F, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x7F, 0xF8, 0x00, 0x1F,
  0xFF, 0x7F, 0xFC, 0x00, 0x1F, 0xFE, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x3F,
  0xFC, 0x00, 0x3F, 0xFE, 0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x3F, 0xFE, 0x00,
  0x3F, 0xFC, 0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x1F, 0xFE, 0x00, 0x7F, 0xFC,
  0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x0F, 0xFF,
  0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0x00, 0xFF,
  0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0x80, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x07, 0xFF, 0x81,
  0xFF, 0xE0, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x03, 0xFF, 0x81, 0xFF, 0xC0,
  0x03, 0xFF, 0xC1, 0xFF, 0xC0, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x01, 0xFF,
  0xC3, 0xFF, 0xC0, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x01, 0xFF, 0xC3, 0xFF,
  0x80, 0x00, 0xFF, 0xE3, 0xFF, 0x80, 0x00, 0xFF, 0xE3, 0xFF, 0x00, 0x00,
  0xFF, 0xE7, 0xFF, 0x00, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x00, 0x7F, 0xE7,
  0xFF, 0x00, 0x00, 0x7F, 0xF7, 0xFE, 0x00, 0x00, 0x7F, 0xF7, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x0F, 0xF8,
  0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0xDF, 0xFC, 0x07, 0xFF,
  0x01, 0xFF, 0xEF, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE7, 0xFF, 0x01, 0xFF,
  0xC0, 0x7F, 0xF3, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF9, 0xFF, 0xC0, 0xFF,
  0xF8, 0x1F, 0xFC, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFE, 0x3F, 0xF8, 0x3F,
  0xFE, 0x0F, 0xFF, 0x1F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0x0F, 0xFE, 0x0F,
  0xFF, 0x83, 0xFF, 0x87, 0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xC3, 0xFF, 0x87,
  0xFF, 0xF0, 0xFF, 0xE1, 0xFF, 0xE3, 0xFF, 0xF8, 0x7F, 0xF0, 0x7F, 0xF1,
  0xFF, 0xFC, 0x3F, 0xF8, 0x3F, 0xF8, 0xFF, 0xFE, 0x3F, 0xF8, 0x1F, 0xFC,
  0x7F, 0xFF, 0x1F, 0xFC, 0x0F, 0xFE, 0x3F, 0xFF, 0xCF, 0xFE, 0x07, 0xFF,
  0x3F, 0xFF, 0xE7, 0xFF, 0x03, 0xFF, 0x9F, 0xFF, 0xF3, 0xFF, 0x80, 0xFF,
  0xEF, 0xFF, 0xF9, 0xFF, 0xC0, 0x7F, 0xF7, 0xFF, 0xFC, 0xFF, 0xC0, 0x3F,
  0xFB, 0xFF, 0xFE, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFB, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFD, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x3F, 0xFF,
  0x80, 0x01, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x0F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x01, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x7F,
  0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x0F,
  0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFD, 0xFF, 0xF0, 0x03, 0xFF, 0xE3, 0xFF, 0xE0, 0x0F, 0xFF, 0x8F,
  0xFF, 0x80, 0x3F, 0xFC, 0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0x7F, 0xFC, 0x07,
  0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x07,
  0xFF, 0x83, 0xFF, 0xC0, 0x1F, 0xFE, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x7F,
  0xF8, 0x00, 0xFF, 0xF1, 0xFF, 0xE0, 0x03, 0xFF, 0xC7, 0xFF, 0x00, 0x07,
  0xFF, 0xBF, 0xFC, 0x00, 0x1F, 0xFE, 0xFF, 0xE0, 0x00, 0x3F, 0xFB, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xBF, 0xF8, 0x00, 0x1F, 0xFE, 0xFF, 0xF0, 0x00, 0x7F, 0xF3, 0xFF, 0xC0,
  0x03, 0xFF, 0xC7, 0xFF, 0x80, 0x0F, 0xFF, 0x1F, 0xFE, 0x00, 0x7F, 0xF8,
  0x7F, 0xFC, 0x01, 0xFF, 0xE0, 0xFF, 0xF0, 0x0F, 0xFF, 0x83, 0xFF, 0xC0,
  0x3F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x1F, 0xFE, 0x07, 0xFF, 0xC0,
  0x7F, 0xFC, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0xFF, 0xF8, 0x03, 0xFF, 0xE3,
  0xFF, 0xE0, 0x0F, 0xFF, 0x9F, 0xFF, 0x00, 0x1F, 0xFF, 0x7F, 0xFC, 0x00,
  0x7F, 0xFC, 0x7F, 0xF8, 0x00, 0x7F, 0xFD, 0xFF, 0xE0, 0x01, 0xFF, 0xE7,
  0xFF, 0x80, 0x07, 0xFF, 0x8F, 0xFF, 0x00, 0x3F, 0xFC, 0x3F, 0xFC, 0x00,
  0xFF, 0xF0, 0x7F, 0xF0, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x1F, 0xFE, 0x07,
  0xFF, 0x80, 0x7F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x07,
  0xFF, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x07,
  0xFF, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x7F,
  0xF0, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x01, 0xFF, 0xCF, 0xFE, 0x00, 0x03,
  0xFF, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0x3F, 0xFB, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0x8F,
  0xFE, 0x3F, 0xF8, 0xFF, 0xE3, 0xFF, 0x8F, 0xFE, 0x3F, 0xF8, 0xFF, 0xE3,
  0xFF, 0x8F, 0xFE, 0x3F, 0xF8, 0xFF, 0xE3, 0xFF, 0x8F, 0xFE, 0x3F, 0xF8,
  0xFF, 0xE3, 0xFF, 0x8F, 0xFE, 0x3F, 0xF8, 0xFF, 0xE3, 0xFF, 0x8F, 0xFE,
  0x3F, 0xF8, 0xFF, 0xE3, 0xFF, 0x8F, 0xFE, 0x3F, 0xF8, 0xFF, 0xE3, 0xFF,
  0x8F, 0xFE, 0x3F, 0xF8, 0xFF, 0xE3, 0xFF, 0x8F, 0xFE, 0x3F, 0xF8, 0xFF,
  0xE3, 0xFF, 0x8F, 0xFE, 0x3F, 0xF8, 0xFF, 0xE3, 0xFF, 0x8F, 0xFE, 0x3F,
  0xF8, 0xFF, 0xE3, 0xFF, 0x8F, 0xFE, 0x3F, 0xF8, 0xFF, 0xE3, 0xFF, 0x8F,
  0xFE, 0x3F, 0xF8, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFC, 0x7F, 0xF1, 0xFF, 0xC7, 0xFF, 0x1F, 0xFC,
  0x7F, 0xF1, 0xFF, 0xC7, 0xFF, 0x1F, 0xFC, 0x7F, 0xF1, 0xFF, 0xC7, 0xFF,
  0x1F, 0xFC, 0x7F, 0xF1, 0xFF, 0xC7, 0xFF, 0x1F, 0xFC, 0x7F, 0xF1, 0xFF,
  0xC7, 0xFF, 0x1F, 0xFC, 0x7F, 0xF1, 0xFF, 0xC7, 0xFF, 0x1F, 0xFC, 0x7F,
  0xF1, 0xFF, 0xC7, 0xFF, 0x1F, 0xFC, 0x7F, 0xF1, 0xFF, 0xC7, 0xFF, 0x1F,
  0xFC, 0x7F, 0xF1, 0xFF, 0xC7, 0xFF, 0x1F, 0xFC, 0x7F, 0xF1, 0xFF, 0xC7,
  0xFF, 0x1F, 0xFC, 0x7F, 0xF1, 0xFF, 0xC7, 0xFF, 0x1F, 0xFC, 0x7F, 0xF1,
  0xFF, 0xC7, 0xFF, 0x1F, 0xFC, 0x7F, 0xF1, 0xFF, 0xC7, 0xFF, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFE,
  0x00, 0xFE, 0x7F, 0x00, 0x7F, 0x3F, 0x80, 0x7F, 0x9F, 0xE0, 0x3F, 0xCF,
  0xF0, 0x1F, 0xC3, 0xF8, 0x1F, 0xE1, 0xFE, 0x0F, 0xF0, 0xFF, 0x07, 0xF0,
  0x7F, 0x87, 0xF8, 0x1F, 0xE3, 0xFC, 0x0F, 0xF1, 0xFE, 0x07, 0xF9, 0xFE,
  0x01, 0xFE, 0xFF, 0x00, 0xFF, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x7F, 0xF9, 0xFF, 0xE3, 0xFF,
  0x87, 0xFF, 0x3F, 0xFC, 0x3F, 0xF9, 0xFF, 0xC1, 0xFF, 0xC0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFE, 0x3F, 0xFC, 0x7F, 0xF3, 0xFF, 0xC3,
  0xFF, 0x9F, 0xFC, 0x1F, 0xFC, 0xFF, 0xE0, 0xFF, 0xE7, 0xFF, 0x07, 0xFF,
  0x3F, 0xF8, 0x3F, 0xF9, 0xFF, 0xC1, 0xFF, 0xCF, 0xFE, 0x0F, 0xFE, 0x7F,
  0xF9, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xDF, 0xFC, 0x3F, 0xFC, 0xFF,
  0xE0, 0x7F, 0xC7, 0xFF, 0x80, 0x78, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x1F, 0xFC, 0x1E, 0x00, 0xFF, 0xE7, 0xFE, 0x07, 0xFF, 0x7F,
  0xFC, 0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE7, 0xFE, 0xFF, 0xFE, 0x3F, 0xF3, 0xFF,
  0xE1, 0xFF, 0x8F, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0x0F, 0xFE, 0x7F, 0xF0, 0x7F, 0xEF,
  0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xF7, 0xFF, 0x07, 0xFF, 0x7F,
  0xF0, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x0F, 0x07, 0xFF, 0x03, 0xFF, 0x3F, 0xF8,
  0x3F, 0xFD, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0x7F, 0xF8, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFE, 0xFF, 0xF0,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFE, 0xFF, 0xC1,
  0xFF, 0xE7, 0xFE, 0x07, 0xFE, 0x3F, 0xF0, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0xE1, 0xFF,
  0xE7, 0xFF, 0x03, 0xFF, 0x9F, 0xFC, 0x07, 0xFE, 0x7F, 0xF0, 0x1F, 0xFB,
  0xFF, 0x80, 0x7F, 0xEF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x00, 0x08, 0x1F, 0xFE, 0x00, 0x60, 0x7F, 0xFC, 0x07, 0xC0,
  0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03,
  0xE0, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x81,
  0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x7F, 0xFC,
  0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F,
  0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07,
  0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F,
  0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80,
  0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xFE,
  0x3F, 0xF0, 0x7F, 0xFE, 0xFF, 0xC3, 0xFF, 0xFB, 0xFF, 0x1F, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xE0, 0xFF, 0xF7, 0xFF, 0x01, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xDF,
  0xFC, 0x07, 0xFF, 0x7F, 0xF8, 0x3F, 0xFD, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xF7, 0xFF, 0x01, 0xFF, 0x9F,
  0xFC, 0x00, 0xF0, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x02, 0x00, 0x3F, 0xFC, 0x0E, 0x01, 0xFF, 0xE0, 0x7F, 0x1F, 0xFF, 0x81,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE,
  0x0F, 0x00, 0xFF, 0xE3, 0xFE, 0x0F, 0xFE, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0x1F, 0x83, 0xFC, 0x7F,
  0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xE3, 0xFC, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x7E, 0x00, 0x3F, 0xC0, 0x1F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0x80, 0x3F, 0xC0,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF,
  0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0,
  0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07,
  0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF,
  0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0,
  0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07,
  0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF,
  0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x1F, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF,
  0xFF, 0xFB, 0xFF, 0xFC, 0xFF, 0xFE, 0x3F, 0xFF, 0x8F, 0xFF, 0x83, 0xFF,
  0xC0, 0x7F, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x7F, 0xFD, 0xFF, 0xC0,
  0xFF, 0xFB, 0xFF, 0x83, 0xFF, 0xE7, 0xFF, 0x07, 0xFF, 0x8F, 0xFE, 0x1F,
  0xFE, 0x1F, 0xFC, 0x7F, 0xFC, 0x3F, 0xF8, 0xFF, 0xF0, 0x7F, 0xF3, 0xFF,
  0xC0, 0xFF, 0xE7, 0xFF, 0x81, 0xFF, 0xDF, 0xFE, 0x03, 0xFF, 0xBF, 0xF8,
  0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xF3, 0xFF, 0x81, 0xFF, 0xC7, 0xFF, 0x83, 0xFF,
  0x87, 0xFF, 0x87, 0xFF, 0x0F, 0xFF, 0x0F, 0xFE, 0x0F, 0xFF, 0x1F, 0xFC,
  0x1F, 0xFE, 0x3F, 0xF8, 0x3F, 0xFE, 0x7F, 0xF0, 0x3F, 0xFC, 0xFF, 0xE0,
  0x7F, 0xFD, 0xFF, 0xC0, 0x7F, 0xFB, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x78, 0x00,
  0x7C, 0x07, 0xFE, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF9, 0xFF, 0xE1, 0xFF,
  0xE1, 0xFF, 0xDF, 0xFF, 0x9F, 0xFF, 0x8F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xC7, 0xFF, 0xC7, 0xFF, 0xBF, 0xFC, 0x3F, 0xFC, 0x1F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x3F,
  0xF8, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFE,
  0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0x81,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xF8, 0x1F, 0xFF,
  0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0xFF,
  0xE0, 0x7F, 0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07,
  0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xF8, 0x1F, 0xFF, 0xFF, 0x81, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xF0,
  0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0xFC, 0x0F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x78, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xCF, 0xFF, 0x8F,
  0xFD, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF1, 0xFF, 0xE1, 0xFF,
  0xE7, 0xFF, 0x03, 0xFF, 0x9F, 0xFC, 0x0F, 0xFE, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F,
  0xF7, 0xFF, 0x01, 0xFF, 0x9F, 0xFC, 0x0F, 0xFE, 0x7F, 0xF8, 0x7F, 0xF9,
  0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x07, 0xFE, 0x3F, 0xF0, 0x3F, 0xFB, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0x87, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF, 0xDF, 0xFE, 0x0F, 0xFE, 0x7F, 0xE0,
  0x7F, 0xF0, 0x78, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0xF8, 0xFF, 0xC1, 0xFF,
  0xE7, 0xFE, 0x3F, 0xFF, 0xBF, 0xF1, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFB,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xF7, 0xFF, 0x87, 0xFF,
  0xBF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0x7F, 0xF0, 0x3F, 0xF3, 0xFF, 0x80, 0x3C, 0x1F, 0xFC, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xEF, 0xFC,
  0x7F, 0xFF, 0xCF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF,
  0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00,
  0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0,
  0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE,
  0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF,
  0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F,
  0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xFF, 0x80,
  0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x3F, 0xF8, 0xFF,
  0xF7, 0xFF, 0x07, 0xFF, 0x7F, 0xF0, 0x7F, 0xF7, 0xFF, 0x07, 0xFF, 0x7F,
  0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xFF, 0xE0, 0x7F, 0xF7, 0xFE, 0x07, 0xFF, 0x7F, 0xE0, 0x7F, 0xF7, 0xFF,
  0x07, 0xFF, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x1F,
  0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x01,
  0xFF, 0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFE, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x01, 0xFF,
  0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x1F,
  0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x01,
  0xFF, 0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0xE0,
  0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x0F,
  0xFF, 0x00, 0x1F, 0x80, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFB, 0xFF, 0x1F, 0xFF, 0x3F, 0xF0, 0x7F, 0xE3, 0xFF, 0x01, 0xF0,
  0x00, 0x00, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xBF, 0xFC, 0x0F, 0xFE, 0x7F, 0xF0, 0x3F, 0xF9, 0xFF, 0xC1, 0xFF,
  0xE7, 0xFF, 0x07, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF0,
  0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0x87, 0xFE, 0x07, 0xFE, 0x3F, 0xF8, 0x1F,
  0xF8, 0xFF, 0xE0, 0x7F, 0xF3, 0xFF, 0x01, 0xFF, 0xCF, 0xFC, 0x03, 0xFF,
  0x3F, 0xF0, 0x0F, 0xFD, 0xFF, 0xC0, 0x3F, 0xF7, 0xFE, 0x00, 0xFF, 0xDF,
  0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x01,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x7F, 0x03, 0xFF, 0xFF, 0xF0,
  0x7F, 0xC1, 0xFF, 0xFF, 0xF8, 0x3F, 0xE0, 0xFF, 0xEF, 0xFC, 0x1F, 0xF0,
  0x7F, 0xE7, 0xFE, 0x0F, 0xF8, 0x3F, 0xF3, 0xFF, 0x0F, 0xFC, 0x1F, 0xF9,
  0xFF, 0x87, 0xFF, 0x0F, 0xFC, 0xFF, 0xC3, 0xFF, 0x87, 0xFE, 0x3F, 0xF1,
  0xFF, 0xC7, 0xFE, 0x1F, 0xF8, 0xFF, 0xE3, 0xFF, 0x0F, 0xFC, 0xFF, 0xF9,
  0xFF, 0x87, 0xFE, 0x7F, 0xFC, 0xFF, 0xC3, 0xFF, 0x3F, 0xFE, 0x7F, 0xE0,
  0xFF, 0x9F, 0xFF, 0x3F, 0xE0, 0x7F, 0xCF, 0xFF, 0x9F, 0xF0, 0x3F, 0xEF,
  0xFF, 0xEF, 0xF8, 0x1F, 0xF7, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFB, 0xFF,
  0xFE, 0x03, 0xFF, 0xFD, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF,
  0x8F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC7, 0xFF, 0xF0, 0x07, 0xFF, 0xE3, 0xFF,
  0xF0, 0x03, 0xFF, 0xF0, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x7F, 0xFC, 0x00,
  0xFF, 0xF8, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x1F, 0xFF, 0x00, 0x1F, 0xFE,
  0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x00,
  0x7F, 0xE0, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0xFF, 0xF0,
  0x3F, 0xFD, 0xFF, 0xC0, 0xFF, 0xE7, 0xFF, 0x83, 0xFF, 0x8F, 0xFE, 0x1F,
  0xFC, 0x3F, 0xF8, 0x7F, 0xF0, 0x7F, 0xF1, 0xFF, 0x81, 0xFF, 0xCF, 0xFE,
  0x07, 0xFF, 0x3F, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0x3F, 0xF8, 0x1F, 0xFC, 0xFF, 0xE0, 0x7F,
  0xF3, 0xFF, 0x83, 0xFF, 0x87, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x7F, 0xF8,
  0x7F, 0xF9, 0xFF, 0xC0, 0xFF, 0xEF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFE, 0x7F, 0xF0, 0x1F, 0xFE, 0x7F, 0xF8, 0x1F,
  0xFE, 0x7F, 0xF8, 0x1F, 0xFE, 0x3F, 0xF8, 0x1F, 0xFC, 0x3F, 0xF8, 0x3F,
  0xFC, 0x3F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xF8, 0x1F, 0xFC, 0x3F,
  0xF8, 0x1F, 0xFC, 0x7F, 0xF8, 0x1F, 0xFC, 0x7F, 0xF8, 0x0F, 0xFC, 0x7F,
  0xF0, 0x0F, 0xFE, 0x7F, 0xF0, 0x0F, 0xFE, 0x7F, 0xF0, 0x0F, 0xFE, 0xFF,
  0xE0, 0x07, 0xFE, 0xFF, 0xE0, 0x07, 0xFE, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07,
  0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x04, 0x00, 0x1E, 0x00, 0x7E, 0x00, 0xFE, 0x01, 0xFF, 0x03, 0xFF, 0x03,
  0xFE, 0x07, 0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x3F, 0xF0, 0xFF, 0xF0, 0xFF,
  0xE0, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF,
  0xE0, 0x3F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xFC, 0x0F, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFE, 0x03, 0xFE, 0x03,
  0xFF, 0x01, 0xFF, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x1E, 0x00, 0x04, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x20, 0x00, 0x1E, 0x00, 0x1F,
  0x80, 0x0F, 0xE0, 0x07, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x3F, 0xE0, 0x1F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF8,
  0x0F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xFC, 0x1F,
  0xFE, 0x07, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xE0, 0x7F, 0xF0,
  0x7F, 0xF8, 0x7F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC,
  0x07, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F,
  0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xFC, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x3C,
  0x00, 0x18, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x03, 0xFC,
  0x3F, 0xFC, 0x07, 0xF8, 0xFF, 0xFC, 0x0F, 0xF3, 0xFF, 0xF8, 0x1F, 0xE7,
  0xFF, 0xF8, 0x3F, 0xDF, 0xFF, 0xF8, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFD, 0xFF, 0x1F, 0xFF, 0xFB, 0xFE, 0x1F, 0xFF, 0xE7, 0xF8,
  0x1F, 0xFF, 0xCF, 0xF0, 0x1F, 0xFF, 0x1F, 0xE0, 0x1F, 0xFC, 0x3F, 0xC0,
  0x1F, 0xF0, 0x00, 0x00, 0x0F, 0x80,
};

const GFXglyph RobotoCondensed_Black69pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 12, 50, 18, 3, -49 },
  { 76, 19, 19, 22, 1, -52 },
  { 122, 32, 49, 35, 1, -49 },
  { 318, 30, 65, 35, 3, -57 },
  { 562, 38, 51, 44, 3, -50 },
  { 805, 38, 51, 41, 2, -50 },
  { 1048, 9, 19, 11, 1, -52 },
  { 1070, 17, 69, 22, 4, -54 },
  { 1217, 17, 69, 22, 2, -54 },
  { 1364, 31, 30, 32, 1, -49 },
  { 1481, 28, 36, 32, 2, -41 },
  { 1607, 13, 22, 19, 1, -9 },
  { 1643, 18, 9, 29, 5, -26 },
  { 1664, 12, 12, 21, 4, -11 },
  { 1682, 22, 53, 21, -1, -49 },
  { 1828, 29, 51, 35, 3, -50 },
  { 2013, 20, 49, 35, 5, -49 },
  { 2136, 30, 50, 35, 2, -50 },
  { 2324, 31, 51, 35, 2, -50 },
  { 2522, 31, 49, 35, 2, -49 },
  { 2712, 30, 50, 35, 2, -49 },
  { 2900, 30, 50, 35, 3, -49 },
  { 3088, 30, 49, 35, 2, -49 },
  { 3272, 29, 51, 35, 3, -50 },
  { 3457, 29, 50, 35, 3, -50 },
  { 3639, 13, 39, 20, 4, -38 },
  { 3703, 14, 51, 19, 2, -38 },
  { 3793, 25, 33, 31, 2, -37 },
  { 3897, 27, 24, 36, 4, -33 },
  { 3978, 25, 33, 31, 4, -37 },
  { 4082, 28, 51, 32, 1, -50 },
  { 4261, 48, 63, 53, 2, -48 },
  { 4639, 41, 49, 42, 0, -49 },
  { 4891, 33, 49, 39, 3, -49 },
  { 5094, 35, 51, 39, 3, -50 },
  { 5318, 33, 49, 39, 3, -49 },
  { 5521, 29, 49, 34, 3, -49 },
  { 5699, 28, 49, 33, 3, -49 },
  { 5871, 35, 51, 41, 3, -50 },
  { 6095, 36, 49, 42, 3, -49 },
  { 6316, 11, 49, 19, 4, -49 },
  { 6384, 30, 50, 34, 1, -49 },
  { 6572, 36, 49, 38, 3, -49 },
  { 6793, 28, 49, 33, 3, -49 },
  { 6965, 46, 49, 52, 3, -49 },
  { 7247, 36, 49, 42, 3, -49 },
  { 7468, 36, 51, 42, 3, -50 },
  { 7698, 34, 49, 40, 3, -49 },
  { 7907, 36, 59, 42, 3, -50 },
  { 8173, 34, 49, 39, 3, -49 },
  { 8382, 34, 51, 38, 2, -50 },
  { 8599, 35, 49, 38, 2, -49 },
  { 8814, 34, 50, 40, 3, -49 },
  { 9027, 40, 49, 40, 0, -49 },
  { 9272, 49, 49, 51, 1, -49 },
  { 9573, 38, 49, 39, 0, -49 },
  { 9806, 38, 49, 38, 0, -49 },
  { 10039, 33, 49, 37, 2, -49 },
  { 10242, 14, 69, 18, 3, -57 },
  { 10363, 28, 53, 27, 0, -49 },
  { 10549, 14, 69, 18, 1, -57 },
  { 10670, 25, 25, 28, 1, -49 },
  { 10749, 26, 8, 27, 1, 0 },
  { 10775, 19, 11, 23, 2, -52 },
  { 10802, 29, 38, 32, 2, -37 },
  { 10940, 29, 53, 34, 3, -52 },
  { 11133, 28, 38, 32, 2, -37 },
  { 11266, 29, 53, 34, 2, -52 },
  { 11459, 30, 38, 33, 2, -37 },
  { 11602, 21, 53, 23, 1, -53 },
  { 11742, 30, 51, 35, 2, -37 },
  { 11934, 28, 52, 34, 3, -52 },
  { 12116, 12, 51, 18, 3, -51 },
  { 12193, 18, 65, 18, -3, -51 },
  { 12340, 31, 52, 34, 3, -52 },
  { 12542, 12, 52, 18, 3, -52 },
  { 12620, 45, 37, 51, 3, -37 },
  { 12829, 28, 37, 34, 3, -37 },
  { 12959, 30, 38, 34, 2, -37 },
  { 13102, 29, 51, 34, 3, -37 },
  { 13287, 29, 51, 34, 2, -37 },
  { 13472, 20, 37, 24, 3, -37 },
  { 13565, 28, 38, 31, 1, -37 },
  { 13698, 20, 47, 22, 1, -46 },
  { 13816, 28, 37, 34, 3, -36 },
  { 13946, 30, 36, 32, 1, -36 },
  { 14081, 41, 36, 43, 1, -36 },
  { 14266, 30, 36, 32, 1, -36 },
  { 14401, 32, 50, 32, 0, -36 },
  { 14601, 27, 36, 32, 2, -36 },
  { 14723, 16, 66, 20, 2, -54 },
  { 14855, 6, 58, 18, 6, -49 },
  { 14899, 17, 66, 20, 2, -54 },
  { 15040, 31, 16, 37, 3, -28 },
};

const GFXfont RobotoCondensed_Black69pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Black69pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Black69pt7bGlyphs,
  0x20, 0x7E, 81
};

#endif // _ROBOTOCONDENSED_BLACK69PT7B_H_
