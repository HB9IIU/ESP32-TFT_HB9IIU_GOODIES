#ifndef _ROBOTOCONDENSED_BLACK64PT7B_H_
#define _ROBOTOCONDENSED_BLACK64PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Black.ttf
// Size: 64pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Black64pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFE, 0xFF, 0xDF, 0xFB, 0xFF,
  0x7F, 0xEF, 0xFD, 0xFF, 0xBF, 0xF7, 0xFE, 0xFF, 0xDF, 0xFB, 0xFF, 0x7F,
  0xEF, 0xFD, 0xFF, 0xBF, 0xF7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F, 0xCF,
  0xF9, 0xFF, 0x3F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x7F, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xF7, 0xFC, 0x7F, 0x03, 0x80, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1,
  0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F,
  0xFE, 0x1F, 0xFF, 0x87, 0xEF, 0xC1, 0xFB, 0xF0, 0x7E, 0xFC, 0x1F, 0xBF,
  0x07, 0xEF, 0xC1, 0xFB, 0xF0, 0x7E, 0xFC, 0x1F, 0xBF, 0x07, 0xE0, 0x00,
  0x3F, 0x1F, 0x80, 0x00, 0xFC, 0x7E, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x0F,
  0xC7, 0xE0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0xFC, 0x7E, 0x00, 0x07, 0xE1,
  0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x7E, 0x3F, 0x00, 0x01, 0xF8, 0xFC,
  0x00, 0x07, 0xE3, 0xF0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x7E, 0x3F, 0x00,
  0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0x1F, 0x80, 0x00, 0xFC, 0x7E, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x1F, 0x8F,
  0xC0, 0x00, 0x7E, 0x3F, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x07, 0xE3, 0xF0,
  0x00, 0x1F, 0x8F, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xC7, 0xE0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0xFC,
  0x7E, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x7E, 0x3F,
  0x00, 0x01, 0xF8, 0xFC, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x1F, 0x8F, 0xC0,
  0x00, 0x7E, 0x3F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xC7, 0xF0, 0x00,
  0x3F, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF1, 0xFF, 0xCF, 0xFE, 0x7F, 0xF0,
  0xFF, 0xCF, 0xFE, 0x1F, 0xFD, 0xFF, 0x81, 0xFF, 0xBF, 0xF0, 0x3F, 0xF7,
  0xFE, 0x07, 0xFE, 0xFF, 0xC0, 0xFF, 0xDF, 0xFC, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xC1, 0xFF, 0xDF, 0xFE, 0x7F, 0xF3, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x01, 0x80, 0x3F, 0x8F, 0xE0, 0x38,
  0x07, 0xF0, 0xFC, 0x0F, 0xC0, 0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x83, 0xF0,
  0x7E, 0x03, 0xF0, 0x7E, 0x0F, 0xC0, 0x7E, 0x0F, 0xC3, 0xF0, 0x0F, 0xC1,
  0xF8, 0x7E, 0x01, 0xFC, 0x3F, 0x1F, 0x80, 0x3F, 0x8F, 0xE3, 0xF0, 0x07,
  0xFB, 0xFC, 0xFC, 0x00, 0x7F, 0xFF, 0x9F, 0x80, 0x0F, 0xFF, 0xE7, 0xE0,
  0x00, 0xFF, 0xF8, 0xFC, 0x00, 0x0F, 0xFE, 0x3F, 0x00, 0x00, 0x7F, 0x8F,
  0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x00, 0xFC, 0x7F,
  0xF0, 0x00, 0x1F, 0x9F, 0xFF, 0x00, 0x07, 0xE7, 0xFF, 0xF0, 0x00, 0xFC,
  0xFF, 0xFE, 0x00, 0x3F, 0x3F, 0xDF, 0xE0, 0x07, 0xE7, 0xF1, 0xFC, 0x01,
  0xF8, 0xFC, 0x1F, 0x80, 0x3F, 0x1F, 0x83, 0xF0, 0x0F, 0xC3, 0xF0, 0x7E,
  0x01, 0xF8, 0x7E, 0x0F, 0xC0, 0x7E, 0x0F, 0xC1, 0xF8, 0x0F, 0xC1, 0xF8,
  0x3F, 0x03, 0xF0, 0x3F, 0x87, 0xE0, 0x7E, 0x07, 0xF1, 0xFC, 0x03, 0x80,
  0xFF, 0xFF, 0x80, 0x10, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F,
  0xFD, 0xFF, 0x80, 0x03, 0xFF, 0x1F, 0xF0, 0x00, 0x7F, 0xC1, 0xFE, 0x00,
  0x0F, 0xF8, 0x3F, 0xC0, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0xFF,
  0x00, 0x07, 0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0xC7, 0xF8, 0x00, 0x0F, 0xF9,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0xFF, 0x01, 0xFF, 0xFC, 0x1F, 0xE0, 0x7F, 0xFF, 0xC3, 0xFC, 0x1F, 0xFF,
  0xFC, 0xFF, 0x87, 0xFF, 0xFF, 0xDF, 0xF0, 0xFF, 0xFF, 0xFB, 0xFE, 0x3F,
  0xF3, 0xFF, 0xFF, 0xC7, 0xFE, 0x7F, 0xFF, 0xF8, 0xFF, 0xC7, 0xFF, 0xFE,
  0x1F, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0xE0, 0xFF,
  0xFE, 0x0F, 0xFC, 0x0F, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xF8,
  0x1F, 0xFE, 0x07, 0xFF, 0xDF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xF7, 0xFF, 0x80, 0xFF, 0xF8,
  0x7F, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE,
  0x00, 0x08, 0x00, 0x38, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0xE0, 0x3F, 0xC0,
  0xFF, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0xFF, 0x01, 0xFE,
  0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0xFF, 0x01, 0xFE, 0x03,
  0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0x00,
  0xFF, 0x01, 0xFE, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x07,
  0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x00, 0x04,
  0x60, 0x00, 0x70, 0x00, 0x78, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xFC, 0x03, 0xFC,
  0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFE, 0x03, 0xFE, 0x01, 0xFE, 0x01, 0xFE,
  0x01, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE,
  0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xFC,
  0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x3F, 0x80, 0x7F, 0x80, 0xFF, 0x00, 0xFE, 0x00,
  0xFC, 0x00, 0x78, 0x00, 0x70, 0x00, 0x60, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x04, 0x01, 0xF0,
  0x04, 0x7C, 0x0F, 0x80, 0xE3, 0xF8, 0x7C, 0x3F, 0x1F, 0xFB, 0xE7, 0xFD,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0x9F, 0xC0,
  0x03, 0xF8, 0x7F, 0x00, 0x3F, 0xC3, 0xFC, 0x03, 0xFC, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x3E, 0x01, 0xF0, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x1F, 0xF1, 0xFE, 0x1F, 0xE3, 0xFE, 0x3F,
  0xC7, 0xF8, 0x7F, 0x8F, 0xF0, 0x3E, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x0E, 0x07, 0xF1, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xC7, 0xF0, 0x78, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F,
  0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xFC,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFB, 0xFF, 0x8F, 0xFC, 0x3F, 0xF9, 0xFF, 0x83, 0xFF, 0x3F,
  0xF0, 0x7F, 0xEF, 0xFC, 0x0F, 0xFD, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xE7,
  0xFE, 0x0F, 0xFC, 0xFF, 0xC1, 0xFF, 0x9F, 0xF8, 0x7F, 0xF1, 0xFF, 0xDF,
  0xFC, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xC0, 0x00, 0xF0, 0x01, 0xFC, 0x01,
  0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFC, 0x3F, 0xF8,
  0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF,
  0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0,
  0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF,
  0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFB, 0xFF, 0xE7, 0xFF, 0x0F, 0xFE, 0x7F,
  0xE0, 0xFF, 0xEF, 0xFE, 0x07, 0xFE, 0xFF, 0xE0, 0x7F, 0xEF, 0xFC, 0x07,
  0xFE, 0xFF, 0xC0, 0x7F, 0xEF, 0xFC, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFB, 0xFF, 0xE7, 0xFF, 0x0F, 0xFE, 0xFF, 0xE0, 0x7F, 0xEF,
  0xFE, 0x07, 0xFE, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x07,
  0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80,
  0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x80, 0x1F, 0xDF, 0xF8, 0x01, 0xFD, 0xFF, 0x80, 0x3F, 0xDF, 0xF8,
  0x03, 0xF9, 0xFF, 0x80, 0x7F, 0x9F, 0xF8, 0x07, 0xF1, 0xFF, 0x80, 0xFF,
  0x1F, 0xF8, 0x0F, 0xF1, 0xFF, 0x81, 0xFE, 0x1F, 0xF8, 0x1F, 0xE1, 0xFF,
  0x83, 0xFE, 0x1F, 0xF8, 0x3F, 0xC1, 0xFF, 0x87, 0xFC, 0x1F, 0xF8, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE7,
  0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xC7, 0xFE,
  0x3F, 0xFE, 0x0F, 0xC0, 0xFF, 0xE0, 0x08, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFE, 0x7F, 0xE0, 0x7F, 0xE7,
  0xFF, 0x0F, 0xFE, 0x7F, 0xF9, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFC,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x3F, 0x00, 0x7F, 0xEF, 0xFC, 0x0F, 0xFD,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0x1F, 0xFE, 0xFF,
  0xE0, 0xFF, 0xEF, 0xFC, 0x0F, 0xFE, 0xFF, 0xC0, 0x7F, 0xEF, 0xFC, 0x07,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFC, 0x07, 0xFE, 0x7F, 0xE0, 0xFF, 0xE7, 0xFE, 0x0F, 0xFE,
  0x3F, 0xFB, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x07,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFC, 0x7F, 0xFB, 0xFF, 0x8F, 0xFE, 0x3F, 0xF9, 0xFF,
  0x83, 0xFF, 0x3F, 0xF0, 0x7F, 0xE7, 0xFE, 0x0F, 0xFC, 0xFF, 0xC1, 0xFF,
  0x9F, 0xF8, 0x3F, 0xF3, 0xFF, 0x07, 0xFE, 0x7F, 0xE0, 0xFF, 0xCF, 0xFC,
  0x1F, 0xF9, 0xFF, 0xC7, 0xFE, 0x1F, 0xF8, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xC7,
  0xFF, 0x1F, 0xF8, 0xFF, 0xC1, 0xFF, 0xBF, 0xF8, 0x3F, 0xF7, 0xFE, 0x07,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x7F,
  0xF7, 0xFF, 0xDF, 0xFE, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFB,
  0xFF, 0x8F, 0xFC, 0x3F, 0xF1, 0xFF, 0x83, 0xFF, 0x7F, 0xF0, 0x7F, 0xEF,
  0xFC, 0x0F, 0xFD, 0xFF, 0x81, 0xFF, 0xBF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFB, 0xFF, 0x87, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0x81, 0xFF, 0xBF, 0xF0, 0x07, 0xE7, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x03, 0xFF,
  0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x07,
  0xF9, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xC7, 0xF8,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xF8, 0xFF, 0x07, 0x00,
  0x07, 0x80, 0xFF, 0x0F, 0xFC, 0x7F, 0xF3, 0xFF, 0xBF, 0xFC, 0xFF, 0xE7,
  0xFF, 0x3F, 0xF0, 0xFF, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0xFF, 0x07,
  0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x3F, 0xE1, 0xFF,
  0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x3F, 0xC1, 0xFE, 0x1F, 0xE0, 0xFF, 0x0F,
  0xF0, 0x1F, 0x00, 0x30, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xC0, 0x0F,
  0xFF, 0x80, 0x7F, 0xFF, 0x07, 0xFF, 0xFE, 0x3F, 0xFF, 0xFD, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x3F, 0xFC, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x00,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0x80,
  0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFE, 0x7F, 0xFB, 0xFF, 0xBF, 0xF8, 0x7F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF,
  0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x07,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x3F, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xE0, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0xFE, 0x00,
  0x00, 0x00, 0xFC, 0x07, 0xF0, 0x03, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0x7F,
  0xF0, 0x1F, 0x83, 0xF8, 0x07, 0xFF, 0xE0, 0xFC, 0x1F, 0x80, 0x7F, 0xFF,
  0x87, 0xF1, 0xFC, 0x07, 0xFF, 0xFC, 0x1F, 0x8F, 0xE0, 0x7F, 0xFF, 0xE0,
  0xFC, 0x7E, 0x03, 0xFC, 0x7F, 0x07, 0xE7, 0xF0, 0x3F, 0xC3, 0xF8, 0x3F,
  0x3F, 0x81, 0xFC, 0x1F, 0xC1, 0xF9, 0xF8, 0x1F, 0xC0, 0xFE, 0x0F, 0xEF,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x7E, 0x07, 0xF0, 0x3F, 0x01, 0xFF, 0xF0,
  0x7F, 0x81, 0xF8, 0x0F, 0xFF, 0x83, 0xF8, 0x1F, 0xC0, 0x7F, 0xFC, 0x1F,
  0xC0, 0xFE, 0x03, 0xFF, 0xE0, 0xFE, 0x07, 0xF0, 0x1F, 0xFF, 0x07, 0xF0,
  0x3F, 0x81, 0xFB, 0xF8, 0x7F, 0x81, 0xFC, 0x0F, 0xDF, 0xC3, 0xFC, 0x0F,
  0xE0, 0x7E, 0xFE, 0x1F, 0xE0, 0x7F, 0x03, 0xF7, 0xF0, 0xFF, 0x03, 0xF8,
  0x1F, 0xBF, 0x87, 0xF8, 0x1F, 0xC0, 0xFD, 0xFC, 0x1F, 0xC0, 0xFE, 0x0F,
  0xCF, 0xE0, 0xFE, 0x0F, 0xF0, 0x7E, 0x7F, 0x07, 0xF8, 0x7F, 0x87, 0xE1,
  0xF8, 0x3F, 0xE7, 0xFC, 0x3F, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F,
  0x07, 0xFF, 0xFF, 0xFF, 0x83, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xC0,
  0xFF, 0xE7, 0xFF, 0x80, 0x7F, 0x01, 0xFE, 0x1F, 0xF8, 0x03, 0xF8, 0x03,
  0x80, 0x3E, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x80,
  0x00, 0x07, 0xFF, 0x80, 0x3C, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x03, 0xFE, 0xFF, 0x80, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x00, 0x7F, 0xEF,
  0xF8, 0x00, 0x01, 0xFF, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x00,
  0x3F, 0xF1, 0xFF, 0x00, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x03, 0xFF, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x01,
  0xFF, 0x83, 0xFF, 0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x3F,
  0xF0, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x7F, 0xF0, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x07, 0xFF, 0x0F, 0xFE,
  0x00, 0x1F, 0xFC, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0xFF, 0xE0, 0x00, 0xFF,
  0xE7, 0xFF, 0x80, 0x03, 0xFF, 0x9F, 0xFC, 0x00, 0x0F, 0xFF, 0x7F, 0xF0,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xFC, 0xFF, 0xE1, 0xFF, 0xFD, 0xFF, 0xC0, 0x7F, 0xFB, 0xFF,
  0x80, 0x7F, 0xF7, 0xFF, 0x00, 0xFF, 0xEF, 0xFE, 0x01, 0xFF, 0xDF, 0xFC,
  0x03, 0xFF, 0xBF, 0xF8, 0x07, 0xFF, 0x7F, 0xF0, 0x0F, 0xFE, 0xFF, 0xE0,
  0x1F, 0xF9, 0xFF, 0xC0, 0x7F, 0xF3, 0xFF, 0x81, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF,
  0xF3, 0xFF, 0x80, 0xFF, 0xF7, 0xFF, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0xFF,
  0xDF, 0xFC, 0x01, 0xFF, 0xBF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0x00, 0xFF, 0xEF, 0xFE, 0x01, 0xFF, 0xDF, 0xFC, 0x1F, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFE, 0x07, 0xFF,
  0x8F, 0xFE, 0x01, 0xFF, 0xC7, 0xFE, 0x00, 0x7F, 0xE7, 0xFF, 0x00, 0x3F,
  0xFB, 0xFF, 0x80, 0x1F, 0xFD, 0xFF, 0xC0, 0x0F, 0xFE, 0xFF, 0xC0, 0x07,
  0xFF, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xBF,
  0xF0, 0x01, 0xFF, 0xDF, 0xFC, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x7F, 0xF3,
  0xFF, 0x00, 0x3F, 0xF1, 0xFF, 0xC0, 0x3F, 0xF8, 0xFF, 0xF0, 0x3F, 0xFC,
  0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xE7, 0xFF, 0xF1,
  0xFF, 0xC0, 0xFF, 0xF3, 0xFF, 0x80, 0xFF, 0xE7, 0xFF, 0x01, 0xFF, 0xCF,
  0xFE, 0x01, 0xFF, 0xDF, 0xFC, 0x03, 0xFF, 0xBF, 0xF8, 0x07, 0xFF, 0x7F,
  0xF0, 0x0F, 0xFE, 0xFF, 0xE0, 0x0F, 0xFD, 0xFF, 0xC0, 0x1F, 0xFB, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xDF, 0xFC, 0x03, 0xFF, 0xBF, 0xF8, 0x07,
  0xFF, 0x7F, 0xF0, 0x0F, 0xFE, 0xFF, 0xE0, 0x1F, 0xFD, 0xFF, 0xC0, 0x3F,
  0xFB, 0xFF, 0x80, 0xFF, 0xE7, 0xFF, 0x01, 0xFF, 0xCF, 0xFE, 0x07, 0xFF,
  0x9F, 0xFC, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00,
  0x03, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0,
  0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xE0, 0x00, 0x3F, 0xF8,
  0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F,
  0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0,
  0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF,
  0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFC, 0x1F, 0xFE, 0x7F, 0xF0,
  0x0F, 0xFE, 0x7F, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0x7F, 0xF0, 0x07, 0xFF, 0x7F, 0xF8,
  0x07, 0xFF, 0x7F, 0xFC, 0x0F, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF,
  0xBF, 0xF0, 0x7F, 0xF7, 0xFF, 0x0F, 0xFE, 0xFF, 0xE1, 0xFF, 0xDF, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xBF, 0xF8, 0x07, 0xFF, 0xDF, 0xFC, 0x03, 0xFF, 0xCF, 0xFE, 0x03,
  0xFF, 0xE7, 0xFF, 0x01, 0xFF, 0xE3, 0xFF, 0x81, 0xFF, 0xE1, 0xFF, 0xC0,
  0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF8,
  0x7F, 0xF8, 0x1F, 0xFC, 0x3F, 0xF8, 0x0F, 0xFE, 0x3F, 0xFC, 0x07, 0xFF,
  0x1F, 0xFC, 0x03, 0xFF, 0x9F, 0xFC, 0x01, 0xFF, 0xCF, 0xFE, 0x00, 0xFF,
  0xEF, 0xFE, 0x00, 0x7F, 0xF7, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xEF, 0xFF,
  0x01, 0xFF, 0xF3, 0xFF, 0x80, 0xFF, 0xF1, 0xFF, 0xE0, 0x7F, 0xF0, 0xFF,
  0xF0, 0x3F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFE, 0x07,
  0xFF, 0x87, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0x81, 0xFF, 0xF1, 0xFF, 0xC0,
  0x7F, 0xF8, 0xFF, 0xE0, 0x3F, 0xFE, 0x7F, 0xF0, 0x0F, 0xFF, 0x3F, 0xF8,
  0x07, 0xFF, 0x9F, 0xFC, 0x03, 0xFF, 0xEF, 0xFE, 0x00, 0xFF, 0xF7, 0xFF,
  0x00, 0x7F, 0xFC, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F,
  0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8,
  0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F,
  0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0,
  0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF,
  0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xDF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFF, 0x7F, 0x03, 0xFF, 0xFF, 0xFF, 0xDF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xF7, 0xF8, 0x3F, 0xBF, 0xFF, 0xFD, 0xFE, 0x1F, 0xEF, 0xFF, 0xFF, 0x3F,
  0x87, 0xFB, 0xFF, 0xFF, 0xCF, 0xF1, 0xFE, 0xFF, 0xFF, 0xF3, 0xFC, 0x7F,
  0x3F, 0xFF, 0xFC, 0x7F, 0x3F, 0xCF, 0xFF, 0xFF, 0x1F, 0xCF, 0xF3, 0xFF,
  0xFF, 0xC7, 0xF3, 0xF8, 0xFF, 0xFF, 0xF9, 0xFE, 0xFE, 0x3F, 0xFF, 0xFE,
  0x3F, 0xBF, 0x8F, 0xFF, 0xFF, 0x8F, 0xFF, 0xE3, 0xFF, 0xFF, 0xE3, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0x0F,
  0xFF, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF8, 0x7F, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0xFE, 0x0F, 0xFF, 0xFF, 0x83,
  0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xF0,
  0x3F, 0xFF, 0xFE, 0x07, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFE, 0x03, 0xFF,
  0xFF, 0xE0, 0x7F, 0x80, 0xFF, 0xFF, 0xF8, 0x0F, 0xE0, 0x3F, 0xF0, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFD, 0xFC, 0x7F, 0xFF, 0xFE, 0xFE,
  0x3F, 0xFF, 0xFF, 0x7F, 0x1F, 0xFF, 0xFF, 0x9F, 0xCF, 0xFF, 0xFF, 0xCF,
  0xE7, 0xFF, 0xFF, 0xE3, 0xFB, 0xFF, 0xFF, 0xF1, 0xFD, 0xFF, 0xFF, 0xF8,
  0xFE, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0x83, 0xFF, 0xC3, 0xFF, 0x80, 0x7F, 0xF0, 0xFF, 0xE0, 0x0F, 0xFE,
  0x7F, 0xF0, 0x03, 0xFF, 0x9F, 0xFC, 0x00, 0x7F, 0xE7, 0xFF, 0x00, 0x1F,
  0xFD, 0xFF, 0xC0, 0x07, 0xFF, 0x7F, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFD, 0xFF, 0x80, 0x07,
  0xFF, 0x7F, 0xF0, 0x01, 0xFF, 0xDF, 0xFC, 0x00, 0x7F, 0xF7, 0xFF, 0x00,
  0x1F, 0xF9, 0xFF, 0xC0, 0x0F, 0xFE, 0x3F, 0xF8, 0x03, 0xFF, 0x8F, 0xFE,
  0x01, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xE0, 0xFF, 0xFD, 0xFF, 0xC0, 0x3F, 0xFB,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0x83, 0xFF, 0xC3, 0xFF, 0x80, 0x7F, 0xF8, 0xFF, 0xE0, 0x0F, 0xFE, 0x7F,
  0xF0, 0x03, 0xFF, 0x9F, 0xFC, 0x00, 0x7F, 0xF7, 0xFF, 0x00, 0x1F, 0xFD,
  0xFF, 0xC0, 0x07, 0xFF, 0x7F, 0xF0, 0x01, 0xFF, 0xDF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xDF,
  0xF8, 0x00, 0x7F, 0xF7, 0xFE, 0x00, 0x1F, 0xFD, 0xFF, 0xC0, 0x07, 0xFF,
  0x7F, 0xF0, 0x01, 0xFF, 0xDF, 0xFC, 0x00, 0x7F, 0xF7, 0xFF, 0x00, 0x1F,
  0xFD, 0xFF, 0xC0, 0x0F, 0xFE, 0x3F, 0xF8, 0x03, 0xFF, 0x8F, 0xFE, 0x01,
  0xFF, 0xE1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x01, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xE0,
  0xFF, 0xFC, 0xFF, 0xE0, 0x3F, 0xFC, 0xFF, 0xE0, 0x1F, 0xFC, 0xFF, 0xE0,
  0x1F, 0xFC, 0xFF, 0xE0, 0x0F, 0xFC, 0xFF, 0xE0, 0x0F, 0xFE, 0xFF, 0xE0,
  0x0F, 0xFE, 0xFF, 0xE0, 0x0F, 0xFC, 0xFF, 0xE0, 0x0F, 0xFC, 0xFF, 0xE0,
  0x0F, 0xFC, 0xFF, 0xE0, 0x1F, 0xFC, 0xFF, 0xE0, 0x1F, 0xFC, 0xFF, 0xE0,
  0x3F, 0xFC, 0xFF, 0xE0, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xE3, 0xFF, 0x80, 0xFF, 0xE3, 0xFF, 0xC0, 0xFF, 0xE1,
  0xFF, 0xC0, 0xFF, 0xE1, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0,
  0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0xF0, 0xFF, 0xE0, 0x7F, 0xF0, 0xFF, 0xE0,
  0x7F, 0xF8, 0xFF, 0xE0, 0x3F, 0xF8, 0xFF, 0xE0, 0x3F, 0xFC, 0xFF, 0xE0,
  0x3F, 0xFC, 0xFF, 0xE0, 0x1F, 0xFC, 0xFF, 0xE0, 0x1F, 0xFE, 0xFF, 0xE0,
  0x0F, 0xFE, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xF0, 0x3F, 0xF8, 0xFF, 0xE0, 0x3F,
  0xFB, 0xFF, 0x80, 0x7F, 0xF7, 0xFF, 0x00, 0xFF, 0xEF, 0xFE, 0x01, 0xFF,
  0xDF, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00,
  0x7F, 0xF7, 0xFE, 0x00, 0xFF, 0xEF, 0xFE, 0x01, 0xFF, 0xDF, 0xFE, 0x07,
  0xFF, 0x1F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xF7, 0xFF, 0x01, 0xFF, 0xCF, 0xFE, 0x03,
  0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFB, 0xFF, 0xC0, 0x03, 0xFF, 0xDF, 0xFE,
  0x00, 0x1F, 0xFC, 0xFF, 0xF0, 0x01, 0xFF, 0xE3, 0xFF, 0x80, 0x0F, 0xFF,
  0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0xFF, 0xF0, 0x03, 0xFF, 0x87, 0xFF, 0x80,
  0x1F, 0xFC, 0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0xFF, 0xE0, 0x0F, 0xFF, 0x07,
  0xFF, 0x00, 0x7F, 0xF0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x1F,
  0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0xFF,
  0xC0, 0x7F, 0xF0, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x1F, 0xF8,
  0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x07, 0xFE, 0x0F, 0xFE, 0x00, 0x3F, 0xF0,
  0x7F, 0xF0, 0x01, 0xFF, 0xC3, 0xFF, 0x00, 0x0F, 0xFE, 0x1F, 0xF8, 0x00,
  0x3F, 0xF1, 0xFF, 0xC0, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x0F, 0xFC, 0x7F,
  0xE0, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x0F,
  0xFD, 0xFF, 0x80, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x01, 0xFF, 0x7F, 0xE0,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xE0,
  0x3F, 0xE0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFC, 0x07, 0xFE, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xF7, 0xFE, 0x07, 0xFF,
  0x03, 0xFF, 0xBF, 0xF0, 0x3F, 0xF8, 0x1F, 0xFD, 0xFF, 0xC1, 0xFF, 0xC0,
  0xFF, 0xCF, 0xFE, 0x0F, 0xFF, 0x07, 0xFE, 0x7F, 0xF0, 0x7F, 0xF8, 0x3F,
  0xF1, 0xFF, 0x87, 0xFF, 0xC1, 0xFF, 0x8F, 0xFC, 0x3F, 0xFE, 0x1F, 0xFC,
  0x7F, 0xE1, 0xFF, 0xF0, 0xFF, 0xE3, 0xFF, 0x0F, 0xFF, 0x87, 0xFE, 0x1F,
  0xFC, 0x7F, 0xFE, 0x3F, 0xF0, 0xFF, 0xE3, 0xFF, 0xF1, 0xFF, 0x83, 0xFF,
  0x3F, 0xFF, 0x8F, 0xFC, 0x1F, 0xF9, 0xFF, 0xFC, 0xFF, 0xE0, 0xFF, 0xCF,
  0xFF, 0xE7, 0xFF, 0x07, 0xFE, 0x7F, 0xFF, 0xBF, 0xF0, 0x3F, 0xF3, 0xFF,
  0xFD, 0xFF, 0x81, 0xFF, 0xDF, 0xFF, 0xEF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0x7F, 0xE0, 0x3F, 0xFF, 0xFF, 0xFB, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFB, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xDF, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x7F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF3, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x1F, 0xFF, 0xE0, 0x07, 0xFF,
  0xF8, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC7, 0xFF, 0xF8, 0x00, 0xFF, 0xFE,
  0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x87,
  0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xC1, 0xFF,
  0xF8, 0x00, 0x3F, 0xFE, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x3F, 0xFE,
  0x00, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x00,
  0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE7, 0xFF, 0x80,
  0x1F, 0xFE, 0x3F, 0xFC, 0x03, 0xFF, 0xC3, 0xFF, 0xC0, 0x3F, 0xFC, 0x1F,
  0xFC, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFE, 0x07, 0xFF,
  0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x07, 0xFF, 0x0F, 0xFE, 0x00, 0x7F, 0xF0,
  0xFF, 0xE0, 0x07, 0xFF, 0x0F, 0xFE, 0x00, 0x3F, 0xF9, 0xFF, 0xC0, 0x03,
  0xFF, 0x9F, 0xFC, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x3F, 0xF9,
  0xFF, 0xC0, 0x03, 0xFF, 0x9F, 0xFC, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x07,
  0xFF, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0x0F, 0xFE, 0x07, 0xFF,
  0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0x83, 0xFF, 0xC0,
  0x3F, 0xF8, 0x3F, 0xFC, 0x03, 0xFF, 0xC3, 0xFF, 0xC0, 0x3F, 0xFC, 0x7F,
  0xF8, 0x01, 0xFF, 0xE7, 0xFF, 0x80, 0x1F, 0xFE, 0x7F, 0xF0, 0x01, 0xFF,
  0xEF, 0xFE, 0x00, 0x3F, 0xF9, 0xFF, 0xE0, 0x07, 0xFF, 0x1F, 0xFC, 0x01,
  0xFF, 0xE3, 0xFF, 0x80, 0x3F, 0xF8, 0x3F, 0xF0, 0x07, 0xFF, 0x07, 0xFF,
  0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFC, 0x07, 0xFF, 0x01,
  0xFF, 0xC0, 0xFF, 0xC0, 0x1F, 0xF8, 0x3F, 0xF8, 0x03, 0xFF, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0xFF, 0xC7,
  0xFE, 0x00, 0x0F, 0xF8, 0xFF, 0xC0, 0x01, 0xFF, 0x9F, 0xF0, 0x00, 0x3F,
  0xF7, 0xFE, 0x00, 0x03, 0xFE, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF,
  0x8F, 0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1,
  0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F,
  0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE,
  0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF, 0xC7,
  0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF,
  0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F,
  0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00,
  0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF8,
  0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x1F,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x07,
  0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xF8, 0xFF,
  0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8,
  0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF, 0x1F,
  0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF,
  0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3,
  0xFF, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F,
  0xE3, 0xFF, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC,
  0x7F, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x03, 0xFF,
  0xC0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x07, 0xEF,
  0xE0, 0x0F, 0xE7, 0xF0, 0x0F, 0xE7, 0xF0, 0x0F, 0xE7, 0xF0, 0x1F, 0xC3,
  0xF8, 0x1F, 0xC3, 0xF8, 0x3F, 0xC3, 0xF8, 0x3F, 0x83, 0xFC, 0x3F, 0x81,
  0xFC, 0x7F, 0x81, 0xFC, 0x7F, 0x81, 0xFE, 0x7F, 0x01, 0xFE, 0xFF, 0x00,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0,
  0x3F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFC, 0x7F, 0xE3, 0xFF, 0x9F, 0xFC, 0x3F, 0xF3, 0xFF, 0x87, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x3F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xC7, 0xFE, 0x1F, 0xF9, 0xFF, 0xC3,
  0xFF, 0x3F, 0xF0, 0x7F, 0xE7, 0xFE, 0x0F, 0xFC, 0xFF, 0xC1, 0xFF, 0x9F,
  0xF8, 0x3F, 0xF3, 0xFF, 0x07, 0xFE, 0x7F, 0xE1, 0xFF, 0xCF, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0xC3, 0xFF, 0x9F, 0xF8, 0x3F, 0xE3, 0xFF, 0x80, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x87, 0xC0,
  0x3F, 0xF3, 0xFE, 0x07, 0xFE, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFD,
  0xFF, 0xE7, 0xFF, 0xBF, 0xF8, 0x3F, 0xF7, 0xFE, 0x07, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFE, 0x07, 0xFE, 0xFF, 0xF3, 0xFF, 0xDF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0x7F, 0xFE,
  0x3F, 0xE7, 0xFF, 0x87, 0xFC, 0x7F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFB, 0xFF, 0x9F, 0xF8, 0x7F, 0xEF, 0xFC, 0x0F, 0xFB, 0xFF,
  0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xF7,
  0xFE, 0x0F, 0xF9, 0xFF, 0xEF, 0xFE, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFE, 0x01, 0xE0, 0xFF, 0xC1, 0xFF, 0x9F, 0xF8, 0x7F,
  0xFB, 0xFF, 0x1F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xF7, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0x7F,
  0xFB, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xDF, 0xF8, 0x3F,
  0xF1, 0xFF, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x7F, 0xFD, 0xFF,
  0xCF, 0xFC, 0x0F, 0xFD, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x41, 0xFF, 0xC0,
  0x1C, 0x3F, 0xFF, 0x3F, 0x83, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x07,
  0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x07,
  0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0x90, 0xFF, 0xE0, 0x0F, 0xFC, 0x00,
  0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x0F, 0xFF, 0xFE,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF,
  0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F,
  0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00,
  0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC,
  0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3F, 0xF3, 0xFF, 0x07, 0xFF, 0xBF, 0xF1, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFD, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0x7F, 0xE0, 0x7F, 0xF7, 0xFF, 0xDF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF,
  0x7F, 0xF0, 0x07, 0x87, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE,
  0x02, 0x00, 0xFF, 0xE0, 0x78, 0x1F, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0xFF,
  0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00,
  0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC1, 0xE0, 0x3F, 0xF9,
  0xFF, 0x07, 0xFF, 0x7F, 0xF8, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xF7,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0x3F, 0x0F, 0xFB, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0x83, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01,
  0xF8, 0x03, 0xFE, 0x07, 0xFE, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07,
  0xFF, 0x07, 0xFE, 0x03, 0xFC, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07,
  0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07,
  0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07,
  0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07,
  0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07,
  0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07,
  0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x1F, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xC0, 0xFF,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x03, 0xFF, 0xDF, 0xF8, 0x3F, 0xFC, 0xFF,
  0xC1, 0xFF, 0xE7, 0xFE, 0x1F, 0xFE, 0x3F, 0xF1, 0xFF, 0xE1, 0xFF, 0x8F,
  0xFE, 0x0F, 0xFC, 0xFF, 0xF0, 0x7F, 0xE7, 0xFF, 0x03, 0xFF, 0x7F, 0xF0,
  0x1F, 0xFB, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xF3, 0xFF, 0x83, 0xFF, 0x1F, 0xFC, 0x1F, 0xF8,
  0x7F, 0xF0, 0xFF, 0xC3, 0xFF, 0x87, 0xFE, 0x1F, 0xFE, 0x3F, 0xF0, 0x7F,
  0xF1, 0xFF, 0x83, 0xFF, 0xCF, 0xFC, 0x0F, 0xFE, 0x7F, 0xE0, 0x7F, 0xFB,
  0xFF, 0x01, 0xFF, 0xDF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0xF0, 0x03, 0xE0, 0x7F, 0xE3, 0xFE, 0x07, 0xFC, 0x3F,
  0xF7, 0xFF, 0x8F, 0xFF, 0x1F, 0xFF, 0xFF, 0xEF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xF7, 0xFF, 0xFF,
  0xF0, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0x7F, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F,
  0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xFE, 0x0F,
  0xFF, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0x83, 0xFF, 0xFF,
  0xC1, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F,
  0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xFC, 0x1F,
  0xFF, 0xFE, 0x0F, 0xFE, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0xFF,
  0x83, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xF8, 0x3F,
  0xFF, 0xFC, 0x1F, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xFE, 0x0F, 0xFF, 0xFF,
  0x07, 0xFF, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF,
  0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xF0, 0x7F,
  0xE0, 0x00, 0x01, 0xE0, 0x3F, 0xE3, 0xFF, 0x0F, 0xF9, 0xFF, 0xE3, 0xFE,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFE, 0xFF, 0xF7, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFB, 0xFF, 0xC7, 0xFE, 0x0F, 0xFE, 0xFF, 0xE0, 0x7F, 0xEF, 0xFE, 0x07,
  0xFE, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xEF, 0xFE,
  0x07, 0xFE, 0x7F, 0xE0, 0xFF, 0xE7, 0xFF, 0x9F, 0xFC, 0x7F, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x1F, 0xF1, 0xFF, 0x03, 0xFF, 0x7F, 0xF8, 0x7F,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFB, 0xFF, 0xDF, 0xFC, 0x1F, 0xFB, 0xFF,
  0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFB, 0xFF, 0x03, 0xFF, 0x7F, 0xF9, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0x1F, 0xFB, 0xFF, 0xC3, 0xFF, 0x3F, 0xE0, 0x7F,
  0xE1, 0xE0, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF,
  0xC7, 0xFC, 0x3F, 0xFC, 0xFF, 0x8F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x7F, 0xFB,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x83, 0xFF, 0xBF, 0xFD, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xE1, 0xFF,
  0xEF, 0xFC, 0x1F, 0xF9, 0xFF, 0x80, 0x78, 0x3F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xBF, 0xE3, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x83, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF,
  0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0,
  0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F,
  0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF,
  0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0xFF, 0xCF, 0xFF, 0x7F, 0xE0,
  0xFF, 0xDF, 0xF8, 0x3F, 0xF7, 0xFE, 0x0F, 0xFD, 0xFF, 0x80, 0x00, 0x7F,
  0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFD,
  0xFF, 0x83, 0xFF, 0x7F, 0xF1, 0xFF, 0xCF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0xFC,
  0x7F, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xFF, 0x03,
  0xFF, 0xC0, 0x7F, 0xF0, 0x03, 0xF0, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFE, 0xFF, 0xC3, 0xFF, 0x1F, 0xF0, 0x1E, 0x00, 0x00,
  0x7F, 0xE0, 0x3F, 0xFB, 0xFF, 0x81, 0xFF, 0x9F, 0xFC, 0x0F, 0xFC, 0xFF,
  0xE0, 0xFF, 0xE3, 0xFF, 0x07, 0xFF, 0x1F, 0xF8, 0x3F, 0xF0, 0xFF, 0xC1,
  0xFF, 0x87, 0xFF, 0x0F, 0xFC, 0x1F, 0xF8, 0x7F, 0xE0, 0xFF, 0xC7, 0xFE,
  0x07, 0xFE, 0x3F, 0xF0, 0x1F, 0xF1, 0xFF, 0x80, 0xFF, 0x8F, 0xFC, 0x07,
  0xFE, 0x7F, 0xC0, 0x3F, 0xF7, 0xFE, 0x00, 0xFF, 0xBF, 0xF0, 0x07, 0xFD,
  0xFF, 0x80, 0x3F, 0xEF, 0xF8, 0x01, 0xFF, 0x7F, 0xC0, 0x07, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC1, 0xFE, 0x0F, 0xFF, 0xFF, 0x07, 0xF8,
  0x3F, 0xFF, 0xFC, 0x1F, 0xE0, 0xFF, 0xDF, 0xF0, 0x7F, 0x83, 0xFE, 0x7F,
  0xC3, 0xFE, 0x0F, 0xF9, 0xFF, 0x0F, 0xFC, 0x3F, 0xE7, 0xFC, 0x3F, 0xF1,
  0xFF, 0x9F, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xE3, 0xFF, 0x1F, 0xF0, 0xFF,
  0x9F, 0xFE, 0x7F, 0xC3, 0xFE, 0x7F, 0xF9, 0xFF, 0x0F, 0xF9, 0xFF, 0xE7,
  0xFC, 0x3F, 0xE7, 0xFF, 0x9F, 0xF0, 0xFF, 0x9F, 0xFE, 0x7F, 0x81, 0xFE,
  0xFF, 0xFF, 0xFE, 0x07, 0xFB, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFC, 0xFF, 0xFE, 0x03, 0xFF,
  0xF3, 0xFF, 0xF0, 0x0F, 0xFF, 0xCF, 0xFF, 0xC0, 0x3F, 0xFF, 0x3F, 0xFF,
  0x00, 0xFF, 0xF8, 0xFF, 0xFC, 0x03, 0xFF, 0xE1, 0xFF, 0xF0, 0x07, 0xFF,
  0x87, 0xFF, 0x80, 0x1F, 0xFE, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x7F, 0xF8,
  0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x1F, 0xFC,
  0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0xFF, 0xC0,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0xFF, 0xE0,
  0x7F, 0xE7, 0xFE, 0x07, 0xFE, 0x7F, 0xF0, 0xFF, 0xE3, 0xFF, 0x0F, 0xFC,
  0x3F, 0xF1, 0xFF, 0xC3, 0xFF, 0x9F, 0xF8, 0x1F, 0xF9, 0xFF, 0x81, 0xFF,
  0xBF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x03,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0x80, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x01, 0xFF, 0xBF, 0xF0, 0x1F, 0xF9, 0xFF, 0x83, 0xFF, 0x9F, 0xF8,
  0x3F, 0xF1, 0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x7F, 0xF0, 0xFF, 0xE7, 0xFE,
  0x0F, 0xFE, 0xFF, 0xE0, 0x7F, 0xEF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFB, 0xFF, 0x81, 0xFF, 0xDF, 0xFC, 0x0F, 0xFE, 0xFF, 0xE0, 0xFF, 0xE3,
  0xFF, 0x07, 0xFF, 0x1F, 0xF8, 0x3F, 0xF8, 0xFF, 0xE1, 0xFF, 0x87, 0xFF,
  0x0F, 0xFC, 0x1F, 0xF8, 0xFF, 0xE0, 0xFF, 0xC7, 0xFF, 0x07, 0xFE, 0x3F,
  0xF0, 0x1F, 0xF9, 0xFF, 0x80, 0xFF, 0xDF, 0xFC, 0x07, 0xFE, 0xFF, 0xC0,
  0x3F, 0xF7, 0xFE, 0x00, 0xFF, 0xBF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80,
  0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0x7F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x00,
  0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x08, 0x00, 0x70, 0x03, 0xF0, 0x0F, 0xE0, 0x3F, 0xE0, 0xFF, 0xC1, 0xFF,
  0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xC0, 0x7F, 0x81, 0xFF, 0x03,
  0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF,
  0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x7F, 0xC1,
  0xFF, 0x87, 0xFE, 0x0F, 0xFC, 0x1F, 0xE0, 0x3F, 0x80, 0x7F, 0xC0, 0xFF,
  0xC1, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0x01, 0xFF, 0x03, 0xFE, 0x07, 0xFC,
  0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03,
  0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0xC0, 0xFF, 0x81, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x03, 0xFE, 0x03, 0xF8,
  0x03, 0xF0, 0x01, 0xC0, 0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x20,
  0x00, 0xF0, 0x01, 0xF8, 0x03, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x01, 0xFE, 0x03,
  0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xF0,
  0x3F, 0xF0, 0x7F, 0xF0, 0x7F, 0xE0, 0x7F, 0xC0, 0x3F, 0x81, 0xFF, 0x07,
  0xFE, 0x1F, 0xFC, 0x3F, 0xE0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03,
  0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF,
  0x03, 0xFE, 0x07, 0xF8, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0x80, 0xFE, 0x01,
  0xF8, 0x03, 0xC0, 0x02, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x1F, 0xC7, 0xFF, 0x01, 0xFE, 0x7F, 0xFC, 0x0F, 0xF3, 0xFF, 0xF0, 0x7F,
  0xBF, 0xFF, 0xC3, 0xF9, 0xFF, 0xFF, 0x3F, 0xCF, 0xFF, 0xFF, 0xFE, 0xFF,
  0x9F, 0xFF, 0xF7, 0xF8, 0x7F, 0xFF, 0x3F, 0x81, 0xFF, 0xF9, 0xFC, 0x0F,
  0xFF, 0x8F, 0xE0, 0x3F, 0xF8, 0x7F, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xF0,
  0x00,
};

const GFXglyph RobotoCondensed_Black64pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 11, 47, 17, 3, -46 },
  { 66, 18, 18, 20, 1, -48 },
  { 107, 30, 46, 33, 1, -46 },
  { 280, 27, 61, 33, 3, -54 },
  { 486, 35, 48, 41, 3, -47 },
  { 696, 35, 48, 38, 2, -47 },
  { 906, 8, 18, 10, 1, -48 },
  { 924, 15, 64, 21, 4, -50 },
  { 1044, 16, 64, 21, 2, -50 },
  { 1172, 29, 28, 30, 1, -46 },
  { 1274, 26, 33, 30, 2, -38 },
  { 1382, 12, 20, 17, 1, -8 },
  { 1412, 17, 8, 27, 5, -24 },
  { 1429, 11, 11, 19, 4, -10 },
  { 1445, 20, 50, 20, -1, -46 },
  { 1570, 27, 48, 33, 3, -47 },
  { 1732, 18, 46, 33, 5, -46 },
  { 1836, 28, 47, 33, 2, -47 },
  { 2001, 28, 48, 33, 2, -47 },
  { 2169, 28, 46, 33, 2, -46 },
  { 2330, 28, 47, 33, 2, -46 },
  { 2495, 28, 47, 33, 3, -46 },
  { 2660, 28, 46, 33, 2, -46 },
  { 2821, 27, 48, 33, 3, -47 },
  { 2983, 27, 47, 33, 3, -47 },
  { 3142, 11, 36, 19, 4, -35 },
  { 3192, 13, 47, 18, 2, -35 },
  { 3269, 23, 31, 29, 2, -35 },
  { 3359, 25, 22, 33, 4, -31 },
  { 3428, 24, 30, 29, 3, -34 },
  { 3518, 26, 48, 29, 1, -47 },
  { 3674, 45, 58, 49, 2, -44 },
  { 4001, 38, 46, 39, 0, -46 },
  { 4220, 31, 46, 36, 3, -46 },
  { 4399, 33, 48, 37, 2, -47 },
  { 4597, 31, 46, 36, 3, -46 },
  { 4776, 27, 46, 31, 3, -46 },
  { 4932, 26, 46, 30, 3, -46 },
  { 5082, 32, 48, 38, 3, -47 },
  { 5274, 33, 46, 39, 3, -46 },
  { 5464, 10, 46, 18, 4, -46 },
  { 5522, 27, 47, 32, 1, -46 },
  { 5681, 33, 46, 36, 3, -46 },
  { 5871, 26, 46, 31, 3, -46 },
  { 6021, 42, 46, 49, 3, -46 },
  { 6263, 33, 46, 39, 3, -46 },
  { 6453, 34, 48, 39, 2, -47 },
  { 6657, 31, 46, 37, 3, -46 },
  { 6836, 34, 55, 39, 2, -47 },
  { 7070, 32, 46, 36, 3, -46 },
  { 7254, 31, 48, 35, 2, -47 },
  { 7440, 33, 46, 36, 1, -46 },
  { 7630, 31, 47, 37, 3, -46 },
  { 7813, 37, 46, 37, 0, -46 },
  { 8026, 45, 46, 48, 1, -46 },
  { 8285, 36, 46, 36, 0, -46 },
  { 8492, 35, 46, 35, 0, -46 },
  { 8694, 31, 46, 34, 2, -46 },
  { 8873, 13, 64, 17, 3, -53 },
  { 8977, 26, 50, 25, 0, -46 },
  { 9140, 13, 64, 17, 1, -53 },
  { 9244, 24, 23, 26, 1, -46 },
  { 9313, 24, 8, 25, 1, 0 },
  { 9337, 17, 10, 22, 2, -48 },
  { 9359, 27, 36, 30, 2, -35 },
  { 9481, 27, 49, 32, 3, -48 },
  { 9647, 26, 36, 29, 2, -35 },
  { 9764, 27, 49, 32, 2, -48 },
  { 9930, 27, 36, 31, 2, -35 },
  { 10052, 20, 49, 21, 1, -49 },
  { 10175, 28, 48, 32, 2, -35 },
  { 10343, 27, 48, 32, 2, -48 },
  { 10505, 11, 48, 17, 3, -48 },
  { 10571, 16, 61, 16, -2, -48 },
  { 10693, 29, 48, 31, 3, -48 },
  { 10867, 11, 48, 17, 3, -48 },
  { 10933, 41, 35, 47, 3, -35 },
  { 11113, 26, 35, 32, 3, -35 },
  { 11227, 28, 36, 32, 2, -35 },
  { 11353, 27, 48, 32, 3, -35 },
  { 11515, 27, 48, 32, 2, -35 },
  { 11677, 18, 35, 22, 3, -35 },
  { 11756, 26, 36, 29, 1, -35 },
  { 11873, 18, 43, 20, 1, -42 },
  { 11970, 26, 35, 32, 3, -34 },
  { 12084, 29, 34, 29, 0, -34 },
  { 12208, 38, 34, 40, 1, -34 },
  { 12370, 28, 34, 29, 1, -34 },
  { 12489, 29, 47, 30, 0, -34 },
  { 12660, 25, 34, 29, 2, -34 },
  { 12767, 15, 61, 19, 2, -50 },
  { 12882, 6, 54, 16, 5, -46 },
  { 12923, 15, 61, 19, 2, -50 },
  { 13038, 29, 15, 35, 3, -26 },
};

const GFXfont RobotoCondensed_Black64pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Black64pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Black64pt7bGlyphs,
  0x20, 0x7E, 75
};

#endif // _ROBOTOCONDENSED_BLACK64PT7B_H_
