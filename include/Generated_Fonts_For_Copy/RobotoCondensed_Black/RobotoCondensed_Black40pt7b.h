#ifndef _ROBOTOCONDENSED_BLACK40PT7B_H_
#define _ROBOTOCONDENSED_BLACK40PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Black.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Black40pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFD, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF8, 0x00, 0x00, 0x07, 0x1F, 0x7F, 0xFF, 0xFD,
  0xF1, 0xC0, 0xF3, 0xFE, 0x7F, 0xCF, 0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xF7,
  0x9E, 0xE3, 0xDC, 0x7B, 0x8F, 0x00, 0x03, 0xCE, 0x00, 0xF3, 0x80, 0x39,
  0xE0, 0x0E, 0x78, 0x07, 0x9E, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x1E, 0x78,
  0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF, 0x0F, 0x3C, 0x03,
  0xCF, 0x00, 0xF3, 0xC0, 0x3C, 0xE0, 0x0F, 0x38, 0x3F, 0xFF, 0xEF, 0xFF,
  0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x87, 0x9E, 0x01, 0xE7, 0x00, 0x79, 0xC0,
  0x1C, 0xF0, 0x07, 0x3C, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x3F, 0x00, 0x7F, 0xE0, 0xFF, 0xF8,
  0x7F, 0xFC, 0x7F, 0xFF, 0x3F, 0x9F, 0x9F, 0x8F, 0xEF, 0xC7, 0xF7, 0xE3,
  0xFB, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x03,
  0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x03, 0xFB, 0xF0, 0xFF, 0xF8, 0x7F,
  0xFC, 0x3F, 0xFF, 0x1F, 0xFF, 0x8F, 0xCF, 0xFF, 0xE7, 0xFF, 0xF1, 0xFF,
  0xF0, 0x7F, 0xF0, 0x0F, 0xE0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1F, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF0,
  0x40, 0xF3, 0xE3, 0xC3, 0xC7, 0x8F, 0x0F, 0x1E, 0x78, 0x3C, 0x79, 0xC0,
  0xF3, 0xEF, 0x03, 0xFF, 0x38, 0x07, 0xFD, 0xE0, 0x1F, 0xEF, 0x00, 0x1F,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0xF8, 0x00, 0xE7,
  0xF0, 0x07, 0xBF, 0xE0, 0x1D, 0xFF, 0xC0, 0xF7, 0x8F, 0x07, 0x9E, 0x3C,
  0x1E, 0x78, 0xF0, 0xF1, 0xE3, 0xC3, 0xC7, 0x8F, 0x0E, 0x1F, 0xFC, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFC, 0xFC, 0x03,
  0xF1, 0xF0, 0x0F, 0xC7, 0xC0, 0x3F, 0x1F, 0x00, 0x7C, 0xF8, 0x01, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0x87, 0xC1, 0xFF, 0x1F,
  0x0F, 0xFE, 0x7C, 0x7F, 0xFD, 0xF1, 0xFF, 0xFF, 0xCF, 0xEF, 0xFF, 0x3F,
  0x9F, 0xFC, 0xFE, 0x7F, 0xE3, 0xF8, 0xFF, 0x8F, 0xF3, 0xFC, 0x1F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xBF, 0x81, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7B, 0xDE, 0xF7, 0xBC, 0x00, 0x80, 0x60, 0x3C, 0x1F,
  0x0F, 0x87, 0xC1, 0xF0, 0x78, 0x3E, 0x0F, 0x87, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC3, 0xF0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xFC, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x03, 0xE0, 0xF8, 0x3E,
  0x07, 0xC1, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x18, 0x02, 0x40, 0x1C, 0x0F,
  0x83, 0xE0, 0x7C, 0x0F, 0x83, 0xE0, 0x7C, 0x1F, 0x07, 0xE0, 0xF8, 0x3E,
  0x0F, 0x83, 0xF0, 0xFC, 0x3F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3E, 0x0F, 0x83, 0xE1, 0xF8,
  0x7C, 0x1F, 0x0F, 0x83, 0xE1, 0xF0, 0xF8, 0x3E, 0x07, 0x01, 0x00, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x41, 0xC0, 0x3C, 0x71,
  0xEF, 0xFD, 0xFB, 0xFF, 0xFE, 0x3F, 0xFF, 0x00, 0xFC, 0x00, 0x7F, 0x00,
  0x3F, 0xE0, 0x1F, 0x78, 0x0F, 0x8F, 0x03, 0xC3, 0xE0, 0x70, 0x70, 0x08,
  0x08, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x3E, 0x7C, 0xF9, 0xF3,
  0xE7, 0xCF, 0x9F, 0x7C, 0xFB, 0xE7, 0xC3, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x18, 0x7E, 0xFE, 0xFF, 0xFE, 0x7E, 0x3C, 0x01, 0xF0,
  0x1F, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x07, 0xC0,
  0x7C, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x01, 0xF0, 0x1F, 0x01,
  0xE0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x7C, 0x07,
  0x80, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0x07, 0xE0, 0x0F, 0xFC, 0x0F,
  0xFF, 0x07, 0xFF, 0xC7, 0xFF, 0xE3, 0xF3, 0xFB, 0xF8, 0xFD, 0xF8, 0x7E,
  0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE1,
  0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF,
  0x87, 0xFF, 0xC3, 0xF7, 0xF1, 0xF9, 0xF9, 0xFC, 0xFF, 0xFC, 0x3F, 0xFE,
  0x1F, 0xFE, 0x07, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0x30, 0x1F, 0x07, 0xF3,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xF0, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x7F, 0x03, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xFF,
  0x9F, 0xCF, 0xE7, 0xE1, 0xFB, 0xF8, 0x7E, 0xFE, 0x1F, 0xBF, 0x87, 0xE0,
  0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xF0, 0x03, 0xF8, 0x01, 0xFF, 0xFF, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7,
  0xFF, 0xFD, 0xFF, 0xFF, 0x03, 0xF0, 0x03, 0xFF, 0x03, 0xFF, 0xF0, 0xFF,
  0xFC, 0x7F, 0xFF, 0x9F, 0xCF, 0xEF, 0xE1, 0xFB, 0xF8, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x03, 0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x00,
  0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0xFC, 0x1F, 0xFF, 0x87, 0xFF, 0xF3, 0xF9, 0xFF, 0xFE, 0x7F, 0xFF,
  0x0F, 0xFF, 0xC1, 0xFF, 0xC0, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x0F,
  0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x3D, 0xFC, 0x1F, 0x7F,
  0x07, 0xDF, 0xC3, 0xE7, 0xF0, 0xF9, 0xFC, 0x7E, 0x7F, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xDF, 0xFF, 0xF0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x3F, 0xFF,
  0x8F, 0xFF, 0xE3, 0xFF, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF, 0x8F, 0xC0, 0x03,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xBE, 0x07, 0xFF, 0xE1, 0xFF,
  0xFC, 0x7F, 0xFF, 0x1F, 0xFF, 0xE0, 0xC3, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0xFE, 0x1F, 0xBF, 0x87, 0xE7,
  0xF3, 0xF9, 0xFF, 0xFE, 0x3F, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x0F,
  0xC0, 0x00, 0x78, 0x00, 0xFC, 0x01, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x81,
  0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0x7C, 0x3F, 0x7F,
  0x1F, 0xFF, 0xCF, 0xFF, 0xF7, 0xFF, 0xFB, 0xF9, 0xFF, 0xF8, 0x7F, 0xFC,
  0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xF1, 0xFD,
  0xF9, 0xFE, 0xFF, 0xFE, 0x3F, 0xFE, 0x0F, 0xFF, 0x03, 0xFE, 0x00, 0x7E,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xF0,
  0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x0F, 0xFC, 0x0F, 0xFF, 0x8F, 0xFF,
  0xC7, 0xFF, 0xF7, 0xF3, 0xFB, 0xF8, 0xFD, 0xFC, 0x7E, 0xFE, 0x3F, 0x7F,
  0x1F, 0x9F, 0x9F, 0xCF, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xF0,
  0xFF, 0xFC, 0xFE, 0x7F, 0x7E, 0x1F, 0xBF, 0x0F, 0xFF, 0x87, 0xFF, 0xC3,
  0xFF, 0xE1, 0xFF, 0xF9, 0xFD, 0xFF, 0xFE, 0x7F, 0xFF, 0x1F, 0xFF, 0x07,
  0xFF, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x07, 0xFC, 0x0F, 0xFF, 0x07, 0xFF,
  0xC7, 0xFF, 0xE7, 0xF3, 0xFB, 0xF8, 0xFD, 0xF8, 0x7E, 0xFC, 0x3F, 0xFE,
  0x1F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0x3F, 0xFF, 0x1F, 0xFF, 0x83, 0xEF, 0xC0, 0x0F, 0xE0, 0x07,
  0xE0, 0x07, 0xF0, 0x1F, 0xF0, 0x3F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF0, 0x07,
  0xF0, 0x03, 0xE0, 0x00, 0x18, 0x7E, 0x7E, 0xFF, 0xFF, 0x7E, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x7E, 0x7E, 0xFF,
  0xFF, 0x7E, 0x3C, 0x08, 0x3F, 0x7F, 0x7F, 0x7F, 0x3F, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x3F, 0x3F,
  0x3F, 0x3F, 0x3F, 0x3E, 0x3E, 0x3E, 0x7C, 0x7C, 0x78, 0x10, 0x00, 0x02,
  0x00, 0x1C, 0x00, 0xF8, 0x07, 0xF0, 0x3F, 0xE1, 0xFF, 0xCF, 0xFF, 0x7F,
  0xF8, 0xFF, 0xC1, 0xFC, 0x03, 0xF8, 0x07, 0xFE, 0x0F, 0xFF, 0x07, 0xFF,
  0x83, 0xFF, 0x81, 0xFF, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x38, 0x00, 0x10,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x01, 0xC0, 0x03, 0xE0, 0x07, 0xF0, 0x0F, 0xF8, 0x1F,
  0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFE, 0x01, 0xFC, 0x07, 0xF8, 0x3F,
  0xF1, 0xFF, 0xEF, 0xFF, 0x3F, 0xF8, 0x7F, 0xC0, 0xFE, 0x01, 0xF0, 0x03,
  0x80, 0x04, 0x00, 0x00, 0x07, 0xE0, 0x1F, 0xF8, 0x7F, 0xFC, 0x7F, 0xFE,
  0xFF, 0xFE, 0xFE, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x07, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x3F,
  0xC7, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0xF8, 0x00, 0x7C, 0x0F, 0x00, 0x03,
  0xC1, 0xF0, 0x00, 0x1E, 0x1E, 0x07, 0xC1, 0xE3, 0xC0, 0xFF, 0x1E, 0x3C,
  0x1F, 0xF8, 0xF7, 0xC3, 0xFF, 0x8F, 0x78, 0x7C, 0xF8, 0xF7, 0x87, 0x8F,
  0x8F, 0x78, 0xF8, 0xF8, 0xF7, 0x8F, 0x8F, 0x0F, 0xF8, 0xF0, 0xF0, 0xFF,
  0x0F, 0x0F, 0x0F, 0xF1, 0xF0, 0xF0, 0xFF, 0x1F, 0x0F, 0x0F, 0xF1, 0xF0,
  0xF0, 0xFF, 0x1F, 0x0F, 0x0E, 0xF0, 0xF1, 0xF1, 0xEF, 0x8F, 0x9F, 0x1E,
  0x78, 0xFF, 0xFB, 0xC7, 0x8F, 0xFF, 0xFC, 0x78, 0x7F, 0x7F, 0x87, 0xC3,
  0xC3, 0xE0, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x30, 0x00, 0x7F, 0xFF, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x03, 0xFF,
  0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xF7, 0xE0, 0x07, 0xE7, 0xE0, 0x07, 0xE7,
  0xE0, 0x07, 0xE7, 0xE0, 0x0F, 0xE3, 0xF0, 0x0F, 0xC3, 0xF0, 0x0F, 0xC3,
  0xF0, 0x1F, 0xC3, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0x00, 0xFE, 0x7F, 0x00,
  0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFC, 0x7F,
  0xBF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFB, 0xF8, 0x7F,
  0x7F, 0x3F, 0xEF, 0xFF, 0xF9, 0xFF, 0xFC, 0x3F, 0xFF, 0xE7, 0xFF, 0xFE,
  0xFE, 0x1F, 0xDF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF,
  0xFC, 0x1F, 0xFF, 0x87, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xF3,
  0xFF, 0xFC, 0x7F, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xFC, 0x03, 0xFF,
  0xF0, 0x3F, 0xFF, 0xC3, 0xFF, 0xFF, 0x1F, 0xEF, 0xF9, 0xFC, 0x0F, 0xCF,
  0xE0, 0x7F, 0x7F, 0x03, 0xFB, 0xF0, 0x1F, 0xFF, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0xFE, 0xFC, 0x07, 0xF7, 0xF0, 0x3F,
  0xBF, 0x83, 0xF8, 0xFF, 0x7F, 0xC7, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0x7F,
  0xFE, 0x01, 0xFF, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x83,
  0xFF, 0xF8, 0x7F, 0xFF, 0x8F, 0xFF, 0xF9, 0xFC, 0xFF, 0xBF, 0x87, 0xF7,
  0xF0, 0x7E, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF,
  0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF,
  0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE1, 0xFD, 0xFC, 0x3F, 0xBF,
  0x9F, 0xF7, 0xFF, 0xFC, 0xFF, 0xFF, 0x1F, 0xFF, 0xC3, 0xFF, 0xF0, 0x7F,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0xF3, 0xFF, 0xF9, 0xFF, 0xFC,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0xFF, 0xE7, 0xF9,
  0xFE, 0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF,
  0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x7F,
  0xFE, 0x07, 0xFF, 0xF0, 0x7F, 0x7F, 0x8F, 0xF7, 0xFF, 0xFF, 0x3F, 0xFF,
  0xF1, 0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0x3F, 0xC0, 0xFE, 0x03, 0xFF, 0xE0,
  0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE,
  0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03,
  0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0,
  0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xFF,
  0xC7, 0xFF, 0xE3, 0xFF, 0xF1, 0xFF, 0xFD, 0xFC, 0xFF, 0xFE, 0x7F, 0xFE,
  0x1F, 0xFE, 0x07, 0xFE, 0x00, 0xFC, 0x00, 0xFE, 0x0F, 0xF7, 0xF0, 0x7F,
  0xBF, 0x87, 0xF9, 0xFC, 0x3F, 0xCF, 0xE3, 0xFC, 0x7F, 0x1F, 0xC3, 0xF9,
  0xFE, 0x1F, 0xCF, 0xE0, 0xFE, 0xFE, 0x07, 0xF7, 0xF0, 0x3F, 0xFF, 0x01,
  0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF,
  0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0xDF, 0xC1, 0xFE, 0xFF, 0x0F,
  0xE3, 0xF8, 0x7F, 0x1F, 0xC3, 0xF8, 0xFF, 0x1F, 0xC3, 0xF8, 0xFE, 0x1F,
  0xE7, 0xF0, 0x7F, 0x3F, 0x83, 0xFD, 0xFC, 0x1F, 0xE0, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFD, 0xF1, 0xFF, 0xFF,
  0x7C, 0x7B, 0xFF, 0xDF, 0x3E, 0xFF, 0xF3, 0xCF, 0xBF, 0xFC, 0xF3, 0xEF,
  0xFF, 0x3E, 0xF3, 0xFF, 0xCF, 0xFC, 0xFF, 0xF9, 0xFF, 0x3F, 0xFE, 0x7F,
  0x8F, 0xFF, 0x9F, 0xE3, 0xFF, 0xE7, 0xF8, 0xFF, 0xF8, 0xFE, 0x3F, 0xFE,
  0x3F, 0x0F, 0xFF, 0x8F, 0xC3, 0xFF, 0xE1, 0xF0, 0xFF, 0xF8, 0x7C, 0x3F,
  0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x03,
  0xFF, 0xF8, 0x3F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE,
  0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xF3, 0xFF, 0xEF, 0x3F, 0xFE,
  0xFB, 0xFF, 0xE7, 0xBF, 0xFE, 0x7B, 0xFF, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF,
  0xE3, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0xFF,
  0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0x00, 0xFE,
  0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0,
  0xFF, 0x3F, 0xC7, 0xF0, 0x3F, 0x9F, 0xC0, 0xFE, 0x7F, 0x03, 0xF9, 0xF8,
  0x07, 0xE7, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFD, 0xF8, 0x07, 0xF7,
  0xE0, 0x1F, 0x9F, 0xC0, 0xFE, 0x7F, 0x03, 0xF9, 0xFC, 0x0F, 0xE3, 0xFC,
  0xFF, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0x80, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0xFE, 0x7F, 0xFF,
  0xEF, 0xFF, 0xFD, 0xFC, 0x3F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x07,
  0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x07, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xF7, 0xFF, 0xFC, 0xFF, 0xFF, 0x1F, 0xFF, 0x83, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x87, 0xFF, 0xFE, 0x3F,
  0xEF, 0xF3, 0xFC, 0x1F, 0xDF, 0xC0, 0xFE, 0xFE, 0x03, 0xF7, 0xE0, 0x1F,
  0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0,
  0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF,
  0xFC, 0x07, 0xEF, 0xE0, 0x7F, 0x7F, 0x83, 0xF9, 0xFE, 0x7F, 0x8F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xC0, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x38, 0x00, 0x00,
  0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xCF, 0xE3, 0xFE, 0xFE, 0x0F, 0xEF, 0xE0, 0xFE, 0xFE, 0x0F, 0xEF,
  0xE0, 0xFE, 0xFE, 0x0F, 0xEF, 0xE0, 0xFE, 0xFE, 0x3F, 0xCF, 0xFF, 0xFC,
  0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFE, 0x7F,
  0x0F, 0xE7, 0xF0, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0xCF, 0xE1,
  0xFC, 0xFE, 0x1F, 0xCF, 0xE0, 0xFE, 0xFE, 0x0F, 0xEF, 0xE0, 0xFF, 0x01,
  0xFC, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xE7,
  0xF8, 0xFE, 0x7F, 0x0F, 0xE7, 0xF0, 0x7F, 0x7F, 0x07, 0xF7, 0xF0, 0x00,
  0x3F, 0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0x80, 0x1F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFE, 0xFE, 0x0F, 0xEF, 0xE0,
  0x7E, 0x7E, 0x07, 0xF7, 0xF0, 0x7E, 0x7F, 0x8F, 0xE3, 0xFF, 0xFE, 0x3F,
  0xFF, 0xC1, 0xFF, 0xFC, 0x07, 0xFF, 0x00, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF,
  0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF,
  0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF,
  0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF,
  0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF,
  0xC7, 0xFB, 0xFF, 0xFE, 0x7F, 0xFF, 0xC7, 0xFF, 0xF0, 0x7F, 0xFC, 0x01,
  0xFC, 0x00, 0xFF, 0x00, 0xFE, 0xFE, 0x03, 0xFD, 0xFC, 0x07, 0xFB, 0xF8,
  0x0F, 0xE7, 0xF8, 0x1F, 0xC7, 0xF0, 0x3F, 0x8F, 0xE0, 0xFE, 0x1F, 0xC1,
  0xFC, 0x1F, 0x83, 0xF8, 0x3F, 0x87, 0xF0, 0x7F, 0x0F, 0xC0, 0xFE, 0x3F,
  0x80, 0xFC, 0x7F, 0x01, 0xF8, 0xFC, 0x03, 0xF9, 0xF8, 0x03, 0xF3, 0xF0,
  0x07, 0xEF, 0xE0, 0x0F, 0xDF, 0x80, 0x1F, 0xBF, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0xFC,
  0x1F, 0x87, 0xFF, 0xC1, 0xF8, 0x7F, 0xFE, 0x1F, 0x87, 0xFF, 0xE3, 0xF8,
  0x7E, 0xFE, 0x3F, 0x87, 0xE7, 0xE3, 0xFC, 0x7E, 0x7E, 0x3F, 0xCF, 0xE7,
  0xE3, 0xFC, 0xFE, 0x7F, 0x7F, 0xCF, 0xE7, 0xF7, 0xFC, 0xFC, 0x7F, 0x7F,
  0xEF, 0xC3, 0xF7, 0xFE, 0xFC, 0x3F, 0x7F, 0xEF, 0xC3, 0xF7, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x81, 0xFF,
  0xBF, 0xF8, 0x1F, 0xFB, 0xFF, 0x81, 0xFF, 0x9F, 0xF8, 0x1F, 0xF9, 0xFF,
  0x81, 0xFF, 0x9F, 0xF0, 0x1F, 0xF1, 0xFF, 0x00, 0xFF, 0x1F, 0xF0, 0x0F,
  0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0xFE, 0x00, 0xFE, 0x0F,
  0xE0, 0x7F, 0x03, 0xFD, 0xFE, 0x0F, 0xE3, 0xF8, 0x3F, 0x8F, 0xE1, 0xFC,
  0x1F, 0xC7, 0xF0, 0x7F, 0x1F, 0xC1, 0xFC, 0xFE, 0x03, 0xFB, 0xF8, 0x0F,
  0xEF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80,
  0x1F, 0xFE, 0x00, 0x7F, 0xFC, 0x03, 0xFB, 0xF0, 0x0F, 0xEF, 0xE0, 0x7F,
  0x3F, 0x81, 0xFC, 0x7F, 0x0F, 0xF1, 0xFC, 0x3F, 0x87, 0xF9, 0xFE, 0x0F,
  0xE7, 0xF8, 0x3F, 0xDF, 0xC0, 0xFF, 0xFF, 0x01, 0xFD, 0xFC, 0x0F, 0xE7,
  0xF0, 0x3F, 0x8F, 0xC0, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC1, 0xF8,
  0x7E, 0x07, 0xF3, 0xF8, 0x0F, 0xCF, 0xC0, 0x3F, 0x3F, 0x00, 0x7E, 0xFC,
  0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F,
  0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC,
  0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC,
  0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0xFE, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x80,
  0x3F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF8,
  0x03, 0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F,
  0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F,
  0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x7F,
  0x83, 0xFF, 0x0F, 0x3C, 0x3C, 0xF1, 0xF3, 0xE7, 0xC7, 0x9E, 0x1E, 0xF8,
  0x7F, 0xE1, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7E, 0x0F, 0xE0, 0xFE, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x07, 0xF0,
  0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xF3, 0xF3, 0xFB, 0xF8,
  0xFC, 0x00, 0x7E, 0x07, 0xFF, 0x0F, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xEF,
  0xE3, 0xF7, 0xF1, 0xFB, 0xF0, 0xFD, 0xFC, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF,
  0x9F, 0xFF, 0xC7, 0xF7, 0xE0, 0xF3, 0xF8, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x7C, 0x3F, 0xFF, 0x1F, 0xFF, 0xCF, 0xFF, 0xF7, 0xFF,
  0xFB, 0xF8, 0xFD, 0xF8, 0x7F, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF,
  0x87, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0xFE, 0x3F,
  0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xCF, 0xFF, 0xC7, 0xE7, 0xC0, 0x07,
  0xF0, 0x1F, 0xFC, 0x3F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFF, 0x7E, 0x3F, 0xFE,
  0x3F, 0xFE, 0x3F, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x3F, 0xFE, 0x3F, 0x7E, 0x3F, 0x7F, 0xFF, 0x7F, 0xFE, 0x3F,
  0xFE, 0x1F, 0xFC, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x87, 0xCF, 0xC7, 0xF7, 0xE7, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFC, 0x3F, 0xFE, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF,
  0xC1, 0xFF, 0xE0, 0xFF, 0xF8, 0x7F, 0xFC, 0x3F, 0xFE, 0x3F, 0xBF, 0xFF,
  0xDF, 0xFF, 0xE7, 0xFF, 0xF1, 0xFD, 0xF8, 0x7C, 0xFC, 0x03, 0xF0, 0x07,
  0xFE, 0x0F, 0xFF, 0x87, 0xFF, 0xE7, 0xFF, 0xFB, 0xF8, 0xFD, 0xF8, 0x7F,
  0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xF0, 0x01, 0xF8, 0x08, 0xFE, 0x1C, 0x7F, 0xFF, 0x1F, 0xFF, 0xC7,
  0xFF, 0xE1, 0xFF, 0xC0, 0x3F, 0x80, 0x01, 0xF8, 0x3F, 0xC3, 0xFE, 0x1F,
  0xF1, 0xFF, 0x8F, 0xE0, 0x7F, 0x03, 0xF0, 0x1F, 0x87, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xCF, 0xC7, 0xFB, 0xF3,
  0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xDF, 0xC7, 0xFF, 0xE1, 0xFF, 0xF8,
  0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F,
  0xFF, 0x87, 0xFF, 0xE1, 0xFD, 0xFC, 0x7F, 0x7F, 0xFF, 0xDF, 0xFF, 0xF3,
  0xFF, 0xFC, 0x7F, 0xFF, 0x07, 0xDF, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x20,
  0xFE, 0x1F, 0xFF, 0x8F, 0xFF, 0xC3, 0xFF, 0xE0, 0x7F, 0xF0, 0x07, 0xF0,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0xF8, 0xFD, 0xFC, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0x7F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0x7D, 0xFB, 0xFF, 0xFF, 0xCF, 0x00, 0x00, 0xFD, 0xFB, 0xF7, 0xEF,
  0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB,
  0xF7, 0xEF, 0xC0, 0x0F, 0x87, 0xE1, 0xFC, 0x7F, 0x1F, 0x83, 0xC0, 0x00,
  0x00, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F,
  0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1,
  0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0xFE, 0xFF, 0xBF, 0xEF, 0xF3, 0xF8,
  0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x0F,
  0xEF, 0xC7, 0xF3, 0xF3, 0xFC, 0xFC, 0xFE, 0x3F, 0x7F, 0x0F, 0xDF, 0xC3,
  0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0xFF,
  0xF8, 0x3F, 0xFF, 0x0F, 0xFF, 0xC3, 0xFB, 0xF8, 0xFC, 0xFE, 0x3F, 0x1F,
  0xCF, 0xC7, 0xF3, 0xF0, 0xFE, 0xFC, 0x3F, 0xBF, 0x0F, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0xF8, 0x3E,
  0x3F, 0x7F, 0x3F, 0xCF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xBF, 0x9F, 0xE7, 0xFF, 0xC7, 0xF1, 0xFF, 0xF0, 0xFC, 0x7F, 0xFC,
  0x3F, 0x1F, 0xFF, 0x0F, 0xC7, 0xFF, 0xC3, 0xF1, 0xFF, 0xF0, 0xFC, 0x7F,
  0xFC, 0x3F, 0x1F, 0xFF, 0x0F, 0xC7, 0xFF, 0xC3, 0xF1, 0xFF, 0xF0, 0xFC,
  0x7F, 0xFC, 0x3F, 0x1F, 0xFF, 0x0F, 0xC7, 0xFF, 0xC3, 0xF1, 0xFF, 0xF0,
  0xFC, 0x7F, 0xFC, 0x3F, 0x1F, 0xC0, 0xFC, 0xF8, 0xFD, 0xFC, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0x03, 0xF0, 0x03, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x7F, 0xFF, 0x9F,
  0xCF, 0xEF, 0xE1, 0xFB, 0xF8, 0x7E, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1,
  0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xEF, 0xE1, 0xF9, 0xFC, 0xFE,
  0x7F, 0xFF, 0x8F, 0xFF, 0xC3, 0xFF, 0xE0, 0x7F, 0xF0, 0x03, 0xF0, 0x00,
  0xFC, 0xF8, 0x7F, 0xFE, 0x3F, 0xFF, 0x9F, 0xFF, 0xEF, 0xFF, 0xF7, 0xF3,
  0xFB, 0xF0, 0xFF, 0xF8, 0x7F, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF,
  0x87, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0xFC, 0x7E, 0xFF, 0xFF,
  0x7F, 0xFF, 0xBF, 0xFF, 0x9F, 0xFF, 0x8F, 0xCF, 0x87, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x00, 0x0F, 0x9F, 0x8F, 0xEF, 0xCF, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xF1, 0xFF, 0xF8, 0x7F, 0xFC, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF,
  0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0xFC, 0x7F,
  0x7F, 0xFF, 0xBF, 0xFF, 0xCF, 0xFF, 0xE3, 0xFB, 0xF0, 0xF9, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0xFC, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC7, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0x1F,
  0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0x7E, 0x7F, 0xFC, 0x7F, 0xFE, 0x3F, 0xFF,
  0x00, 0x7F, 0x80, 0x7F, 0xF0, 0x3F, 0xFC, 0x0F, 0xFE, 0x03, 0xFE, 0x00,
  0xFF, 0xFC, 0x7F, 0xFC, 0x3F, 0xFE, 0x7F, 0x7F, 0xFE, 0x3F, 0xFE, 0x1F,
  0xF8, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF1, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7F, 0xCF, 0xF9, 0xFF,
  0x1F, 0xE0, 0xFC, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFE, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0x3F, 0xBF, 0x1F, 0x3F, 0xFE, 0x1F, 0xDF,
  0x87, 0xF7, 0xF1, 0xF9, 0xFC, 0x7E, 0x3F, 0x3F, 0x8F, 0xCF, 0xE3, 0xF3,
  0xF0, 0xFC, 0xFC, 0x1F, 0xBF, 0x07, 0xEF, 0xC1, 0xFF, 0xE0, 0x7F, 0xF8,
  0x0F, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFC, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x7C, 0x7F,
  0xF8, 0xF8, 0xFF, 0xF1, 0xF1, 0xFF, 0xE7, 0xE3, 0xFF, 0xCF, 0xE7, 0xEF,
  0x9F, 0xCF, 0x9F, 0x3F, 0xBF, 0x3F, 0x7F, 0x7E, 0x7F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF8, 0xFF, 0xBF, 0xE1, 0xFF, 0x7F, 0xC3, 0xFE, 0xFF, 0x87, 0xFD,
  0xFF, 0x0F, 0xF1, 0xFE, 0x0F, 0xE3, 0xF8, 0x1F, 0xC7, 0xF0, 0x3F, 0x8F,
  0xE0, 0x7F, 0x1F, 0xC0, 0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x00, 0x7F, 0x1F,
  0xDF, 0xC7, 0xE3, 0xF3, 0xF8, 0xFE, 0xFC, 0x1F, 0xBF, 0x07, 0xFF, 0xC1,
  0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F,
  0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x7E, 0xFC, 0x3F, 0xBF,
  0x0F, 0xCF, 0xE3, 0xF1, 0xF9, 0xFC, 0x7E, 0x7E, 0x1F, 0xC0, 0xFE, 0x1F,
  0xDF, 0x87, 0xF7, 0xF1, 0xFD, 0xFC, 0x7E, 0x7F, 0x3F, 0x8F, 0xCF, 0xE3,
  0xF3, 0xF0, 0xFE, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F,
  0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x07, 0xF8,
  0x01, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7E,
  0x00, 0x1F, 0x00, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF,
  0x7F, 0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x07, 0xF0,
  0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x81,
  0xE0, 0xF8, 0x3E, 0x1F, 0x87, 0xC1, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xF8, 0xFE, 0x3F, 0x0F, 0x83, 0xF0, 0xFE,
  0x1F, 0x83, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0x7C, 0x1F, 0x07, 0xE0, 0xF8, 0x3E, 0x07, 0x80, 0x60, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x60, 0x1C, 0x07, 0x83, 0xF0, 0x7E, 0x0F, 0x83, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xF0, 0xFC, 0x1F,
  0xC7, 0xF0, 0x7C, 0x3F, 0x1F, 0xC7, 0xC3, 0xF0, 0xFC, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x1F, 0x8F, 0xC1, 0xE0,
  0x70, 0x18, 0x00, 0x1E, 0x00, 0x0F, 0xE1, 0xF7, 0xFC, 0x7F, 0xFF, 0x9F,
  0xFF, 0xFF, 0xBE, 0x7F, 0xEF, 0x0F, 0xFB, 0xC1, 0xFC, 0x00, 0x3C, 0x00,
};

const GFXglyph RobotoCondensed_Black40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 7, 28, 11, 2, -28 },
  { 26, 11, 11, 13, 1, -30 },
  { 42, 18, 28, 21, 1, -28 },
  { 105, 17, 36, 20, 2, -32 },
  { 182, 22, 28, 26, 2, -28 },
  { 259, 22, 28, 24, 1, -28 },
  { 336, 5, 11, 6, 1, -30 },
  { 343, 10, 40, 13, 2, -31 },
  { 393, 10, 40, 13, 1, -31 },
  { 443, 18, 17, 19, 1, -28 },
  { 482, 16, 21, 19, 1, -23 },
  { 524, 7, 13, 11, 1, -5 },
  { 536, 10, 5, 17, 3, -15 },
  { 543, 8, 7, 12, 2, -7 },
  { 550, 12, 30, 12, 0, -28 },
  { 595, 17, 28, 20, 2, -28 },
  { 655, 12, 28, 20, 3, -28 },
  { 697, 18, 28, 20, 1, -28 },
  { 760, 18, 28, 20, 1, -28 },
  { 823, 18, 28, 20, 1, -28 },
  { 886, 18, 28, 20, 1, -28 },
  { 949, 17, 28, 20, 2, -28 },
  { 1009, 18, 28, 20, 1, -28 },
  { 1072, 17, 28, 20, 2, -28 },
  { 1132, 17, 28, 20, 2, -28 },
  { 1192, 8, 23, 12, 2, -23 },
  { 1215, 8, 31, 11, 1, -23 },
  { 1246, 15, 20, 18, 1, -22 },
  { 1284, 16, 13, 21, 2, -19 },
  { 1310, 15, 20, 18, 2, -22 },
  { 1348, 16, 28, 18, 1, -28 },
  { 1404, 28, 37, 31, 1, -28 },
  { 1534, 24, 28, 24, 0, -28 },
  { 1618, 19, 28, 23, 2, -28 },
  { 1685, 21, 28, 23, 1, -28 },
  { 1759, 19, 28, 22, 2, -28 },
  { 1826, 17, 28, 20, 2, -28 },
  { 1886, 16, 28, 19, 2, -28 },
  { 1942, 20, 28, 24, 2, -28 },
  { 2012, 20, 28, 24, 2, -28 },
  { 2082, 7, 28, 11, 2, -28 },
  { 2107, 17, 28, 20, 1, -28 },
  { 2167, 21, 28, 22, 2, -28 },
  { 2241, 16, 28, 19, 2, -28 },
  { 2297, 26, 28, 30, 2, -28 },
  { 2388, 20, 28, 24, 2, -28 },
  { 2458, 22, 28, 24, 1, -28 },
  { 2535, 19, 28, 23, 2, -28 },
  { 2602, 21, 33, 24, 2, -28 },
  { 2689, 20, 28, 23, 2, -28 },
  { 2759, 20, 28, 22, 1, -28 },
  { 2829, 20, 28, 22, 1, -28 },
  { 2899, 19, 28, 23, 2, -28 },
  { 2966, 23, 28, 23, 0, -28 },
  { 3047, 28, 28, 30, 1, -28 },
  { 3145, 22, 28, 23, 0, -28 },
  { 3222, 22, 28, 22, 0, -28 },
  { 3299, 19, 28, 21, 1, -28 },
  { 3366, 8, 40, 11, 2, -33 },
  { 3406, 16, 30, 15, 0, -28 },
  { 3466, 8, 40, 11, 1, -33 },
  { 3506, 14, 14, 16, 1, -28 },
  { 3531, 15, 5, 16, 0, 0 },
  { 3541, 11, 6, 14, 1, -30 },
  { 3550, 17, 21, 19, 1, -21 },
  { 3595, 17, 30, 20, 2, -30 },
  { 3659, 16, 21, 18, 1, -21 },
  { 3701, 17, 30, 20, 1, -30 },
  { 3765, 17, 21, 19, 1, -21 },
  { 3810, 13, 30, 13, 0, -30 },
  { 3859, 18, 29, 20, 1, -21 },
  { 3925, 16, 30, 20, 2, -30 },
  { 3985, 7, 29, 10, 2, -29 },
  { 4011, 10, 37, 10, -1, -29 },
  { 4058, 18, 30, 20, 2, -30 },
  { 4126, 6, 30, 10, 2, -30 },
  { 4149, 26, 21, 30, 2, -21 },
  { 4218, 16, 21, 20, 2, -21 },
  { 4260, 18, 21, 20, 1, -21 },
  { 4308, 17, 29, 20, 2, -21 },
  { 4370, 17, 29, 20, 1, -21 },
  { 4432, 11, 21, 14, 2, -21 },
  { 4461, 16, 21, 18, 1, -21 },
  { 4503, 11, 26, 13, 1, -26 },
  { 4539, 16, 21, 20, 2, -21 },
  { 4581, 18, 21, 18, 0, -21 },
  { 4629, 23, 21, 25, 1, -21 },
  { 4690, 18, 21, 18, 0, -21 },
  { 4738, 18, 29, 18, 0, -21 },
  { 4804, 16, 21, 18, 1, -21 },
  { 4846, 10, 38, 12, 1, -31 },
  { 4894, 4, 33, 10, 3, -28 },
  { 4911, 10, 38, 12, 1, -31 },
  { 4959, 18, 9, 22, 2, -16 },
};

const GFXfont RobotoCondensed_Black40pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Black40pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Black40pt7bGlyphs,
  0x20, 0x7E, 47
};

#endif // _ROBOTOCONDENSED_BLACK40PT7B_H_
