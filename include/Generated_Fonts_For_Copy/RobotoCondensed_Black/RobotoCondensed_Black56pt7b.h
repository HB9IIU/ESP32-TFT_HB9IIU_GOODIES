#ifndef _ROBOTOCONDENSED_BLACK56PT7B_H_
#define _ROBOTOCONDENSED_BLACK56PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Black.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Black56pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xEF, 0xFB, 0xFE, 0xFF, 0xBF, 0xEF, 0xFB, 0xFE, 0xFF,
  0xBF, 0xEF, 0xFB, 0xFE, 0xFF, 0xBF, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7,
  0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x1F, 0xC7, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x3F, 0xEF, 0xFB, 0xFE, 0xFF, 0xBF,
  0xEF, 0xF9, 0xFC, 0x08, 0x00, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC,
  0x7F, 0xFC, 0x7F, 0xFC, 0x7E, 0xFC, 0x7E, 0xFC, 0x7E, 0xFC, 0x7E, 0xF8,
  0x7E, 0xF8, 0x7E, 0xF8, 0x7E, 0xF8, 0x7E, 0xF8, 0x7E, 0xF8, 0x7E, 0xF8,
  0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x1F, 0x00, 0x07, 0xC7, 0xC0, 0x03,
  0xF3, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x8F, 0x80,
  0x03, 0xE3, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x9F,
  0x80, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x01, 0xF1, 0xF0, 0x00, 0x7C, 0x7C, 0x00,
  0x3F, 0x3F, 0x00, 0x0F, 0x8F, 0xC0, 0x03, 0xE3, 0xE0, 0x00, 0xF8, 0xF8,
  0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x8F, 0x80, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x01,
  0xF1, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x1F, 0x00, 0x07, 0xC7, 0xC0,
  0x03, 0xF3, 0xF0, 0x00, 0xF8, 0xFC, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x8F,
  0x80, 0x03, 0xE3, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0xC0, 0x03,
  0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x3F, 0xE3, 0xFF, 0x3F, 0xE1, 0xFF, 0x3F,
  0xE1, 0xFF, 0x3F, 0xE1, 0xFF, 0x3F, 0xE1, 0xFF, 0x3F, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00,
  0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0x81, 0xFF, 0x7F, 0xC1, 0xFF, 0x7F, 0xC1, 0xFF, 0x7F, 0xE1, 0xFF, 0x7F,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80,
  0xC0, 0x3F, 0x1F, 0x83, 0xE0, 0x7C, 0x3F, 0x07, 0xC0, 0xF8, 0x7E, 0x1F,
  0x01, 0xF0, 0xFC, 0x7E, 0x03, 0xE1, 0xF8, 0xF8, 0x07, 0xC3, 0xF3, 0xF0,
  0x0F, 0x87, 0xE7, 0xC0, 0x1F, 0x8F, 0xDF, 0x80, 0x3F, 0xFF, 0x3E, 0x00,
  0x7F, 0xFE, 0xFC, 0x00, 0x7F, 0xF9, 0xF0, 0x00, 0x7F, 0xF7, 0xE0, 0x00,
  0x7F, 0x8F, 0x80, 0x00, 0x08, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x8F, 0xF0, 0x00,
  0x1F, 0x7F, 0xF0, 0x00, 0x7C, 0xFF, 0xF0, 0x00, 0xFB, 0xFF, 0xF0, 0x03,
  0xE7, 0xFF, 0xE0, 0x07, 0xDF, 0x8F, 0xC0, 0x1F, 0x3F, 0x0F, 0x80, 0x7E,
  0x7E, 0x1F, 0x00, 0xF8, 0xFC, 0x3F, 0x03, 0xF1, 0xF8, 0x7E, 0x07, 0xC3,
  0xF0, 0xF8, 0x1F, 0x87, 0xE1, 0xF0, 0x3E, 0x0F, 0xC3, 0xE0, 0x3C, 0x0F,
  0xFF, 0xC0, 0x10, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFE, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x7F, 0x0F, 0xF0, 0x01, 0xFC,
  0x3F, 0xC0, 0x07, 0xF0, 0xFF, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0x8F,
  0xE0, 0x01, 0xFE, 0x7F, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x3F, 0xC1, 0xFF, 0xF8, 0xFF, 0x0F,
  0xFF, 0xF3, 0xFC, 0x7F, 0xFF, 0xCF, 0xF1, 0xFF, 0xFF, 0xBF, 0xCF, 0xFB,
  0xFF, 0xFF, 0x3F, 0xEF, 0xFF, 0xF8, 0xFF, 0x9F, 0xFF, 0xE3, 0xFE, 0x3F,
  0xFF, 0x8F, 0xF8, 0x7F, 0xFC, 0x3F, 0xE1, 0xFF, 0xF0, 0xFF, 0x83, 0xFF,
  0xC3, 0xFF, 0x07, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xF7, 0xFE, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0xC0, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF,
  0x7E, 0x00, 0x10, 0x00, 0xE0, 0x07, 0x80, 0x3E, 0x01, 0xFC, 0x0F, 0xE0,
  0x7F, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x80,
  0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8,
  0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x3F,
  0x00, 0xFE, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0xFC, 0x03,
  0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xF8, 0x01, 0xE0,
  0x03, 0x80, 0x04, 0x20, 0x00, 0x70, 0x01, 0xF0, 0x03, 0xF0, 0x0F, 0xF0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x0E, 0x00, 0x10, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x01, 0x80, 0xF8, 0x08, 0xF8, 0x7C,
  0x1E, 0x7F, 0x3E, 0x7F, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x03, 0xF3, 0xF0, 0x03, 0xF8, 0xFC, 0x03,
  0xF8, 0x7F, 0x01, 0xF8, 0x1F, 0xC0, 0x7C, 0x07, 0xC0, 0x1C, 0x03, 0x80,
  0x00, 0x00, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xE1, 0xFC, 0x3F, 0x87,
  0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x1F, 0xC3, 0xF8, 0xFE, 0x1F, 0xC7,
  0xF0, 0x3C, 0x01, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0E, 0x0F, 0xE7, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFD, 0xFF, 0x3F, 0x81, 0x00, 0x00, 0x3F, 0x80, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0,
  0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xE0,
  0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFE, 0x3F, 0xE3, 0xFE, 0x7F, 0xC3, 0xFE, 0x7F, 0xC1, 0xFF,
  0x7F, 0xC1, 0xFF, 0x7F, 0x81, 0xFF, 0x7F, 0x81, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x81, 0xFF, 0x7F, 0x81, 0xFF, 0x7F, 0x81, 0xFF, 0x7F, 0xC1, 0xFF,
  0x7F, 0xC1, 0xFF, 0x7F, 0xC3, 0xFE, 0x3F, 0xE3, 0xFE, 0x3F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0,
  0x03, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x08, 0x00, 0x00, 0x03, 0x80,
  0x07, 0xC0, 0x1F, 0xE0, 0x3F, 0xF0, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0x1F, 0xFC, 0x0F,
  0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07,
  0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x08,
  0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xC3,
  0xFE, 0xFF, 0x83, 0xFE, 0xFF, 0x83, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x81, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x08, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFE, 0x7F, 0xE1, 0xFF, 0x3F, 0xE0, 0xFF, 0xDF, 0xF0, 0x3F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF,
  0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF,
  0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0x81, 0xFF, 0x7F, 0xC0, 0xFF, 0xBF, 0xF0, 0xFF, 0xDF,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00,
  0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x1F, 0xBF, 0xE0, 0x0F, 0xDF, 0xF0,
  0x0F, 0xEF, 0xF8, 0x07, 0xE7, 0xFC, 0x07, 0xF3, 0xFE, 0x03, 0xF9, 0xFF,
  0x03, 0xF8, 0xFF, 0x81, 0xFC, 0x7F, 0xC1, 0xFC, 0x3F, 0xE0, 0xFE, 0x1F,
  0xF0, 0xFF, 0x0F, 0xF8, 0x7F, 0x07, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFE, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x9F, 0x80, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x7F, 0xCF, 0xFE, 0x0F, 0x03, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC3, 0xFE, 0x7F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0,
  0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x10, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF,
  0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x1F, 0xFC,
  0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x03, 0xFE, 0x3E, 0x01, 0xFF, 0x7F, 0xC0, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xEF,
  0xFE, 0x3F, 0xF7, 0xFE, 0x0F, 0xFB, 0xFE, 0x07, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F,
  0xF7, 0xF8, 0x0F, 0xFB, 0xFE, 0x07, 0xFD, 0xFF, 0x07, 0xFE, 0xFF, 0x83,
  0xFE, 0x3F, 0xE3, 0xFF, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x00, 0x08, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x08, 0x00, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x7F, 0xE3, 0xFE, 0x7F, 0xC3, 0xFE,
  0x7F, 0xC3, 0xFE, 0x7F, 0xC3, 0xFF, 0x7F, 0xC3, 0xFE, 0x7F, 0xC3, 0xFE,
  0x7F, 0xC3, 0xFE, 0x3F, 0xE3, 0xFE, 0x3F, 0xE7, 0xFC, 0x1F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xE3, 0xFE, 0x7F, 0xC3, 0xFE,
  0x7F, 0xC1, 0xFF, 0x7F, 0xC1, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x81, 0xFF, 0x7F, 0xC1, 0xFF, 0x7F, 0xC1, 0xFF, 0x7F, 0xE3, 0xFF,
  0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x08, 0x00,
  0x00, 0x08, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC,
  0x7F, 0xE3, 0xFE, 0x7F, 0xC3, 0xFE, 0x7F, 0xC1, 0xFE, 0x7F, 0xC1, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xC1, 0xFF, 0x7F, 0xC1, 0xFF, 0x7F, 0xC1, 0xFF,
  0x7F, 0xE3, 0xFF, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x07, 0xFD, 0xFE, 0x01, 0xF9, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFC,
  0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0E, 0x07, 0xF1, 0xFF, 0x7F, 0xEF, 0xFD, 0xFF, 0x9F,
  0xF3, 0xFE, 0x3F, 0x80, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x81, 0xFC,
  0x7F, 0xCF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFC, 0xFF, 0x8F, 0xE0, 0x20, 0x07,
  0x03, 0xF8, 0xFF, 0xBF, 0xF7, 0xFE, 0xFF, 0xDF, 0xF9, 0xFE, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC3, 0xF8, 0x7F,
  0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0xFE, 0x1F,
  0xC7, 0xF8, 0xFE, 0x3F, 0xC7, 0xF0, 0x7C, 0x01, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x01, 0xC0, 0x00, 0x3E, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x80, 0x1F,
  0xFC, 0x07, 0xFF, 0xE0, 0xFF, 0xFF, 0x1F, 0xFF, 0xFB, 0xFF, 0xFE, 0x3F,
  0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x80,
  0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x80, 0x00, 0x0E, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x07, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xF0, 0xFF, 0xFC, 0x0F, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xE0,
  0x00, 0xF8, 0x00, 0x0E, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0xFF, 0xC7, 0xFD, 0xFF,
  0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xE0, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0xFC, 0x01, 0xFC, 0x0F, 0xC1, 0xF8, 0x0F, 0xFE,
  0x0F, 0x87, 0xE0, 0x3F, 0xFE, 0x1F, 0x8F, 0xC0, 0xFF, 0xFE, 0x1F, 0x1F,
  0x03, 0xFF, 0xFC, 0x3E, 0x7E, 0x07, 0xF3, 0xF0, 0x7C, 0xFC, 0x1F, 0xC7,
  0xE0, 0xF9, 0xF8, 0x3F, 0x0F, 0xC1, 0xFB, 0xE0, 0xFE, 0x1F, 0x83, 0xFF,
  0xC1, 0xF8, 0x3F, 0x07, 0xFF, 0x83, 0xF0, 0x7E, 0x0F, 0xFF, 0x0F, 0xE0,
  0xFC, 0x0F, 0xFE, 0x1F, 0xC1, 0xF8, 0x1F, 0xFC, 0x3F, 0x83, 0xF0, 0x7F,
  0xF8, 0x7F, 0x07, 0xE0, 0xFF, 0xF0, 0xFC, 0x0F, 0xC1, 0xFF, 0xE1, 0xF8,
  0x1F, 0x83, 0xEF, 0xC3, 0xF0, 0x3F, 0x07, 0xDF, 0x87, 0xE0, 0x7E, 0x0F,
  0xBF, 0x0F, 0xC1, 0xF8, 0x1F, 0x7E, 0x1F, 0xC3, 0xF0, 0x7E, 0xFC, 0x3F,
  0x87, 0xE0, 0xF9, 0xF8, 0x7F, 0x1F, 0xE3, 0xF3, 0xF0, 0x7F, 0xFF, 0xCF,
  0xC3, 0xE0, 0xFF, 0xFF, 0xFF, 0x87, 0xE0, 0xFF, 0xDF, 0xFE, 0x0F, 0xC1,
  0xFF, 0x3F, 0xF8, 0x1F, 0x80, 0xFC, 0x1F, 0xE0, 0x1F, 0x80, 0x40, 0x0C,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x02,
  0x00, 0x00, 0xFF, 0xE0, 0x7C, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x03,
  0xFC, 0xFF, 0x00, 0x01, 0xFF, 0x3F, 0xC0, 0x00, 0x7F, 0xCF, 0xF8, 0x00,
  0x1F, 0xE3, 0xFE, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x03, 0xFE, 0x1F, 0xF0,
  0x00, 0xFF, 0x87, 0xFC, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x1F, 0xF0, 0x3F,
  0xE0, 0x07, 0xFC, 0x0F, 0xF8, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x3F, 0xF0,
  0xFF, 0x80, 0x0F, 0xFC, 0x7F, 0xE0, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x7F,
  0xE7, 0xFE, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x07, 0xFE, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFE, 0x1F, 0xFE, 0xFF,
  0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFB, 0xFE, 0x03,
  0xFE, 0xFF, 0x83, 0xFF, 0xBF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFB,
  0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC,
  0x3F, 0xF0, 0x7F, 0xF3, 0xFF, 0x01, 0xFF, 0x9F, 0xF8, 0x07, 0xFC, 0xFF,
  0x80, 0x3F, 0xE7, 0xFC, 0x01, 0xFF, 0x7F, 0xE0, 0x0F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x3F,
  0xFF, 0xFC, 0x01, 0xFF, 0xBF, 0xE0, 0x0F, 0xFD, 0xFF, 0x00, 0x7F, 0xCF,
  0xF8, 0x03, 0xFE, 0x7F, 0xE0, 0x3F, 0xF1, 0xFF, 0x83, 0xFF, 0x8F, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x10, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xF3, 0xFE, 0x3F, 0xFC, 0xFF, 0x83, 0xFF, 0xBF, 0xE0, 0x7F,
  0xEF, 0xF8, 0x0F, 0xFB, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xEF, 0xF8, 0x1F, 0xFB, 0xFE, 0x0F, 0xFE,
  0xFF, 0x8F, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x03, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFE, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xFC, 0x3F, 0xF8, 0x3F, 0xF1, 0xFF, 0x80, 0xFF, 0x9F,
  0xF8, 0x07, 0xFC, 0xFF, 0xC0, 0x3F, 0xF7, 0xFC, 0x00, 0xFF, 0xBF, 0xE0,
  0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x83, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0x80, 0x3F, 0xF7, 0xFC, 0x01, 0xFF, 0xBF, 0xE0, 0x0F, 0xFD,
  0xFF, 0x00, 0x7F, 0xEF, 0xFC, 0x03, 0xFF, 0x3F, 0xF0, 0x1F, 0xF9, 0xFF,
  0xC1, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x18, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xC3, 0xFE, 0x7F, 0xE7, 0xFE, 0x7F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0,
  0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x10, 0x00, 0xFF, 0x80, 0x7F,
  0xF7, 0xFC, 0x03, 0xFF, 0xBF, 0xE0, 0x3F, 0xF9, 0xFF, 0x01, 0xFF, 0xCF,
  0xF8, 0x1F, 0xFC, 0x7F, 0xC0, 0xFF, 0xC3, 0xFE, 0x0F, 0xFE, 0x1F, 0xF0,
  0x7F, 0xE0, 0xFF, 0x87, 0xFF, 0x07, 0xFC, 0x3F, 0xF0, 0x3F, 0xE3, 0xFF,
  0x01, 0xFF, 0x1F, 0xF8, 0x0F, 0xF9, 0xFF, 0x80, 0x7F, 0xCF, 0xF8, 0x03,
  0xFE, 0xFF, 0xC0, 0x1F, 0xF7, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFB, 0xFF, 0x01, 0xFF,
  0xDF, 0xFC, 0x0F, 0xFC, 0x7F, 0xE0, 0x7F, 0xC3, 0xFF, 0x83, 0xFE, 0x0F,
  0xFC, 0x1F, 0xF0, 0x7F, 0xF0, 0xFF, 0x81, 0xFF, 0x87, 0xFC, 0x0F, 0xFE,
  0x3F, 0xE0, 0x7F, 0xF1, 0xFF, 0x01, 0xFF, 0x8F, 0xF8, 0x0F, 0xFE, 0x7F,
  0xC0, 0x3F, 0xF3, 0xFE, 0x01, 0xFF, 0xDF, 0xF0, 0x0F, 0xFE, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xEF, 0xC0, 0xFF, 0xFF, 0xFF, 0x7F, 0x07, 0xFF, 0xFF,
  0xFB, 0xF8, 0x3F, 0x7F, 0xFF, 0xDF, 0xC3, 0xFB, 0xFF, 0xFF, 0x7E, 0x1F,
  0xDF, 0xFF, 0xFB, 0xF8, 0xFE, 0xFF, 0xFF, 0xDF, 0xC7, 0xE7, 0xFF, 0xFE,
  0xFE, 0x7F, 0x3F, 0xFF, 0xF3, 0xF3, 0xF9, 0xFF, 0xFF, 0x9F, 0x9F, 0x8F,
  0xFF, 0xFC, 0xFE, 0xFC, 0x7F, 0xFF, 0xE7, 0xF7, 0xE3, 0xFF, 0xFF, 0x1F,
  0xFF, 0x3F, 0xFF, 0xF8, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xFF, 0x8F, 0xFF,
  0xFE, 0x1F, 0xFC, 0x7F, 0xFF, 0xF0, 0xFF, 0xE3, 0xFF, 0xFF, 0x87, 0xFE,
  0x1F, 0xFF, 0xFC, 0x3F, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0x87, 0xFF, 0xFF,
  0x07, 0xFC, 0x3F, 0xFF, 0xF8, 0x3F, 0xC1, 0xFF, 0xFF, 0xC1, 0xFE, 0x0F,
  0xFF, 0xFE, 0x07, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0x03, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xBF, 0x1F, 0xFF, 0xFB, 0xF1,
  0xFF, 0xFF, 0xBF, 0x1F, 0xFF, 0xF9, 0xF9, 0xFF, 0xFF, 0x9F, 0x9F, 0xFF,
  0xF8, 0xFD, 0xFF, 0xFF, 0x8F, 0xDF, 0xFF, 0xF8, 0xFD, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8,
  0x3F, 0xF8, 0x7F, 0xF1, 0xFF, 0x80, 0xFF, 0xC7, 0xFE, 0x01, 0xFF, 0x9F,
  0xF0, 0x07, 0xFE, 0x7F, 0xC0, 0x0F, 0xFB, 0xFF, 0x00, 0x3F, 0xEF, 0xFC,
  0x00, 0xFF, 0xBF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xF0, 0x03, 0xFE, 0xFF, 0xC0, 0x0F, 0xF9, 0xFF, 0x00, 0x3F, 0xE7, 0xFC,
  0x01, 0xFF, 0x9F, 0xF8, 0x07, 0xFE, 0x7F, 0xE0, 0x3F, 0xF0, 0xFF, 0xE1,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x08, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE7, 0xFC, 0x1F, 0xFE, 0xFF,
  0x80, 0xFF, 0xDF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x1F, 0xFB, 0xFE, 0x0F, 0xFF,
  0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0x80, 0xFF,
  0xC7, 0xFE, 0x01, 0xFF, 0x9F, 0xF0, 0x07, 0xFE, 0x7F, 0xC0, 0x0F, 0xFB,
  0xFF, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xF9,
  0xFF, 0x00, 0x3F, 0xE7, 0xFC, 0x01, 0xFF, 0x9F, 0xF8, 0x07, 0xFE, 0x3F,
  0xF0, 0x3F, 0xF0, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x09, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x40, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE7, 0xFC,
  0x1F, 0xFE, 0xFF, 0x80, 0xFF, 0xDF, 0xF0, 0x1F, 0xFB, 0xFE, 0x01, 0xFF,
  0x7F, 0xC0, 0x3F, 0xEF, 0xF8, 0x07, 0xFD, 0xFF, 0x00, 0xFF, 0xBF, 0xE0,
  0x1F, 0xF7, 0xFC, 0x03, 0xFE, 0xFF, 0x80, 0xFF, 0xDF, 0xF0, 0x1F, 0xFB,
  0xFE, 0x0F, 0xFE, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0x83, 0xFE, 0x3F, 0xF0, 0x7F, 0xC7, 0xFE, 0x0F, 0xF8, 0x7F,
  0xE1, 0xFF, 0x0F, 0xFC, 0x3F, 0xE0, 0xFF, 0xC7, 0xFC, 0x1F, 0xF8, 0xFF,
  0x83, 0xFF, 0x1F, 0xF0, 0x3F, 0xF3, 0xFE, 0x07, 0xFE, 0x7F, 0xC0, 0x7F,
  0xEF, 0xF8, 0x0F, 0xFD, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x7F, 0xF0, 0xFF, 0xCF, 0xFC, 0x0F, 0xF9,
  0xFF, 0x01, 0xFF, 0xBF, 0xE0, 0x3F, 0xF7, 0xFC, 0x03, 0xFE, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0xEF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xEF, 0xFC, 0x1F, 0xF9, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xF7, 0xFE, 0x03,
  0xFE, 0xFF, 0xE0, 0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0x7F, 0xE0, 0x03, 0xFF, 0x7F, 0xE0, 0x07, 0xFF, 0x7F, 0xE0, 0x07, 0xFF,
  0x3F, 0xF0, 0x07, 0xFE, 0x3F, 0xF0, 0x07, 0xFE, 0x3F, 0xF0, 0x07, 0xFE,
  0x3F, 0xF0, 0x0F, 0xFC, 0x1F, 0xF0, 0x0F, 0xFC, 0x1F, 0xF8, 0x0F, 0xFC,
  0x1F, 0xF8, 0x0F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF8,
  0x0F, 0xF8, 0x1F, 0xF8, 0x0F, 0xFC, 0x1F, 0xF0, 0x07, 0xFC, 0x1F, 0xF0,
  0x07, 0xFC, 0x1F, 0xF0, 0x07, 0xFC, 0x3F, 0xF0, 0x07, 0xFC, 0x3F, 0xE0,
  0x03, 0xFE, 0x3F, 0xE0, 0x03, 0xFE, 0x3F, 0xE0, 0x03, 0xFE, 0x3F, 0xE0,
  0x03, 0xFE, 0x7F, 0xC0, 0x01, 0xFE, 0x7F, 0xC0, 0x01, 0xFF, 0x7F, 0xC0,
  0x01, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0xFF, 0x80, 0xFF, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0xFF, 0xC1,
  0xFF, 0x03, 0xFE, 0xFF, 0xC1, 0xFF, 0x03, 0xFE, 0x7F, 0xC1, 0xFF, 0x03,
  0xFE, 0x7F, 0xC1, 0xFF, 0x83, 0xFE, 0x7F, 0xC1, 0xFF, 0x87, 0xFE, 0x7F,
  0xC3, 0xFF, 0x87, 0xFC, 0x7F, 0xC3, 0xFF, 0x87, 0xFC, 0x7F, 0xE3, 0xFF,
  0x87, 0xFC, 0x3F, 0xE3, 0xFF, 0xC7, 0xFC, 0x3F, 0xE3, 0xFF, 0xC7, 0xFC,
  0x3F, 0xE3, 0xFF, 0xC7, 0xFC, 0x3F, 0xE7, 0xFF, 0xCF, 0xF8, 0x3F, 0xE7,
  0xFF, 0xCF, 0xF8, 0x3F, 0xE7, 0xFF, 0xCF, 0xF8, 0x1F, 0xF7, 0xFF, 0xEF,
  0xF8, 0x1F, 0xF7, 0xFF, 0xEF, 0xF8, 0x1F, 0xFF, 0xFF, 0xEF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xEF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xEF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xEF, 0xFF, 0xF0, 0x0F, 0xFF, 0xEF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xE7, 0xFF, 0xE0, 0x07, 0xFF, 0xE7, 0xFF, 0xE0, 0x07, 0xFF, 0xC7, 0xFF,
  0xE0, 0x07, 0xFF, 0xC7, 0xFF, 0xE0, 0x07, 0xFF, 0xC7, 0xFF, 0xE0, 0x07,
  0xFF, 0xC3, 0xFF, 0xC0, 0x07, 0xFF, 0xC3, 0xFF, 0xC0, 0x03, 0xFF, 0x83,
  0xFF, 0xC0, 0x03, 0xFF, 0x83, 0xFF, 0xC0, 0x03, 0xFF, 0x83, 0xFF, 0xC0,
  0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0x03, 0xFF,
  0x81, 0xFF, 0x80, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFE,
  0xFF, 0xE0, 0x1F, 0xF8, 0xFF, 0xC0, 0x7F, 0xF1, 0xFF, 0x80, 0xFF, 0xC1,
  0xFF, 0x81, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x03, 0xFE, 0x0F, 0xFC, 0x07,
  0xFE, 0x1F, 0xF8, 0x0F, 0xFC, 0x7F, 0xE0, 0x0F, 0xFC, 0xFF, 0xC0, 0x1F,
  0xF9, 0xFF, 0x00, 0x1F, 0xF7, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x3F, 0xEF, 0xFC,
  0x00, 0xFF, 0xCF, 0xF8, 0x01, 0xFF, 0x1F, 0xF8, 0x07, 0xFE, 0x3F, 0xF0,
  0x0F, 0xFC, 0x3F, 0xF0, 0x3F, 0xF0, 0x7F, 0xE0, 0x7F, 0xE0, 0xFF, 0xE1,
  0xFF, 0xC0, 0xFF, 0xC3, 0xFF, 0x01, 0xFF, 0x87, 0xFE, 0x03, 0xFF, 0x9F,
  0xFC, 0x03, 0xFF, 0x3F, 0xF0, 0x07, 0xFF, 0x7F, 0xC0, 0x0F, 0xFC, 0xFF,
  0xC0, 0x1F, 0xF9, 0xFF, 0x80, 0x3F, 0xF1, 0xFF, 0x00, 0x7F, 0xC3, 0xFF,
  0x01, 0xFF, 0x83, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xFC,
  0x1F, 0xF8, 0x0F, 0xF8, 0x3F, 0xE0, 0x1F, 0xF0, 0x7F, 0xC0, 0x1F, 0xE1,
  0xFF, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x7F, 0x8F,
  0xF0, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0xFF, 0x7F, 0x80, 0x01, 0xFE, 0xFF,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F, 0xCF, 0xF9, 0xFF, 0x3F,
  0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F, 0xCF, 0xF9, 0xFF, 0x3F, 0xE7,
  0xFC, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F, 0xCF, 0xF9, 0xFF, 0x3F, 0xE7, 0xFC,
  0xFF, 0x9F, 0xF3, 0xFE, 0x7F, 0xCF, 0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF,
  0x9F, 0xF3, 0xFE, 0x7F, 0xCF, 0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F,
  0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFC,
  0x00, 0x1F, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F, 0xCF, 0xF9,
  0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F, 0xCF, 0xF9, 0xFF,
  0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F, 0xCF, 0xF9, 0xFF, 0x3F,
  0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F, 0xCF, 0xF9, 0xFF, 0x3F, 0xE7,
  0xFC, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F, 0xCF, 0xF9, 0xFF, 0x3F, 0xE7, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x7F,
  0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xDF, 0x80, 0xFD, 0xF8, 0x1F,
  0x9F, 0x81, 0xF9, 0xFC, 0x1F, 0x8F, 0xC3, 0xF8, 0xFC, 0x3F, 0x0F, 0xE3,
  0xF0, 0x7E, 0x7F, 0x07, 0xE7, 0xF0, 0x7F, 0x7E, 0x07, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0xFE, 0x00, 0x08, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x7F, 0xE7,
  0xFE, 0x7F, 0xC3, 0xFE, 0x7F, 0xC3, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x7F, 0xE3, 0xFE, 0x7F, 0xC3,
  0xFE, 0x7F, 0xC3, 0xFE, 0xFF, 0x83, 0xFE, 0xFF, 0x83, 0xFE, 0xFF, 0x83,
  0xFE, 0xFF, 0xC7, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFE, 0x1F, 0xFB, 0xFF, 0x07, 0xF1, 0xFF, 0x00, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x82,
  0x00, 0xFF, 0x9F, 0xE0, 0xFF, 0xBF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xC3,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFC, 0xFF, 0xBF, 0xF8, 0xFF, 0x9F, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xE1, 0xFF, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x3F, 0xF0, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x03, 0xF9, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F,
  0xC1, 0xFF, 0x7F, 0xC1, 0xFF, 0x7F, 0xC1, 0xFF, 0x7F, 0xC1, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0x7F,
  0xC1, 0xFF, 0x7F, 0xC1, 0xFF, 0x7F, 0xC1, 0xFF, 0x7F, 0xC1, 0xFF, 0x7F,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F,
  0xFE, 0xFF, 0x0F, 0xFE, 0xFF, 0x03, 0xF8, 0xFF, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x7F,
  0xC3, 0xFE, 0xFF, 0x81, 0xFE, 0xFF, 0x81, 0xFE, 0xFF, 0x81, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x10, 0x7F, 0xC0, 0x30, 0x7F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x7F, 0xF0, 0x7F, 0xF8, 0x7F, 0xFC,
  0x3F, 0xFE, 0x3F, 0xFF, 0x1F, 0xF8, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE,
  0x01, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE3, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07,
  0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0xFF, 0x0F, 0xFE, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC1, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x0F, 0xFD,
  0xFF, 0x07, 0xF9, 0xFF, 0x00, 0x41, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03,
  0xFF, 0x0E, 0x07, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x01, 0xFE,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xF9, 0xFE, 0x1F, 0xF7, 0xFE, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0x07, 0xFC, 0x1F, 0x0F, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFD, 0xFE,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xDF, 0xF7, 0xFD, 0xFF, 0x7F, 0xDF,
  0xF7, 0xFD, 0xFF, 0x7F, 0xDF, 0xF7, 0xFD, 0xFF, 0x7F, 0xDF, 0xF7, 0xFD,
  0xFF, 0x7F, 0xDF, 0xF7, 0xFD, 0xFF, 0x7F, 0xDF, 0xF7, 0xFD, 0xFF, 0x7F,
  0xDF, 0xF7, 0xFD, 0xFF, 0x7F, 0xDF, 0xF0, 0x01, 0xF0, 0x0F, 0xE0, 0x7F,
  0xC1, 0xFF, 0x0F, 0xFC, 0x1F, 0xF0, 0x7F, 0xC0, 0xFE, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07,
  0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1,
  0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0,
  0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC,
  0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF,
  0x07, 0xFC, 0x7F, 0xFF, 0xFF, 0xBF, 0xFE, 0xFF, 0xFB, 0xFF, 0xCF, 0xFE,
  0x3F, 0xF0, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x83, 0xFF, 0xBF, 0xE0,
  0xFF, 0xCF, 0xF8, 0x7F, 0xF3, 0xFE, 0x1F, 0xF8, 0xFF, 0x8F, 0xFC, 0x3F,
  0xE3, 0xFF, 0x0F, 0xF9, 0xFF, 0x83, 0xFE, 0xFF, 0xC0, 0xFF, 0xBF, 0xF0,
  0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0,
  0xFF, 0xCF, 0xF8, 0x3F, 0xE3, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F,
  0xF8, 0xFF, 0x87, 0xFE, 0x3F, 0xE0, 0xFF, 0xCF, 0xF8, 0x3F, 0xF3, 0xFE,
  0x07, 0xFE, 0xFF, 0x81, 0xFF, 0xBF, 0xE0, 0x7F, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF1, 0xFE, 0x0F, 0xF0, 0xFF, 0x3F, 0xF1, 0xFF, 0x8F, 0xF7,
  0xFF, 0x3F, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0x87, 0xFE,
  0x3F, 0xFF, 0xF0, 0x7F, 0xC1, 0xFF, 0xFF, 0x07, 0xFC, 0x1F, 0xFF, 0xF0,
  0x7F, 0xC1, 0xFF, 0xFF, 0x07, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xC1, 0xFF,
  0xFF, 0x07, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xC1, 0xFF, 0xFF, 0x07, 0xFC,
  0x1F, 0xFF, 0xF0, 0x7F, 0xC1, 0xFF, 0xFF, 0x07, 0xFC, 0x1F, 0xFF, 0xF0,
  0x7F, 0xC1, 0xFF, 0xFF, 0x07, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xC1, 0xFF,
  0xFF, 0x07, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xC1, 0xFF, 0xFF, 0x07, 0xFC,
  0x1F, 0xFF, 0xF0, 0x7F, 0xC1, 0xFF, 0xFF, 0x07, 0xFC, 0x1F, 0xFF, 0xF0,
  0x7F, 0xC1, 0xFF, 0xFF, 0x07, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xC1, 0xFF,
  0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x1F, 0xE3, 0xFE,
  0xFF, 0xE7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0xFF,
  0xC3, 0xFE, 0xFF, 0x83, 0xFE, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFE, 0xFF, 0xC3, 0xFE, 0x7F,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x9F, 0xE0, 0xFF, 0xBF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF,
  0xC3, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF8, 0xFF, 0xBF, 0xF0, 0xFF, 0x9F, 0xE0, 0xFF, 0x82, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0xFF, 0x0F,
  0xFE, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xC1, 0xFF, 0x7F, 0xC1, 0xFF, 0x7F,
  0xC1, 0xFF, 0x7F, 0xC1, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0x81, 0xFF, 0x7F, 0xC1, 0xFF, 0x7F, 0xC1, 0xFF, 0x7F,
  0xC1, 0xFF, 0x7F, 0xC1, 0xFF, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x03,
  0xFD, 0xFF, 0x00, 0x41, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0x9F, 0xFF, 0xBF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xC0, 0xFF, 0x80, 0xFF,
  0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF,
  0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF,
  0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF,
  0x80, 0x00, 0x10, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x3F, 0xE3, 0xFE,
  0x7F, 0xC3, 0xFE, 0xFF, 0x07, 0xFD, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07,
  0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC1, 0xFF, 0x7F, 0x83,
  0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x08, 0x00, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xFF, 0x1F,
  0xFF, 0x1F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x00,
  0x30, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC3, 0xFF, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0x1F, 0xFD, 0xFF, 0x0F, 0xF1, 0xFF, 0x00, 0x80, 0x00, 0x7F, 0xC0,
  0xFF, 0xBF, 0xE0, 0x7F, 0xDF, 0xF0, 0x7F, 0xEF, 0xF8, 0x3F, 0xE3, 0xFE,
  0x1F, 0xF1, 0xFF, 0x0F, 0xF8, 0xFF, 0x87, 0xFC, 0x7F, 0xC7, 0xFC, 0x1F,
  0xE3, 0xFE, 0x0F, 0xF9, 0xFF, 0x07, 0xFC, 0xFF, 0x83, 0xFE, 0x7F, 0x80,
  0xFF, 0x3F, 0xC0, 0x7F, 0xBF, 0xE0, 0x3F, 0xDF, 0xE0, 0x1F, 0xFF, 0xF0,
  0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFE,
  0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0x07, 0xF0, 0xFF,
  0xFF, 0xC3, 0xF8, 0x7F, 0xFF, 0xE1, 0xFC, 0x3F, 0xFF, 0xF0, 0xFE, 0x1F,
  0xE7, 0xF8, 0xFF, 0x0F, 0xF3, 0xFC, 0x7F, 0xC7, 0xF9, 0xFE, 0x3F, 0xE3,
  0xFC, 0xFF, 0x1F, 0xF1, 0xFE, 0x7F, 0x8F, 0xF8, 0xFF, 0x1F, 0xCF, 0xFE,
  0xFF, 0x0F, 0xF7, 0xFF, 0x7F, 0x87, 0xFB, 0xFF, 0xBF, 0xC3, 0xFD, 0xFF,
  0xDF, 0xE1, 0xFE, 0xFF, 0xEF, 0xF0, 0x7F, 0xFD, 0xFF, 0xF0, 0x3F, 0xFE,
  0xFF, 0xF8, 0x1F, 0xFF, 0x7F, 0xFC, 0x0F, 0xFF, 0xBF, 0xFE, 0x07, 0xFF,
  0x8F, 0xFF, 0x03, 0xFF, 0xC7, 0xFF, 0x80, 0xFF, 0xE3, 0xFF, 0x80, 0x7F,
  0xF1, 0xFF, 0xC0, 0x3F, 0xF8, 0xFF, 0xE0, 0x1F, 0xF8, 0x3F, 0xF0, 0x0F,
  0xFC, 0x1F, 0xF8, 0x03, 0xFE, 0x0F, 0xF8, 0x01, 0xFF, 0x07, 0xFC, 0x00,
  0xFF, 0x83, 0xFE, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0xC1, 0xFF, 0x7F, 0xC3, 0xFE, 0x7F, 0xC3, 0xFE, 0x7F, 0xC3, 0xFE,
  0x3F, 0xE7, 0xFC, 0x3F, 0xE7, 0xFC, 0x1F, 0xE7, 0xF8, 0x1F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0,
  0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x3F, 0xE7, 0xFC,
  0x3F, 0xE7, 0xFC, 0x7F, 0xE7, 0xFC, 0x7F, 0xC3, 0xFE, 0x7F, 0xC3, 0xFE,
  0xFF, 0xC3, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xDF, 0xF0, 0x3F,
  0xE7, 0xFC, 0x1F, 0xF9, 0xFF, 0x87, 0xFE, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8,
  0x7F, 0xC3, 0xFE, 0x3F, 0xF0, 0xFF, 0x8F, 0xF8, 0x1F, 0xF3, 0xFE, 0x07,
  0xFC, 0xFF, 0x81, 0xFF, 0x3F, 0xE0, 0x3F, 0xDF, 0xF0, 0x0F, 0xF7, 0xFC,
  0x03, 0xFD, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x07, 0xFF,
  0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x03,
  0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80,
  0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x10, 0x01, 0xE0, 0x0F, 0x80, 0x7E, 0x03, 0xFC,
  0x1F, 0xE0, 0x7F, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE,
  0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x0F, 0xF0, 0xFF, 0xC3, 0xFE,
  0x0F, 0xE0, 0x3F, 0xC0, 0xFF, 0x83, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x1F,
  0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0x80, 0x3E, 0x00, 0x78,
  0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x60, 0x03, 0xC0, 0x3F,
  0x01, 0xFC, 0x0F, 0xF0, 0x7F, 0x81, 0xFE, 0x0F, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1,
  0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0x7F, 0x83, 0xFE, 0x0F,
  0xF8, 0x3F, 0xC0, 0xFE, 0x07, 0xF0, 0xFF, 0x87, 0xFC, 0x7F, 0x83, 0xFC,
  0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07,
  0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xF8, 0x1F, 0xC1, 0xFE,
  0x0F, 0xF0, 0xFF, 0x07, 0xF8, 0x3F, 0x81, 0xF8, 0x07, 0x80, 0x30, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xFC, 0x07, 0xF1, 0xFF, 0xC1, 0xFC, 0xFF, 0xF0,
  0x7F, 0x3F, 0xFE, 0x1F, 0xDF, 0xFF, 0xCF, 0xE7, 0xFF, 0xFF, 0xF9, 0xFC,
  0xFF, 0xFE, 0x7E, 0x1F, 0xFF, 0x1F, 0x83, 0xFF, 0xCF, 0xE0, 0x7F, 0xE3,
  0xF8, 0x0F, 0xF0, 0x00, 0x01, 0xF0, 0x00,
};

const GFXglyph RobotoCondensed_Black56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 10, 41, 15, 3, -40 },
  { 53, 16, 16, 18, 1, -42 },
  { 85, 26, 40, 29, 1, -40 },
  { 215, 24, 53, 29, 2, -47 },
  { 374, 31, 42, 36, 3, -41 },
  { 537, 30, 42, 33, 2, -41 },
  { 695, 7, 16, 9, 1, -42 },
  { 709, 14, 56, 18, 3, -44 },
  { 807, 15, 56, 18, 1, -44 },
  { 912, 25, 24, 26, 1, -40 },
  { 987, 23, 29, 26, 1, -33 },
  { 1071, 11, 18, 15, 1, -7 },
  { 1096, 15, 7, 24, 4, -21 },
  { 1110, 10, 10, 17, 3, -9 },
  { 1123, 17, 43, 17, 0, -40 },
  { 1215, 24, 42, 29, 2, -41 },
  { 1341, 17, 40, 29, 4, -40 },
  { 1426, 24, 41, 29, 2, -41 },
  { 1549, 25, 42, 29, 1, -41 },
  { 1681, 25, 40, 29, 2, -40 },
  { 1806, 24, 41, 29, 2, -40 },
  { 1929, 25, 41, 29, 2, -40 },
  { 2058, 24, 40, 29, 2, -40 },
  { 2178, 24, 42, 29, 2, -41 },
  { 2304, 24, 41, 29, 2, -41 },
  { 2427, 11, 32, 16, 3, -31 },
  { 2471, 11, 42, 16, 2, -31 },
  { 2529, 21, 27, 25, 1, -30 },
  { 2600, 22, 19, 29, 3, -27 },
  { 2653, 20, 27, 25, 3, -30 },
  { 2721, 23, 42, 26, 1, -41 },
  { 2842, 39, 51, 43, 2, -39 },
  { 3091, 34, 40, 34, 0, -40 },
  { 3261, 26, 40, 32, 3, -40 },
  { 3391, 29, 42, 32, 2, -41 },
  { 3544, 26, 40, 31, 3, -40 },
  { 3674, 23, 40, 27, 3, -40 },
  { 3789, 22, 40, 27, 3, -40 },
  { 3899, 29, 42, 33, 2, -41 },
  { 4052, 28, 40, 34, 3, -40 },
  { 4192, 10, 40, 16, 3, -40 },
  { 4242, 24, 41, 28, 1, -40 },
  { 4365, 29, 40, 31, 3, -40 },
  { 4510, 23, 40, 27, 3, -40 },
  { 4625, 37, 40, 43, 3, -40 },
  { 4810, 28, 40, 34, 3, -40 },
  { 4950, 30, 42, 34, 2, -41 },
  { 5108, 27, 40, 32, 3, -40 },
  { 5243, 30, 48, 34, 2, -41 },
  { 5423, 27, 40, 32, 3, -40 },
  { 5558, 27, 42, 31, 2, -41 },
  { 5700, 29, 40, 31, 1, -40 },
  { 5845, 27, 41, 32, 3, -40 },
  { 5984, 32, 40, 33, 0, -40 },
  { 6144, 40, 40, 42, 1, -40 },
  { 6344, 31, 40, 32, 0, -40 },
  { 6499, 31, 40, 31, 0, -40 },
  { 6654, 26, 40, 30, 2, -40 },
  { 6784, 11, 57, 15, 3, -47 },
  { 6863, 23, 43, 22, 0, -40 },
  { 6987, 11, 57, 15, 1, -47 },
  { 7066, 20, 20, 22, 1, -40 },
  { 7116, 21, 7, 22, 1, 0 },
  { 7135, 16, 9, 19, 1, -42 },
  { 7153, 24, 32, 26, 1, -31 },
  { 7249, 24, 43, 28, 2, -42 },
  { 7378, 22, 32, 26, 2, -31 },
  { 7466, 24, 43, 28, 1, -42 },
  { 7595, 24, 32, 27, 2, -31 },
  { 7691, 17, 43, 19, 1, -43 },
  { 7783, 24, 42, 28, 2, -31 },
  { 7909, 23, 42, 28, 2, -42 },
  { 8030, 10, 42, 15, 2, -42 },
  { 8083, 14, 53, 14, -2, -42 },
  { 8176, 26, 42, 27, 2, -42 },
  { 8313, 9, 42, 15, 3, -42 },
  { 8361, 36, 31, 41, 3, -31 },
  { 8501, 23, 31, 28, 2, -31 },
  { 8591, 24, 32, 28, 2, -31 },
  { 8687, 24, 42, 28, 2, -31 },
  { 8813, 24, 42, 28, 1, -31 },
  { 8939, 16, 31, 19, 2, -31 },
  { 9001, 23, 32, 25, 1, -31 },
  { 9093, 16, 38, 18, 1, -37 },
  { 9169, 24, 31, 28, 2, -30 },
  { 9262, 25, 30, 26, 0, -30 },
  { 9356, 33, 30, 35, 1, -30 },
  { 9480, 24, 30, 26, 1, -30 },
  { 9570, 26, 41, 26, 0, -30 },
  { 9704, 21, 30, 26, 2, -30 },
  { 9783, 14, 54, 16, 1, -44 },
  { 9878, 5, 47, 14, 5, -40 },
  { 9908, 13, 54, 16, 2, -44 },
  { 9996, 26, 13, 30, 2, -23 },
};

const GFXfont RobotoCondensed_Black56pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Black56pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Black56pt7bGlyphs,
  0x20, 0x7E, 66
};

#endif // _ROBOTOCONDENSED_BLACK56PT7B_H_
