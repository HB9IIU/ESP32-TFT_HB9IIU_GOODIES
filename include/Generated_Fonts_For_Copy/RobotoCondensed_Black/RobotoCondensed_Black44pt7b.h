#ifndef _ROBOTOCONDENSED_BLACK44PT7B_H_
#define _ROBOTOCONDENSED_BLACK44PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Black.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Black44pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x7F, 0x7F, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x00, 0x00,
  0x00, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0x7E, 0x3C, 0xF9, 0xFF, 0x9F, 0xF9,
  0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xEF, 0x1E, 0xF1,
  0xEF, 0x1E, 0x01, 0xE7, 0x80, 0x1E, 0x78, 0x03, 0xE7, 0x80, 0x3C, 0x78,
  0x03, 0xCF, 0x80, 0x3C, 0xF0, 0x03, 0xCF, 0x00, 0x3C, 0xF0, 0x03, 0xCF,
  0x07, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF0, 0x79,
  0xE0, 0x07, 0x9E, 0x00, 0x79, 0xE0, 0x07, 0x9E, 0x00, 0xF1, 0xE0, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x0F, 0x3C, 0x00,
  0xF3, 0xC0, 0x1F, 0x3C, 0x01, 0xE3, 0xC0, 0x1E, 0x7C, 0x01, 0xE7, 0x80,
  0x1E, 0x78, 0x01, 0xE7, 0x80, 0x1E, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x3F, 0x80, 0x1F, 0xFC, 0x07, 0xFF,
  0xC1, 0xFF, 0xFC, 0x3F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFC, 0x7F, 0x3F, 0x8F,
  0xF7, 0xF0, 0xFE, 0xFE, 0x1F, 0xDF, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF,
  0x00, 0x1F, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xDF, 0xC3, 0xFF, 0xF8, 0x3F,
  0xFF, 0x0F, 0xFF, 0xF1, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xF1, 0xFF, 0xFC,
  0x1F, 0xFF, 0x01, 0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x7F, 0xE0, 0x00, 0xF9, 0xF0, 0xE0, 0xF9, 0xF0, 0xF0, 0xF0,
  0xF1, 0xE0, 0xF0, 0xF1, 0xE0, 0xF0, 0xF3, 0xC0, 0xF9, 0xF7, 0xC0, 0xF9,
  0xF7, 0x80, 0x7F, 0xEF, 0x00, 0x7F, 0xEF, 0x00, 0x3F, 0xDE, 0x00, 0x1F,
  0x9E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0xF8, 0x00, 0x7B, 0xFC, 0x00,
  0xFF, 0xFE, 0x00, 0xF7, 0xFF, 0x01, 0xFF, 0x9F, 0x01, 0xEF, 0x8F, 0x03,
  0xCF, 0x8F, 0x03, 0xCF, 0x8F, 0x07, 0x8F, 0x8F, 0x07, 0x8F, 0x8F, 0x0F,
  0x0F, 0x9F, 0x03, 0x07, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xF8, 0x01, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x0F,
  0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x1F, 0x8F, 0xC0, 0x1F,
  0x8F, 0xC0, 0x1F, 0x8F, 0x80, 0x1F, 0x8F, 0x80, 0x1F, 0x9F, 0x80, 0x1F,
  0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF8, 0x7E, 0x1F, 0xFC, 0x7E, 0x3F, 0xFC, 0xFC, 0x7F, 0xFE, 0xFC, 0x7F,
  0xFF, 0xFC, 0xFE, 0x7F, 0xFC, 0xFE, 0x3F, 0xFC, 0xFE, 0x3F, 0xF8, 0xFF,
  0x1F, 0xF8, 0xFF, 0x0F, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x80, 0x60, 0x3C, 0x1F,
  0x0F, 0x87, 0xE1, 0xF0, 0xFC, 0x3E, 0x0F, 0x87, 0xC1, 0xF0, 0x7C, 0x3F,
  0x0F, 0xC3, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0xC3, 0xF0, 0x7C,
  0x1F, 0x07, 0xC0, 0xF8, 0x3E, 0x0F, 0xC1, 0xF0, 0x7E, 0x0F, 0x81, 0xF0,
  0x3C, 0x06, 0x00, 0x80, 0x40, 0x0E, 0x01, 0xE0, 0x7E, 0x07, 0xC0, 0x7C,
  0x0F, 0xC0, 0xF8, 0x1F, 0x81, 0xF0, 0x3E, 0x07, 0xE0, 0xFC, 0x0F, 0x81,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3E, 0x07, 0xC1, 0xF8, 0x3E, 0x0F, 0xC1, 0xF0, 0x7C,
  0x1F, 0x81, 0xE0, 0x38, 0x04, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0xC1, 0xC1, 0xBE, 0x38, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xF0, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0xC0, 0x1F, 0x78, 0x07, 0xCF, 0x81, 0xF8, 0xF8, 0x3E, 0x0F, 0x83, 0x81,
  0xE0, 0x10, 0x10, 0x00, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F,
  0x3F, 0x3F, 0x3E, 0x7E, 0x7C, 0xFC, 0xF8, 0x10, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7C, 0xFE, 0xFE, 0xFF, 0xFE, 0xFE, 0x7C,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x01, 0xFF,
  0x80, 0x7F, 0xF8, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0xFF, 0xFF, 0x1F, 0xC7,
  0xF7, 0xF0, 0xFE, 0xFE, 0x1F, 0xDF, 0xC1, 0xFB, 0xF8, 0x3F, 0xFF, 0x07,
  0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F,
  0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F,
  0xBF, 0x87, 0xF7, 0xF0, 0xFE, 0x7F, 0x1F, 0xCF, 0xFF, 0xF0, 0xFF, 0xFE,
  0x1F, 0xFF, 0x81, 0xFF, 0xF0, 0x1F, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x18,
  0x03, 0xC0, 0xFE, 0x3F, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFE, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F,
  0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F,
  0xFF, 0xC7, 0xFF, 0xFE, 0x7F, 0x1F, 0xE7, 0xF0, 0xFE, 0xFF, 0x0F, 0xEF,
  0xE0, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xE0, 0x07, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F,
  0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF0, 0x03, 0xF8, 0x00, 0xFF, 0xF0,
  0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7, 0xFF, 0xFE, 0x7F, 0x0F,
  0xE7, 0xF0, 0xFE, 0xFF, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x3F, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xE7, 0xFF, 0xFE,
  0x7F, 0xFF, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00,
  0xFF, 0xC0, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x07, 0xDF, 0xC0, 0x7D, 0xFC, 0x0F, 0x9F, 0xC0, 0xF9, 0xFC,
  0x1F, 0x9F, 0xC1, 0xF1, 0xFC, 0x3F, 0x1F, 0xC7, 0xE1, 0xFC, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF,
  0xFF, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE,
  0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x7C, 0x07, 0xFF,
  0xF0, 0x7F, 0xFF, 0x87, 0xFF, 0xFC, 0x7F, 0xFF, 0xC3, 0xF1, 0xFE, 0x02,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0xFE, 0x7F, 0x0F, 0xE7, 0xF0, 0xFE, 0x7F, 0x0F, 0xE7, 0xFF, 0xFE,
  0x3F, 0xFF, 0xC3, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x7F, 0xE0, 0x01, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x1F, 0xC0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0xFF,
  0xE0, 0x3F, 0xFC, 0x0F, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0,
  0x01, 0xFD, 0xF0, 0x7F, 0x7F, 0x8F, 0xFF, 0xF9, 0xFF, 0xFF, 0xBF, 0xFF,
  0xF7, 0xFF, 0xFE, 0xFE, 0x1F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07,
  0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0x7F, 0x1F,
  0xEF, 0xFF, 0xF8, 0xFF, 0xFF, 0x1F, 0xFF, 0xC1, 0xFF, 0xF0, 0x1F, 0xFC,
  0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x01,
  0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFF, 0xFF, 0x9F,
  0xC7, 0xF7, 0xF8, 0xFE, 0xFF, 0x1F, 0xDF, 0xE3, 0xF9, 0xFC, 0x7F, 0x3F,
  0x8F, 0xE7, 0xFF, 0xF8, 0x7F, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x3F,
  0xFF, 0x0F, 0xFF, 0xF1, 0xFC, 0xFF, 0x7F, 0x0F, 0xEF, 0xE1, 0xFD, 0xFC,
  0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0xFE, 0xFF, 0x1F, 0xDF, 0xFF, 0xF9, 0xFF,
  0xFF, 0x3F, 0xFF, 0xC3, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0xFE, 0x00, 0x03,
  0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xF8, 0x1F, 0xFF, 0x87, 0xFF, 0xF8, 0xFF,
  0xFF, 0x1F, 0xC7, 0xF7, 0xF0, 0xFE, 0xFE, 0x1F, 0xDF, 0xC3, 0xFB, 0xF8,
  0x7F, 0x7F, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7, 0xFF, 0xFD,
  0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0x7D,
  0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x01, 0xFF,
  0xC0, 0x3F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xC0,
  0x00, 0x7C, 0xFE, 0xFE, 0xFF, 0xFE, 0xFE, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0xFE, 0xFF, 0xFF, 0xFE, 0xFE,
  0x7C, 0x1F, 0x1F, 0xDF, 0xEF, 0xF3, 0xF9, 0xFC, 0x78, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF1,
  0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0x87, 0xC7, 0xE3, 0xE3, 0xF1, 0xF0,
  0xF8, 0x18, 0x00, 0x00, 0x01, 0x00, 0x07, 0x00, 0x1F, 0x00, 0x7F, 0x01,
  0xFF, 0x07, 0xFF, 0x1F, 0xFF, 0xFF, 0xFC, 0xFF, 0xF0, 0xFF, 0x80, 0xFE,
  0x00, 0xFF, 0x80, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0x01,
  0xFF, 0x00, 0x7F, 0x00, 0x1F, 0x00, 0x07, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xF0, 0x00, 0xFC,
  0x00, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xFF, 0x07,
  0xFF, 0x01, 0xFF, 0x00, 0x3F, 0x01, 0xFF, 0x07, 0xFF, 0x1F, 0xFF, 0xFF,
  0xFC, 0xFF, 0xF0, 0xFF, 0xC0, 0xFF, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0x80,
  0x00, 0x07, 0xF0, 0x07, 0xFF, 0x03, 0xFF, 0xF1, 0xFF, 0xFC, 0x7F, 0xFF,
  0xBF, 0xFF, 0xEF, 0xE3, 0xFB, 0xF8, 0xFF, 0xFE, 0x1F, 0xC0, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x00, 0x7E, 0x01, 0xF0,
  0x00, 0x3E, 0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x7C, 0x3E, 0x03,
  0xE0, 0x78, 0xF8, 0x1F, 0xF0, 0xF1, 0xF0, 0x7F, 0xF1, 0xE3, 0xC1, 0xFF,
  0xE3, 0xEF, 0x87, 0xE7, 0xC3, 0xDF, 0x0F, 0x8F, 0x87, 0xBE, 0x3E, 0x1F,
  0x0F, 0x78, 0x7C, 0x3E, 0x1E, 0xF0, 0xF8, 0x7C, 0x3D, 0xE1, 0xF0, 0xF8,
  0x7F, 0xC7, 0xE1, 0xE0, 0xFF, 0x8F, 0x83, 0xC1, 0xFF, 0x1F, 0x07, 0x83,
  0xFE, 0x3E, 0x0F, 0x0F, 0x7C, 0x7E, 0x3E, 0x1E, 0x78, 0xFC, 0x7C, 0x3C,
  0xF0, 0xF9, 0xF8, 0xF1, 0xE1, 0xFF, 0xFF, 0xE3, 0xE1, 0xFF, 0xFF, 0x87,
  0xC3, 0xF9, 0xFE, 0x0F, 0x81, 0xE1, 0xF8, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80,
  0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xEF,
  0xC0, 0x03, 0xFB, 0xF8, 0x00, 0xFC, 0xFE, 0x00, 0x7F, 0x1F, 0x80, 0x1F,
  0xC7, 0xF0, 0x07, 0xF1, 0xFC, 0x03, 0xF8, 0x7F, 0x00, 0xFE, 0x0F, 0xE0,
  0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0xE0, 0x1F, 0xE3, 0xF8,
  0x07, 0xF9, 0xFE, 0x00, 0xFE, 0x7F, 0x80, 0x3F, 0xDF, 0xE0, 0x0F, 0xFF,
  0xF0, 0x03, 0xFC, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xEF, 0xE0,
  0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xBF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x01,
  0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xE7, 0xF8, 0x7F, 0xBF, 0xC0, 0xFF, 0xFF,
  0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x01, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0xFF, 0x7F, 0x87, 0xF9, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x1F, 0xFE, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xE1, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xF8, 0x7F, 0xDF, 0xC1, 0xFE,
  0xFE, 0x07, 0xF7, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0,
  0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF,
  0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03,
  0xFF, 0xF8, 0x1F, 0xDF, 0xC1, 0xFE, 0xFE, 0x0F, 0xF7, 0xFF, 0xFF, 0x3F,
  0xFF, 0xF9, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x7F, 0xFF, 0x03, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF,
  0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xF3, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xFF, 0xEF, 0xFF,
  0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE7, 0xF8, 0x3F, 0x9F, 0xC0, 0xFF, 0xFF,
  0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xFC,
  0x07, 0xFF, 0xF0, 0x1F, 0xDF, 0xC0, 0x7F, 0x7F, 0x83, 0xFD, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF,
  0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF,
  0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF,
  0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xF8,
  0xFE, 0xFF, 0x3F, 0xCF, 0xFF, 0xF9, 0xFF, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF,
  0xF0, 0x1F, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x03, 0xFF, 0xFC, 0x0F, 0xFB,
  0xF8, 0x1F, 0xE7, 0xF0, 0x7F, 0xCF, 0xE0, 0xFF, 0x1F, 0xC3, 0xFE, 0x3F,
  0x87, 0xF8, 0x7F, 0x1F, 0xE0, 0xFE, 0x3F, 0xC1, 0xFC, 0xFF, 0x03, 0xF9,
  0xFC, 0x07, 0xF7, 0xF8, 0x0F, 0xEF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF,
  0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE,
  0x07, 0xFF, 0xFC, 0x0F, 0xFB, 0xFC, 0x1F, 0xF7, 0xF8, 0x3F, 0xC7, 0xF8,
  0x7F, 0x0F, 0xF0, 0xFE, 0x1F, 0xF1, 0xFC, 0x1F, 0xE3, 0xF8, 0x3F, 0xE7,
  0xF0, 0x3F, 0xCF, 0xE0, 0x7F, 0xDF, 0xC0, 0x7F, 0xBF, 0x80, 0xFF, 0x80,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFB, 0xE3, 0xFF, 0xFF, 0xDF, 0x1F, 0x7F, 0xFE, 0xFC, 0xFB, 0xFF,
  0xF3, 0xE7, 0xDF, 0xFF, 0x9F, 0x7E, 0xFF, 0xFC, 0xFB, 0xE7, 0xFF, 0xE7,
  0xDF, 0x3F, 0xFF, 0x1F, 0xF9, 0xFF, 0xF8, 0xFF, 0x8F, 0xFF, 0xC7, 0xFC,
  0x7F, 0xFE, 0x3F, 0xE3, 0xFF, 0xF0, 0xFF, 0x1F, 0xFF, 0x87, 0xF0, 0xFF,
  0xFC, 0x3F, 0x87, 0xFF, 0xE0, 0xFC, 0x3F, 0xFF, 0x07, 0xE1, 0xFF, 0xF8,
  0x3E, 0x0F, 0xE0, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0x8F, 0xFF, 0xEF, 0x9F, 0xFF, 0xDF, 0x3F, 0xFF, 0x9E, 0x7F, 0xFF, 0x3E,
  0xFF, 0xFE, 0x7D, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF,
  0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0x80, 0x00, 0xFE, 0x00,
  0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0x1F, 0xE1, 0xFF, 0x7F, 0x81, 0xFE, 0xFF, 0x01, 0xFD, 0xFC,
  0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0,
  0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03,
  0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xC0, 0x7F, 0x7F, 0x81, 0xFE, 0x7F, 0x87, 0xFC, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xEF, 0xE0, 0x7F, 0xBF, 0x80,
  0xFE, 0xFE, 0x03, 0xFB, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFE,
  0xFE, 0x03, 0xFB, 0xF8, 0x1F, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x3F,
  0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x1F, 0xE1,
  0xFF, 0x3F, 0x81, 0xFE, 0xFF, 0x01, 0xFD, 0xFE, 0x03, 0xFF, 0xF8, 0x07,
  0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F,
  0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF,
  0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x7F, 0x3F,
  0x81, 0xFE, 0x7F, 0x87, 0xFC, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x02, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xF0, 0x7F, 0xBF,
  0xC1, 0xFE, 0xFF, 0x03, 0xFB, 0xFC, 0x0F, 0xEF, 0xF0, 0x3F, 0xBF, 0xC0,
  0xFE, 0xFF, 0x07, 0xFB, 0xFC, 0x1F, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF,
  0x3F, 0xC3, 0xFC, 0xFF, 0x0F, 0xF1, 0xFC, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F,
  0xE3, 0xFC, 0x3F, 0xCF, 0xF0, 0xFF, 0x3F, 0xC1, 0xFE, 0xFF, 0x07, 0xFB,
  0xFC, 0x1F, 0xEF, 0xF0, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x1F, 0xFE, 0x00,
  0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE7, 0xF8,
  0x7F, 0x9F, 0xE0, 0xFE, 0x7F, 0x83, 0xFD, 0xFE, 0x0F, 0xF7, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01,
  0xFE, 0xFF, 0x03, 0xF9, 0xFC, 0x0F, 0xF7, 0xF0, 0x3F, 0xDF, 0xC0, 0xFF,
  0x7F, 0x83, 0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x0F,
  0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x03,
  0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF,
  0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F,
  0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8,
  0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF,
  0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0,
  0x7F, 0xFF, 0x07, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFC, 0x7F, 0xFF, 0xC1,
  0xFF, 0xFE, 0x07, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x7F, 0x9F,
  0xE0, 0x1F, 0xE7, 0xF8, 0x07, 0xF9, 0xFE, 0x01, 0xFE, 0x7F, 0x80, 0xFF,
  0x0F, 0xF0, 0x3F, 0xC3, 0xFC, 0x0F, 0xF0, 0xFF, 0x03, 0xF8, 0x1F, 0xC0,
  0xFE, 0x07, 0xF0, 0x7F, 0x81, 0xFE, 0x1F, 0xE0, 0x7F, 0x87, 0xF0, 0x0F,
  0xE1, 0xFC, 0x03, 0xF8, 0x7F, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0xCF, 0xE0,
  0x07, 0xF3, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x3F, 0x00, 0x0F, 0xDF,
  0xC0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x07,
  0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0xFE, 0x0F, 0xC0, 0xFF, 0xFC, 0x1F, 0xC3, 0xFF, 0xF8, 0x3F, 0x87,
  0xFF, 0xF0, 0x7F, 0x0F, 0xEF, 0xF1, 0xFE, 0x1F, 0xCF, 0xE3, 0xFC, 0x3F,
  0x9F, 0xC7, 0xFC, 0x7F, 0x3F, 0x8F, 0xF8, 0xFE, 0x7F, 0x1F, 0xF3, 0xF8,
  0xFE, 0x7F, 0xE7, 0xF1, 0xFE, 0xFF, 0xCF, 0xE1, 0xFD, 0xFF, 0x9F, 0xC3,
  0xFB, 0xFF, 0xBF, 0x87, 0xF7, 0xFF, 0x7F, 0x0F, 0xEF, 0xFE, 0xFC, 0x1F,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFB, 0xFF, 0xC0, 0xFF, 0xF7, 0xFF, 0x81, 0xFF, 0xEF, 0xFE, 0x03, 0xFF,
  0x9F, 0xFC, 0x03, 0xFF, 0x3F, 0xF8, 0x07, 0xFE, 0x3F, 0xF0, 0x0F, 0xFC,
  0x7F, 0xE0, 0x1F, 0xF8, 0xFF, 0xC0, 0x3F, 0xE1, 0xFF, 0x00, 0x7F, 0xC3,
  0xFE, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0xFF, 0x07, 0xF8, 0x01, 0xFE, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0xFF, 0x7F, 0x81, 0xFF, 0x3F, 0xC1, 0xFE, 0x3F,
  0xC1, 0xFE, 0x1F, 0xC3, 0xFC, 0x1F, 0xE3, 0xFC, 0x1F, 0xE3, 0xF8, 0x0F,
  0xE7, 0xF8, 0x0F, 0xF7, 0xF0, 0x07, 0xF7, 0xF0, 0x07, 0xFF, 0xE0, 0x03,
  0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x03,
  0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x07, 0xF7, 0xF0, 0x0F, 0xF7, 0xF8, 0x0F,
  0xE7, 0xF8, 0x1F, 0xE3, 0xF8, 0x1F, 0xE3, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F,
  0xC1, 0xFE, 0x7F, 0xC1, 0xFE, 0x7F, 0x81, 0xFF, 0x7F, 0x80, 0xFF, 0xFF,
  0x00, 0xFF, 0x7F, 0x80, 0xFE, 0x7F, 0x81, 0xFE, 0x3F, 0x81, 0xFE, 0x3F,
  0x81, 0xFC, 0x3F, 0xC1, 0xFC, 0x1F, 0xC3, 0xF8, 0x1F, 0xC3, 0xF8, 0x0F,
  0xE3, 0xF8, 0x0F, 0xE7, 0xF0, 0x07, 0xE7, 0xF0, 0x07, 0xF7, 0xE0, 0x07,
  0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0xC0, 0x03, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC,
  0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F,
  0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7,
  0xF3, 0xF9, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F,
  0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7,
  0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC,
  0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x1E, 0xF8, 0x3E, 0x78, 0x3E,
  0x7C, 0x3E, 0x7C, 0x7C, 0x7C, 0x7C, 0x3E, 0x7C, 0x3E, 0xFC, 0x3E, 0xF8,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x7F, 0x07, 0xF8, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7E, 0x03, 0xF0, 0x03,
  0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFE,
  0x7F, 0x9F, 0xC7, 0xF3, 0xF8, 0xFE, 0x00, 0x1F, 0xC0, 0xFF, 0xF8, 0x7F,
  0xFF, 0x1F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFE, 0x3F, 0xBF, 0x87, 0xF7, 0xF0,
  0xFE, 0xFE, 0x1F, 0xDF, 0xE7, 0xFB, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF,
  0xFC, 0x7F, 0xBF, 0x83, 0xE7, 0xF8, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF9, 0xF0, 0x7F, 0xFF, 0x8F, 0xFF,
  0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFE, 0x1F, 0xDF, 0xC3,
  0xFB, 0xF8, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83,
  0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0xFF, 0xC3, 0xFB, 0xF8, 0x7F, 0x7F, 0xFF,
  0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xEF, 0xF8, 0xFC, 0x7C,
  0x00, 0x03, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0xFE, 0x7F, 0xFF,
  0x9F, 0xFF, 0xF7, 0xF1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE1, 0xFF, 0xF8,
  0x7F, 0x7F, 0x1F, 0xDF, 0xFF, 0xF7, 0xFF, 0xF8, 0xFF, 0xFE, 0x1F, 0xFF,
  0x03, 0xFF, 0x80, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0x3F, 0x8F, 0xF7, 0xF3, 0xFF, 0xFE,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xC1, 0xFF,
  0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF,
  0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xFC, 0x3F, 0xBF, 0xFF, 0xF7,
  0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0x7F, 0x07, 0xCF, 0xE0,
  0x03, 0xF8, 0x01, 0xFF, 0xE0, 0x7F, 0xFE, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC,
  0xFF, 0xFF, 0x9F, 0xC3, 0xFB, 0xF8, 0x7F, 0x7F, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x01, 0x8F, 0xFF, 0xF0, 0xFF, 0xFF, 0x1F, 0xFF, 0xE1,
  0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x0F, 0xF0, 0x7F,
  0xC3, 0xFF, 0x0F, 0xFC, 0x7F, 0xF1, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x07, 0xE7, 0xE3, 0xFE, 0xFC, 0xFF, 0xFF,
  0x9F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xC3, 0xFF, 0xF8, 0x7F,
  0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF,
  0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x7F, 0x7F, 0x0F, 0xEF, 0xFF, 0xFD,
  0xFF, 0xFF, 0x9F, 0xFF, 0xF3, 0xFF, 0xFE, 0x3F, 0xFF, 0xC1, 0xFB, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE1, 0x01, 0xFC, 0x38, 0xFF, 0x8F, 0xFF, 0xE1,
  0xFF, 0xFC, 0x7F, 0xFF, 0x07, 0xFF, 0x80, 0x1F, 0xC0, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE7, 0xC3, 0xFB, 0xFC,
  0xFF, 0xFF, 0x3F, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1,
  0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F,
  0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xC0,
  0x3C, 0xFE, 0xFE, 0xFF, 0xFE, 0xFE, 0x3C, 0x00, 0x00, 0xFE, 0xFE, 0xFE,
  0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE,
  0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0x03, 0xC0, 0xFE, 0x0F,
  0xE0, 0xFF, 0x0F, 0xE0, 0x7E, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xEF, 0xFE, 0xFF, 0xEF, 0xFC, 0xFF, 0xCF, 0xF8, 0xFE, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x1F, 0xEF, 0xE3, 0xFC, 0xFE, 0x3F, 0xCF, 0xE7, 0xF8, 0xFE, 0x7F, 0x0F,
  0xEF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80,
  0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x0F, 0xF7, 0xF0, 0xFE, 0x7F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0xCF, 0xE3,
  0xFC, 0xFE, 0x1F, 0xEF, 0xE1, 0xFE, 0xFE, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFE, 0x3E, 0x0F, 0x8F, 0xEF, 0xF3, 0xFC, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x3F, 0xC7, 0xFF, 0xE1, 0xFC, 0x7F, 0xFE, 0x1F, 0xC7, 0xFF, 0xE1, 0xFC,
  0x7F, 0xFE, 0x1F, 0xC7, 0xFF, 0xE1, 0xFC, 0x7F, 0xFE, 0x1F, 0xC7, 0xFF,
  0xE1, 0xFC, 0x7F, 0xFE, 0x1F, 0xC7, 0xFF, 0xE1, 0xFC, 0x7F, 0xFE, 0x1F,
  0xC7, 0xFF, 0xE1, 0xFC, 0x7F, 0xFE, 0x1F, 0xC7, 0xFF, 0xE1, 0xFC, 0x7F,
  0xFE, 0x1F, 0xC7, 0xFF, 0xE1, 0xFC, 0x7F, 0xFE, 0x1F, 0xC7, 0xF0, 0xFC,
  0x7C, 0x3F, 0x3F, 0xCF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF,
  0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE,
  0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87,
  0xFF, 0xE1, 0xFC, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFE, 0x1F, 0xFF,
  0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0xDF, 0xC3, 0xFF, 0xF8, 0x7F, 0xFE, 0x0F,
  0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F,
  0xFF, 0x83, 0xFF, 0xF8, 0x7F, 0x7F, 0x0F, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF,
  0x1F, 0xFF, 0xE1, 0xFF, 0xF8, 0x1F, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x7C,
  0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xBF, 0x87, 0xF7, 0xF0, 0xFE, 0xFE, 0x1F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F,
  0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x87, 0xFF, 0xF0, 0xFE,
  0xFE, 0x1F, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9,
  0xFF, 0xFE, 0x3F, 0x9F, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0x07, 0xC7, 0xE3, 0xFD, 0xFC, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF,
  0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF,
  0x83, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x9F,
  0xFF, 0xF3, 0xFF, 0xFE, 0x3F, 0xDF, 0xC1, 0xF3, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0xFE, 0x7F, 0xEF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x00, 0x07, 0xF0, 0x07, 0xFF, 0x83, 0xFF, 0xF1,
  0xFF, 0xFE, 0x7F, 0xFF, 0x9F, 0x8F, 0xEF, 0xE1, 0xFF, 0xF8, 0x00, 0x7F,
  0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x0F, 0xFF, 0x00, 0xFF,
  0xE0, 0x0F, 0xFB, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0x87, 0xF7, 0xFF, 0xF9,
  0xFF, 0xFE, 0x3F, 0xFF, 0x07, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0x83, 0xF8,
  0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF3, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8,
  0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xFF, 0x3F, 0xF3, 0xFF,
  0x1F, 0xF0, 0xFF, 0x07, 0xF0, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF,
  0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE,
  0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87,
  0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0x7F, 0xFF, 0xCF, 0xF7, 0xF0, 0xF9, 0xFC, 0xFF, 0x0F, 0xF7,
  0xF0, 0xFE, 0x7F, 0x0F, 0xE7, 0xF0, 0xFE, 0x3F, 0x8F, 0xE3, 0xF9, 0xFC,
  0x3F, 0x9F, 0xC3, 0xF9, 0xFC, 0x1F, 0x9F, 0xC1, 0xF9, 0xF8, 0x1F, 0xDF,
  0x81, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF,
  0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0xFC, 0x3E, 0x1F, 0xFF, 0x8F,
  0x87, 0xFF, 0xE3, 0xF1, 0xFB, 0xF8, 0xFC, 0x7E, 0xFE, 0x7F, 0x1F, 0x9F,
  0x9F, 0xCF, 0xE7, 0xE7, 0xFB, 0xF9, 0xF9, 0xFE, 0xFC, 0x7E, 0xFF, 0xBF,
  0x1F, 0xBF, 0xEF, 0xC3, 0xFF, 0xFB, 0xF0, 0xFF, 0xFF, 0xFC, 0x3F, 0xF7,
  0xFE, 0x0F, 0xFD, 0xFF, 0x83, 0xFF, 0x3F, 0xE0, 0x7F, 0xCF, 0xF8, 0x1F,
  0xE3, 0xFE, 0x07, 0xF8, 0xFF, 0x81, 0xFE, 0x3F, 0xC0, 0x7F, 0x87, 0xF0,
  0x0F, 0xE1, 0xFC, 0x03, 0xF0, 0x7F, 0x00, 0xFC, 0x1F, 0xC0, 0x7F, 0x0F,
  0xE7, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF9, 0xFC, 0x1F, 0xDF, 0xC1, 0xFF,
  0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x07,
  0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x00,
  0xFF, 0xF8, 0x1F, 0xFF, 0x81, 0xFD, 0xFC, 0x3F, 0x9F, 0xC3, 0xF9, 0xFC,
  0x3F, 0x8F, 0xE7, 0xF0, 0xFE, 0x7F, 0x0F, 0xF0, 0xFF, 0x0F, 0xF7, 0xF0,
  0xFF, 0x7F, 0x0F, 0xE7, 0xF0, 0xFE, 0x7F, 0x8F, 0xE3, 0xF9, 0xFE, 0x3F,
  0x9F, 0xC3, 0xF9, 0xFC, 0x1F, 0x9F, 0xC1, 0xFF, 0xF8, 0x1F, 0xFF, 0x81,
  0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0,
  0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x1F,
  0xC0, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80,
  0x7F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x80, 0x78, 0x1F, 0x07, 0xF0, 0xFC, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x3F, 0x07, 0xE3, 0xFC, 0x7F, 0x0F, 0x81, 0xF8, 0x3F, 0x83, 0xF8, 0x3F,
  0x03, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x1F, 0x83, 0xF8, 0x3E, 0x03, 0xC0, 0x10,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x60, 0x0F, 0x01, 0xF0, 0x7F,
  0x07, 0xE0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x83, 0xF0, 0x7F, 0x87, 0xF0, 0x3E,
  0x1F, 0xC3, 0xF8, 0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xE0, 0xFC, 0x3F,
  0x83, 0xE0, 0x78, 0x0C, 0x00, 0x0F, 0x00, 0x03, 0xFC, 0x1F, 0x3F, 0xE1,
  0xF7, 0xFF, 0x3F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0xF8, 0xFF, 0xEF, 0x87,
  0xFC, 0xF8, 0x3F, 0x80, 0x01, 0xF0,
};

const GFXglyph RobotoCondensed_Black44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 8, 31, 12, 2, -31 },
  { 32, 12, 12, 14, 1, -33 },
  { 50, 20, 31, 23, 1, -31 },
  { 128, 19, 39, 23, 2, -35 },
  { 221, 24, 31, 28, 2, -31 },
  { 314, 24, 31, 26, 1, -31 },
  { 407, 5, 12, 7, 1, -33 },
  { 415, 10, 45, 14, 3, -35 },
  { 472, 11, 45, 14, 1, -35 },
  { 534, 19, 19, 20, 1, -31 },
  { 580, 18, 22, 20, 1, -26 },
  { 630, 8, 14, 12, 1, -5 },
  { 644, 12, 6, 19, 3, -17 },
  { 653, 8, 7, 13, 3, -7 },
  { 660, 13, 34, 14, 0, -31 },
  { 716, 19, 31, 23, 2, -31 },
  { 790, 13, 31, 23, 3, -31 },
  { 841, 20, 31, 23, 1, -31 },
  { 919, 20, 31, 23, 1, -31 },
  { 997, 20, 31, 23, 1, -31 },
  { 1075, 20, 31, 23, 1, -31 },
  { 1153, 19, 31, 23, 2, -31 },
  { 1227, 20, 31, 23, 1, -31 },
  { 1305, 19, 31, 23, 2, -31 },
  { 1379, 19, 31, 23, 2, -31 },
  { 1453, 8, 24, 13, 3, -24 },
  { 1477, 9, 33, 12, 1, -24 },
  { 1515, 16, 21, 20, 1, -24 },
  { 1557, 17, 16, 23, 3, -22 },
  { 1591, 16, 21, 20, 2, -24 },
  { 1633, 18, 31, 20, 1, -31 },
  { 1703, 31, 40, 34, 1, -30 },
  { 1858, 26, 31, 27, 0, -31 },
  { 1959, 21, 31, 25, 2, -31 },
  { 2041, 22, 31, 25, 2, -31 },
  { 2127, 21, 31, 25, 2, -31 },
  { 2209, 19, 31, 21, 2, -31 },
  { 2283, 18, 31, 21, 2, -31 },
  { 2353, 22, 31, 26, 2, -31 },
  { 2439, 23, 31, 27, 2, -31 },
  { 2529, 8, 31, 12, 2, -31 },
  { 2560, 19, 31, 22, 1, -31 },
  { 2634, 23, 31, 25, 2, -31 },
  { 2724, 18, 31, 21, 2, -31 },
  { 2794, 29, 31, 33, 2, -31 },
  { 2907, 23, 31, 27, 2, -31 },
  { 2997, 23, 31, 27, 2, -31 },
  { 3087, 22, 31, 25, 2, -31 },
  { 3173, 23, 37, 27, 2, -31 },
  { 3280, 22, 31, 25, 2, -31 },
  { 3366, 22, 31, 24, 1, -31 },
  { 3452, 22, 31, 24, 1, -31 },
  { 3538, 21, 31, 25, 2, -31 },
  { 3620, 26, 31, 26, 0, -31 },
  { 3721, 31, 31, 33, 1, -31 },
  { 3842, 24, 31, 25, 0, -31 },
  { 3935, 24, 31, 24, 0, -31 },
  { 4028, 21, 31, 24, 1, -31 },
  { 4110, 9, 45, 12, 2, -37 },
  { 4161, 18, 34, 17, 0, -31 },
  { 4238, 9, 45, 12, 1, -37 },
  { 4289, 16, 16, 18, 1, -31 },
  { 4321, 17, 5, 17, 0, 0 },
  { 4332, 12, 7, 15, 1, -33 },
  { 4343, 19, 23, 21, 1, -23 },
  { 4398, 19, 33, 22, 2, -33 },
  { 4477, 18, 23, 20, 1, -23 },
  { 4529, 19, 33, 22, 1, -33 },
  { 4608, 19, 23, 21, 1, -23 },
  { 4663, 14, 33, 15, 0, -33 },
  { 4721, 19, 32, 22, 1, -23 },
  { 4797, 18, 33, 22, 2, -33 },
  { 4872, 8, 32, 12, 2, -32 },
  { 4904, 12, 41, 11, -2, -32 },
  { 4966, 20, 33, 22, 2, -33 },
  { 5049, 7, 33, 12, 2, -33 },
  { 5078, 28, 23, 32, 2, -23 },
  { 5159, 18, 23, 22, 2, -23 },
  { 5211, 19, 23, 22, 1, -23 },
  { 5266, 19, 32, 22, 2, -23 },
  { 5342, 19, 32, 22, 1, -23 },
  { 5418, 12, 23, 15, 2, -23 },
  { 5453, 18, 23, 20, 1, -23 },
  { 5505, 12, 29, 14, 1, -29 },
  { 5549, 18, 23, 22, 2, -23 },
  { 5601, 20, 23, 20, 0, -23 },
  { 5659, 26, 23, 27, 1, -23 },
  { 5734, 20, 23, 20, 0, -23 },
  { 5792, 20, 32, 20, 0, -23 },
  { 5872, 16, 23, 20, 2, -23 },
  { 5918, 11, 42, 13, 1, -34 },
  { 5976, 4, 37, 11, 4, -31 },
  { 5995, 11, 42, 13, 1, -34 },
  { 6053, 20, 10, 24, 2, -18 },
};

const GFXfont RobotoCondensed_Black44pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Black44pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Black44pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _ROBOTOCONDENSED_BLACK44PT7B_H_
