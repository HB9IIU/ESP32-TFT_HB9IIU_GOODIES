#ifndef _ROBOTOCONDENSED_BLACK62PT7B_H_
#define _ROBOTOCONDENSED_BLACK62PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Black.ttf
// Size: 62pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Black62pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0x7F, 0xEF, 0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F,
  0xCF, 0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F, 0xCF,
  0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x10, 0x1F, 0xC7, 0xFD, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF,
  0x1F, 0xC0, 0x40, 0xFE, 0x3F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF,
  0xE3, 0xFF, 0xF1, 0xFF, 0xF8, 0xFF, 0xF8, 0x7F, 0xFC, 0x3F, 0xFE, 0x1F,
  0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE1, 0xFB, 0xF0, 0xFD, 0xF8,
  0x7E, 0xFC, 0x3F, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x01, 0xF8, 0xF8, 0x00,
  0x0F, 0x8F, 0xC0, 0x00, 0xFC, 0x7E, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x3F,
  0x1F, 0x80, 0x01, 0xF8, 0xFC, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x7E, 0x3E,
  0x00, 0x03, 0xE1, 0xF0, 0x00, 0x1F, 0x1F, 0x80, 0x01, 0xF8, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xC0, 0x7E, 0x3F,
  0x00, 0x03, 0xF1, 0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0xFC, 0x7E, 0x00,
  0x07, 0xE3, 0xF0, 0x00, 0x3F, 0x1F, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x1F,
  0x8F, 0xC0, 0x3F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC,
  0x03, 0xE3, 0xF0, 0x00, 0x3F, 0x1F, 0x80, 0x01, 0xF8, 0xFC, 0x00, 0x0F,
  0xC7, 0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x1F, 0x8F,
  0x80, 0x00, 0xF8, 0xFC, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x7E, 0x3F, 0x00,
  0x03, 0xF1, 0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE3, 0xFF, 0x3F, 0xF9, 0xFF, 0xC7, 0xFF,
  0x7F, 0xE0, 0xFF, 0xDF, 0xF8, 0x3F, 0xF7, 0xFE, 0x0F, 0xFD, 0xFF, 0x83,
  0xFF, 0x7F, 0xE0, 0xFF, 0xDF, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFE, 0x1F, 0xFD, 0xFF, 0xCF, 0xFE, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x40, 0x0F, 0xE7, 0xF0, 0x1C, 0x03, 0xF0,
  0xFE, 0x0F, 0xC0, 0xFC, 0x3F, 0x83, 0xF0, 0x3F, 0x0F, 0xE1, 0xF8, 0x0F,
  0xC3, 0xF8, 0x7E, 0x03, 0xF0, 0xFE, 0x3F, 0x00, 0xFC, 0x3F, 0x8F, 0xC0,
  0x3F, 0x0F, 0xE7, 0xE0, 0x0F, 0xC3, 0xF9, 0xF0, 0x03, 0xF9, 0xFC, 0xFC,
  0x00, 0x7F, 0xFF, 0x3E, 0x00, 0x1F, 0xFF, 0xDF, 0x80, 0x03, 0xFF, 0xEF,
  0xC0, 0x00, 0x7F, 0xF3, 0xF0, 0x00, 0x0F, 0xF9, 0xF8, 0x00, 0x00, 0x20,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x01, 0xF9, 0xFF, 0x00, 0x00, 0xFC, 0xFF, 0xE0,
  0x00, 0x3F, 0x7F, 0xFC, 0x00, 0x1F, 0xBF, 0xFF, 0x80, 0x07, 0xEF, 0xFF,
  0xE0, 0x03, 0xF7, 0xF1, 0xFC, 0x00, 0xF9, 0xFC, 0x7F, 0x00, 0x7E, 0x7F,
  0x0F, 0xC0, 0x1F, 0x1F, 0x83, 0xF0, 0x0F, 0xC7, 0xE0, 0xFC, 0x07, 0xE1,
  0xF8, 0x3F, 0x01, 0xF8, 0x7E, 0x0F, 0xC0, 0xFC, 0x1F, 0xC3, 0xF0, 0x3F,
  0x07, 0xF0, 0xFC, 0x0F, 0x81, 0xFE, 0x7F, 0x00, 0xE0, 0x3F, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x07,
  0xFC, 0x3F, 0xC0, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x7F, 0xC3, 0xFC, 0x00,
  0x1F, 0xF0, 0xFF, 0x00, 0x07, 0xFC, 0x3F, 0xC0, 0x01, 0xFF, 0x0F, 0xF0,
  0x00, 0x7F, 0xC7, 0xF8, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0x07, 0xF8, 0x1F, 0xFF, 0xE1, 0xFE, 0x07, 0xFF, 0xF8, 0x7F, 0x83,
  0xFF, 0xFF, 0x1F, 0xE1, 0xFF, 0xFF, 0xEF, 0xF8, 0x7F, 0xDF, 0xFF, 0xFE,
  0x3F, 0xF7, 0xFF, 0xFF, 0x8F, 0xFC, 0xFF, 0xFF, 0xC3, 0xFF, 0x1F, 0xFF,
  0xF0, 0xFF, 0xC7, 0xFF, 0xFC, 0x3F, 0xF0, 0xFF, 0xFF, 0x0F, 0xFC, 0x1F,
  0xFF, 0x83, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xFC,
  0x7F, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xDF, 0xFC, 0x03, 0xFF, 0xC3, 0xFF, 0x80, 0x0F, 0x80, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE,
  0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0x00, 0x08, 0x00, 0xE0, 0x07, 0xC0,
  0x3F, 0x01, 0xFC, 0x07, 0xF0, 0x3F, 0x81, 0xFE, 0x07, 0xF0, 0x3F, 0x80,
  0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x81,
  0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFF, 0x01, 0xFC, 0x07,
  0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xF0,
  0x1F, 0xC0, 0x3F, 0x00, 0x7C, 0x00, 0xE0, 0x00, 0x80, 0x60, 0x00, 0xE0,
  0x01, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0,
  0x3F, 0xC0, 0x3F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0xFF, 0x01, 0xFE, 0x01,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03,
  0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x81, 0xFF,
  0x03, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x81,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x01, 0xFE,
  0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x81, 0xFE, 0x03, 0xF8, 0x07,
  0xE0, 0x07, 0x80, 0x0E, 0x00, 0x10, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x07, 0x01, 0xF8, 0x0C,
  0x7C, 0x1F, 0x83, 0xC7, 0xF9, 0xF0, 0xFE, 0xFF, 0xFF, 0x7F, 0xEF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x01,
  0xFB, 0xF0, 0x00, 0x3F, 0xBF, 0x80, 0x07, 0xF1, 0xFC, 0x00, 0xFE, 0x0F,
  0xE0, 0x1F, 0xE0, 0xFF, 0x01, 0xFC, 0x07, 0xF0, 0x07, 0x80, 0x3E, 0x00,
  0x38, 0x03, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x1F, 0xF1, 0xFE, 0x1F, 0xE1, 0xFE, 0x1F, 0xE3, 0xFC,
  0x3F, 0xC7, 0xF8, 0x7F, 0x0F, 0xF0, 0x3E, 0x00, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x0E, 0x0F, 0xF3, 0xFF, 0x7F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x7F, 0xC7, 0xF0, 0x10, 0x00, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFC, 0x7F, 0xF7, 0xFF, 0x1F, 0xF8, 0x7F, 0xE7, 0xFC, 0x1F, 0xFB, 0xFF,
  0x03, 0xFE, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFC, 0x0F, 0xF9, 0xFF, 0x07, 0xFE, 0x7F, 0xE1, 0xFF, 0x9F,
  0xFD, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x01, 0xF0, 0x03, 0xFC,
  0x03, 0xFF, 0x07, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xF0, 0x3F,
  0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC,
  0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00,
  0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F,
  0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC,
  0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00,
  0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFB, 0xFF, 0xCF, 0xFC, 0x3F, 0xFB, 0xFF, 0x83, 0xFF, 0x7F, 0xE0, 0x7F,
  0xEF, 0xFC, 0x0F, 0xFD, 0xFF, 0x81, 0xFF, 0xBF, 0xF0, 0x3F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x1F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x7F, 0xFB, 0xFF, 0xDF, 0xFC,
  0x1F, 0xFB, 0xFF, 0x03, 0xFF, 0x7F, 0xE0, 0x3F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE7, 0xFF,
  0x9F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07,
  0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x03, 0xFB,
  0xFF, 0x00, 0x7F, 0x7F, 0xE0, 0x1F, 0xEF, 0xFC, 0x03, 0xF9, 0xFF, 0x80,
  0xFF, 0x3F, 0xF0, 0x1F, 0xC7, 0xFE, 0x07, 0xF8, 0xFF, 0xC0, 0xFF, 0x1F,
  0xF8, 0x3F, 0xC3, 0xFF, 0x07, 0xF8, 0x7F, 0xE1, 0xFF, 0x0F, 0xFC, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC,
  0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0x3F, 0x00, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x1F,
  0xF0, 0xFF, 0xF0, 0x3C, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0x3F, 0xF0, 0x7F, 0xE7, 0xFF,
  0xBF, 0xFC, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF,
  0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x3F, 0x80, 0xFF,
  0xDF, 0xFC, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF7, 0xFF,
  0x0F, 0xFE, 0xFF, 0xC0, 0xFF, 0xDF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x1F, 0xF9,
  0xFF, 0x03, 0xFF, 0x3F, 0xF0, 0xFF, 0xE7, 0xFF, 0x3F, 0xF8, 0x7F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x40,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x7F, 0xF3, 0xFF, 0x9F,
  0xF8, 0x7F, 0xE7, 0xFE, 0x1F, 0xFB, 0xFF, 0x87, 0xFE, 0xFF, 0xC1, 0xFF,
  0xBF, 0xF0, 0x7F, 0xE7, 0xFC, 0x1F, 0xF9, 0xFF, 0x87, 0xFE, 0x7F, 0xE1,
  0xFF, 0x9F, 0xF8, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC7, 0xFE, 0x3F, 0xF9, 0xFF, 0x87,
  0xFE, 0xFF, 0xC0, 0xFF, 0xBF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0xFF, 0xE7, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFC, 0x7F, 0xF7, 0xFF, 0x1F, 0xF8, 0x7F, 0xEF, 0xFC, 0x1F, 0xFB,
  0xFF, 0x07, 0xFE, 0xFF, 0xC0, 0xFF, 0xBF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFE, 0x1F, 0xFD, 0xFF, 0xCF, 0xFF, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x81, 0xFF,
  0xBF, 0xE0, 0x1F, 0x9F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFC,
  0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x07, 0xFF,
  0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1E, 0x0F, 0xF1, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x7F, 0xC7, 0xF0, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0E, 0x07, 0xF1, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xC7, 0xF0, 0x10, 0x00, 0x03, 0x00, 0xFF, 0x0F, 0xFC, 0x7F, 0xE7, 0xFF,
  0xBF, 0xFD, 0xFF, 0xC7, 0xFE, 0x3F, 0xF0, 0xFE, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x07,
  0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0xFF, 0x07, 0xF8, 0x3F, 0x83, 0xFC,
  0x1F, 0xC1, 0xFE, 0x03, 0xE0, 0x06, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x70, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xF0,
  0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xC0, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x0F, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x7F, 0xFE, 0x07, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0,
  0x3F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x7F, 0xF7,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC,
  0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x0F, 0xC0, 0x3F,
  0x07, 0xF0, 0x0F, 0xFE, 0x03, 0xF0, 0xFC, 0x03, 0xFF, 0xF0, 0x7E, 0x3F,
  0x80, 0xFF, 0xFF, 0x0F, 0xC7, 0xE0, 0x3F, 0xFF, 0xE0, 0xFC, 0xFC, 0x07,
  0xFF, 0xFC, 0x1F, 0xBF, 0x81, 0xFE, 0x3F, 0x83, 0xF7, 0xF0, 0x3F, 0x87,
  0xF0, 0x7E, 0xFC, 0x0F, 0xE0, 0xFE, 0x0F, 0xDF, 0x81, 0xFC, 0x1F, 0x81,
  0xFB, 0xF0, 0x7F, 0x03, 0xF0, 0x3F, 0xFE, 0x0F, 0xE0, 0x7E, 0x07, 0xFF,
  0xC1, 0xFC, 0x0F, 0xC0, 0xFF, 0xF8, 0x3F, 0x81, 0xF8, 0x1F, 0xFE, 0x0F,
  0xF0, 0x3F, 0x03, 0xFF, 0xC1, 0xFE, 0x0F, 0xE0, 0x7F, 0xF8, 0x3F, 0x81,
  0xFC, 0x0F, 0xFF, 0x07, 0xF0, 0x3F, 0x81, 0xFF, 0xE0, 0xFE, 0x07, 0xF0,
  0x3F, 0xFC, 0x1F, 0xC0, 0xFE, 0x07, 0xDF, 0x83, 0xF8, 0x1F, 0xC1, 0xFB,
  0xF0, 0x7F, 0x83, 0xF8, 0x3F, 0x7F, 0x0F, 0xF0, 0xFF, 0x07, 0xEF, 0xE1,
  0xFE, 0x1F, 0xE1, 0xF9, 0xFC, 0x1F, 0xE7, 0xFC, 0x3F, 0x1F, 0x83, 0xFF,
  0xFF, 0xDF, 0xC3, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0x07, 0xFF, 0xFF,
  0xFE, 0x0F, 0xE0, 0x7F, 0xE7, 0xFF, 0x81, 0xFC, 0x07, 0xF8, 0x7F, 0xC0,
  0x1F, 0xC0, 0x3C, 0x03, 0xE0, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0x7F,
  0xC0, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x07,
  0xFE, 0x7F, 0xC0, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x01, 0xFF, 0x1F, 0xF8,
  0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0xFF, 0xC3, 0xFE, 0x00, 0x07, 0xFE,
  0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x03, 0xFF, 0x07, 0xFE, 0x00,
  0x1F, 0xF8, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x0F, 0xFC, 0x07,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xC1, 0xFF, 0x80, 0x0F, 0xFE, 0x1F, 0xFC, 0x00, 0x3F, 0xF0,
  0xFF, 0xE0, 0x01, 0xFF, 0xC7, 0xFF, 0x00, 0x0F, 0xFE, 0x7F, 0xF0, 0x00,
  0x7F, 0xF3, 0xFF, 0x80, 0x03, 0xFF, 0x9F, 0xFC, 0x00, 0x0F, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xF0, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xC0,
  0xFF, 0xFB, 0xFF, 0x00, 0xFF, 0xEF, 0xFC, 0x03, 0xFF, 0xBF, 0xF0, 0x07,
  0xFE, 0xFF, 0xC0, 0x1F, 0xFB, 0xFF, 0x00, 0x7F, 0xEF, 0xFC, 0x01, 0xFF,
  0xBF, 0xF0, 0x0F, 0xFE, 0xFF, 0xC0, 0x3F, 0xF3, 0xFF, 0x01, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xF3, 0xFF, 0x00, 0xFF, 0xEF, 0xFC, 0x03, 0xFF, 0xBF, 0xF0, 0x07,
  0xFE, 0xFF, 0xC0, 0x1F, 0xFB, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xEF,
  0xFC, 0x03, 0xFF, 0xBF, 0xF0, 0x1F, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xFC, 0x3F, 0xF8, 0x1F, 0xFE, 0x3F, 0xF0, 0x07, 0xFE, 0x7F, 0xF0, 0x07,
  0xFE, 0x7F, 0xF0, 0x07, 0xFF, 0x7F, 0xE0, 0x03, 0xFF, 0x7F, 0xE0, 0x03,
  0xFF, 0x7F, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x03,
  0xFF, 0x7F, 0xE0, 0x03, 0xFF, 0x7F, 0xE0, 0x03, 0xFF, 0x7F, 0xE0, 0x07,
  0xFF, 0x7F, 0xE0, 0x07, 0xFF, 0x7F, 0xF0, 0x07, 0xFE, 0x3F, 0xF0, 0x0F,
  0xFE, 0x3F, 0xF8, 0x1F, 0xFE, 0x1F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x01, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFC, 0xFF, 0xC3,
  0xFF, 0xE7, 0xFE, 0x07, 0xFF, 0xBF, 0xF0, 0x1F, 0xFD, 0xFF, 0x80, 0x7F,
  0xEF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xC0, 0x3F, 0xF7, 0xFE, 0x03, 0xFF, 0xBF, 0xF0, 0x3F, 0xFD,
  0xFF, 0x83, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xFC, 0xFF, 0xF0, 0x3F, 0xF9, 0xFF, 0xC0, 0x3F, 0xF3, 0xFF, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFD, 0xFF, 0x80, 0x1F, 0xFB, 0xFF, 0x80, 0x3F, 0xF7, 0xFF, 0x80,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0,
  0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xDF, 0xFC, 0x1F, 0xF9, 0xFF,
  0x83, 0xFF, 0x3F, 0xF8, 0xFF, 0xE7, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x40, 0x00,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFE, 0xFF, 0xC0, 0x3F, 0xFE,
  0xFF, 0xC0, 0x3F, 0xFC, 0xFF, 0xC0, 0x7F, 0xF8, 0xFF, 0xC0, 0x7F, 0xF8,
  0xFF, 0xC0, 0xFF, 0xF0, 0xFF, 0xC0, 0xFF, 0xF0, 0xFF, 0xC1, 0xFF, 0xE0,
  0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0xC3, 0xFF, 0x80,
  0xFF, 0xC3, 0xFF, 0x00, 0xFF, 0xC7, 0xFF, 0x00, 0xFF, 0xC7, 0xFE, 0x00,
  0xFF, 0xCF, 0xFE, 0x00, 0xFF, 0xDF, 0xFC, 0x00, 0xFF, 0xDF, 0xF8, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFB, 0xFF, 0x80,
  0xFF, 0xF3, 0xFF, 0xC0, 0xFF, 0xE1, 0xFF, 0xC0, 0xFF, 0xC1, 0xFF, 0xE0,
  0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0xF0,
  0xFF, 0xC0, 0x7F, 0xF0, 0xFF, 0xC0, 0x7F, 0xF8, 0xFF, 0xC0, 0x7F, 0xF8,
  0xFF, 0xC0, 0x3F, 0xFC, 0xFF, 0xC0, 0x3F, 0xFC, 0xFF, 0xC0, 0x1F, 0xFE,
  0xFF, 0xC0, 0x1F, 0xFE, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFD, 0xFC, 0x1F,
  0xDF, 0xFF, 0xFE, 0xFE, 0x0F, 0xEF, 0xFF, 0xFF, 0x7F, 0x8F, 0xF7, 0xFF,
  0xFF, 0x9F, 0xC7, 0xF3, 0xFF, 0xFF, 0xCF, 0xE3, 0xF9, 0xFF, 0xFF, 0xE7,
  0xF1, 0xFC, 0xFF, 0xFF, 0xF3, 0xFD, 0xFE, 0x7F, 0xFF, 0xF8, 0xFE, 0xFE,
  0x3F, 0xFF, 0xFC, 0x7F, 0x7F, 0x1F, 0xFF, 0xFE, 0x3F, 0xBF, 0x8F, 0xFF,
  0xFF, 0x1F, 0xDF, 0xC7, 0xFF, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xFF, 0xC3,
  0xFF, 0xE1, 0xFF, 0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x7F, 0xF0,
  0x7F, 0xFF, 0xF8, 0x3F, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xFC, 0x1F, 0xFF,
  0xFE, 0x0F, 0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFE, 0x07, 0xFF, 0xFF, 0x81,
  0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xC0,
  0xFF, 0xFF, 0xF0, 0x1F, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xE0, 0x3F, 0xF0,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xDF, 0x87, 0xFF,
  0xFF, 0xDF, 0xC7, 0xFF, 0xFF, 0xCF, 0xC7, 0xFF, 0xFF, 0xCF, 0xE7, 0xFF,
  0xFF, 0xCF, 0xE7, 0xFF, 0xFF, 0xC7, 0xE7, 0xFF, 0xFF, 0xC7, 0xF7, 0xFF,
  0xFF, 0xC3, 0xF7, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFE, 0x0F,
  0xFF, 0x0F, 0xFE, 0x03, 0xFF, 0xCF, 0xFE, 0x00, 0xFF, 0xE7, 0xFF, 0x00,
  0x3F, 0xF3, 0xFF, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x0F, 0xFE, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFD,
  0xFF, 0x80, 0x0F, 0xFE, 0xFF, 0xC0, 0x07, 0xFF, 0x7F, 0xE0, 0x03, 0xFF,
  0x3F, 0xF8, 0x01, 0xFF, 0x9F, 0xFC, 0x01, 0xFF, 0xC7, 0xFF, 0x00, 0xFF,
  0xE3, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x04, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE,
  0xFF, 0xC0, 0x7F, 0xFB, 0xFF, 0x00, 0xFF, 0xEF, 0xFC, 0x01, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFB, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFE, 0x0F, 0xFF, 0x0F, 0xFE, 0x01, 0xFF,
  0xC7, 0xFE, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x3F, 0xF3, 0xFF, 0x80, 0x1F,
  0xFD, 0xFF, 0x80, 0x0F, 0xFE, 0xFF, 0xC0, 0x07, 0xFF, 0x7F, 0xE0, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x1F, 0xFD, 0xFF, 0x80, 0x0F, 0xFE, 0xFF,
  0xC0, 0x07, 0xFF, 0x7F, 0xF0, 0x03, 0xFF, 0xBF, 0xF8, 0x01, 0xFF, 0x8F,
  0xFC, 0x01, 0xFF, 0xC7, 0xFF, 0x00, 0xFF, 0xE3, 0xFF, 0xC1, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x05, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x02, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0xFC, 0xFF, 0xC0, 0x7F, 0xF9, 0xFF, 0x80, 0x7F, 0xF3, 0xFF, 0x00, 0xFF,
  0xE7, 0xFE, 0x00, 0xFF, 0xCF, 0xFC, 0x01, 0xFF, 0x9F, 0xF8, 0x03, 0xFF,
  0x3F, 0xF0, 0x07, 0xFE, 0x7F, 0xE0, 0x0F, 0xFC, 0xFF, 0xC0, 0x1F, 0xF9,
  0xFF, 0x80, 0x7F, 0xF3, 0xFF, 0x00, 0xFF, 0xE7, 0xFE, 0x07, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFC, 0x7F, 0xF8, 0x1F, 0xF8,
  0x7F, 0xF0, 0x3F, 0xF0, 0xFF, 0xE0, 0x7F, 0xE0, 0xFF, 0xE0, 0xFF, 0xC1,
  0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0xC3, 0xFF, 0x03, 0xFF, 0x87, 0xFE, 0x07,
  0xFF, 0x0F, 0xFC, 0x07, 0xFF, 0x1F, 0xF8, 0x0F, 0xFE, 0x3F, 0xF0, 0x1F,
  0xFE, 0x7F, 0xE0, 0x1F, 0xFC, 0xFF, 0xC0, 0x3F, 0xF9, 0xFF, 0x80, 0x3F,
  0xFB, 0xFF, 0x00, 0x7F, 0xF7, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xE0, 0xFF, 0xE7, 0xFF,
  0x01, 0xFF, 0xDF, 0xFC, 0x07, 0xFF, 0x7F, 0xF0, 0x1F, 0xFD, 0xFF, 0xC0,
  0x3F, 0xF7, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xDF, 0xF8, 0x07, 0xFF,
  0x7F, 0xF0, 0x1F, 0xF9, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x06,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0x9F, 0xFC, 0x0F,
  0xFE, 0x7F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0xFF, 0xF7, 0xFF, 0x00, 0x0F, 0xFF, 0x7F, 0xF0, 0x00, 0xFF,
  0xE7, 0xFF, 0x80, 0x0F, 0xFE, 0x3F, 0xF8, 0x01, 0xFF, 0xE3, 0xFF, 0x80,
  0x1F, 0xFC, 0x3F, 0xF8, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x1F, 0xFC, 0x1F,
  0xFC, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x3F, 0xF8, 0x1F, 0xFC, 0x03, 0xFF,
  0x81, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xE0,
  0x3F, 0xF0, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x7F, 0xF0, 0x07,
  0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x07, 0xFF, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0xFF, 0xE0, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x3F, 0xF0,
  0xFF, 0xC0, 0x01, 0xFF, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0xFF, 0x80, 0x01,
  0xFF, 0x9F, 0xF8, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x00, 0xFF, 0x9F, 0xF8,
  0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x00, 0xFF, 0xDF, 0xF0, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xFF, 0xFC,
  0x07, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xE0, 0x7F, 0xF7, 0xFE, 0x07,
  0xFE, 0x07, 0xFE, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xE7, 0xFE, 0x07, 0xFE,
  0x07, 0xFE, 0x7F, 0xE0, 0xFF, 0xE0, 0x7F, 0xE7, 0xFE, 0x0F, 0xFF, 0x07,
  0xFE, 0x7F, 0xE0, 0xFF, 0xF0, 0x7F, 0xE3, 0xFF, 0x0F, 0xFF, 0x0F, 0xFC,
  0x3F, 0xF0, 0xFF, 0xF0, 0xFF, 0xC3, 0xFF, 0x0F, 0xFF, 0x0F, 0xFC, 0x3F,
  0xF1, 0xFF, 0xF8, 0xFF, 0xC3, 0xFF, 0x1F, 0xFF, 0x8F, 0xFC, 0x3F, 0xF1,
  0xFF, 0xF8, 0xFF, 0xC1, 0xFF, 0x9F, 0xFF, 0x9F, 0xF8, 0x1F, 0xF9, 0xFF,
  0xF9, 0xFF, 0x81, 0xFF, 0xBF, 0xFF, 0xDF, 0xF8, 0x1F, 0xFB, 0xFF, 0xFD,
  0xFF, 0x81, 0xFF, 0xBF, 0xFF, 0xDF, 0xF8, 0x1F, 0xFB, 0xFF, 0xFD, 0xFF,
  0x80, 0xFF, 0xBF, 0xFF, 0xDF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFB, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0x9F, 0xFF, 0xE0, 0x07, 0xFF, 0xF9, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x9F,
  0xFF, 0xE0, 0x07, 0xFF, 0xF9, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x1F, 0xFF,
  0xE0, 0x07, 0xFF, 0xF0, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x0F, 0xFF, 0xC0,
  0x03, 0xFF, 0xF0, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x0F, 0xFF, 0xC0, 0x03,
  0xFF, 0xF0, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0x03, 0xFF,
  0xE0, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0,
  0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x3F,
  0xF8, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x03, 0xFF, 0xDF,
  0xFE, 0x00, 0xFF, 0xF3, 0xFF, 0x80, 0x3F, 0xF8, 0xFF, 0xF0, 0x1F, 0xFE,
  0x1F, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF,
  0xE0, 0x3F, 0xF8, 0x3F, 0xF8, 0x07, 0xFE, 0x0F, 0xFC, 0x01, 0xFF, 0xC7,
  0xFF, 0x00, 0x7F, 0xF1, 0xFF, 0x80, 0x0F, 0xFC, 0x7F, 0xE0, 0x03, 0xFF,
  0xBF, 0xF8, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xEF, 0xFC, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x0F, 0xFE, 0xFF, 0xE0, 0x03,
  0xFF, 0x1F, 0xF8, 0x01, 0xFF, 0xC7, 0xFF, 0x00, 0x7F, 0xF1, 0xFF, 0xC0,
  0x3F, 0xF8, 0x3F, 0xF8, 0x0F, 0xFE, 0x0F, 0xFE, 0x07, 0xFF, 0x83, 0xFF,
  0x81, 0xFF, 0xC0, 0x7F, 0xF0, 0x7F, 0xF0, 0x1F, 0xFC, 0x3F, 0xFC, 0x07,
  0xFF, 0x8F, 0xFE, 0x00, 0xFF, 0xE7, 0xFF, 0x80, 0x3F, 0xFD, 0xFF, 0xE0,
  0x0F, 0xFF, 0x7F, 0xF0, 0x01, 0xFF, 0xDF, 0xFC, 0x00, 0xFF, 0xE7, 0xFF,
  0x00, 0x3F, 0xF8, 0xFF, 0xC0, 0x0F, 0xFC, 0x3F, 0xF8, 0x07, 0xFF, 0x07,
  0xFE, 0x01, 0xFF, 0xC1, 0xFF, 0x80, 0x7F, 0xE0, 0x7F, 0xF0, 0x1F, 0xF8,
  0x0F, 0xFC, 0x0F, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0xFF,
  0xC0, 0x1F, 0xF8, 0x7F, 0xE0, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0xFF, 0x87,
  0xFC, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x07, 0xFC, 0xFF, 0xC0, 0x01, 0xFF,
  0x3F, 0xE0, 0x00, 0x7F, 0xEF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xCF, 0xFC, 0xFF, 0xCF, 0xFC, 0xFF, 0xCF, 0xFC, 0xFF, 0xCF,
  0xFC, 0xFF, 0xCF, 0xFC, 0xFF, 0xCF, 0xFC, 0xFF, 0xCF, 0xFC, 0xFF, 0xCF,
  0xFC, 0xFF, 0xCF, 0xFC, 0xFF, 0xCF, 0xFC, 0xFF, 0xCF, 0xFC, 0xFF, 0xCF,
  0xFC, 0xFF, 0xCF, 0xFC, 0xFF, 0xCF, 0xFC, 0xFF, 0xCF, 0xFC, 0xFF, 0xCF,
  0xFC, 0xFF, 0xCF, 0xFC, 0xFF, 0xCF, 0xFC, 0xFF, 0xCF, 0xFC, 0xFF, 0xCF,
  0xFC, 0xFF, 0xCF, 0xFC, 0xFF, 0xCF, 0xFC, 0xFF, 0xCF, 0xFC, 0xFF, 0xCF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3,
  0xFF, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F,
  0xE3, 0xFF, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC,
  0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F,
  0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF,
  0x8F, 0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1,
  0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F,
  0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x07, 0xEF, 0xC0, 0x0F, 0xDF, 0x80,
  0x3F, 0xBF, 0x80, 0x7F, 0x7F, 0x00, 0xFC, 0x7E, 0x03, 0xF8, 0xFE, 0x07,
  0xF1, 0xFC, 0x1F, 0xC1, 0xFC, 0x3F, 0x83, 0xF8, 0x7F, 0x07, 0xF1, 0xFE,
  0x0F, 0xF3, 0xF8, 0x0F, 0xE7, 0xF0, 0x1F, 0xDF, 0xE0, 0x3F, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xFC, 0x07, 0xFC,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0xFF, 0xE3, 0xFF, 0x3F,
  0xF0, 0xFF, 0xCF, 0xFC, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF1, 0xFF, 0xEF, 0xFC, 0xFF,
  0xE3, 0xFF, 0x3F, 0xF0, 0xFF, 0xCF, 0xFC, 0x3F, 0xF3, 0xFF, 0x0F, 0xFC,
  0xFF, 0x83, 0xFF, 0x3F, 0xF0, 0xFF, 0xCF, 0xFC, 0x3F, 0xF3, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF8, 0xFF,
  0xF7, 0xFE, 0x1F, 0xFD, 0xFF, 0x83, 0xFE, 0x7F, 0xF0, 0x08, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x40, 0x0F, 0xFC, 0xFF,
  0x03, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFD, 0xFF, 0xEF,
  0xFC, 0x1F, 0xFB, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFB, 0xFF, 0xCF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF,
  0xBF, 0xFE, 0x3F, 0xEF, 0xFF, 0x0F, 0xF8, 0xFF, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFE, 0x7F, 0xF3, 0xFF, 0x7F, 0xE0, 0xFF, 0xBF, 0xF0, 0x7F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x03, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xDF, 0xFD, 0xFF,
  0xCF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x08, 0x3F, 0xF0,
  0x3F, 0xCF, 0xFC, 0x3F, 0xFB, 0xFF, 0x1F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xCF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0x7F, 0xC3, 0xFF, 0x9F, 0xF0, 0x3F, 0xC7, 0xFC, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0,
  0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFB, 0xFF, 0x8F, 0xFC, 0x1F, 0xF9,
  0xFF, 0x03, 0xFF, 0x7F, 0xE0, 0x3F, 0xEF, 0xFC, 0x07, 0xFD, 0xFF, 0x80,
  0xFF, 0xBF, 0xF0, 0x1F, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x04, 0x0F, 0xFE, 0x01, 0xC1, 0xFF, 0xF1, 0xF8, 0x1F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x0F, 0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xF0, 0x3F,
  0xFE, 0x0F, 0xFF, 0xC3, 0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0xFE, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF,
  0x07, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF,
  0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x87, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC,
  0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8,
  0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0,
  0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0,
  0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0,
  0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xC7, 0xFC, 0x1F, 0xFE, 0xFF, 0x8F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x7F, 0xFB,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFD, 0xFF,
  0xE7, 0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0x7F, 0xE0, 0x7F,
  0xCF, 0xFC, 0x00, 0x81, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE,
  0x00, 0x01, 0xFF, 0x81, 0xC0, 0x7F, 0xF0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x7F, 0x83, 0xFF,
  0x3F, 0xF8, 0xFF, 0xDF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFD, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFC, 0x1E, 0x1F, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x8F, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x07, 0xF8, 0x1F, 0xF8, 0x3F,
  0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x03, 0xFC, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07,
  0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF,
  0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0,
  0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F,
  0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC,
  0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07,
  0xFE, 0x0F, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xBF, 0xFE,
  0x7F, 0xFC, 0xFF, 0xF1, 0xFF, 0x83, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC1, 0xFF,
  0xEF, 0xFC, 0x1F, 0xFC, 0xFF, 0xC3, 0xFF, 0xCF, 0xFC, 0x7F, 0xF8, 0xFF,
  0xC7, 0xFF, 0x0F, 0xFC, 0xFF, 0xE0, 0xFF, 0xCF, 0xFE, 0x0F, 0xFD, 0xFF,
  0xC0, 0xFF, 0xDF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xEF, 0xFE, 0x0F, 0xFC, 0x7F, 0xE0, 0xFF, 0xC7, 0xFF,
  0x0F, 0xFC, 0x7F, 0xF0, 0xFF, 0xC3, 0xFF, 0x8F, 0xFC, 0x3F, 0xF8, 0xFF,
  0xC1, 0xFF, 0xCF, 0xFC, 0x1F, 0xFC, 0xFF, 0xC1, 0xFF, 0xEF, 0xFC, 0x0F,
  0xFE, 0xFF, 0xC0, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x01, 0x00, 0xFF, 0x87, 0xF8,
  0x1F, 0xE0, 0xFF, 0x9F, 0xFC, 0x3F, 0xF8, 0xFF, 0xBF, 0xFE, 0x7F, 0xFC,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xF7, 0xFF, 0xEF,
  0xFF, 0xFF, 0xC3, 0xFF, 0x87, 0xFF, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0xFF,
  0xC1, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF,
  0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0x83, 0xFF,
  0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0xFF, 0xC1,
  0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0x83,
  0xFF, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0xFF,
  0xC1, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF,
  0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0x83, 0xFF,
  0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0xFF, 0xC1,
  0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0x83,
  0xFF, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF1, 0xFF,
  0x0F, 0xFC, 0xFF, 0xE3, 0xFF, 0x7F, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xF0, 0x00, 0x04, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFB, 0xFF, 0xCF, 0xFC, 0x1F, 0xFB, 0xFF, 0x03, 0xFF, 0x7F, 0xE0,
  0x7F, 0xEF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFE, 0xFF, 0xC0, 0xFF, 0xCF, 0xFC, 0x1F,
  0xF9, 0xFF, 0xEF, 0xFF, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x01, 0x00, 0x3F,
  0xE3, 0xFC, 0x0F, 0xFB, 0xFF, 0xC3, 0xFE, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xF7,
  0xFF, 0xBF, 0xF0, 0x7F, 0xEF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x7F, 0xEF, 0xFF, 0x7F, 0xFB,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x3F, 0xF3, 0xFC, 0x0F, 0xFC,
  0x10, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x20, 0x00, 0x01, 0xFF, 0x1F, 0xF0,
  0xFF, 0xE7, 0xFC, 0x7F, 0xFD, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x3F, 0xFD, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0x0F, 0xFE, 0xFF, 0xC0, 0xFF, 0x3F, 0xF0, 0x06, 0x0F, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC7, 0xFF, 0xE7, 0xFF, 0xF7, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFC, 0x7F, 0xE7, 0xFF, 0x7F, 0xE1, 0xFF, 0xBF, 0xE0, 0xFF, 0xDF, 0xF0,
  0x7F, 0xEF, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFC,
  0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F,
  0xDF, 0xF0, 0x7F, 0xEF, 0xFE, 0x7F, 0xF7, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x00, 0xFF,
  0xF0, 0x00, 0x02, 0x00, 0x00, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0xFF,
  0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF,
  0xEF, 0xFF, 0xF8, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFF, 0xF1, 0xFF, 0xFC,
  0x7F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFE, 0x01,
  0xFF, 0x80, 0x02, 0x00, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF0, 0x3F, 0xF7, 0xFC, 0x0F, 0xFD, 0xFF, 0x83, 0xFF, 0x7F, 0xE0,
  0xFF, 0xDF, 0xFE, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF1, 0xFF, 0xF7, 0xFC, 0x3F, 0xF9, 0xFF,
  0x07, 0xFC, 0x7F, 0xC0, 0x10, 0x00, 0x00, 0x7F, 0xE0, 0x7F, 0xF7, 0xFE,
  0x07, 0xFF, 0x7F, 0xE0, 0x7F, 0xE7, 0xFF, 0x07, 0xFE, 0x3F, 0xF0, 0x7F,
  0xE3, 0xFF, 0x0F, 0xFE, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x1F,
  0xF0, 0xFF, 0xC1, 0xFF, 0x8F, 0xF8, 0x1F, 0xF8, 0xFF, 0x80, 0xFF, 0x9F,
  0xF8, 0x0F, 0xF9, 0xFF, 0x80, 0xFF, 0x9F, 0xF0, 0x0F, 0xF9, 0xFF, 0x00,
  0x7F, 0xDF, 0xF0, 0x07, 0xFD, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0,
  0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0x81, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xE0, 0xFF,
  0xFF, 0xF0, 0xFF, 0x07, 0xFC, 0xFF, 0x87, 0xF8, 0x3F, 0xE7, 0xFC, 0x3F,
  0xE1, 0xFF, 0x3F, 0xE1, 0xFF, 0x0F, 0xF9, 0xFF, 0x0F, 0xF8, 0x7F, 0xCF,
  0xF8, 0xFF, 0xC7, 0xFC, 0x7F, 0xC7, 0xFF, 0x3F, 0xE1, 0xFE, 0x3F, 0xF9,
  0xFF, 0x0F, 0xF9, 0xFF, 0xCF, 0xF8, 0x7F, 0xDF, 0xFE, 0x7F, 0xC3, 0xFE,
  0xFF, 0xF3, 0xFC, 0x1F, 0xF7, 0xFF, 0xDF, 0xE0, 0x7F, 0xBF, 0xFE, 0xFF,
  0x03, 0xFD, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xDF, 0xFF, 0xC0, 0xFF, 0xFE,
  0xFF, 0xFE, 0x07, 0xFF, 0xF7, 0xFF, 0xE0, 0x1F, 0xFF, 0x3F, 0xFF, 0x00,
  0xFF, 0xF8, 0xFF, 0xF8, 0x07, 0xFF, 0xC7, 0xFF, 0xC0, 0x3F, 0xFE, 0x3F,
  0xFE, 0x01, 0xFF, 0xF1, 0xFF, 0xE0, 0x0F, 0xFF, 0x0F, 0xFF, 0x00, 0x3F,
  0xF8, 0x3F, 0xF8, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x0F, 0xFE, 0x0F, 0xFE,
  0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x0F, 0xF8,
  0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x03, 0xFE, 0x03, 0xFE, 0x00,
  0xFF, 0xE0, 0xFF, 0xEF, 0xFC, 0x1F, 0xF9, 0xFF, 0x83, 0xFF, 0x1F, 0xF8,
  0xFF, 0xC3, 0xFF, 0x1F, 0xF8, 0x7F, 0xE3, 0xFE, 0x07, 0xFE, 0xFF, 0xC0,
  0xFF, 0xDF, 0xF8, 0x0F, 0xFB, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x1F, 0xFB, 0xFE,
  0x03, 0xFF, 0x7F, 0xE0, 0xFF, 0xCF, 0xFC, 0x1F, 0xF8, 0xFF, 0xC3, 0xFF,
  0x1F, 0xF8, 0xFF, 0xC1, 0xFF, 0x9F, 0xF8, 0x3F, 0xF7, 0xFF, 0x07, 0xFE,
  0xFF, 0xC0, 0x7F, 0xE0, 0xFF, 0xE0, 0x3F, 0xF7, 0xFE, 0x07, 0xFF, 0x7F,
  0xE0, 0x7F, 0xF7, 0xFF, 0x07, 0xFE, 0x3F, 0xF0, 0x7F, 0xE3, 0xFF, 0x0F,
  0xFE, 0x3F, 0xF0, 0xFF, 0xE3, 0xFF, 0x0F, 0xFC, 0x1F, 0xF8, 0xFF, 0xC1,
  0xFF, 0x8F, 0xFC, 0x1F, 0xF9, 0xFF, 0x81, 0xFF, 0x9F, 0xF8, 0x0F, 0xF9,
  0xFF, 0x80, 0xFF, 0xDF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x0C, 0x00, 0x78, 0x01, 0xF0, 0x07, 0xF0, 0x1F, 0xE0, 0x7F, 0xC0,
  0xFF, 0x03, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF,
  0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0,
  0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xF8, 0x1F, 0xF0, 0x3F,
  0xE3, 0xFF, 0x87, 0xFE, 0x0F, 0xF8, 0x1F, 0xE0, 0x3F, 0xE0, 0x7F, 0xE0,
  0xFF, 0xE0, 0x7F, 0xE0, 0x7F, 0xC0, 0x7F, 0x80, 0xFF, 0x81, 0xFF, 0x03,
  0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF,
  0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xE0, 0x3F, 0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0x7F, 0x00, 0x7C, 0x00,
  0x78, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x60, 0x00, 0xF0, 0x01, 0xF0, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0,
  0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x3F, 0xF8, 0x3F, 0xF0, 0x3F,
  0xE0, 0x3F, 0xC0, 0xFF, 0x83, 0xFF, 0x0F, 0xFE, 0x1F, 0xF0, 0x7F, 0xC0,
  0xFF, 0x81, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F,
  0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0,
  0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x01, 0xFE, 0x07, 0xFC, 0x1F, 0xF0, 0x3F,
  0xC0, 0x7F, 0x80, 0x7C, 0x00, 0xF0, 0x00, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x7F, 0x1F, 0xFC, 0x07, 0xF3, 0xFF, 0xE0, 0xFF, 0x7F,
  0xFF, 0x0F, 0xF7, 0xFF, 0xF9, 0xFE, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFE, 0xFF, 0x1F, 0xFF, 0xCF, 0xE0, 0xFF, 0xFC, 0xFE, 0x07, 0xFF, 0x8F,
  0xE0, 0x3F, 0xF8, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xC0,
};

const GFXglyph RobotoCondensed_Black62pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 11, 45, 16, 3, -44 },
  { 63, 17, 17, 20, 1, -47 },
  { 100, 29, 44, 32, 1, -44 },
  { 260, 26, 58, 32, 3, -51 },
  { 449, 34, 46, 40, 3, -45 },
  { 645, 34, 46, 37, 2, -45 },
  { 841, 8, 17, 10, 1, -47 },
  { 858, 14, 63, 20, 4, -49 },
  { 969, 15, 63, 20, 2, -49 },
  { 1088, 28, 27, 29, 1, -44 },
  { 1183, 25, 33, 29, 2, -37 },
  { 1287, 12, 20, 17, 1, -8 },
  { 1317, 16, 8, 26, 5, -23 },
  { 1333, 11, 11, 19, 4, -10 },
  { 1349, 19, 48, 19, 0, -44 },
  { 1463, 26, 46, 32, 3, -45 },
  { 1613, 18, 44, 32, 5, -44 },
  { 1712, 27, 45, 32, 2, -45 },
  { 1864, 27, 46, 32, 2, -45 },
  { 2020, 27, 44, 32, 2, -44 },
  { 2169, 27, 45, 32, 2, -44 },
  { 2321, 27, 45, 32, 3, -44 },
  { 2473, 27, 44, 32, 2, -44 },
  { 2622, 26, 46, 32, 3, -45 },
  { 2772, 26, 45, 32, 3, -45 },
  { 2919, 11, 35, 18, 4, -34 },
  { 2968, 13, 46, 17, 2, -34 },
  { 3043, 22, 29, 28, 2, -33 },
  { 3123, 24, 22, 32, 4, -30 },
  { 3189, 23, 29, 28, 3, -33 },
  { 3273, 25, 46, 28, 1, -45 },
  { 3417, 43, 57, 48, 2, -43 },
  { 3724, 37, 44, 38, 0, -44 },
  { 3928, 30, 44, 35, 3, -44 },
  { 4093, 32, 46, 35, 2, -45 },
  { 4277, 29, 44, 35, 3, -44 },
  { 4437, 26, 44, 30, 3, -44 },
  { 4580, 25, 44, 29, 3, -44 },
  { 4718, 31, 46, 37, 3, -45 },
  { 4897, 32, 44, 38, 3, -44 },
  { 5073, 10, 44, 17, 4, -44 },
  { 5128, 27, 45, 31, 1, -44 },
  { 5280, 32, 44, 35, 3, -44 },
  { 5456, 25, 44, 30, 3, -44 },
  { 5594, 41, 44, 47, 3, -44 },
  { 5820, 32, 44, 38, 3, -44 },
  { 5996, 33, 46, 37, 2, -45 },
  { 6186, 30, 44, 36, 3, -44 },
  { 6351, 33, 53, 37, 2, -45 },
  { 6570, 31, 44, 35, 3, -44 },
  { 6741, 30, 46, 34, 2, -45 },
  { 6914, 32, 44, 34, 1, -44 },
  { 7090, 30, 45, 36, 3, -44 },
  { 7259, 36, 44, 36, 0, -44 },
  { 7457, 44, 44, 46, 1, -44 },
  { 7699, 34, 44, 35, 0, -44 },
  { 7886, 34, 44, 34, 0, -44 },
  { 8073, 29, 44, 33, 2, -44 },
  { 8233, 12, 63, 17, 3, -52 },
  { 8328, 26, 48, 24, 0, -44 },
  { 8484, 13, 63, 17, 1, -52 },
  { 8587, 23, 22, 25, 1, -44 },
  { 8651, 23, 8, 25, 1, 0 },
  { 8674, 16, 10, 21, 2, -47 },
  { 8694, 26, 35, 29, 2, -34 },
  { 8808, 26, 48, 31, 3, -47 },
  { 8964, 25, 35, 28, 2, -34 },
  { 9074, 26, 48, 31, 2, -47 },
  { 9230, 27, 35, 30, 2, -34 },
  { 9349, 19, 48, 21, 1, -48 },
  { 9463, 27, 47, 31, 2, -34 },
  { 9622, 26, 47, 31, 2, -47 },
  { 9775, 10, 46, 16, 3, -46 },
  { 9833, 15, 59, 16, -2, -46 },
  { 9944, 28, 47, 30, 3, -47 },
  { 10109, 10, 47, 16, 3, -47 },
  { 10168, 40, 34, 46, 3, -34 },
  { 10338, 26, 34, 31, 2, -34 },
  { 10449, 27, 35, 31, 2, -34 },
  { 10568, 26, 47, 31, 3, -34 },
  { 10721, 26, 47, 31, 2, -34 },
  { 10874, 17, 34, 21, 3, -34 },
  { 10947, 25, 35, 28, 1, -34 },
  { 11057, 18, 42, 19, 1, -41 },
  { 11152, 26, 34, 31, 2, -33 },
  { 11263, 28, 33, 29, 0, -33 },
  { 11379, 37, 33, 39, 1, -33 },
  { 11532, 27, 33, 28, 1, -33 },
  { 11644, 28, 46, 29, 0, -33 },
  { 11805, 24, 33, 28, 2, -33 },
  { 11904, 15, 59, 18, 1, -48 },
  { 12015, 6, 52, 16, 5, -44 },
  { 12054, 15, 59, 18, 2, -48 },
  { 12165, 28, 14, 34, 3, -25 },
};

const GFXfont RobotoCondensed_Black62pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Black62pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Black62pt7bGlyphs,
  0x20, 0x7E, 73
};

#endif // _ROBOTOCONDENSED_BLACK62PT7B_H_
