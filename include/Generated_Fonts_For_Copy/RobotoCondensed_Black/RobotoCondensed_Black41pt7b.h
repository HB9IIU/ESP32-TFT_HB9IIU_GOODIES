#ifndef _ROBOTOCONDENSED_BLACK41PT7B_H_
#define _ROBOTOCONDENSED_BLACK41PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Black.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Black41pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0xFD, 0xFB, 0xF7,
  0xEF, 0xDF, 0xBE, 0x7C, 0xF9, 0xF0, 0x00, 0x00, 0x0F, 0x3F, 0xFF, 0xFF,
  0xFB, 0xF3, 0xC0, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC,
  0x7F, 0x8F, 0xF1, 0xFC, 0x3B, 0x87, 0x00, 0x03, 0xCF, 0x00, 0x79, 0xE0,
  0x0F, 0x3C, 0x01, 0xE7, 0x00, 0x38, 0xE0, 0x0F, 0x3C, 0x01, 0xE7, 0x80,
  0x3C, 0xF0, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF0,
  0x73, 0xC0, 0x1E, 0x78, 0x03, 0xCF, 0x00, 0x79, 0xE0, 0x0F, 0x3C, 0x1F,
  0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0xFF, 0xF8, 0x3C, 0xF0, 0x07,
  0x9E, 0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x03, 0xCE, 0x00, 0x73, 0xC0, 0x1E,
  0x78, 0x03, 0xCF, 0x00, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x3F, 0x00, 0x7F, 0xE0, 0x7F, 0xF8, 0x7F, 0xFE, 0x7F, 0xFF, 0x3F,
  0x9F, 0xDF, 0x8F, 0xEF, 0xC3, 0xF7, 0xE1, 0xFB, 0xF0, 0x01, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x1F,
  0xF0, 0x03, 0xF8, 0x00, 0xFF, 0xF8, 0x7F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF,
  0x8F, 0xFF, 0xE7, 0xF7, 0xFF, 0xFB, 0xFF, 0xF8, 0xFF, 0xF8, 0x3F, 0xF8,
  0x03, 0xF0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1F,
  0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0x0C, 0x0F, 0x1E,
  0x1E, 0x1E, 0x3C, 0x78, 0x3C, 0x78, 0xF0, 0x78, 0xF3, 0xC0, 0xF1, 0xE7,
  0x01, 0xE3, 0xDE, 0x03, 0xFF, 0xB8, 0x03, 0xFE, 0xF0, 0x03, 0xFB, 0xC0,
  0x03, 0xE7, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3D, 0xF0, 0x00, 0xF7, 0xF8,
  0x01, 0xFF, 0xF8, 0x07, 0xBF, 0xF0, 0x0E, 0xF9, 0xE0, 0x3D, 0xE3, 0xC0,
  0xF3, 0xC7, 0xC1, 0xE7, 0x8F, 0x87, 0x8F, 0x1F, 0x0F, 0x1F, 0x3C, 0x0C,
  0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF8, 0x01, 0xFF,
  0xF0, 0x03, 0xF7, 0xE0, 0x0F, 0xC7, 0xC0, 0x1F, 0x8F, 0x80, 0x3F, 0x1F,
  0x00, 0x3E, 0x7E, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xC0,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x7E, 0x0F, 0xFC, 0xFC, 0x3F, 0xF9, 0xF8,
  0xFF, 0xFB, 0xF1, 0xFB, 0xFF, 0xE7, 0xF7, 0xFF, 0x8F, 0xE7, 0xFF, 0x1F,
  0xC7, 0xFE, 0x3F, 0x87, 0xF8, 0x7F, 0x9F, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x7F, 0x1F, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xDE, 0xF7, 0xBD, 0xE0, 0x00, 0x80, 0x70, 0x3C, 0x1F,
  0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x3E, 0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x03, 0xE0, 0xF8, 0x3E,
  0x07, 0xC1, 0xF0, 0x3E, 0x0F, 0x81, 0xF0, 0x3C, 0x07, 0x00, 0x80, 0x40,
  0x1C, 0x0F, 0x83, 0xE0, 0x7C, 0x0F, 0x83, 0xE0, 0x7C, 0x1F, 0x07, 0xE0,
  0xF8, 0x3E, 0x0F, 0xC3, 0xF0, 0xFC, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xE0, 0xF8, 0x7E, 0x1F, 0x07, 0xC3, 0xE0, 0xF8, 0x7C, 0x3E, 0x0F, 0x81,
  0xC0, 0x40, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x38, 0x78, 0x6F, 0xDE, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFF, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x0F, 0x78, 0x07, 0xDF, 0x03, 0xE3,
  0xE0, 0xF0, 0x7C, 0x1C, 0x1C, 0x02, 0x02, 0x00, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x7C, 0xFB, 0xE7, 0xC3, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x1C, 0x7E, 0x7F, 0xFF, 0xFF, 0x7E, 0x3C, 0x00, 0xF0, 0x1F,
  0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x7C,
  0x07, 0xC0, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x01, 0xF0,
  0x1F, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x07, 0xC0,
  0x7C, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0x03, 0xE0, 0x07,
  0xFC, 0x07, 0xFF, 0x07, 0xFF, 0xC7, 0xFF, 0xF3, 0xFB, 0xFB, 0xF8, 0xFF,
  0xFC, 0x7F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1,
  0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF,
  0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xF1, 0xFF, 0xF8, 0xFE, 0xFE, 0xFE,
  0x7F, 0xFF, 0x1F, 0xFF, 0x07, 0xFF, 0x01, 0xFF, 0x00, 0x3F, 0x00, 0x00,
  0x30, 0x0F, 0x07, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xFF, 0x81,
  0xFF, 0xF0, 0xFF, 0xFE, 0x3F, 0xFF, 0x9F, 0xCF, 0xE7, 0xE1, 0xFF, 0xF8,
  0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF,
  0xC0, 0x03, 0xF0, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0xFE, 0x7F, 0xFF,
  0x9F, 0xCF, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0F,
  0xFC, 0x03, 0xFF, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0xFE, 0x0F,
  0xFF, 0x83, 0xFF, 0xE1, 0xFD, 0xFC, 0xFF, 0x7F, 0xFF, 0x8F, 0xFF, 0xE3,
  0xFF, 0xF0, 0x3F, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x0F,
  0xFC, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x7B, 0xF0, 0x3E, 0xFC, 0x0F, 0x3F,
  0x07, 0xCF, 0xC1, 0xF3, 0xF0, 0xF8, 0xFC, 0x3E, 0x3F, 0x1F, 0x8F, 0xC7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFC, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x3F, 0xFF, 0x8F, 0xFF, 0xE3, 0xFF, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF,
  0x8F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07,
  0xEF, 0x81, 0xFF, 0xF8, 0x7F, 0xFF, 0x1F, 0xFF, 0xE7, 0xFF, 0xF8, 0x78,
  0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0xFE, 0x1F,
  0xFF, 0x87, 0xF7, 0xF1, 0xFD, 0xFE, 0xFE, 0x7F, 0xFF, 0x8F, 0xFF, 0xC1,
  0xFF, 0xF0, 0x3F, 0xF0, 0x03, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x7F, 0x00,
  0x7F, 0xC0, 0x3F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFC, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xEF, 0x83, 0xF7, 0xF8, 0xFF, 0xFF,
  0x3F, 0xFF, 0xCF, 0xFF, 0xFB, 0xF8, 0xFE, 0xFC, 0x3F, 0xBF, 0x07, 0xFF,
  0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x87, 0xFF, 0xE3, 0xF9, 0xFC,
  0xFE, 0x7F, 0xFF, 0x8F, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xF0, 0x03, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0,
  0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x0F, 0xFE, 0x0F,
  0xFF, 0x8F, 0xFF, 0xE7, 0xFF, 0xF3, 0xFB, 0xFB, 0xF8, 0xFF, 0xFC, 0x7F,
  0xFE, 0x3F, 0xFF, 0x1F, 0xDF, 0x8F, 0xCF, 0xEF, 0xE3, 0xFF, 0xE0, 0xFF,
  0xE0, 0x7F, 0xF0, 0x7F, 0xFC, 0x7F, 0xFF, 0x3F, 0x1F, 0xBF, 0x8F, 0xFF,
  0x87, 0xFF, 0xC1, 0xFF, 0xE1, 0xFF, 0xF8, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0x8F, 0xFF, 0x83, 0xFF, 0x80, 0x7F, 0x00, 0x03, 0xE0, 0x07,
  0xFC, 0x07, 0xFF, 0x07, 0xFF, 0xC7, 0xFF, 0xF3, 0xFB, 0xFB, 0xF8, 0xFD,
  0xFC, 0x7F, 0xFC, 0x3F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1,
  0xFF, 0xF0, 0xFF, 0xF8, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0x9F, 0xFF, 0xC7,
  0xFF, 0xE1, 0xF7, 0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x1F, 0xFC,
  0x0F, 0xFC, 0x07, 0xFC, 0x03, 0xFC, 0x01, 0xF8, 0x00, 0xF0, 0x00, 0x1C,
  0x7E, 0x7F, 0xFF, 0x7F, 0x7E, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x7E, 0x7F, 0xFF, 0x7F, 0x7E, 0x3C, 0x1E, 0x1F,
  0x9F, 0xCF, 0xF7, 0xF9, 0xF8, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C,
  0x7E, 0x3F, 0x1F, 0x0F, 0x8F, 0xC7, 0xC3, 0xC0, 0x40, 0x00, 0x02, 0x00,
  0x1C, 0x00, 0xF8, 0x07, 0xF0, 0x3F, 0xE1, 0xFF, 0xCF, 0xFF, 0x7F, 0xF8,
  0xFF, 0xC1, 0xFE, 0x03, 0xFC, 0x07, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0xC3,
  0xFF, 0x81, 0xFF, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x38, 0x00, 0x10, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x01, 0xC0, 0x03, 0xE0, 0x07, 0xF0, 0x0F, 0xF8, 0x1F, 0xFE,
  0x1F, 0xFF, 0x0F, 0xFF, 0x07, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x3F, 0xF1,
  0xFF, 0xEF, 0xFF, 0xBF, 0xFC, 0x7F, 0xC0, 0xFE, 0x01, 0xF0, 0x03, 0x80,
  0x04, 0x00, 0x00, 0x07, 0xF0, 0x1F, 0xFC, 0x3F, 0xFE, 0x7F, 0xFE, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFE, 0x3F, 0xFC, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x7F, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x03,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80,
  0x07, 0xFD, 0xFF, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xE0, 0x03, 0xE0, 0x3E,
  0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3C, 0x1E, 0x07, 0xE0, 0xF1, 0xF0, 0x7F,
  0x87, 0x8F, 0x07, 0xFE, 0x3C, 0x78, 0x7F, 0xF0, 0xE7, 0xC7, 0xC7, 0x87,
  0xBC, 0x3E, 0x3C, 0x3D, 0xE1, 0xE1, 0xE1, 0xEF, 0x1F, 0x0F, 0x0F, 0xF8,
  0xF8, 0x78, 0x7F, 0xC7, 0xC3, 0xC3, 0xFE, 0x3E, 0x3E, 0x1F, 0xF1, 0xE1,
  0xF0, 0xFF, 0x8F, 0x0F, 0x87, 0x7C, 0x7C, 0x7C, 0x7B, 0xE3, 0xE3, 0xE3,
  0xDF, 0x1F, 0x3F, 0x3C, 0x78, 0xFF, 0xFF, 0xE3, 0xC3, 0xFF, 0xFE, 0x1E,
  0x1F, 0xCF, 0xE0, 0xF8, 0x3C, 0x3E, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x30,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x01, 0xFB, 0xF0, 0x00,
  0xFD, 0xF8, 0x00, 0x7E, 0xFC, 0x00, 0x7F, 0x7E, 0x00, 0x3F, 0x1F, 0x80,
  0x1F, 0x8F, 0xC0, 0x1F, 0xC7, 0xE0, 0x0F, 0xE3, 0xF8, 0x07, 0xE1, 0xFC,
  0x07, 0xF0, 0x7E, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x3F, 0x80, 0xFE, 0x3F, 0x80,
  0x7F, 0x9F, 0xC0, 0x1F, 0xCF, 0xE0, 0x0F, 0xEF, 0xF0, 0x07, 0xF0, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF,
  0xE3, 0xFE, 0xFE, 0x0F, 0xEF, 0xE0, 0xFE, 0xFE, 0x0F, 0xEF, 0xE0, 0xFE,
  0xFE, 0x0F, 0xEF, 0xE0, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xE0, 0xFE, 0xFE, 0x0F, 0xEF, 0xE0,
  0x7E, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xEF, 0xE3, 0xFE, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xF0, 0xFF, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xC3, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFD, 0xFE, 0x0F, 0xEF, 0xE0, 0x7F, 0x7F, 0x01, 0xFB,
  0xF8, 0x0F, 0xDF, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x03, 0xF7, 0xF0, 0x1F, 0xBF, 0x81, 0xFD, 0xFE, 0x0F,
  0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x0F,
  0xFF, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC,
  0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFD, 0xFF, 0xBF, 0x87, 0xF7, 0xF0, 0x7F,
  0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF,
  0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF,
  0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x87, 0xF7,
  0xF3, 0xFE, 0xFF, 0xFF, 0x9F, 0xFF, 0xF3, 0xFF, 0xFC, 0x7F, 0xFE, 0x0F,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0xFE,
  0xFF, 0xFF, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFD,
  0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xFC, 0x07,
  0xFF, 0xF0, 0x7F, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xEF, 0xF9, 0xFC, 0x1F,
  0xDF, 0xC0, 0x7E, 0xFE, 0x03, 0xF7, 0xF0, 0x1F, 0xBF, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFE, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0,
  0x3F, 0xFF, 0x01, 0xFD, 0xFC, 0x0F, 0xEF, 0xF9, 0xFF, 0x7F, 0xFF, 0xF9,
  0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0xFE,
  0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F,
  0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0,
  0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0x80,
  0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07,
  0xFF, 0xE0, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xFF, 0xE3, 0xFF, 0xF1, 0xFF, 0xF8, 0xFF, 0xFE, 0xFF, 0x7F, 0xFF, 0x3F,
  0xFF, 0x8F, 0xFF, 0x83, 0xFF, 0x80, 0x7E, 0x00, 0xFE, 0x07, 0xFF, 0xF0,
  0x7F, 0xBF, 0x83, 0xFD, 0xFC, 0x3F, 0xCF, 0xE1, 0xFC, 0x7F, 0x1F, 0xE3,
  0xF8, 0xFE, 0x1F, 0xCF, 0xF0, 0xFE, 0x7F, 0x07, 0xF7, 0xF0, 0x3F, 0xBF,
  0x81, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F,
  0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFE, 0xFF,
  0x0F, 0xF3, 0xF8, 0x7F, 0x1F, 0xE3, 0xF8, 0xFF, 0x1F, 0xC3, 0xFC, 0xFE,
  0x1F, 0xE7, 0xF0, 0x7F, 0x3F, 0x83, 0xFD, 0xFC, 0x1F, 0xEF, 0xE0, 0x7F,
  0x80, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0xF8, 0xFF, 0xFF, 0xDF, 0x1F, 0x7F, 0xFB,
  0xE3, 0xEF, 0xFF, 0x7C, 0x7D, 0xFF, 0xF7, 0x8F, 0x3F, 0xFE, 0xFB, 0xEF,
  0xFF, 0xDF, 0x7D, 0xFF, 0xFB, 0xEF, 0xBF, 0xFF, 0x3D, 0xE7, 0xFF, 0xE7,
  0xFC, 0xFF, 0xFC, 0xFF, 0x9F, 0xFF, 0x9F, 0xF3, 0xFF, 0xF1, 0xFC, 0x7F,
  0xFE, 0x3F, 0x8F, 0xFF, 0xC7, 0xF1, 0xFF, 0xF8, 0x7C, 0x3F, 0xFF, 0x0F,
  0x87, 0xFF, 0xE1, 0xF0, 0xFE, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0,
  0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0x3F, 0xFF, 0x79, 0xFF, 0xFB, 0xEF, 0xFF, 0xCF, 0x7F, 0xFE,
  0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE1, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0,
  0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x87, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFB, 0xFC, 0x1F, 0xDF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x1F,
  0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8,
  0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF,
  0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0xCF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x1F, 0xFE, 0x00,
  0x1F, 0xC0, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xEF, 0xE1, 0xFE, 0xFE, 0x0F, 0xEF, 0xE0, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF,
  0xE3, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0,
  0xFF, 0xFC, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xF0,
  0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0xFF, 0xF9, 0xFC, 0x1F, 0xDF, 0xC0,
  0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF,
  0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03,
  0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF,
  0x01, 0xFD, 0xFC, 0x1F, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF,
  0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7E, 0x00, 0x01, 0xE0, 0x00, 0x06, 0x00, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xE3,
  0xFE, 0xFE, 0x0F, 0xEF, 0xE0, 0xFE, 0xFE, 0x07, 0xEF, 0xE0, 0x7E, 0xFE,
  0x07, 0xEF, 0xE0, 0xFE, 0xFE, 0x0F, 0xEF, 0xE3, 0xFE, 0xFF, 0xFF, 0xCF,
  0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xE7, 0xF0,
  0xFE, 0x7F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0xCF, 0xE1, 0xFC, 0xFE, 0x1F,
  0xCF, 0xE1, 0xFE, 0xFE, 0x0F, 0xEF, 0xE0, 0xFF, 0xFE, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0xC1, 0xFF, 0xFC, 0x3F, 0xFF, 0xE7,
  0xFD, 0xFF, 0x7F, 0x07, 0xF7, 0xF0, 0x7F, 0x7F, 0x07, 0xF7, 0xF0, 0x00,
  0x3F, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0x80, 0x3F, 0xFC, 0x00, 0x7F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xFF, 0xE0,
  0x7F, 0xFE, 0x07, 0xF7, 0xF0, 0x7F, 0x7F, 0x07, 0xF7, 0xF8, 0xFF, 0x3F,
  0xFF, 0xE3, 0xFF, 0xFE, 0x1F, 0xFF, 0xC0, 0x7F, 0xF8, 0x01, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F,
  0xFE, 0x0F, 0xEF, 0xFB, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0xFC, 0x3F, 0xFF,
  0x80, 0xFF, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x7F, 0x00, 0xFE,
  0x7F, 0x00, 0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0x81, 0xFE, 0x3F, 0x81, 0xFC,
  0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x1F, 0xC3, 0xF8, 0x1F, 0xC3, 0xF8,
  0x1F, 0xC3, 0xF8, 0x1F, 0xC3, 0xF8, 0x0F, 0xC3, 0xF0, 0x0F, 0xE7, 0xF0,
  0x0F, 0xE7, 0xF0, 0x0F, 0xE7, 0xE0, 0x07, 0xE7, 0xE0, 0x07, 0xE7, 0xE0,
  0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0xFE, 0x1F, 0x83,
  0xFF, 0xF0, 0xFC, 0x1F, 0xFF, 0x87, 0xF0, 0xFD, 0xFC, 0x3F, 0x8F, 0xEF,
  0xE3, 0xFC, 0x7F, 0x3F, 0x1F, 0xE3, 0xF9, 0xF8, 0xFF, 0x1F, 0xCF, 0xE7,
  0xF8, 0xFC, 0x7F, 0x3F, 0xE7, 0xE3, 0xF9, 0xFF, 0x3F, 0x1F, 0xDF, 0xFB,
  0xF8, 0x7E, 0xFF, 0xDF, 0xC3, 0xF7, 0xFE, 0xFE, 0x1F, 0xBF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xEF, 0xFE, 0x07, 0xFF, 0x7F, 0xF0, 0x3F, 0xF3, 0xFF, 0x01, 0xFF, 0x9F,
  0xF8, 0x0F, 0xFC, 0xFF, 0xC0, 0x7F, 0xE7, 0xFE, 0x01, 0xFF, 0x1F, 0xF0,
  0x0F, 0xF8, 0xFF, 0x80, 0x7F, 0x87, 0xF8, 0x03, 0xFC, 0x3F, 0xC0, 0x1F,
  0xE1, 0xFE, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x7F, 0x01, 0xFC, 0xFF, 0x07,
  0xF8, 0xFE, 0x0F, 0xE1, 0xFC, 0x1F, 0xC3, 0xFC, 0x7F, 0x83, 0xF8, 0xFE,
  0x07, 0xF1, 0xFC, 0x07, 0xF7, 0xF0, 0x0F, 0xEF, 0xE0, 0x0F, 0xFF, 0x80,
  0x1F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x1F,
  0xFF, 0x00, 0x3F, 0x7E, 0x00, 0xFE, 0xFE, 0x01, 0xFD, 0xFC, 0x07, 0xF1,
  0xFC, 0x0F, 0xE3, 0xF8, 0x3F, 0xC7, 0xF8, 0x7F, 0x07, 0xF1, 0xFE, 0x0F,
  0xF3, 0xFC, 0x1F, 0xE7, 0xF0, 0x1F, 0xE0, 0xFF, 0x01, 0xFD, 0xFC, 0x07,
  0xF7, 0xF0, 0x3F, 0x8F, 0xE0, 0xFE, 0x3F, 0x83, 0xF8, 0xFE, 0x1F, 0xC1,
  0xFC, 0x7F, 0x07, 0xF1, 0xF8, 0x0F, 0xC7, 0xE0, 0x3F, 0x3F, 0x80, 0x7E,
  0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0xFE,
  0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE,
  0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE,
  0xFE, 0xFE, 0xFE, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x03,
  0xF8, 0x00, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x7F,
  0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F,
  0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F,
  0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xC0,
  0x1F, 0x80, 0x3F, 0x80, 0x7F, 0x01, 0xFE, 0x03, 0xFE, 0x07, 0xBC, 0x1F,
  0x78, 0x3E, 0xF8, 0x79, 0xF1, 0xF1, 0xE3, 0xE3, 0xE7, 0x87, 0xDF, 0x0F,
  0xBE, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7F, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0, 0x07, 0xF0,
  0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xE7, 0xFF, 0xF3, 0xF1, 0xFB, 0xF8,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x03, 0xFF, 0x87, 0xFF, 0xC7, 0xFF, 0xE7,
  0xFF, 0xF7, 0xF1, 0xFB, 0xF8, 0xFD, 0xFC, 0x7E, 0xFE, 0x3F, 0x7F, 0xFF,
  0xBF, 0xFF, 0xEF, 0xFF, 0xF3, 0xFB, 0xF8, 0x78, 0xFC, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x7C, 0x3F, 0x7F, 0x9F, 0xFF, 0xEF, 0xFF,
  0xF7, 0xFF, 0xFB, 0xF8, 0xFF, 0xF8, 0x7F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF,
  0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F,
  0xFC, 0x3F, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xF7, 0xEF,
  0xF3, 0xF3, 0xE0, 0x03, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x87, 0xFF, 0xE7,
  0xFF, 0xF3, 0xF9, 0xFB, 0xF8, 0xFF, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x7F, 0xFC,
  0x7F, 0x7F, 0x3F, 0x3F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xC1, 0xFF, 0xC0,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x87, 0xCF, 0xC7,
  0xF7, 0xE7, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFD, 0xFC, 0xFF, 0xFC, 0x3F,
  0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xF0,
  0xFF, 0xF8, 0x7F, 0xFC, 0x3F, 0xFE, 0x1F, 0xBF, 0x9F, 0xDF, 0xFF, 0xEF,
  0xFF, 0xF3, 0xFF, 0xF8, 0xFE, 0xFC, 0x3E, 0x3E, 0x03, 0xF8, 0x03, 0xFF,
  0x81, 0xFF, 0xF0, 0xFF, 0xFC, 0x7F, 0xFF, 0x9F, 0xC7, 0xE7, 0xE1, 0xFF,
  0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x08, 0x7F, 0x8F, 0x1F, 0xFF,
  0xC3, 0xFF, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0x00, 0xFF, 0x00, 0x01, 0xF8,
  0x1F, 0xC1, 0xFE, 0x1F, 0xF1, 0xFF, 0x8F, 0xF0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F,
  0x00, 0x07, 0xCF, 0xC7, 0xFB, 0xF3, 0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF,
  0xDF, 0xC7, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF,
  0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8,
  0x7F, 0x7F, 0x1F, 0xDF, 0xFF, 0xF7, 0xFF, 0xFC, 0xFF, 0xFF, 0x1F, 0xFF,
  0xC1, 0xF7, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x0C, 0x3F, 0xC7, 0xFF, 0xE3,
  0xFF, 0xF8, 0xFF, 0xFC, 0x1F, 0xFE, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x7C, 0x3F, 0x7F, 0x1F, 0xFF, 0xCF, 0xFF,
  0xF7, 0xFF, 0xFB, 0xF9, 0xFD, 0xF8, 0x7F, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF,
  0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F,
  0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE1,
  0xFF, 0xF0, 0xFE, 0x10, 0xFB, 0xFF, 0xFF, 0xFF, 0x9E, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0x00, 0xF8, 0x3F, 0x87,
  0xF0, 0xFE, 0x1F, 0x81, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x3F, 0x87, 0xF0,
  0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE,
  0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F,
  0xC3, 0xF8, 0x7F, 0x0F, 0xE3, 0xFD, 0xFF, 0x3F, 0xE7, 0xF8, 0xFE, 0x1F,
  0x80, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x0F, 0xFF,
  0xC7, 0xFB, 0xF1, 0xFC, 0xFC, 0xFF, 0x3F, 0x3F, 0x8F, 0xDF, 0xC3, 0xF7,
  0xF0, 0xFF, 0xF8, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xF8,
  0x3F, 0xFF, 0x0F, 0xFF, 0xC3, 0xFB, 0xF8, 0xFE, 0xFE, 0x3F, 0x1F, 0xCF,
  0xC7, 0xF3, 0xF1, 0xFE, 0xFC, 0x3F, 0xBF, 0x0F, 0xFF, 0xC1, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xFC, 0x78, 0x3E, 0x3F, 0x7F, 0x9F, 0xCF, 0xFF, 0xEF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xE7, 0xFF, 0xC3,
  0xF0, 0xFF, 0xF0, 0xFC, 0x3F, 0xFC, 0x3F, 0x0F, 0xFF, 0x0F, 0xC3, 0xFF,
  0xC3, 0xF0, 0xFF, 0xF0, 0xFC, 0x3F, 0xFC, 0x3F, 0x0F, 0xFF, 0x0F, 0xC3,
  0xFF, 0xC3, 0xF0, 0xFF, 0xF0, 0xFC, 0x3F, 0xFC, 0x3F, 0x0F, 0xFF, 0x0F,
  0xC3, 0xFF, 0xC3, 0xF0, 0xFF, 0xF0, 0xFC, 0x3F, 0xFC, 0x3F, 0x0F, 0xFF,
  0x0F, 0xC3, 0xF0, 0xFC, 0xF8, 0x7E, 0xFF, 0x3F, 0xFF, 0x9F, 0xFF, 0xEF,
  0xFF, 0xF7, 0xF3, 0xFB, 0xF0, 0xFF, 0xF8, 0x7F, 0xFC, 0x3F, 0xFE, 0x1F,
  0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0xF8,
  0x7F, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF,
  0xE1, 0xFC, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xF0, 0xFF, 0xFC, 0x7F,
  0xFF, 0x9F, 0xCF, 0xE7, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87,
  0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFD,
  0xF8, 0x7F, 0x7F, 0x3F, 0x9F, 0xFF, 0xE3, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F,
  0xFE, 0x00, 0xFE, 0x00, 0xFC, 0xF8, 0x7E, 0xFF, 0x3F, 0xFF, 0x9F, 0xFF,
  0xEF, 0xFF, 0xF7, 0xF1, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0xFC, 0x1F, 0xFE,
  0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0xFF,
  0xF8, 0x7F, 0xFE, 0x3F, 0xFF, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xCF, 0xDF,
  0xE7, 0xE7, 0xC3, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x0F, 0x8F, 0xC7, 0xFF,
  0xF3, 0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xDF, 0xCF, 0xFF, 0xE1, 0xFF,
  0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE,
  0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0x7F, 0x3F, 0xDF, 0xFF,
  0xF7, 0xFF, 0xFC, 0xFF, 0xFF, 0x1F, 0xFF, 0xC3, 0xE7, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0xFC, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC7, 0xF0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x00, 0x07,
  0xF0, 0x1F, 0xFC, 0x3F, 0xFE, 0x7F, 0xFF, 0x7F, 0xFF, 0xFE, 0x3F, 0xFE,
  0x3F, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0xE0, 0x3F, 0xF8, 0x1F, 0xFE, 0x07,
  0xFF, 0x01, 0xFF, 0x00, 0x7F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFF, 0xFF, 0x7F,
  0xFF, 0x3F, 0xFE, 0x1F, 0xFC, 0x07, 0xF0, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7F, 0x0F, 0xF9, 0xFF, 0x3F, 0xE3, 0xFC, 0x1F, 0x80, 0xFC, 0x3F, 0xFE,
  0x1F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xF0, 0xFF,
  0xF8, 0x7F, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0xC3,
  0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xF3, 0xFB, 0xF8, 0xF9, 0xFC, 0xFE, 0x1F, 0xDF, 0x87,
  0xF7, 0xF1, 0xFD, 0xFC, 0x7F, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF3, 0xF8,
  0xFE, 0xFE, 0x1F, 0xBF, 0x07, 0xEF, 0xC1, 0xFB, 0xF0, 0x7E, 0xFC, 0x0F,
  0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF0, 0x07, 0xFC, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0xFC, 0x7C,
  0x3F, 0xFC, 0x7C, 0x3F, 0xFC, 0x7E, 0x7F, 0xFC, 0x7E, 0x7E, 0xFC, 0x7E,
  0x7E, 0x7C, 0xFE, 0x7E, 0x7E, 0xFE, 0x7E, 0x7E, 0xFF, 0x7E, 0x7E, 0xFF,
  0x7C, 0x7E, 0xFF, 0x7C, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xEF,
  0xFC, 0x3F, 0xE7, 0xF8, 0x3F, 0xE7, 0xF8, 0x3F, 0xE7, 0xF8, 0x1F, 0xC7,
  0xF8, 0x1F, 0xC7, 0xF8, 0x1F, 0xC3, 0xF8, 0x1F, 0xC3, 0xF0, 0x1F, 0xC3,
  0xF0, 0x0F, 0x83, 0xF0, 0x7F, 0x1F, 0xCF, 0xE3, 0xF8, 0xFC, 0x7E, 0x1F,
  0xDF, 0xC1, 0xFB, 0xF0, 0x3F, 0x7E, 0x07, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F,
  0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xE0, 0x1F,
  0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xF8, 0x1F, 0xBF, 0x07, 0xF7, 0xF0, 0xFE,
  0x7E, 0x3F, 0x8F, 0xE7, 0xF1, 0xFC, 0xFC, 0x1F, 0x80, 0xFE, 0x0F, 0xEF,
  0xE3, 0xF9, 0xFC, 0x7F, 0x3F, 0x8F, 0xE7, 0xF1, 0xF8, 0x7E, 0x7F, 0x0F,
  0xCF, 0xE1, 0xFD, 0xFC, 0x1F, 0xBF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F,
  0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xE0, 0x07,
  0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0xFF, 0x7F,
  0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x00, 0xFE, 0x00, 0xFC, 0x01,
  0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x80, 0xE0, 0x78, 0x3F, 0x1F, 0x87,
  0xC1, 0xF0, 0x7C, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x3F, 0x8F, 0xC3, 0xE0, 0xFC, 0x3F, 0x87, 0xE0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF8, 0x3F, 0x07, 0x80, 0xE0, 0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x60,
  0x1C, 0x07, 0x83, 0xF0, 0x7E, 0x0F, 0x83, 0xE0, 0xF8, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x07, 0xF0, 0xFC, 0x1F,
  0x0F, 0xC7, 0xF1, 0xF8, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3E, 0x0F, 0x87, 0xE3, 0xF0, 0x78, 0x1C, 0x06, 0x00,
  0x1F, 0x00, 0x0F, 0xE0, 0xF7, 0xFC, 0x7D, 0xFF, 0x9F, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0x8F, 0xFB, 0xC1, 0xFC, 0x00, 0x3E, 0x00,
};

const GFXglyph RobotoCondensed_Black41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 7, 29, 11, 2, -29 },
  { 27, 11, 11, 13, 1, -31 },
  { 43, 19, 29, 21, 1, -29 },
  { 112, 17, 37, 21, 2, -33 },
  { 191, 23, 29, 26, 2, -29 },
  { 275, 23, 29, 24, 1, -29 },
  { 359, 5, 12, 6, 1, -31 },
  { 367, 10, 41, 13, 2, -32 },
  { 419, 10, 41, 13, 1, -32 },
  { 471, 18, 18, 19, 1, -29 },
  { 512, 17, 22, 19, 1, -25 },
  { 559, 7, 13, 11, 1, -5 },
  { 571, 11, 5, 17, 3, -15 },
  { 578, 8, 7, 12, 2, -7 },
  { 585, 12, 32, 13, 0, -29 },
  { 633, 17, 29, 21, 2, -29 },
  { 695, 12, 29, 21, 3, -29 },
  { 739, 18, 29, 21, 1, -29 },
  { 805, 18, 29, 21, 1, -29 },
  { 871, 18, 29, 21, 1, -29 },
  { 937, 18, 29, 21, 1, -29 },
  { 1003, 18, 29, 21, 2, -29 },
  { 1069, 18, 29, 21, 1, -29 },
  { 1135, 17, 29, 21, 2, -29 },
  { 1197, 17, 29, 21, 2, -29 },
  { 1259, 8, 23, 12, 2, -23 },
  { 1282, 9, 31, 11, 1, -23 },
  { 1317, 15, 20, 18, 1, -22 },
  { 1355, 16, 13, 21, 2, -19 },
  { 1381, 15, 20, 18, 2, -22 },
  { 1419, 16, 29, 19, 1, -29 },
  { 1477, 29, 37, 31, 1, -28 },
  { 1612, 25, 29, 25, 0, -29 },
  { 1703, 20, 29, 23, 2, -29 },
  { 1776, 21, 29, 23, 1, -29 },
  { 1853, 19, 29, 23, 2, -29 },
  { 1922, 17, 29, 20, 2, -29 },
  { 1984, 17, 29, 19, 2, -29 },
  { 2046, 21, 29, 24, 2, -29 },
  { 2123, 21, 29, 25, 2, -29 },
  { 2200, 7, 29, 11, 2, -29 },
  { 2226, 17, 29, 20, 1, -29 },
  { 2288, 21, 29, 23, 2, -29 },
  { 2365, 17, 29, 20, 2, -29 },
  { 2427, 27, 29, 31, 2, -29 },
  { 2525, 21, 29, 25, 2, -29 },
  { 2602, 21, 29, 25, 2, -29 },
  { 2679, 20, 29, 24, 2, -29 },
  { 2752, 21, 34, 25, 2, -29 },
  { 2842, 20, 29, 23, 2, -29 },
  { 2915, 20, 29, 23, 1, -29 },
  { 2988, 21, 29, 23, 1, -29 },
  { 3065, 20, 29, 24, 2, -29 },
  { 3138, 24, 29, 24, 0, -29 },
  { 3225, 29, 29, 30, 1, -29 },
  { 3331, 23, 29, 23, 0, -29 },
  { 3415, 22, 29, 23, 0, -29 },
  { 3495, 20, 29, 22, 1, -29 },
  { 3568, 8, 41, 11, 2, -34 },
  { 3609, 17, 32, 16, 0, -29 },
  { 3677, 8, 41, 11, 1, -34 },
  { 3718, 15, 15, 16, 1, -29 },
  { 3747, 16, 5, 16, 0, 0 },
  { 3757, 11, 6, 14, 1, -30 },
  { 3766, 17, 22, 19, 1, -22 },
  { 3813, 17, 31, 20, 2, -31 },
  { 3879, 17, 22, 19, 1, -22 },
  { 3926, 17, 31, 20, 1, -31 },
  { 3992, 18, 22, 20, 1, -22 },
  { 4042, 13, 31, 14, 0, -31 },
  { 4093, 18, 30, 21, 1, -22 },
  { 4161, 17, 31, 20, 2, -31 },
  { 4227, 7, 31, 11, 2, -31 },
  { 4255, 11, 39, 10, -2, -31 },
  { 4309, 18, 31, 20, 2, -31 },
  { 4379, 7, 31, 11, 2, -31 },
  { 4407, 26, 22, 30, 2, -22 },
  { 4479, 17, 22, 20, 2, -22 },
  { 4526, 18, 22, 20, 1, -22 },
  { 4576, 17, 30, 20, 2, -22 },
  { 4640, 18, 30, 20, 1, -22 },
  { 4708, 11, 22, 14, 2, -22 },
  { 4739, 16, 22, 19, 1, -22 },
  { 4783, 11, 27, 13, 1, -27 },
  { 4821, 17, 22, 20, 2, -22 },
  { 4868, 18, 22, 19, 0, -22 },
  { 4918, 24, 22, 26, 1, -22 },
  { 4984, 19, 22, 19, 0, -22 },
  { 5037, 19, 30, 19, 0, -22 },
  { 5109, 16, 22, 19, 1, -22 },
  { 5153, 10, 39, 12, 1, -32 },
  { 5202, 4, 34, 10, 3, -29 },
  { 5219, 10, 39, 12, 1, -32 },
  { 5268, 18, 9, 22, 2, -16 },
};

const GFXfont RobotoCondensed_Black41pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Black41pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Black41pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _ROBOTOCONDENSED_BLACK41PT7B_H_
