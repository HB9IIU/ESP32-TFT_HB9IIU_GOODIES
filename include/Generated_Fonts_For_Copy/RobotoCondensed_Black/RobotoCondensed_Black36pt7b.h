#ifndef _ROBOTOCONDENSED_BLACK36PT7B_H_
#define _ROBOTOCONDENSED_BLACK36PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Black.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Black36pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x9E, 0x79, 0xE0, 0x00, 0x7B, 0xFF, 0xFF, 0xFD, 0xE0, 0xF9, 0xFF, 0x3F,
  0xE7, 0xF8, 0xFF, 0x1D, 0xE3, 0xBC, 0x77, 0x8E, 0xF1, 0xDE, 0x38, 0x07,
  0xBC, 0x07, 0xBC, 0x07, 0x3C, 0x07, 0x38, 0x07, 0x38, 0x07, 0x38, 0x0F,
  0x38, 0x0F, 0x38, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x0E, 0x70, 0x0E,
  0x70, 0x0E, 0x70, 0x1E, 0x70, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x1C,
  0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x3C, 0xE0, 0x3D, 0xE0, 0x3D, 0xE0, 0x39,
  0xE0, 0x39, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x03,
  0xE0, 0x0F, 0xF8, 0x1F, 0xFC, 0x3F, 0xFE, 0x3F, 0x7E, 0x7E, 0x3F, 0x7E,
  0x3F, 0x7E, 0x3F, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x1F,
  0xF0, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0xFC, 0x3F, 0x7C,
  0x3F, 0x7C, 0x3F, 0x7E, 0x3F, 0x7F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFC, 0x0F,
  0xF8, 0x03, 0xF0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x3E, 0x00, 0x07,
  0xF0, 0x00, 0xFF, 0x80, 0x0F, 0x78, 0x60, 0xE3, 0x8F, 0x0E, 0x3C, 0xE0,
  0xE3, 0xDE, 0x0E, 0x39, 0xC0, 0xF7, 0xBC, 0x0F, 0xFB, 0x80, 0x7F, 0x78,
  0x03, 0xE7, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xEF, 0x80, 0x1D,
  0xFC, 0x03, 0xBF, 0xE0, 0x3B, 0xDE, 0x07, 0x38, 0xE0, 0xF3, 0x8F, 0x0E,
  0x38, 0xF1, 0xE3, 0x8E, 0x1C, 0x3D, 0xE0, 0x43, 0xFE, 0x00, 0x1F, 0xC0,
  0x00, 0xF8, 0x03, 0xE0, 0x00, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xE7, 0xC0, 0x3E, 0x3C, 0x03, 0xE7, 0xC0, 0x3E, 0x7C,
  0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x0F, 0xC0, 0x03, 0xFE,
  0x7C, 0x3F, 0xE7, 0xC7, 0xFF, 0x7C, 0xFD, 0xFF, 0xCF, 0xDF, 0xFC, 0xFC,
  0xFF, 0xCF, 0xC7, 0xF8, 0xFC, 0x7F, 0x8F, 0xFF, 0xF0, 0x7F, 0xFF, 0x87,
  0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0xFC, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x01, 0x01, 0x81, 0xE1, 0xE1, 0xE0, 0xF0, 0xF0, 0x78, 0x7C, 0x3C, 0x1E,
  0x0F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87,
  0xC3, 0xE1, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x83, 0xC1, 0xE0, 0x78, 0x3C,
  0x0F, 0x03, 0xC0, 0xC0, 0x20, 0x40, 0x70, 0x3C, 0x0F, 0x07, 0xC1, 0xE0,
  0xF8, 0x3C, 0x1F, 0x0F, 0x87, 0xC1, 0xE0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x0F, 0x87, 0xC3,
  0xE1, 0xE1, 0xF0, 0xF0, 0xF8, 0xF8, 0x78, 0x38, 0x08, 0x00, 0x01, 0xE0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x06, 0x1C, 0x13, 0xCE, 0x79, 0xFF,
  0xFC, 0xFF, 0xFF, 0x07, 0xF8, 0x01, 0xF0, 0x01, 0xFC, 0x01, 0xEF, 0x01,
  0xE3, 0xC1, 0xF1, 0xE0, 0x70, 0x70, 0x00, 0x20, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0xF3, 0xCF, 0x3D,
  0xF7, 0xDE, 0xFB, 0xC2, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x39,
  0xFB, 0xFF, 0xFF, 0xCF, 0x00, 0x01, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x1E, 0x03, 0xC0, 0x78, 0x00, 0x0F, 0xC0, 0x3F, 0xE0,
  0xFF, 0xE3, 0xFF, 0xC7, 0xFF, 0xDF, 0x9F, 0xBF, 0x1F, 0x7C, 0x3F, 0xF8,
  0x7F, 0xF0, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0x87, 0xFF, 0x0F, 0xFE, 0x1F,
  0xFC, 0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE1, 0xFF, 0xE3, 0xEF, 0xCF, 0xCF,
  0xFF, 0x9F, 0xFE, 0x1F, 0xFC, 0x1F, 0xF0, 0x1F, 0x80, 0x00, 0xC0, 0xF1,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC,
  0x3F, 0xFE, 0x7F, 0xFE, 0x7E, 0x7E, 0xFC, 0x3E, 0xFC, 0x3E, 0xFC, 0x3E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x80,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xE0,
  0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0x7F, 0xFE, 0xFC, 0x7E, 0xFC, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFE, 0x07, 0xFC, 0x07, 0xF8,
  0x07, 0xFC, 0x07, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFF, 0xFE, 0x7F, 0xFE, 0x7F, 0xFC, 0x1F, 0xF8,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xFC,
  0x03, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xFC, 0x0F, 0xFC, 0x1E, 0xFC,
  0x1E, 0xFC, 0x3E, 0xFC, 0x3C, 0xFC, 0x7C, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x3F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFE,
  0x3F, 0xFE, 0x3F, 0xFE, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7D, 0xF0, 0x7F, 0xF8, 0x7F, 0xFC, 0x7F, 0xFE, 0x7C, 0x7E, 0x00, 0x3E,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0x7E, 0x7E,
  0x7F, 0xFE, 0x7F, 0xFE, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xE0, 0x00, 0x78,
  0x03, 0xF8, 0x07, 0xF8, 0x0F, 0xF8, 0x1F, 0xF8, 0x3F, 0x80, 0x3F, 0x00,
  0x3E, 0x00, 0x7E, 0x00, 0x7E, 0xF8, 0x7D, 0xFC, 0x7F, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0x7C, 0x1F, 0x7C, 0x3F,
  0x7E, 0x3F, 0x7E, 0x3F, 0x3F, 0xFF, 0x3F, 0xFE, 0x1F, 0xFC, 0x0F, 0xF8,
  0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8,
  0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x0F, 0xC0, 0x7F, 0xE1, 0xFF, 0xE3,
  0xFF, 0xEF, 0xFF, 0xDF, 0x9F, 0xBF, 0x1F, 0x7E, 0x3E, 0xFC, 0x7D, 0xF9,
  0xF9, 0xFF, 0xF1, 0xFF, 0xC1, 0xFF, 0x07, 0xFF, 0x1F, 0xFF, 0x7E, 0x7E,
  0xFC, 0x7F, 0xF0, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0xC7, 0xFF, 0xFF, 0xBF,
  0xFF, 0x3F, 0xFC, 0x3F, 0xF0, 0x1F, 0x80, 0x03, 0xE0, 0x0F, 0xF0, 0x1F,
  0xF8, 0x3F, 0xFC, 0x3F, 0xFE, 0x7E, 0x7E, 0x7E, 0x3E, 0x7C, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0x7C, 0x3F, 0x7C, 0x3F, 0x7E, 0x3F, 0x7F, 0x7F, 0x3F,
  0xFF, 0x3F, 0xFF, 0x1F, 0xFE, 0x07, 0xBE, 0x00, 0x7E, 0x00, 0x7C, 0x01,
  0xFC, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0x00, 0x38,
  0xFB, 0xFF, 0xF7, 0xCF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0x3E, 0xFF, 0xFD, 0xF1, 0xC0, 0x3C, 0xFD, 0xFB, 0xF7, 0xE7, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x3E, 0x79, 0xF0, 0xC0, 0x00, 0x08, 0x01, 0xC0, 0x3E, 0x07, 0xF0,
  0xFF, 0xBF, 0xFF, 0xFF, 0x1F, 0xE0, 0xFC, 0x07, 0xF8, 0x3F, 0xF0, 0xFF,
  0xF0, 0xFF, 0x81, 0xFC, 0x03, 0xE0, 0x07, 0x00, 0x08, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x07, 0x00, 0x3E,
  0x01, 0xFC, 0x0F, 0xFC, 0x7F, 0xF8, 0x7F, 0xE0, 0xFF, 0x01, 0xF8, 0x3F,
  0xC7, 0xFF, 0xFF, 0xEF, 0xFC, 0x7F, 0x03, 0xE0, 0x1C, 0x00, 0x80, 0x00,
  0x0F, 0xC0, 0xFF, 0xC7, 0xFF, 0xBF, 0xFE, 0xFF, 0xFF, 0xF3, 0xFF, 0x8F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0xFE, 0x07, 0xF0, 0x1F,
  0x80, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x1E, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0xFC, 0x1F, 0x80, 0xF8,
  0x03, 0xE0, 0xF8, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x78, 0x1F, 0x0E, 0x3C,
  0x3F, 0xC7, 0x3C, 0x3F, 0xF3, 0xDE, 0x3F, 0x79, 0xEF, 0x1E, 0x3C, 0x77,
  0x0F, 0x1C, 0x3F, 0x8F, 0x0E, 0x1F, 0xC7, 0x8F, 0x0F, 0xE3, 0xC7, 0x87,
  0xF1, 0xE3, 0xC3, 0xF8, 0xF1, 0xE1, 0xFC, 0x78, 0xF1, 0xFE, 0x3C, 0x78,
  0xFF, 0x1E, 0x3C, 0x77, 0x8F, 0xBE, 0x79, 0xC7, 0xFF, 0xF8, 0xF1, 0xFB,
  0xF8, 0x78, 0x78, 0xF8, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0x1E, 0x00, 0x1F, 0xFF, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0x7E, 0x00, 0x7C, 0xF8,
  0x01, 0xF3, 0xE0, 0x0F, 0xCF, 0xC0, 0x3F, 0x3F, 0x00, 0xF8, 0xFC, 0x07,
  0xE1, 0xF0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF0, 0xFC, 0x0F, 0xC7, 0xE0, 0x3F, 0x9F, 0x80, 0x7E,
  0x7E, 0x01, 0xFB, 0xF8, 0x07, 0xE0, 0xFF, 0xF0, 0x7F, 0xFE, 0x3F, 0xFF,
  0x9F, 0xFF, 0xEF, 0xFF, 0xF7, 0xE1, 0xFB, 0xF0, 0xFF, 0xF8, 0x3F, 0xFC,
  0x1F, 0xFE, 0x1F, 0xBF, 0x0F, 0xDF, 0xFF, 0xCF, 0xFF, 0xC7, 0xFF, 0xF3,
  0xFF, 0xFD, 0xF8, 0x7E, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0xFC, 0xFF, 0xFC, 0x7F,
  0xF8, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC3,
  0xFF, 0xFC, 0xFE, 0x1F, 0x9F, 0x83, 0xF3, 0xF0, 0x3F, 0xFE, 0x07, 0xFF,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0xFD, 0xF8, 0x1F, 0xBF,
  0x07, 0xE7, 0xF0, 0xFC, 0x7F, 0xFF, 0x8F, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F,
  0xFE, 0x00, 0x7F, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFF, 0x1F, 0xFF,
  0xCF, 0xFF, 0xE7, 0xE3, 0xFB, 0xF0, 0xFD, 0xF8, 0x7E, 0xFC, 0x1F, 0xFE,
  0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F,
  0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x0F, 0xDF, 0x87, 0xEF, 0xC7,
  0xF7, 0xFF, 0xF3, 0xFF, 0xF9, 0xFF, 0xF8, 0xFF, 0xF0, 0x7F, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xFF, 0xE7, 0xFF, 0xCF, 0xFF,
  0x9F, 0xFF, 0x3F, 0xFE, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x03,
  0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0xFE,
  0x1F, 0x9F, 0x81, 0xFB, 0xF0, 0x3F, 0x7E, 0x07, 0xEF, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0x8F, 0xFF, 0xF1,
  0xFF, 0x7E, 0x07, 0xEF, 0xC0, 0xFD, 0xF8, 0x1F, 0xBF, 0x03, 0xF7, 0xF0,
  0xFE, 0x7F, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFE, 0x0F, 0xFF, 0x00, 0x3F,
  0x80, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F,
  0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F,
  0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFF, 0xF1, 0xFF, 0xE3, 0xFF, 0xCF, 0xFF,
  0xFF, 0x9F, 0xFF, 0x3F, 0xFC, 0x3F, 0xF0, 0x1F, 0x80, 0xFC, 0x1F, 0xFF,
  0x0F, 0xFF, 0xC3, 0xFB, 0xF1, 0xFC, 0xFC, 0x7F, 0x3F, 0x3F, 0x8F, 0xCF,
  0xC3, 0xF3, 0xF0, 0xFD, 0xF8, 0x3F, 0x7E, 0x0F, 0xFF, 0x03, 0xFF, 0xC0,
  0xFF, 0xF0, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F,
  0xBF, 0x0F, 0xCF, 0xE3, 0xF1, 0xF8, 0xFC, 0x7F, 0x3F, 0x1F, 0xCF, 0xC3,
  0xFB, 0xF0, 0xFE, 0xFC, 0x1F, 0xFF, 0x07, 0xF0, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFB, 0xC7, 0xFF, 0xFB, 0xC7, 0xBF, 0xFB, 0xC7, 0xBF, 0xFB, 0xE7, 0xBF,
  0xF9, 0xEF, 0xBF, 0xFD, 0xEF, 0x3F, 0xFD, 0xEF, 0x3F, 0xFD, 0xFF, 0x3F,
  0xFC, 0xFF, 0x3F, 0xFC, 0xFE, 0x3F, 0xFC, 0xFE, 0x3F, 0xFC, 0xFE, 0x3F,
  0xFC, 0x7E, 0x3F, 0xFC, 0x7C, 0x3F, 0xFC, 0x7C, 0x3F, 0xFC, 0x3C, 0x3F,
  0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFF, 0x0F, 0xFF,
  0xC3, 0xFF, 0xF0, 0xFF, 0xFE, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFC,
  0xFF, 0xFF, 0x3F, 0xFD, 0xEF, 0xFF, 0x7B, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF,
  0xFC, 0xFF, 0xFF, 0x1F, 0xFF, 0xC7, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xFF,
  0x0F, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x03, 0xF0, 0x01,
  0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0xFE,
  0x1F, 0x9F, 0x83, 0xFB, 0xF0, 0x3F, 0x7E, 0x07, 0xFF, 0xC0, 0xFF, 0xF0,
  0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0,
  0x3F, 0xFE, 0x07, 0xEF, 0xC0, 0xFD, 0xF8, 0x1F, 0xBF, 0x07, 0xF7, 0xF0,
  0xFC, 0x7F, 0xFF, 0x8F, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0x7F,
  0x00, 0xFF, 0xF0, 0x7F, 0xFE, 0x3F, 0xFF, 0x9F, 0xFF, 0xEF, 0xFF, 0xF7,
  0xE1, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07,
  0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xF9, 0xFF, 0xF8, 0xFF,
  0xF0, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0xFE, 0x1F, 0x9F,
  0x81, 0xFB, 0xF0, 0x3F, 0x7E, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF,
  0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE,
  0x07, 0xEF, 0xC0, 0xFD, 0xF8, 0x1F, 0xBF, 0x03, 0xF7, 0xF0, 0xFC, 0x7F,
  0xFF, 0x8F, 0xFF, 0xE0, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7C, 0x00, 0x07, 0x00, 0x00, 0x40, 0xFF,
  0xF0, 0x3F, 0xFF, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0x0F,
  0xEF, 0xC1, 0xFB, 0xF0, 0x7E, 0xFC, 0x1F, 0xBF, 0x07, 0xEF, 0xC1, 0xFB,
  0xF0, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0x8F, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF,
  0xFC, 0x3F, 0x3F, 0x0F, 0xCF, 0xE3, 0xF3, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F,
  0xCF, 0xC3, 0xF3, 0xF0, 0xFE, 0xFC, 0x3F, 0xBF, 0x07, 0xE0, 0x03, 0xF0,
  0x03, 0xFF, 0x01, 0xFF, 0xF0, 0xFF, 0xFC, 0x7F, 0xFF, 0x9F, 0x87, 0xE7,
  0xE1, 0xF9, 0xF8, 0x3F, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0xFF,
  0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x1F,
  0xBF, 0x07, 0xEF, 0xC1, 0xFB, 0xF8, 0x7E, 0x7E, 0x1F, 0x9F, 0xFF, 0xE3,
  0xFF, 0xF8, 0x7F, 0xFC, 0x0F, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0xFC, 0x1F, 0xFE, 0x0F,
  0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8,
  0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF,
  0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07,
  0xFF, 0x83, 0xFF, 0xC3, 0xFF, 0xFF, 0xF9, 0xFF, 0xFC, 0x7F, 0xFC, 0x1F,
  0xFC, 0x03, 0xF8, 0x00, 0xFE, 0x03, 0xFB, 0xF0, 0x1F, 0x9F, 0x80, 0xFC,
  0xFE, 0x0F, 0xE7, 0xF0, 0x7F, 0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0x87, 0xE0,
  0xFC, 0x3F, 0x8F, 0xE0, 0xFC, 0x7E, 0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x80,
  0xF8, 0xF8, 0x07, 0xEF, 0xC0, 0x3F, 0x7E, 0x01, 0xFB, 0xF0, 0x07, 0xDF,
  0x00, 0x3E, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0xFC, 0x3E, 0x1F, 0xFE, 0x1F, 0x0F, 0xFF, 0x1F, 0x87, 0xFF, 0x8F,
  0xC3, 0xFF, 0xC7, 0xF1, 0xF7, 0xE3, 0xF9, 0xF9, 0xF1, 0xFC, 0xFC, 0xFD,
  0xFE, 0x7E, 0x7E, 0xFF, 0x3F, 0x3F, 0x7F, 0xDF, 0x9F, 0xBF, 0xEF, 0x8F,
  0xDF, 0xF7, 0xC3, 0xEF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8,
  0x7F, 0xEF, 0xFC, 0x3F, 0xF7, 0xFC, 0x1F, 0xFB, 0xFE, 0x07, 0xF9, 0xFF,
  0x03, 0xFC, 0xFF, 0x81, 0xFE, 0x3F, 0xC0, 0xFF, 0x1F, 0xE0, 0x7F, 0x8F,
  0xE0, 0x3F, 0xC7, 0xF0, 0x0F, 0xC3, 0xF8, 0x07, 0xE1, 0xFC, 0x00, 0x7E,
  0x07, 0xF7, 0xF0, 0xFE, 0x3F, 0x0F, 0xE3, 0xF0, 0xFC, 0x3F, 0x9F, 0xC1,
  0xF9, 0xF8, 0x1F, 0x9F, 0x80, 0xFD, 0xF8, 0x0F, 0xFF, 0x00, 0x7F, 0xF0,
  0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xDF, 0x81, 0xF9,
  0xF8, 0x1F, 0x9F, 0xC3, 0xF8, 0xFC, 0x3F, 0x0F, 0xC7, 0xF0, 0xFE, 0x7F,
  0x07, 0xEF, 0xE0, 0x7F, 0xFE, 0x07, 0xE7, 0xE0, 0x7E, 0x7E, 0x0F, 0xE3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xF8, 0x1F, 0x9F, 0x81, 0xF9, 0xF8,
  0x0F, 0x9F, 0x00, 0xFB, 0xF0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE,
  0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xF8, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07,
  0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xBF, 0x7E,
  0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF,
  0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xF7, 0xEF, 0xDF,
  0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7,
  0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x3F, 0x81, 0xFC, 0x1F, 0xE0,
  0xF7, 0x87, 0xBC, 0x79, 0xE3, 0xC7, 0x9E, 0x3D, 0xE1, 0xEF, 0x0F, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0x83, 0xF0, 0x7C,
  0x0F, 0x81, 0xE0, 0x0F, 0xE0, 0x3F, 0xE0, 0xFF, 0xE3, 0xFF, 0xEF, 0xCF,
  0xDF, 0x9F, 0x80, 0x1F, 0x07, 0xFE, 0x3F, 0xFC, 0xFF, 0xFB, 0xF9, 0xF7,
  0xE3, 0xEF, 0xC7, 0xDF, 0x8F, 0xBF, 0x3F, 0x7F, 0xFE, 0x7F, 0xFC, 0xFE,
  0xFC, 0x79, 0xF8, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF9, 0xE1, 0xFF, 0xF3, 0xFF, 0xF7,
  0xFF, 0xEF, 0xFF, 0xDF, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF0,
  0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0x87, 0xFF, 0x0F, 0xFF, 0xFF, 0x7F, 0xFE,
  0xFF, 0xFD, 0xFF, 0xF3, 0xE7, 0x80, 0x0F, 0xE0, 0x3F, 0xE0, 0xFF, 0xE3,
  0xFF, 0xE7, 0xFF, 0xDF, 0x8F, 0xBF, 0x1F, 0xFE, 0x3F, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC7, 0xFF, 0x8F, 0x9F, 0xFF, 0x3F, 0xFE,
  0x3F, 0xF8, 0x3F, 0xE0, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x0F, 0x7E, 0x7F,
  0xFD, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0x1F, 0xFE, 0x3F,
  0xFC, 0x7F, 0xF8, 0xFF, 0xF1, 0xFF, 0xE3, 0xFF, 0xC7, 0xFF, 0x8F, 0xFF,
  0xFF, 0xBF, 0xFF, 0x7F, 0xFE, 0x7F, 0x7C, 0x7C, 0xF8, 0x07, 0xE0, 0x1F,
  0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0x7F, 0xFE, 0xFC, 0x3E, 0xFC, 0x3E, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFC, 0x00, 0xFE,
  0x08, 0x7F, 0xFC, 0x7F, 0xFE, 0x3F, 0xFE, 0x1F, 0xFC, 0x07, 0xF0, 0x03,
  0xF0, 0x7F, 0x0F, 0xF1, 0xFF, 0x1F, 0xF1, 0xF8, 0x1F, 0x01, 0xF0, 0xFF,
  0xEF, 0xFE, 0xFF, 0xEF, 0xFE, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x00, 0x0F, 0xBF, 0x3F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF,
  0x7F, 0xFF, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0x7F, 0xFF, 0x7F, 0xFF,
  0x7F, 0xFF, 0x3F, 0xFF, 0x0F, 0xBF, 0x00, 0x3F, 0x10, 0x7E, 0x1C, 0xFE,
  0x3F, 0xFE, 0x3F, 0xFC, 0x3F, 0xF8, 0x0F, 0xE0, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0xF1, 0xFB, 0xFB, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0x0F,
  0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF,
  0x87, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF0, 0xF8, 0x73,
  0xEF, 0xFF, 0xF9, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x0F, 0x87, 0xE3,
  0xF1, 0xF0, 0x78, 0x00, 0x00, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC,
  0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F,
  0x8F, 0xC7, 0xE3, 0xF1, 0xFF, 0xFB, 0xFD, 0xFE, 0xFE, 0x7C, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0xFE, 0xF8, 0xFE, 0xF9, 0xFC, 0xF9, 0xF8, 0xFB,
  0xF0, 0xFB, 0xF0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF,
  0xF0, 0xFF, 0xF0, 0xFD, 0xF8, 0xF9, 0xF8, 0xF9, 0xFC, 0xF8, 0xFC, 0xF8,
  0xFE, 0xF8, 0x7E, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xF9, 0xF0, 0xF1, 0xF7, 0xF7, 0xF3, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x9F, 0x8F, 0xFE, 0x3F, 0x1F, 0xFC, 0x7E,
  0x3F, 0xF8, 0xFC, 0x7F, 0xF1, 0xF8, 0xFF, 0xE3, 0xF1, 0xFF, 0xC7, 0xE3,
  0xFF, 0x8F, 0xC7, 0xFF, 0x1F, 0x8F, 0xFE, 0x3F, 0x1F, 0xFC, 0x7E, 0x3F,
  0xF8, 0xFC, 0x7F, 0xF1, 0xF8, 0xFF, 0xE3, 0xF1, 0xF8, 0xFC, 0xF9, 0xFB,
  0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0x0F, 0xFE, 0x1F,
  0xFC, 0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0x87, 0xFF,
  0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF0, 0xF8, 0x07, 0xE0, 0x1F,
  0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0x7F, 0xFE, 0xFC, 0x7E, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3E, 0x7F, 0xFE, 0x7F, 0xFE, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xE0, 0xF9,
  0xE1, 0xFF, 0xF3, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0xDF, 0x0F, 0xFE, 0x1F,
  0xFC, 0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0x87, 0xFF,
  0x0F, 0xFF, 0xFF, 0x7F, 0xFE, 0xFF, 0xF9, 0xFF, 0xF3, 0xE7, 0x87, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x00,
  0x1F, 0x3E, 0x7F, 0x7D, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0x1F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF8, 0xFF, 0xF1, 0xFF, 0xE3, 0xFF, 0xC7,
  0xFF, 0x8F, 0xFF, 0xFF, 0xBF, 0xFF, 0x7F, 0xFE, 0x7F, 0xFC, 0x3D, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0xF9, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xE0, 0xF8,
  0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F,
  0x80, 0x0F, 0xC0, 0xFF, 0xC7, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xF3, 0xFF,
  0xC0, 0x1F, 0xC0, 0x7F, 0xC0, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x00, 0xFF,
  0xE1, 0xFF, 0xCF, 0xFF, 0xFF, 0x7F, 0xF8, 0xFF, 0xC0, 0xFC, 0x00, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0xF1, 0xFE, 0x3F, 0xC3, 0xF8, 0x3F, 0xFC, 0x3F, 0xF8, 0x7F,
  0xF0, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0x87, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC,
  0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0x8F, 0xDF, 0xFF,
  0xBF, 0xFF, 0x7F, 0xFE, 0x7F, 0x7C, 0x7C, 0xF8, 0xFC, 0x3F, 0x7E, 0x3F,
  0x7E, 0x3F, 0x7E, 0x3E, 0x7E, 0x7E, 0x3E, 0x7E, 0x3E, 0x7E, 0x3F, 0x7C,
  0x1F, 0x7C, 0x1F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0xF8, 0xF1,
  0xFF, 0xC7, 0xCF, 0xFE, 0x3E, 0x7D, 0xF3, 0xF3, 0xEF, 0xDF, 0x9F, 0x3E,
  0xFC, 0xF9, 0xF7, 0xF7, 0xCF, 0xBF, 0xBE, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF,
  0x0F, 0xF7, 0xF8, 0x7F, 0xBF, 0xC3, 0xF9, 0xFE, 0x1F, 0xCF, 0xE0, 0xFE,
  0x3F, 0x07, 0xF1, 0xF8, 0x1F, 0x8F, 0xC0, 0xF8, 0x7E, 0x07, 0xC3, 0xE0,
  0x7E, 0x3F, 0x7E, 0x3E, 0x3E, 0x7E, 0x3F, 0x7E, 0x1F, 0x7C, 0x1F, 0xFC,
  0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8,
  0x1F, 0xFC, 0x1F, 0xFC, 0x3F, 0x7C, 0x3F, 0x7E, 0x7E, 0x7E, 0x7E, 0x3F,
  0x7E, 0x3F, 0xFC, 0x3F, 0x7E, 0x3F, 0x7E, 0x3F, 0x7E, 0x7E, 0x7E, 0x7E,
  0x3E, 0x7E, 0x3F, 0x7E, 0x3F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xF8,
  0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0,
  0x3F, 0x80, 0x3F, 0x80, 0x3E, 0x00, 0x7F, 0xFD, 0xFF, 0xF7, 0xFF, 0xDF,
  0xFF, 0x7F, 0xF8, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x01,
  0xFC, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0x03, 0x83, 0xC3, 0xE1, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF1, 0xF1, 0xF8, 0xF8, 0x7C,
  0x3F, 0x0F, 0x83, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0xE0, 0xF0, 0x7C, 0x1E, 0x07, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x40, 0x38, 0x3E, 0x0F, 0x87,
  0xC3, 0xE0, 0xF0, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8,
  0x3F, 0x0F, 0x87, 0xC7, 0xE7, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0x8F, 0x87, 0xC3, 0xE1, 0xF1, 0xF0, 0x70, 0x20, 0x00, 0x1E, 0x00,
  0x7F, 0x0F, 0x7F, 0x9F, 0xFF, 0xFF, 0xFF, 0xFE, 0xF1, 0xFE, 0xF1, 0xFC,
  0x00, 0x78,
};

const GFXglyph RobotoCondensed_Black36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 6, 26, 10, 2, -26 },
  { 21, 11, 10, 11, 0, -27 },
  { 35, 16, 26, 18, 1, -26 },
  { 87, 16, 33, 18, 1, -30 },
  { 153, 20, 26, 23, 2, -26 },
  { 218, 20, 26, 21, 1, -26 },
  { 283, 4, 10, 6, 1, -27 },
  { 288, 9, 36, 12, 2, -28 },
  { 329, 9, 36, 12, 1, -28 },
  { 370, 17, 16, 17, 0, -26 },
  { 404, 15, 19, 17, 1, -21 },
  { 440, 6, 11, 10, 1, -4 },
  { 449, 9, 5, 15, 3, -14 },
  { 455, 7, 6, 11, 2, -6 },
  { 461, 11, 28, 11, 0, -26 },
  { 500, 15, 26, 18, 2, -26 },
  { 549, 10, 26, 18, 3, -26 },
  { 582, 16, 26, 18, 1, -26 },
  { 634, 16, 26, 18, 1, -26 },
  { 686, 16, 26, 18, 1, -26 },
  { 738, 16, 26, 18, 1, -26 },
  { 790, 16, 26, 18, 1, -26 },
  { 842, 16, 26, 18, 1, -26 },
  { 894, 15, 26, 18, 2, -26 },
  { 943, 16, 26, 18, 1, -26 },
  { 995, 7, 20, 11, 2, -20 },
  { 1013, 7, 27, 10, 1, -20 },
  { 1037, 13, 17, 16, 1, -19 },
  { 1065, 14, 13, 19, 2, -18 },
  { 1088, 13, 17, 16, 2, -19 },
  { 1116, 14, 26, 17, 1, -26 },
  { 1162, 25, 33, 28, 1, -25 },
  { 1266, 22, 26, 22, 0, -26 },
  { 1338, 17, 26, 20, 2, -26 },
  { 1394, 19, 26, 21, 1, -26 },
  { 1456, 17, 26, 20, 2, -26 },
  { 1512, 15, 26, 18, 2, -26 },
  { 1561, 14, 26, 17, 2, -26 },
  { 1607, 19, 26, 21, 1, -26 },
  { 1669, 18, 26, 22, 2, -26 },
  { 1728, 6, 26, 10, 2, -26 },
  { 1748, 15, 26, 18, 1, -26 },
  { 1797, 18, 26, 20, 2, -26 },
  { 1856, 14, 26, 17, 2, -26 },
  { 1902, 24, 26, 27, 2, -26 },
  { 1980, 18, 26, 22, 2, -26 },
  { 2039, 19, 26, 22, 1, -26 },
  { 2101, 17, 26, 21, 2, -26 },
  { 2157, 19, 31, 22, 1, -26 },
  { 2231, 18, 26, 20, 2, -26 },
  { 2290, 18, 26, 20, 1, -26 },
  { 2349, 18, 26, 20, 1, -26 },
  { 2408, 17, 26, 21, 2, -26 },
  { 2464, 21, 26, 21, 0, -26 },
  { 2533, 25, 26, 27, 1, -26 },
  { 2615, 20, 26, 20, 0, -26 },
  { 2680, 20, 26, 20, 0, -26 },
  { 2745, 17, 26, 19, 1, -26 },
  { 2801, 7, 36, 10, 2, -30 },
  { 2833, 15, 28, 14, 0, -26 },
  { 2886, 7, 36, 10, 1, -30 },
  { 2918, 13, 13, 14, 1, -26 },
  { 2940, 14, 4, 14, 0, 0 },
  { 2947, 10, 6, 12, 1, -27 },
  { 2955, 15, 19, 17, 1, -19 },
  { 2991, 15, 27, 18, 2, -27 },
  { 3042, 15, 19, 17, 1, -19 },
  { 3078, 15, 27, 18, 1, -27 },
  { 3129, 16, 19, 17, 1, -19 },
  { 3167, 12, 27, 12, 0, -27 },
  { 3208, 16, 26, 18, 1, -19 },
  { 3260, 15, 27, 18, 1, -27 },
  { 3311, 6, 27, 9, 2, -27 },
  { 3332, 9, 34, 9, -1, -27 },
  { 3371, 16, 27, 18, 2, -27 },
  { 3425, 6, 27, 9, 2, -27 },
  { 3446, 23, 19, 27, 2, -19 },
  { 3501, 15, 19, 18, 1, -19 },
  { 3537, 16, 19, 18, 1, -19 },
  { 3575, 15, 26, 18, 2, -19 },
  { 3624, 15, 26, 18, 1, -19 },
  { 3673, 10, 19, 12, 2, -19 },
  { 3697, 14, 19, 16, 1, -19 },
  { 3731, 11, 24, 11, 0, -24 },
  { 3764, 15, 19, 18, 1, -19 },
  { 3800, 16, 19, 17, 0, -19 },
  { 3838, 21, 19, 22, 1, -19 },
  { 3888, 16, 19, 16, 0, -19 },
  { 3926, 16, 26, 17, 0, -19 },
  { 3978, 14, 19, 16, 1, -19 },
  { 4012, 9, 34, 11, 1, -28 },
  { 4051, 3, 31, 9, 3, -26 },
  { 4063, 9, 34, 11, 1, -28 },
  { 4102, 16, 8, 20, 2, -14 },
};

const GFXfont RobotoCondensed_Black36pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Black36pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Black36pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _ROBOTOCONDENSED_BLACK36PT7B_H_
