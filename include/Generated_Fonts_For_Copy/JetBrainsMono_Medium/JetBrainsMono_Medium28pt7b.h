#ifndef _JETBRAINSMONO_MEDIUM28PT7B_H_
#define _JETBRAINSMONO_MEDIUM28PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Medium.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Medium28pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x38, 0x00, 0x07,
  0xBE, 0xE0, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0x06,
  0x1C, 0x0C, 0x30, 0x38, 0x60, 0x60, 0xC0, 0xC3, 0x8F, 0xFF, 0xDF, 0xFF,
  0x8E, 0x18, 0x1C, 0x30, 0x30, 0x60, 0x61, 0xC0, 0xC3, 0x01, 0x86, 0x1F,
  0xFF, 0xBF, 0xFF, 0x18, 0x70, 0x30, 0xE0, 0x61, 0x81, 0xC3, 0x03, 0x86,
  0x00, 0x02, 0x00, 0x10, 0x00, 0x80, 0x0F, 0x03, 0xFE, 0x3F, 0xF9, 0xC9,
  0xDE, 0x4F, 0xE2, 0x3F, 0x10, 0x3C, 0x80, 0xF4, 0x07, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7E, 0x02, 0x78, 0x11, 0xC0, 0x8F, 0xC4, 0x7E, 0x27, 0xBF,
  0x79, 0xFF, 0x83, 0xF8, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x08,
  0x00, 0xBF, 0x01, 0x9D, 0xC1, 0x9C, 0x61, 0xCE, 0x30, 0xC7, 0x18, 0xC3,
  0x8C, 0xE0, 0xEE, 0x60, 0x7F, 0x60, 0x0E, 0x60, 0x00, 0x70, 0x00, 0x30,
  0x00, 0x33, 0xE0, 0x3B, 0xF8, 0x19, 0x8C, 0x19, 0xC6, 0x1C, 0xE3, 0x0C,
  0x71, 0x8C, 0x18, 0xCE, 0x0F, 0xEE, 0x03, 0xE0, 0x07, 0x80, 0x3F, 0xC0,
  0xFF, 0xC1, 0xC3, 0x83, 0x87, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x7C, 0x01, 0xF8, 0x03, 0xB8, 0xFE, 0x39, 0xDC, 0x7F, 0x38, 0x7E,
  0x70, 0x78, 0xE0, 0x71, 0xE1, 0xE1, 0xE7, 0xE3, 0xFE, 0xE3, 0xF1, 0xE0,
  0xFF, 0xFF, 0xFF, 0x00, 0x81, 0xC3, 0xE3, 0xE3, 0xC3, 0xC1, 0xC0, 0xE0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x07, 0x03, 0x81, 0xE0, 0x7C, 0x1F, 0x87, 0xC0, 0xE0, 0x80, 0x70,
  0x3E, 0x0F, 0x81, 0xE0, 0x70, 0x1C, 0x0E, 0x07, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0xF0, 0x70, 0x78, 0x38,
  0x7C, 0xFC, 0x78, 0x38, 0x00, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x06, 0x38, 0xDF, 0x27, 0xFF, 0x7F, 0x0F, 0xF0, 0x03, 0x80, 0x0D, 0x80,
  0x3B, 0x80, 0xE3, 0x83, 0xC7, 0x83, 0x06, 0x00, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x00, 0x3E, 0x78, 0xF1, 0xC7, 0x8E, 0x1C,
  0x70, 0xFF, 0xFF, 0xFF, 0xE0, 0x67, 0xFF, 0xFF, 0x00, 0x00, 0x78, 0x03,
  0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0xC0,
  0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x1E,
  0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00,
  0xF0, 0x07, 0x00, 0x00, 0x07, 0x01, 0xFE, 0x1F, 0xFC, 0xE1, 0xEE, 0x07,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x39, 0xF9, 0xCF, 0xCE, 0x7E,
  0x23, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x83, 0x9E, 0x7C, 0x7F,
  0xC1, 0xFC, 0x00, 0x0F, 0x81, 0xFC, 0x1E, 0xE1, 0xE7, 0x0E, 0x38, 0x41,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x87, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0x01, 0xFE, 0x1F, 0xF9, 0xE1, 0xEE, 0x07, 0x70, 0x3C, 0x00, 0xE0,
  0x0E, 0x00, 0x70, 0x07, 0x80, 0x38, 0x03, 0x80, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xF3, 0xFF, 0x80, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x01, 0xF0,
  0x0F, 0xE0, 0x7F, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x80, 0x1F, 0x81, 0xFC,
  0x0E, 0xE0, 0x73, 0xCF, 0x9F, 0xF8, 0x3F, 0x80, 0x01, 0xE0, 0x1C, 0x03,
  0x80, 0x78, 0x07, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x38, 0x77, 0x87, 0x70,
  0x7E, 0x07, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x7F, 0xF3, 0xFF, 0x9C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0F, 0xFC, 0x7F, 0xF3, 0xC7, 0x9C, 0x1C, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xFC, 0x0F, 0xF0, 0x73, 0xCF, 0x8F, 0xF8, 0x3F, 0x80, 0x03,
  0xC0, 0x3C, 0x01, 0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x07, 0x70,
  0x77, 0xE7, 0xFF, 0xBC, 0x1D, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xF0, 0x7B, 0xCF, 0x8F, 0xF8, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xF8,
  0x0F, 0xC0, 0x7E, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0E,
  0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00,
  0x70, 0x07, 0x80, 0x38, 0x00, 0x0F, 0x01, 0xFF, 0x1F, 0xF8, 0xE1, 0xEF,
  0x07, 0x70, 0x3B, 0x81, 0xCE, 0x0E, 0x78, 0xE1, 0xFE, 0x03, 0xE0, 0x7F,
  0xC7, 0x8F, 0x78, 0x3B, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x83, 0xDE, 0x7C,
  0xFF, 0xC1, 0xFC, 0x00, 0x0F, 0x01, 0xFE, 0x1F, 0xFD, 0xE1, 0xEE, 0x07,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x83, 0xDE, 0x3C, 0xFF, 0xE3,
  0xFF, 0x00, 0x70, 0x07, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x1C,
  0x01, 0xE0, 0x00, 0x67, 0xFF, 0xF7, 0x00, 0x00, 0x00, 0x00, 0x07, 0x7F,
  0xFE, 0x39, 0xF7, 0xDF, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3D, 0xE7,
  0x9C, 0x73, 0x8E, 0x38, 0x00, 0x08, 0x01, 0xC0, 0x3E, 0x07, 0xE0, 0xFC,
  0x1F, 0x03, 0xE0, 0x1C, 0x00, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3C, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0x00, 0x3E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x00, 0x78, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC0, 0x78, 0x03, 0x00, 0x00, 0xFE, 0x3F, 0xC0,
  0xF8, 0x0F, 0x01, 0xC0, 0x70, 0x1C, 0x0F, 0x07, 0x8F, 0xE3, 0xE0, 0xC0,
  0x30, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x07, 0x81, 0xE0, 0x03, 0xC0,
  0x3F, 0xE0, 0xFF, 0xE3, 0xC0, 0xE7, 0x00, 0xDC, 0x01, 0xF8, 0x03, 0xF0,
  0x67, 0xE3, 0xFF, 0xC7, 0x3F, 0x8C, 0x3F, 0x18, 0x7E, 0x30, 0xFC, 0x61,
  0xF8, 0xC3, 0xF1, 0x87, 0xE3, 0x0F, 0xC7, 0xFF, 0x87, 0xDF, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0xC0, 0x0F, 0x80, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x76, 0x00, 0xEE, 0x01, 0xDC, 0x03, 0x38,
  0x0E, 0x30, 0x1C, 0x70, 0x38, 0xE0, 0x71, 0xC1, 0xC1, 0x83, 0xFF, 0x87,
  0xFF, 0x0F, 0xFE, 0x38, 0x1C, 0x70, 0x1C, 0xE0, 0x39, 0xC0, 0x77, 0x00,
  0xF0, 0xFF, 0xC7, 0xFF, 0x38, 0x3D, 0xC0, 0xEE, 0x03, 0xF0, 0x1F, 0x81,
  0xDC, 0x1E, 0xFF, 0xE7, 0xFE, 0x3F, 0xFD, 0xC0, 0xEE, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x7F, 0xFF, 0xBF, 0xF9, 0xFF, 0x80, 0x07, 0x01,
  0xFF, 0x1F, 0xFC, 0xF1, 0xEF, 0x07, 0xF0, 0x1F, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x07,
  0xE0, 0x3B, 0x83, 0x9F, 0x7C, 0x7F, 0xC1, 0xFC, 0x00, 0xFF, 0xC7, 0xFF,
  0x38, 0x7D, 0xC0, 0xEE, 0x07, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x0E, 0xE0,
  0xF7, 0xFF, 0xBF, 0xF9, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xFF, 0xEF, 0xFE, 0xFF, 0xEE, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xFF, 0xF7, 0xFF, 0xBF, 0xFD, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x07, 0x01, 0xFF,
  0x1F, 0xFC, 0xF1, 0xEF, 0x07, 0xF0, 0x1F, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0xFF, 0xC7, 0xFE, 0x3F, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3B, 0x83, 0x9F, 0x7C, 0x7F, 0xC1, 0xFC, 0x00, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xFF, 0xFF, 0xFC, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xF8, 0x3F, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1F, 0x80, 0xFC, 0x07, 0xF0, 0x7B, 0xEF, 0x8F,
  0xF8, 0x3F, 0x80, 0xE0, 0x3F, 0x81, 0xEE, 0x07, 0x38, 0x3C, 0xE0, 0xE3,
  0x87, 0x8E, 0x1C, 0x38, 0xF0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x38, 0xF0,
  0xE1, 0xC3, 0x87, 0x8E, 0x0E, 0x38, 0x3C, 0xE0, 0x73, 0x81, 0xEE, 0x03,
  0xB8, 0x0F, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0x83, 0xFC,
  0x3F, 0xB1, 0xBD, 0x8D, 0xEC, 0xFF, 0x36, 0xF9, 0xB7, 0xED, 0xBF, 0x79,
  0xF9, 0xCF, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x70, 0xF0, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F,
  0xC3, 0xF6, 0x1F, 0xB8, 0xFD, 0xC7, 0xE6, 0x3F, 0x39, 0xF9, 0xCF, 0xC6,
  0x7E, 0x3B, 0xF1, 0xDF, 0x86, 0xFC, 0x3F, 0xE1, 0xFF, 0x07, 0xF8, 0x3F,
  0xC0, 0xF0, 0x0F, 0x01, 0xFE, 0x1F, 0xF8, 0xE1, 0xEF, 0x07, 0x70, 0x3F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x73, 0x83, 0x9F, 0x7C, 0x7F, 0xC1, 0xFC,
  0x00, 0xFF, 0xE3, 0xFF, 0xCE, 0x0F, 0xB8, 0x0E, 0xE0, 0x3B, 0x80, 0xFE,
  0x03, 0xF8, 0x0E, 0xE0, 0x7B, 0xFF, 0xCF, 0xFE, 0x3F, 0xF0, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0x07, 0x01, 0xFE, 0x1F, 0xFC, 0xE1, 0xEF, 0x07, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x7F, 0x83, 0x9F, 0x7C, 0x7F, 0xC1, 0xFC, 0x00, 0xE0,
  0x07, 0x80, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0xFF, 0xC7, 0xFF, 0xB8, 0x3D,
  0xC0, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x77, 0xFF, 0xBF,
  0xF9, 0xFF, 0x0E, 0x1C, 0x70, 0xE3, 0x83, 0x9C, 0x1C, 0xE0, 0xF7, 0x03,
  0xB8, 0x1F, 0xC0, 0x70, 0x0F, 0x81, 0xFF, 0x1F, 0xFC, 0xE0, 0xEF, 0x07,
  0xF0, 0x1F, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x1F, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0xE0, 0x3F, 0x83, 0xDF, 0x7C, 0xFF,
  0xC1, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x81, 0xFC, 0x0E, 0x70, 0x73, 0xEF, 0x8F, 0xF8, 0x3F, 0x80, 0xF0,
  0x1E, 0xE0, 0x39, 0xC0, 0x73, 0x80, 0xE7, 0x03, 0x87, 0x07, 0x0E, 0x0E,
  0x1C, 0x1C, 0x38, 0x70, 0x38, 0xE0, 0x71, 0xC0, 0xE3, 0x81, 0xCE, 0x01,
  0xDC, 0x03, 0xB8, 0x07, 0x70, 0x06, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0xC3, 0x8F, 0x87, 0x1F, 0x8A, 0x3F, 0x14, 0x7E, 0x68, 0xFC, 0xD9,
  0xF9, 0xB3, 0x73, 0x66, 0x66, 0xCC, 0xCD, 0x99, 0x93, 0x33, 0x26, 0xE7,
  0xC5, 0xCF, 0x8B, 0x9F, 0x1F, 0x3E, 0x3C, 0x7C, 0x78, 0x78, 0xF0, 0xF1,
  0xE1, 0xC3, 0xC0, 0xF0, 0x1E, 0xF0, 0x70, 0xE0, 0xE1, 0xE3, 0x81, 0xC7,
  0x03, 0xDC, 0x03, 0xB8, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0x00, 0x1F, 0x00,
  0x3E, 0x00, 0xEE, 0x01, 0xDC, 0x07, 0x1C, 0x1E, 0x38, 0x38, 0x38, 0xF0,
  0x71, 0xC0, 0x77, 0x80, 0xF0, 0xE0, 0x1E, 0xE0, 0x39, 0xC0, 0x71, 0xC1,
  0xC3, 0x83, 0x83, 0x8E, 0x07, 0x1C, 0x07, 0x70, 0x0E, 0xE0, 0x1F, 0x80,
  0x1F, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0xFF, 0xF7, 0xFF, 0x80, 0x1C,
  0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x07, 0x80, 0x38, 0x03,
  0xC0, 0x1C, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x03, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0x70, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x70, 0x01,
  0xC0, 0xFF, 0xFF, 0xF8, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0xFF, 0xFF, 0xFC,
  0x07, 0x00, 0x7C, 0x03, 0x60, 0x3B, 0x81, 0x9C, 0x1C, 0x70, 0xE3, 0x8E,
  0x0C, 0x70, 0x77, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xF1, 0xC3, 0x87,
  0x07, 0x01, 0xFF, 0x1F, 0xFC, 0xE0, 0xEF, 0x07, 0x00, 0x3C, 0x01, 0xE7,
  0xFF, 0x7F, 0xFF, 0x83, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF8, 0x5D, 0xFE,
  0xE7, 0xE7, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x30, 0x77, 0xF3,
  0xBF, 0xDF, 0x1E, 0xF0, 0x77, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFE, 0x0F, 0xF0, 0x77, 0xEF, 0xBB, 0xF9, 0xCF, 0x80, 0x07,
  0x01, 0xFF, 0x1F, 0xFC, 0xF1, 0xEF, 0x07, 0xF0, 0x1F, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x7F, 0x07, 0x3E, 0xF8, 0xFF, 0x83,
  0xF8, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x0E, 0x73, 0xF7, 0x7F, 0xF7,
  0x0B, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xF0, 0x77, 0x9F, 0x7F, 0xF3, 0xF7, 0x07, 0x01, 0xFE, 0x1F, 0xF8,
  0xE0, 0xEE, 0x07, 0x70, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x38,
  0x01, 0xC0, 0x07, 0x07, 0xBC, 0x78, 0xFF, 0x83, 0xF8, 0x07, 0xF8, 0x3F,
  0xC3, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x0E, 0x03, 0xFF, 0x7F, 0xF7, 0x0F,
  0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x77, 0x07,
  0x7F, 0xF3, 0xFF, 0x1F, 0x70, 0x07, 0x00, 0x70, 0x07, 0x3F, 0xF3, 0xFE,
  0x3F, 0xC0, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x38, 0x77, 0xF3,
  0xBF, 0xDF, 0x1E, 0xF0, 0x77, 0x03, 0xB8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xF0, 0x07,
  0x00, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x7F, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0xC0, 0x3C, 0x07, 0x80, 0xE0, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x7F, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x1E, 0xFF,
  0xDF, 0xF3, 0xF8, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x07, 0x80, 0xEE, 0x07, 0x38, 0x3C, 0xE0, 0xE3, 0x87, 0x0E, 0x3C, 0x3F,
  0xE0, 0xFF, 0x83, 0x8F, 0x0E, 0x1C, 0x38, 0x78, 0xE0, 0xF3, 0x81, 0xCE,
  0x07, 0xB8, 0x0F, 0xFF, 0x01, 0xFE, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0F,
  0xFC, 0x0F, 0xF8, 0x0F, 0xF0, 0x0C, 0x66, 0xF7, 0xBF, 0xFF, 0x8E, 0x7C,
  0x73, 0xE3, 0x9F, 0x1C, 0xF8, 0xE7, 0xC7, 0x3E, 0x39, 0xF1, 0xCF, 0x8E,
  0x7C, 0x73, 0xE3, 0x9F, 0x1C, 0xF8, 0xE7, 0x03, 0x87, 0x7F, 0x3B, 0xFD,
  0xF1, 0xEF, 0x07, 0x70, 0x3B, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0x07, 0x01, 0xFE,
  0x1F, 0xF8, 0xF1, 0xEF, 0x07, 0x70, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0xF7, 0x07, 0x3E, 0xF8, 0xFF, 0x83, 0xF8, 0x03,
  0x87, 0x7F, 0x3B, 0xFD, 0xF1, 0xEF, 0x07, 0x70, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xE0, 0xFF, 0x07, 0x7E, 0xFB, 0xBF, 0x9C,
  0xF8, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x0E, 0x03,
  0xF7, 0x7F, 0xF7, 0x0F, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xF0, 0x77, 0xDF, 0x7F, 0xF3, 0xF7, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x03, 0x0E, 0xFC, 0xFF, 0xEF, 0x0F,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x07, 0x01, 0xFF, 0x1F, 0xFC, 0xE0,
  0xE7, 0x00, 0xB8, 0x01, 0xE0, 0x0F, 0xF8, 0x1F, 0xF0, 0x0F, 0x80, 0x1E,
  0x00, 0x7E, 0x03, 0xBC, 0x79, 0xFF, 0xC7, 0xFC, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x03, 0xFF, 0xFF, 0xFF, 0xC1, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x7E, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x1C, 0xE0, 0xE7, 0xDF, 0x1F, 0xF0, 0x7F, 0x00, 0xF0, 0x1D, 0xC0, 0x77,
  0x01, 0xCE, 0x0E, 0x38, 0x38, 0xE0, 0xE1, 0xC7, 0x07, 0x1C, 0x1C, 0x70,
  0x3B, 0x80, 0xEE, 0x03, 0xB8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xC3,
  0x8F, 0xC7, 0x1F, 0x8E, 0x3F, 0x14, 0x66, 0x68, 0xCC, 0xD9, 0x99, 0xB3,
  0x33, 0x6E, 0x74, 0xDC, 0xE8, 0xB1, 0xF1, 0x61, 0xE3, 0xC3, 0xC7, 0x87,
  0x8F, 0x0E, 0x1E, 0x00, 0x78, 0x3C, 0x70, 0x70, 0x71, 0xC0, 0xF7, 0x80,
  0xEE, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1D, 0xC0, 0x7B,
  0xC0, 0xE3, 0x83, 0x87, 0x8F, 0x07, 0xBC, 0x07, 0x80, 0xF0, 0x1E, 0xE0,
  0x39, 0xE0, 0xE1, 0xC1, 0xC3, 0x83, 0x83, 0x8E, 0x07, 0x1C, 0x0F, 0x38,
  0x0E, 0xE0, 0x1D, 0xC0, 0x1B, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0x70, 0x00,
  0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x7F,
  0xF7, 0xFF, 0x00, 0xF0, 0x0E, 0x01, 0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF8,
  0x0F, 0xC0, 0xFE, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x1E, 0x0F, 0xE0, 0x7F, 0x80, 0x1E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x7F, 0x01, 0xF8, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1F, 0x00, 0x7F,
  0x83, 0xFC, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x1F, 0xC0, 0xFC, 0x07, 0xC0, 0x00, 0x78, 0x1F,
  0xF0, 0xFB, 0xCF, 0x8F, 0x7C, 0x3F, 0xE0, 0xF8,
};

const GFXglyph JetBrainsMono_Medium28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 5, 20, 17, 6, -20 },
  { 14, 9, 8, 17, 4, -20 },
  { 23, 15, 20, 17, 1, -20 },
  { 61, 13, 28, 17, 2, -24 },
  { 107, 17, 21, 17, 0, -21 },
  { 152, 15, 21, 17, 1, -21 },
  { 192, 3, 8, 17, 7, -20 },
  { 195, 9, 27, 17, 5, -24 },
  { 226, 9, 27, 17, 3, -24 },
  { 257, 15, 14, 17, 1, -17 },
  { 284, 13, 13, 17, 2, -16 },
  { 306, 7, 8, 17, 4, -4 },
  { 313, 9, 3, 17, 4, -11 },
  { 317, 5, 5, 17, 6, -5 },
  { 321, 13, 26, 17, 2, -23 },
  { 364, 13, 21, 17, 2, -21 },
  { 399, 13, 20, 17, 2, -20 },
  { 432, 13, 21, 17, 2, -21 },
  { 467, 13, 20, 17, 2, -20 },
  { 500, 12, 20, 17, 2, -20 },
  { 530, 13, 20, 17, 2, -20 },
  { 563, 13, 20, 17, 2, -20 },
  { 596, 13, 20, 17, 2, -20 },
  { 629, 13, 21, 17, 2, -21 },
  { 664, 13, 21, 17, 2, -21 },
  { 699, 5, 16, 17, 6, -16 },
  { 709, 6, 20, 17, 5, -16 },
  { 724, 13, 15, 17, 2, -17 },
  { 749, 12, 10, 17, 2, -14 },
  { 764, 13, 15, 17, 2, -17 },
  { 789, 10, 20, 17, 4, -20 },
  { 814, 15, 26, 17, 1, -21 },
  { 863, 15, 20, 17, 1, -20 },
  { 901, 13, 20, 17, 2, -20 },
  { 934, 13, 21, 17, 2, -21 },
  { 969, 13, 20, 17, 2, -20 },
  { 1002, 12, 20, 17, 3, -20 },
  { 1032, 13, 20, 17, 2, -20 },
  { 1065, 13, 21, 17, 2, -21 },
  { 1100, 12, 20, 17, 2, -20 },
  { 1130, 11, 20, 17, 3, -20 },
  { 1158, 13, 20, 17, 1, -20 },
  { 1191, 14, 20, 17, 2, -20 },
  { 1226, 12, 20, 17, 3, -20 },
  { 1256, 13, 20, 17, 2, -20 },
  { 1289, 13, 20, 17, 2, -20 },
  { 1322, 13, 21, 17, 2, -21 },
  { 1357, 14, 20, 17, 2, -20 },
  { 1392, 13, 26, 17, 2, -21 },
  { 1435, 13, 20, 17, 2, -20 },
  { 1468, 13, 21, 17, 2, -21 },
  { 1503, 14, 20, 17, 1, -20 },
  { 1538, 13, 20, 17, 2, -20 },
  { 1571, 15, 20, 17, 1, -20 },
  { 1609, 15, 20, 17, 1, -20 },
  { 1647, 15, 20, 17, 1, -20 },
  { 1685, 15, 20, 17, 1, -20 },
  { 1723, 13, 20, 17, 2, -20 },
  { 1756, 8, 26, 17, 5, -23 },
  { 1782, 13, 26, 17, 2, -23 },
  { 1825, 7, 26, 17, 4, -23 },
  { 1848, 13, 10, 17, 2, -20 },
  { 1865, 13, 2, 17, 2, 1 },
  { 1869, 6, 4, 17, 5, -22 },
  { 1872, 13, 16, 17, 2, -16 },
  { 1898, 13, 20, 17, 2, -20 },
  { 1931, 13, 16, 17, 2, -16 },
  { 1957, 12, 20, 17, 2, -20 },
  { 1987, 13, 16, 17, 2, -16 },
  { 2013, 13, 20, 17, 2, -20 },
  { 2046, 12, 21, 17, 2, -16 },
  { 2078, 13, 20, 17, 2, -20 },
  { 2111, 14, 22, 17, 2, -22 },
  { 2150, 11, 27, 17, 2, -22 },
  { 2188, 14, 20, 17, 2, -20 },
  { 2223, 15, 20, 17, 1, -20 },
  { 2261, 13, 16, 17, 2, -16 },
  { 2287, 13, 16, 17, 2, -16 },
  { 2313, 13, 16, 17, 2, -16 },
  { 2339, 13, 21, 17, 2, -16 },
  { 2374, 12, 21, 17, 2, -16 },
  { 2406, 12, 16, 17, 3, -16 },
  { 2430, 13, 16, 17, 2, -16 },
  { 2456, 14, 20, 17, 1, -20 },
  { 2491, 13, 15, 17, 2, -15 },
  { 2516, 14, 15, 17, 1, -15 },
  { 2543, 15, 15, 17, 1, -15 },
  { 2572, 15, 15, 17, 1, -15 },
  { 2601, 15, 20, 17, 1, -15 },
  { 2639, 12, 15, 17, 2, -15 },
  { 2662, 13, 26, 17, 2, -23 },
  { 2705, 3, 26, 17, 7, -23 },
  { 2715, 13, 26, 17, 2, -23 },
  { 2758, 13, 6, 17, 2, -13 },
};

const GFXfont JetBrainsMono_Medium28pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Medium28pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Medium28pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _JETBRAINSMONO_MEDIUM28PT7B_H_
