#ifndef _JETBRAINSMONO_MEDIUM34PT7B_H_
#define _JETBRAINSMONO_MEDIUM34PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Medium.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Medium34pt7bBitmaps[] PROGMEM = {
  0x00, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBC, 0xE7, 0x39, 0xCE, 0x70,
  0x00, 0x00, 0x7B, 0xFF, 0xF0, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFE, 0x1F,
  0xC3, 0xF8, 0x7F, 0x0E, 0xE1, 0xDC, 0x38, 0x03, 0x83, 0x80, 0xE0, 0xC0,
  0x30, 0x30, 0x0C, 0x1C, 0x07, 0x07, 0x01, 0xC1, 0xC0, 0x70, 0x71, 0xFF,
  0xFF, 0x7F, 0xFF, 0xC3, 0x83, 0x80, 0xE0, 0xE0, 0x38, 0x38, 0x0E, 0x0E,
  0x03, 0x83, 0x00, 0xC1, 0xC0, 0x70, 0x70, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF,
  0xFF, 0xF8, 0x60, 0x60, 0x38, 0x38, 0x0E, 0x0E, 0x03, 0x83, 0x80, 0xE0,
  0xE0, 0x38, 0x70, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x07, 0xF0, 0x1F, 0xFC, 0x3F, 0xFE, 0x7D, 0xBE, 0x79, 0x8F,
  0x79, 0x8F, 0x71, 0x8F, 0x79, 0x80, 0x79, 0x80, 0x7D, 0x80, 0x3F, 0x80,
  0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x01, 0x9F, 0x01, 0x8F,
  0x01, 0x8F, 0xF1, 0x87, 0xF1, 0x8F, 0xF1, 0x8F, 0x7D, 0x9F, 0x7F, 0xFE,
  0x3F, 0xFC, 0x0F, 0xF0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x1F, 0x00, 0x73, 0xF8, 0x0E, 0x7B, 0xC0, 0xE6, 0x1C, 0x1C,
  0xE1, 0xC3, 0x8E, 0x1C, 0x38, 0xE1, 0xC7, 0x0E, 0x1C, 0xE0, 0x71, 0xCC,
  0x07, 0xF9, 0xC0, 0x3F, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xCF, 0xC0, 0x1D, 0xFE, 0x03, 0x9C, 0xF0, 0x73, 0x87, 0x07,
  0x38, 0x70, 0xE3, 0x87, 0x1C, 0x38, 0x71, 0x83, 0x87, 0x38, 0x1C, 0xF7,
  0x01, 0xFE, 0xE0, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF8, 0x0F, 0xFE, 0x07,
  0x8F, 0x87, 0x83, 0xC3, 0xC0, 0xE1, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xBC, 0x3F, 0x8F,
  0x1D, 0xC3, 0xDE, 0xE1, 0xEE, 0x70, 0x7F, 0x38, 0x1F, 0x1C, 0x07, 0x8E,
  0x07, 0xC7, 0x87, 0xF3, 0xFF, 0xFC, 0xFF, 0xDE, 0x3F, 0x87, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF7, 0x00, 0x40, 0x30, 0x3C, 0x3F, 0x1F, 0x87, 0x83,
  0xC1, 0xE0, 0x78, 0x1C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0x78, 0x1E,
  0x03, 0xC0, 0xF8, 0x1F, 0x03, 0xF0, 0x7C, 0x0F, 0x00, 0x40, 0x80, 0x38,
  0x0F, 0x83, 0xF0, 0x7E, 0x07, 0xC0, 0xF0, 0x1E, 0x03, 0x80, 0xF0, 0x3C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x3C, 0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x3C, 0x3F, 0x3F, 0x8F,
  0x83, 0xC0, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x00, 0xE0, 0x18, 0x38, 0x67, 0x8C, 0x7F, 0xFB, 0x7F, 0x7F, 0xFF,
  0x81, 0xFF, 0x00, 0x1E, 0x00, 0x0E, 0xC0, 0x07, 0x38, 0x03, 0xCF, 0x00,
  0xF1, 0xE0, 0x78, 0x7C, 0x1C, 0x0E, 0x01, 0x01, 0x00, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x1F, 0x1E, 0x3E, 0x3C, 0x3C, 0x3C, 0x78,
  0x78, 0x70, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x31, 0xFF, 0xFF, 0xFD,
  0xE0, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78,
  0x00, 0x78, 0x00, 0xF0, 0x00, 0x0F, 0xE0, 0x7F, 0xE1, 0xFF, 0xE7, 0xC3,
  0xEF, 0x01, 0xDC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x8C, 0x7F, 0x3C, 0xFE, 0x79, 0xFC, 0xF3, 0xF8, 0xC7, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFF, 0x01, 0xFF, 0x07, 0x9F, 0xFF,
  0x1F, 0xFC, 0x1F, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x3F, 0xC0, 0x7D, 0xC0,
  0xF9, 0xC0, 0xF1, 0xC0, 0xC1, 0xC0, 0x81, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC,
  0x7C, 0x3E, 0x78, 0x1E, 0xF0, 0x0F, 0xF0, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFE, 0x7F, 0xFE,
  0x7F, 0xFE, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0xE0, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0x7E, 0x00, 0x1E,
  0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0x70, 0x1E, 0x78, 0x3E, 0x7F, 0xFC, 0x3F, 0xF8, 0x0F, 0xF0, 0x00, 0x3C,
  0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xF0, 0x73, 0xC0, 0xEF, 0x01,
  0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0xFF, 0xFD, 0xFF,
  0xFB, 0xFF, 0xF7, 0xFF, 0xEF, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xEF, 0xE3, 0xFF, 0xE7, 0xFF, 0xEF, 0x83, 0xDE, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7F, 0x00, 0xFF, 0x01,
  0xDF, 0x07, 0x9F, 0xFF, 0x1F, 0xFC, 0x1F, 0xE0, 0x00, 0xF0, 0x01, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x3D, 0xF8, 0x7F, 0xFC, 0x7F, 0xFE, 0x78, 0x1F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F,
  0x78, 0x0F, 0x7C, 0x1E, 0x3F, 0xFE, 0x1F, 0xFC, 0x0F, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1E,
  0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00,
  0x07, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7C, 0x3E, 0x78, 0x1E, 0x78, 0x0E,
  0x78, 0x0E, 0x78, 0x0E, 0x78, 0x1E, 0x3C, 0x3C, 0x1F, 0x7C, 0x0F, 0xF0,
  0x07, 0xF0, 0x1F, 0xF8, 0x3C, 0x3C, 0x78, 0x1E, 0x78, 0x0F, 0x70, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0x78, 0x0F, 0x7C, 0x1E, 0x3F, 0xFE, 0x1F, 0xFC,
  0x0F, 0xF0, 0x07, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7C, 0x3E, 0x78, 0x0F,
  0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F,
  0x78, 0x1F, 0x7E, 0x7F, 0x3F, 0xFE, 0x1F, 0xDE, 0x02, 0x3C, 0x00, 0x78,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x7B, 0xFF, 0xFF, 0x78, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xBF, 0xFF, 0xF7, 0x80, 0x3C, 0xFD, 0xFB, 0xF3, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x9E, 0x3C, 0xF9, 0xE3,
  0xC7, 0x1E, 0x3C, 0x70, 0x00, 0x06, 0x00, 0x3C, 0x01, 0xF8, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0x80, 0x7C, 0x00, 0xE0, 0x01, 0xE0, 0x03, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0x00, 0x0E,
  0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xC0, 0x01, 0xE0, 0x03, 0xF0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1E, 0x00, 0x7C, 0x03, 0xF8, 0x1F, 0xC0,
  0xFE, 0x07, 0xF0, 0x3F, 0x80, 0x7C, 0x00, 0xE0, 0x01, 0x00, 0x00, 0xFF,
  0x07, 0xFE, 0x3F, 0xF9, 0xFF, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x3C, 0x3F, 0xE1, 0xFE, 0x0F, 0xE0, 0x78, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xF0,
  0x1E, 0x78, 0x03, 0xDC, 0x00, 0x77, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x39,
  0xF8, 0x3F, 0x7E, 0x0F, 0xEF, 0x87, 0x8F, 0xE1, 0xC1, 0xF8, 0x70, 0x7E,
  0x1C, 0x1F, 0x87, 0x07, 0xE1, 0xC1, 0xF8, 0x70, 0x7E, 0x1C, 0x1F, 0x87,
  0x07, 0xE1, 0xE3, 0xF8, 0x3F, 0xFF, 0x07, 0xDD, 0xC0, 0x00, 0x70, 0x00,
  0x1E, 0x00, 0x03, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0xF0, 0x03, 0xFC, 0x00,
  0x3F, 0x00, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF8, 0x01, 0xEE, 0x00, 0x7B, 0x80, 0x1C, 0xE0, 0x07, 0x3C, 0x03, 0xC7,
  0x00, 0xF1, 0xC0, 0x38, 0x78, 0x0E, 0x1E, 0x07, 0x87, 0x81, 0xE0, 0xE0,
  0x70, 0x3C, 0x1F, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xF0, 0x1E, 0x38,
  0x07, 0x9E, 0x01, 0xE7, 0x80, 0x39, 0xE0, 0x0F, 0xF0, 0x03, 0xC0, 0xFF,
  0xC1, 0xFF, 0xE3, 0xFF, 0xE7, 0x07, 0xEE, 0x03, 0xDC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1D, 0xC0, 0x7B, 0x83, 0xE7, 0xFF, 0x8F, 0xFF, 0x1F,
  0xFF, 0xB8, 0x0F, 0x70, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0xFE, 0x01, 0xFC, 0x0F, 0xFF, 0xFF, 0x7F, 0xFC, 0xFF, 0xE0, 0x0F, 0xE0,
  0x7F, 0xF1, 0xFF, 0xE7, 0xC3, 0xEF, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x7F, 0x80, 0xFF,
  0x01, 0xFF, 0x07, 0x9F, 0xFF, 0x1F, 0xFC, 0x1F, 0xE0, 0xFF, 0x81, 0xFF,
  0xE3, 0xFF, 0xE7, 0xFF, 0xEF, 0x03, 0xDE, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x03,
  0xDE, 0x1F, 0xBF, 0xFE, 0x7F, 0xF8, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0xBC, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0xBC, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x0F, 0xE0, 0x7F, 0xF1, 0xFF, 0xE7,
  0xC3, 0xEF, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x80, 0xFF, 0x01, 0xFF, 0x07, 0x9F,
  0xFF, 0x1F, 0xFC, 0x1F, 0xE0, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0x78, 0x0F, 0x7C, 0x1E, 0x3F, 0xFE, 0x1F, 0xFC,
  0x0F, 0xF0, 0xF0, 0x0F, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3C, 0xF0, 0x3C,
  0xF0, 0x78, 0xF0, 0x78, 0xF0, 0xF0, 0xF0, 0xF0, 0xF1, 0xE0, 0xF1, 0xE0,
  0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xE0, 0xF1, 0xE0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0x78, 0xF0, 0x78, 0xF0, 0x7C, 0xF0, 0x3C, 0xF0, 0x3E, 0xF0, 0x1E,
  0xF0, 0x1E, 0xF0, 0x0F, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xF8, 0x0F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x1B, 0xFC, 0x3F, 0xEC, 0x3F,
  0xEE, 0x37, 0xEE, 0x77, 0xE6, 0x77, 0xE7, 0x67, 0xE7, 0x67, 0xF3, 0xE7,
  0xF3, 0xE7, 0xF3, 0xC7, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF,
  0x83, 0xFB, 0x87, 0xF7, 0x0F, 0xEE, 0x1F, 0xCE, 0x3F, 0x9C, 0x7F, 0x38,
  0xFE, 0x39, 0xFC, 0x73, 0xF8, 0xE7, 0xF0, 0xEF, 0xE1, 0xDF, 0xC3, 0xBF,
  0x83, 0xFF, 0x07, 0x7E, 0x0F, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0,
  0x3E, 0x0F, 0xE0, 0x7F, 0xE1, 0xFF, 0xE7, 0xC3, 0xEF, 0x03, 0xDE, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x80, 0xFF, 0x03, 0xDF, 0x0F, 0x9F, 0xFE, 0x1F, 0xFC, 0x1F, 0xE0,
  0xFF, 0xE0, 0xFF, 0xF8, 0xFF, 0xFC, 0xF0, 0xFE, 0xF0, 0x1E, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1E, 0xF0, 0x3E,
  0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xE0, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x0F, 0xE0, 0x7F, 0xE1, 0xFF, 0xE7, 0xC3, 0xEF, 0x03, 0xDC,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFF, 0x01, 0xFF, 0x07, 0x9F, 0xFF, 0x1F, 0xFC, 0x1F,
  0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07,
  0x80, 0xFF, 0xC0, 0xFF, 0xF0, 0xFF, 0xFC, 0xF0, 0xFC, 0xF0, 0x1E, 0xF0,
  0x1E, 0xF0, 0x0E, 0xF0, 0x0E, 0xF0, 0x0E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0,
  0xFC, 0xFF, 0xFC, 0xFF, 0xF0, 0xFF, 0xE0, 0xF1, 0xE0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x3E, 0xF0,
  0x1E, 0xF0, 0x1F, 0x07, 0xF0, 0x1F, 0xFC, 0x3F, 0xFE, 0x7C, 0x3E, 0x78,
  0x0F, 0x78, 0x0F, 0x70, 0x0F, 0x78, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3F,
  0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x00,
  0x0F, 0x00, 0x0F, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0x7C, 0x1E, 0x7F,
  0xFE, 0x3F, 0xFC, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x80,
  0xFF, 0x03, 0xDF, 0x0F, 0x9F, 0xFE, 0x1F, 0xFC, 0x1F, 0xE0, 0xF0, 0x03,
  0xDE, 0x00, 0xF7, 0x80, 0x39, 0xE0, 0x1E, 0x38, 0x07, 0x8F, 0x01, 0xE3,
  0xC0, 0x70, 0xF0, 0x1C, 0x1C, 0x0F, 0x07, 0x03, 0xC1, 0xE0, 0xE0, 0x78,
  0x38, 0x0E, 0x1E, 0x03, 0x87, 0x80, 0xF1, 0xC0, 0x3C, 0x70, 0x07, 0x3C,
  0x01, 0xCF, 0x00, 0x7B, 0x80, 0x1E, 0xE0, 0x03, 0xB8, 0x00, 0xFE, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0xE0, 0xE1, 0xFC, 0x3C, 0x3F,
  0x87, 0x87, 0x70, 0xF0, 0xEE, 0x1E, 0x1D, 0xE3, 0x63, 0xBC, 0x6C, 0x73,
  0x8D, 0x8E, 0x71, 0xB1, 0xCE, 0x76, 0x39, 0xCC, 0xCF, 0x39, 0x99, 0xC7,
  0x33, 0x38, 0xE6, 0x67, 0x1C, 0xCE, 0xE3, 0x98, 0xDC, 0x7B, 0x1B, 0x87,
  0xE3, 0x70, 0xF8, 0x6E, 0x1F, 0x0D, 0xC3, 0xE1, 0xB0, 0x7C, 0x3E, 0x0F,
  0x87, 0xC1, 0xF0, 0xF8, 0x3E, 0x0F, 0x00, 0x78, 0x03, 0xDE, 0x01, 0xE3,
  0xC0, 0x78, 0xF0, 0x3C, 0x1E, 0x0E, 0x07, 0x87, 0x80, 0xF1, 0xC0, 0x1C,
  0xF0, 0x07, 0xB8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xE0,
  0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x07, 0xBC, 0x03, 0xCF, 0x00,
  0xF1, 0xE0, 0x78, 0x78, 0x1E, 0x0F, 0x0F, 0x03, 0xC3, 0xC0, 0x79, 0xE0,
  0x1E, 0xF0, 0x03, 0xC0, 0xF0, 0x03, 0xDC, 0x00, 0xF7, 0x80, 0x38, 0xE0,
  0x1E, 0x3C, 0x07, 0x0F, 0x03, 0xC1, 0xE0, 0xE0, 0x78, 0x78, 0x0F, 0x1E,
  0x03, 0xCF, 0x00, 0x7B, 0xC0, 0x1E, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00,
  0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xE0, 0x03, 0xC0, 0x0F,
  0x00, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00,
  0x78, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x38, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x80, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xEE, 0x03, 0x9C, 0x07, 0x1C, 0x1C, 0x38, 0x38, 0x78, 0xF0, 0x71, 0xC0,
  0xF7, 0x80, 0xEE, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x78, 0x3C, 0x3C, 0x1F, 0x07, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC, 0x3C, 0x3E,
  0x78, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x0F, 0xFF, 0x3F, 0xFF,
  0x7F, 0xFF, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F,
  0x7E, 0xFF, 0x7F, 0xEF, 0x1F, 0xCF, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0xF8, 0x73, 0xFC, 0xEF, 0xFD, 0xD8,
  0xFB, 0xC0, 0xF7, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFF, 0x07, 0xBF,
  0xFF, 0x7F, 0xFC, 0xF7, 0xF0, 0x0F, 0xE0, 0x7F, 0xE1, 0xFF, 0xE7, 0xE3,
  0xEF, 0x03, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x03, 0xFC, 0x07, 0xFC, 0x1E, 0x7F,
  0xFC, 0x7F, 0xF0, 0x7F, 0x80, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC7, 0xC7, 0x9F, 0xEF, 0x7F, 0xDF, 0xF0, 0xFF,
  0xC0, 0xFF, 0x80, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFF, 0x03, 0xFF, 0x0F, 0xDF, 0xFF,
  0xBF, 0xEF, 0x1F, 0x9E, 0x0F, 0xC0, 0x7F, 0xE1, 0xFF, 0xE7, 0xC1, 0xEF,
  0x01, 0xDC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x07, 0xFC, 0x1E, 0x7F, 0xFC,
  0x7F, 0xF0, 0x7F, 0x80, 0x00, 0x7F, 0x01, 0xFF, 0x03, 0xFF, 0x07, 0xE0,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x1F, 0x1E, 0x7F, 0xBD, 0xFF, 0x7F,
  0xC3, 0xFF, 0x03, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFF, 0x01, 0xFE, 0x07, 0xFF, 0x3F, 0xBF, 0xEF,
  0x3F, 0xDE, 0x1E, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x8F,
  0xFF, 0x1F, 0xFC, 0x3F, 0xE0, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0xF8, 0x7B, 0xFC, 0xFF, 0xFD, 0xF0, 0xFB,
  0xC0, 0xF7, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x1E, 0x01, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x7F, 0xC0,
  0x7F, 0xC0, 0x7F, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x20,
  0x07, 0x80, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xF3, 0xFF, 0x9F, 0xFC, 0xFF, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x01, 0xF3, 0xFF,
  0x9F, 0xF8, 0xFF, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x0F, 0xF0, 0x1E, 0xF0, 0x3E, 0xF0, 0x3C,
  0xF0, 0x78, 0xF0, 0xF8, 0xF0, 0xF0, 0xF1, 0xE0, 0xFF, 0xE0, 0xFF, 0xC0,
  0xFF, 0xE0, 0xF1, 0xE0, 0xF0, 0xF0, 0xF0, 0xF8, 0xF0, 0x78, 0xF0, 0x3C,
  0xF0, 0x3E, 0xF0, 0x1E, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC,
  0x03, 0xFF, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0xFC, 0x03, 0xFF,
  0x00, 0x7F, 0xC0, 0xEF, 0x1E, 0xEF, 0xBF, 0xFF, 0xBF, 0xF1, 0xC7, 0xE1,
  0xC7, 0xE1, 0xC7, 0xE1, 0xC7, 0xE1, 0xC7, 0xE1, 0xC7, 0xE1, 0xC7, 0xE1,
  0xC7, 0xE1, 0xC7, 0xE1, 0xC7, 0xE1, 0xC7, 0xE1, 0xC7, 0xE1, 0xC7, 0xE1,
  0xC7, 0xE1, 0xC7, 0xE1, 0xC7, 0xF3, 0xE1, 0xEF, 0xF3, 0xFF, 0xF7, 0xE3,
  0xEF, 0x03, 0xDE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x78, 0x0F, 0xC0, 0x7F, 0xE1, 0xFF, 0xE7, 0xE3,
  0xEF, 0x03, 0xDE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xFC, 0x0F, 0x7C, 0x3E, 0x7F,
  0xF8, 0x7F, 0xF0, 0x7F, 0x80, 0xF3, 0xE1, 0xEF, 0xF3, 0xFF, 0xF7, 0xE3,
  0xEF, 0x03, 0xDE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF4, 0x1E, 0xEF,
  0xFD, 0xDF, 0xF3, 0x9F, 0xC7, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x00, 0x1F, 0x1E, 0x7F, 0xBD, 0xFF, 0x7F, 0xC3, 0xFF,
  0x03, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x0F, 0xFC, 0x3F, 0x7F, 0xFE,
  0xFF, 0xBC, 0x7E, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0xF3, 0xF0, 0xF7, 0xF8, 0xFF, 0xFC, 0xFC, 0x3E, 0xF8,
  0x1E, 0xF0, 0x0E, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0x1F, 0xE0, 0x7F, 0xF1, 0xFF, 0xF7, 0xC1,
  0xEF, 0x01, 0xFE, 0x00, 0x3C, 0x00, 0x7E, 0x00, 0x7F, 0xE0, 0x7F, 0xF0,
  0x3F, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xF8, 0x07, 0xF8, 0x0F, 0xFF,
  0xFC, 0xFF, 0xF8, 0x7F, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x07,
  0xFE, 0x03, 0xFE, 0x00, 0xFE, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x0F, 0x7C, 0x3E, 0x7F,
  0xF8, 0x7F, 0xE0, 0x7F, 0x80, 0xE0, 0x07, 0xF8, 0x03, 0xBC, 0x03, 0xCE,
  0x01, 0xE7, 0x80, 0xE3, 0xC0, 0xF0, 0xE0, 0x78, 0x78, 0x38, 0x3C, 0x3C,
  0x0E, 0x1E, 0x07, 0x8E, 0x03, 0xC7, 0x00, 0xE7, 0x80, 0x7B, 0x80, 0x3D,
  0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0xE0, 0xE1,
  0xF8, 0x78, 0x7E, 0x1E, 0x1F, 0x87, 0x87, 0x71, 0xE1, 0xDC, 0x6C, 0x77,
  0x1B, 0x19, 0xC6, 0xCE, 0x73, 0x33, 0x9C, 0xCC, 0xE3, 0x33, 0x38, 0xEC,
  0xCE, 0x3B, 0x1B, 0x8E, 0xC6, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x07, 0x87, 0xC1, 0xE1, 0xF0, 0x78, 0x07, 0xCF, 0x01, 0xE3, 0xE0, 0xF0,
  0x78, 0x78, 0x0F, 0x1E, 0x03, 0xCF, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x03,
  0xF0, 0x00, 0x78, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x07, 0xBC, 0x03, 0xCF,
  0x00, 0xF1, 0xE0, 0x78, 0x7C, 0x3C, 0x0F, 0x1F, 0x01, 0xEF, 0x80, 0x7C,
  0xF0, 0x07, 0xF8, 0x07, 0xBC, 0x03, 0xCF, 0x01, 0xE7, 0x81, 0xE1, 0xE0,
  0xF0, 0xF0, 0x78, 0x78, 0x78, 0x1E, 0x3C, 0x0F, 0x1C, 0x03, 0x9E, 0x01,
  0xEF, 0x00, 0xF7, 0x00, 0x3B, 0x80, 0x1F, 0xC0, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xF7,
  0xFF, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7E, 0x01, 0xFC, 0x07, 0xF8,
  0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x3F, 0xE0, 0x7F, 0x80,
  0xFF, 0x80, 0x1F, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1F,
  0xE0, 0x3F, 0xC0, 0x3F, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01,
  0xFC, 0x03, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x01, 0xFF, 0x80, 0xFF, 0x03, 0xFE, 0x0F, 0x80, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x00, 0x78, 0x00, 0x1C, 0x00,
  0x7F, 0x07, 0xFF, 0x87, 0xF7, 0xC7, 0xE1, 0xE7, 0xE1, 0xFF, 0xE0, 0xFE,
  0x00, 0x1C,
};

const GFXglyph JetBrainsMono_Medium34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 20, 0, -1 },
  { 1, 5, 25, 20, 8, -25 },
  { 17, 11, 10, 20, 5, -25 },
  { 31, 18, 25, 20, 1, -25 },
  { 88, 16, 35, 20, 2, -30 },
  { 158, 20, 25, 20, 0, -25 },
  { 221, 17, 25, 20, 2, -25 },
  { 275, 4, 10, 20, 8, -25 },
  { 280, 10, 33, 20, 6, -29 },
  { 322, 10, 33, 20, 4, -29 },
  { 364, 18, 18, 20, 1, -21 },
  { 405, 16, 16, 20, 2, -19 },
  { 437, 8, 10, 20, 5, -5 },
  { 447, 11, 3, 20, 5, -13 },
  { 452, 6, 6, 20, 7, -6 },
  { 457, 16, 32, 20, 2, -28 },
  { 521, 15, 25, 20, 3, -25 },
  { 568, 16, 25, 20, 3, -25 },
  { 618, 16, 25, 20, 2, -25 },
  { 668, 16, 25, 20, 2, -25 },
  { 718, 15, 25, 20, 2, -25 },
  { 765, 15, 25, 20, 3, -25 },
  { 812, 16, 25, 20, 2, -25 },
  { 862, 16, 25, 20, 2, -25 },
  { 912, 16, 25, 20, 2, -25 },
  { 962, 16, 25, 20, 2, -25 },
  { 1012, 6, 19, 20, 7, -19 },
  { 1027, 7, 24, 20, 6, -19 },
  { 1048, 15, 18, 20, 3, -20 },
  { 1082, 15, 12, 20, 3, -17 },
  { 1105, 15, 18, 20, 3, -20 },
  { 1139, 13, 25, 20, 4, -25 },
  { 1180, 18, 31, 20, 1, -25 },
  { 1250, 18, 25, 20, 1, -25 },
  { 1307, 15, 25, 20, 3, -25 },
  { 1354, 15, 25, 20, 3, -25 },
  { 1401, 15, 25, 20, 3, -25 },
  { 1448, 15, 25, 20, 3, -25 },
  { 1495, 15, 25, 20, 3, -25 },
  { 1542, 15, 25, 20, 3, -25 },
  { 1589, 15, 25, 20, 3, -25 },
  { 1636, 14, 25, 20, 3, -25 },
  { 1680, 16, 25, 20, 1, -25 },
  { 1730, 16, 25, 20, 3, -25 },
  { 1780, 14, 25, 20, 4, -25 },
  { 1824, 16, 25, 20, 2, -25 },
  { 1874, 15, 25, 20, 3, -25 },
  { 1921, 15, 25, 20, 3, -25 },
  { 1968, 16, 25, 20, 3, -25 },
  { 2018, 15, 31, 20, 3, -25 },
  { 2077, 16, 25, 20, 3, -25 },
  { 2127, 16, 25, 20, 2, -25 },
  { 2177, 17, 25, 20, 2, -25 },
  { 2231, 15, 25, 20, 3, -25 },
  { 2278, 18, 25, 20, 1, -25 },
  { 2335, 19, 25, 20, 1, -25 },
  { 2395, 18, 25, 20, 1, -25 },
  { 2452, 18, 25, 20, 1, -25 },
  { 2509, 15, 25, 20, 3, -25 },
  { 2556, 9, 32, 20, 7, -28 },
  { 2592, 16, 32, 20, 2, -28 },
  { 2656, 9, 32, 20, 5, -28 },
  { 2692, 15, 13, 20, 3, -25 },
  { 2717, 16, 3, 20, 2, 1 },
  { 2723, 8, 5, 20, 6, -27 },
  { 2728, 16, 19, 20, 2, -19 },
  { 2766, 15, 25, 20, 3, -25 },
  { 2813, 15, 19, 20, 3, -19 },
  { 2849, 15, 25, 20, 3, -25 },
  { 2896, 15, 19, 20, 3, -19 },
  { 2932, 16, 25, 20, 2, -25 },
  { 2982, 15, 25, 20, 3, -19 },
  { 3029, 15, 25, 20, 3, -25 },
  { 3076, 16, 27, 20, 3, -27 },
  { 3130, 13, 33, 20, 3, -27 },
  { 3184, 16, 25, 20, 3, -25 },
  { 3234, 18, 25, 20, 1, -25 },
  { 3291, 16, 19, 20, 2, -19 },
  { 3329, 15, 19, 20, 3, -19 },
  { 3365, 15, 19, 20, 3, -19 },
  { 3401, 15, 25, 20, 3, -19 },
  { 3448, 15, 25, 20, 3, -19 },
  { 3495, 16, 19, 20, 3, -19 },
  { 3533, 15, 19, 20, 3, -19 },
  { 3569, 16, 24, 20, 2, -24 },
  { 3617, 15, 19, 20, 3, -19 },
  { 3653, 17, 19, 20, 2, -19 },
  { 3694, 18, 19, 20, 1, -19 },
  { 3737, 18, 19, 20, 1, -19 },
  { 3780, 17, 25, 20, 2, -19 },
  { 3834, 15, 19, 20, 3, -19 },
  { 3870, 15, 32, 20, 3, -28 },
  { 3930, 4, 32, 20, 8, -28 },
  { 3946, 15, 32, 20, 3, -28 },
  { 4006, 16, 8, 20, 2, -16 },
};

const GFXfont JetBrainsMono_Medium34pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Medium34pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Medium34pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _JETBRAINSMONO_MEDIUM34PT7B_H_
