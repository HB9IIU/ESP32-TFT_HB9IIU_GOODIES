#ifndef _JETBRAINSMONO_MEDIUM16PT7B_H_
#define _JETBRAINSMONO_MEDIUM16PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Medium.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Medium16pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFE, 0x0F, 0xCE, 0x73, 0x9C, 0x80, 0x19, 0x08, 0x84, 0x4F,
  0xF7, 0xF9, 0x90, 0xC8, 0x44, 0xFF, 0x93, 0x09, 0x8C, 0x80, 0x10, 0x10,
  0x3C, 0x7E, 0xD2, 0xD0, 0xF0, 0x78, 0x3E, 0x16, 0x13, 0xD3, 0xF6, 0x7C,
  0x10, 0x10, 0x70, 0xF6, 0x6D, 0x93, 0x68, 0xFE, 0x09, 0x00, 0x80, 0x7E,
  0x14, 0x89, 0x24, 0x4B, 0x1E, 0x38, 0x7C, 0x46, 0x40, 0x60, 0x60, 0xF3,
  0x9A, 0x8E, 0x84, 0xCE, 0x7B, 0xFF, 0x80, 0x1B, 0x99, 0x8C, 0x63, 0x18,
  0xC6, 0x31, 0x86, 0x1C, 0x20, 0xC3, 0x0C, 0x21, 0x8C, 0x63, 0x18, 0xC6,
  0x67, 0x72, 0x00, 0x18, 0x18, 0x99, 0xF7, 0x7C, 0x38, 0x6C, 0x66, 0x44,
  0x18, 0x18, 0x18, 0xFF, 0xFF, 0x18, 0x18, 0x18, 0x7B, 0x48, 0xFF, 0xC0,
  0x7D, 0x80, 0x07, 0x06, 0x04, 0x0C, 0x0C, 0x08, 0x18, 0x18, 0x30, 0x30,
  0x20, 0x60, 0x60, 0x40, 0xC0, 0x3C, 0xFF, 0x1E, 0x1C, 0x3B, 0x76, 0xE1,
  0xC3, 0x85, 0x99, 0xE0, 0x18, 0x78, 0xF8, 0x98, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0xFF, 0xFF, 0x3C, 0x7E, 0xC6, 0xC2, 0x06, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xFF, 0xFF, 0x7E, 0xFC, 0x30, 0xC3, 0x07, 0x81, 0x81, 0x03,
  0x8F, 0x9B, 0xE0, 0x06, 0x18, 0x60, 0x83, 0x0C, 0xF1, 0xE3, 0xFF, 0xFC,
  0x18, 0x30, 0x7E, 0xFD, 0x02, 0x05, 0xDF, 0xF1, 0x81, 0x03, 0x85, 0x9B,
  0xE0, 0x0C, 0x18, 0x30, 0x30, 0x60, 0x7E, 0xE6, 0xC3, 0xC3, 0xC2, 0x66,
  0x3C, 0xFF, 0xFF, 0xC2, 0xC6, 0x06, 0x0C, 0x0C, 0x08, 0x18, 0x18, 0x30,
  0x30, 0x3C, 0xFF, 0x1E, 0x16, 0x67, 0x9F, 0x23, 0xC3, 0x87, 0x9B, 0xE0,
  0x3C, 0x7E, 0xC2, 0xC3, 0xC3, 0xC6, 0x7E, 0x16, 0x0C, 0x18, 0x18, 0x30,
  0x7D, 0x00, 0x07, 0x60, 0x7D, 0x00, 0x03, 0xDB, 0x40, 0x02, 0x0C, 0x73,
  0x8C, 0x1C, 0x0E, 0x07, 0x02, 0xFF, 0xFC, 0x00, 0x0F, 0xE0, 0x81, 0xC1,
  0xE0, 0xF0, 0x61, 0xCF, 0x70, 0x80, 0xF3, 0xE0, 0xC3, 0x0C, 0x77, 0x98,
  0x60, 0x06, 0x18, 0x3C, 0x66, 0xC3, 0x81, 0x8D, 0x9B, 0x91, 0x91, 0x91,
  0x93, 0x9D, 0x80, 0xC0, 0x78, 0x38, 0x18, 0x38, 0x38, 0x2C, 0x2C, 0x64,
  0x66, 0x46, 0x7E, 0xC2, 0xC3, 0xC3, 0xF8, 0xFE, 0xC6, 0xC2, 0xC6, 0xFC,
  0xFE, 0xC2, 0xC3, 0xC3, 0xCE, 0xFC, 0x3C, 0xFF, 0x1E, 0x1C, 0x18, 0x30,
  0x60, 0xC1, 0x85, 0x99, 0xE0, 0xF9, 0xFF, 0x1E, 0x1C, 0x38, 0x70, 0xE1,
  0xC3, 0x8F, 0xFF, 0xE0, 0xFF, 0xFF, 0x06, 0x0C, 0x1F, 0xFF, 0xE0, 0xC1,
  0x83, 0xFF, 0xF0, 0xFF, 0xFF, 0x06, 0x0C, 0x1F, 0xFF, 0xE0, 0xC1, 0x83,
  0x06, 0x00, 0x3C, 0xFF, 0x1E, 0x1C, 0x18, 0x33, 0xE1, 0xC3, 0x85, 0x99,
  0xE0, 0xC3, 0x87, 0x0E, 0x1C, 0x3F, 0xFF, 0xE1, 0xC3, 0x87, 0x0E, 0x10,
  0xFF, 0xF3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xCF, 0xFF, 0x1E, 0x3C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x07, 0x0F, 0x3B, 0xE0, 0xC3, 0xC6, 0xC6, 0xCC,
  0xCC, 0xF8, 0xF8, 0xCC, 0xCC, 0xC6, 0xC6, 0xC3, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x03, 0xFF, 0xF0, 0xC7, 0xE7, 0xA7, 0xAF, 0xEB,
  0xDB, 0xDB, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xE3, 0xC7, 0x8F, 0x9D, 0x3A,
  0x76, 0xE5, 0xCB, 0x9F, 0x1E, 0x30, 0x3C, 0xFF, 0x1E, 0x1C, 0x38, 0x70,
  0xE1, 0xC3, 0x8D, 0x99, 0xE0, 0xFC, 0xFE, 0xC3, 0xC3, 0xC3, 0xC7, 0xFE,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x3C, 0x7E, 0xC6, 0xC2, 0xC2, 0xC2, 0xC2,
  0xC2, 0xC2, 0xC2, 0x66, 0x3C, 0x0C, 0x06, 0x07, 0xF8, 0xFE, 0xC2, 0xC3,
  0xC3, 0xC6, 0xFC, 0xCC, 0xCC, 0xC6, 0xC6, 0xC3, 0x3C, 0x7E, 0xC6, 0xC0,
  0xE0, 0x78, 0x3E, 0x06, 0x03, 0xC3, 0xE6, 0x7C, 0xFF, 0xFF, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xC3, 0x87, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0xC3, 0x8D, 0x99, 0xE0, 0xC3, 0xC3, 0xC2, 0xC6, 0x46,
  0x66, 0x64, 0x2C, 0x2C, 0x3C, 0x38, 0x18, 0xCC, 0xE6, 0x53, 0x29, 0xB4,
  0xDA, 0xAD, 0x56, 0xEA, 0x73, 0x39, 0x9C, 0xC6, 0x60, 0xC3, 0xC6, 0x66,
  0x6C, 0x3C, 0x18, 0x18, 0x3C, 0x6C, 0x66, 0xC6, 0xC3, 0xC1, 0xB0, 0xD8,
  0xC6, 0x63, 0x60, 0xF0, 0x70, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xFF,
  0xFC, 0x18, 0x60, 0xC3, 0x04, 0x18, 0x60, 0xC3, 0xFF, 0xF0, 0xFC, 0xCC,
  0xCC, 0xCC, 0xCC, 0xCC, 0xCF, 0xF0, 0xC0, 0x60, 0x60, 0x60, 0x30, 0x30,
  0x10, 0x18, 0x18, 0x0C, 0x0C, 0x0C, 0x06, 0x06, 0x03, 0xF1, 0x11, 0x11,
  0x11, 0x11, 0x11, 0x1F, 0xF0, 0x18, 0x70, 0xF1, 0x26, 0x48, 0xF0, 0x80,
  0xFF, 0xFF, 0xC9, 0x80, 0x3C, 0xFF, 0x18, 0x17, 0xF8, 0x70, 0xE3, 0x7A,
  0xC1, 0x83, 0x06, 0xEF, 0xF8, 0xF0, 0xE1, 0xC3, 0x87, 0x9E, 0xE0, 0x3C,
  0xFF, 0x0E, 0x0C, 0x18, 0x30, 0xB3, 0x3C, 0x02, 0x04, 0x09, 0xD7, 0xB8,
  0xF0, 0xE1, 0xC3, 0x8D, 0x9B, 0xD0, 0x3C, 0xDF, 0x0E, 0x1F, 0xF8, 0x30,
  0x33, 0x3C, 0x0F, 0x1F, 0x30, 0x30, 0xFF, 0xFF, 0x30, 0x30, 0x30, 0x30,
  0x30, 0x30, 0x3A, 0xF7, 0x1E, 0x1C, 0x38, 0xF1, 0xBD, 0x02, 0x0D, 0xFB,
  0xE0, 0xC1, 0x83, 0x06, 0xEF, 0xF8, 0xF0, 0xE1, 0xC3, 0x87, 0x0E, 0x10,
  0x08, 0x18, 0x18, 0x00, 0x78, 0x78, 0x18, 0x18, 0x18, 0x18, 0x18, 0xFF,
  0xFF, 0x04, 0x30, 0xC0, 0x7D, 0xF0, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x3F,
  0xFC, 0xC0, 0xC0, 0xC0, 0xC3, 0xC6, 0xCC, 0xCC, 0xF8, 0xCC, 0xCC, 0xC6,
  0xC3, 0xF8, 0x7C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x03, 0xE1, 0xF0, 0xB6, 0xDB, 0xD3, 0xD3, 0xD3, 0xD3, 0xD3, 0xD3, 0xD3,
  0xDD, 0xFF, 0x1E, 0x1C, 0x38, 0x70, 0xE1, 0xC2, 0x3C, 0xFF, 0x1E, 0x1C,
  0x38, 0x70, 0xB3, 0x3C, 0xDD, 0xFF, 0x1E, 0x1C, 0x38, 0x70, 0xF3, 0xDD,
  0x83, 0x06, 0x00, 0x3A, 0xF7, 0x1E, 0x1C, 0x38, 0x71, 0xB3, 0x7A, 0x04,
  0x08, 0x10, 0xB9, 0xFB, 0x1C, 0x38, 0x10, 0x20, 0x40, 0x80, 0x3C, 0xFF,
  0x03, 0x07, 0xE0, 0xC0, 0xF3, 0x7E, 0x30, 0x63, 0xFF, 0xF3, 0x06, 0x0C,
  0x18, 0x30, 0x7C, 0x78, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x71, 0xB3, 0x3C,
  0xC3, 0xC2, 0x46, 0x66, 0x64, 0x6C, 0x3C, 0x38, 0x38, 0xCC, 0xA6, 0x53,
  0x69, 0xB7, 0x53, 0xA9, 0xCC, 0x66, 0x33, 0x00, 0xC3, 0x66, 0x6C, 0x3C,
  0x18, 0x3C, 0x6C, 0x66, 0xC3, 0xC3, 0xC2, 0x46, 0x66, 0x64, 0x3C, 0x3C,
  0x18, 0x18, 0x10, 0x30, 0x30, 0xFF, 0xFC, 0x38, 0x61, 0x86, 0x18, 0x7F,
  0xFE, 0x0E, 0x18, 0x60, 0x40, 0x81, 0x3E, 0x78, 0x18, 0x10, 0x20, 0xC1,
  0x81, 0xC1, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0xE0, 0x60, 0xC1, 0x83, 0x06,
  0x07, 0x8F, 0x30, 0x60, 0xC1, 0x83, 0x1E, 0x38, 0x00, 0xF3, 0x9B, 0x8E,
};

const GFXglyph JetBrainsMono_Medium16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 2, 12, 10, 4, -12 },
  { 4, 5, 5, 10, 2, -12 },
  { 8, 9, 12, 10, 0, -12 },
  { 22, 8, 16, 10, 1, -14 },
  { 38, 10, 12, 10, 0, -12 },
  { 53, 8, 12, 10, 1, -12 },
  { 65, 2, 5, 10, 4, -12 },
  { 67, 5, 15, 10, 3, -13 },
  { 77, 5, 15, 10, 2, -13 },
  { 87, 8, 9, 10, 1, -10 },
  { 96, 8, 8, 10, 1, -9 },
  { 104, 3, 5, 10, 3, -2 },
  { 106, 5, 2, 10, 2, -6 },
  { 108, 3, 3, 10, 3, -3 },
  { 110, 8, 15, 10, 1, -13 },
  { 125, 7, 12, 10, 1, -12 },
  { 136, 8, 12, 10, 1, -12 },
  { 148, 8, 12, 10, 1, -12 },
  { 160, 7, 12, 10, 1, -12 },
  { 171, 7, 12, 10, 1, -12 },
  { 182, 7, 12, 10, 1, -12 },
  { 193, 8, 12, 10, 1, -12 },
  { 205, 8, 12, 10, 1, -12 },
  { 217, 7, 12, 10, 1, -12 },
  { 228, 8, 12, 10, 1, -12 },
  { 240, 3, 9, 10, 3, -9 },
  { 244, 3, 12, 10, 3, -9 },
  { 249, 7, 9, 10, 1, -10 },
  { 257, 7, 5, 10, 1, -8 },
  { 262, 7, 9, 10, 1, -10 },
  { 270, 6, 12, 10, 2, -12 },
  { 279, 8, 15, 10, 1, -12 },
  { 294, 8, 12, 10, 1, -12 },
  { 306, 8, 12, 10, 1, -12 },
  { 318, 7, 12, 10, 1, -12 },
  { 329, 7, 12, 10, 1, -12 },
  { 340, 7, 12, 10, 1, -12 },
  { 351, 7, 12, 10, 1, -12 },
  { 362, 7, 12, 10, 1, -12 },
  { 373, 7, 12, 10, 1, -12 },
  { 384, 6, 12, 10, 2, -12 },
  { 393, 7, 12, 10, 1, -12 },
  { 404, 8, 12, 10, 1, -12 },
  { 416, 7, 12, 10, 2, -12 },
  { 427, 8, 12, 10, 1, -12 },
  { 439, 7, 12, 10, 1, -12 },
  { 450, 7, 12, 10, 1, -12 },
  { 461, 8, 12, 10, 1, -12 },
  { 473, 8, 15, 10, 1, -12 },
  { 488, 8, 12, 10, 1, -12 },
  { 500, 8, 12, 10, 1, -12 },
  { 512, 8, 12, 10, 1, -12 },
  { 524, 7, 12, 10, 1, -12 },
  { 535, 8, 12, 10, 1, -12 },
  { 547, 9, 12, 10, 0, -12 },
  { 561, 8, 12, 10, 1, -12 },
  { 573, 9, 12, 10, 0, -12 },
  { 587, 7, 12, 10, 1, -12 },
  { 598, 4, 15, 10, 3, -13 },
  { 606, 8, 15, 10, 1, -13 },
  { 621, 4, 15, 10, 2, -13 },
  { 629, 7, 7, 10, 1, -12 },
  { 636, 8, 2, 10, 1, 0 },
  { 638, 3, 3, 10, 3, -13 },
  { 640, 7, 9, 10, 1, -9 },
  { 648, 7, 12, 10, 1, -12 },
  { 659, 7, 9, 10, 1, -9 },
  { 667, 7, 12, 10, 1, -12 },
  { 678, 7, 9, 10, 1, -9 },
  { 686, 8, 12, 10, 1, -12 },
  { 698, 7, 12, 10, 1, -9 },
  { 709, 7, 12, 10, 1, -12 },
  { 720, 8, 13, 10, 1, -13 },
  { 733, 6, 16, 10, 1, -13 },
  { 745, 8, 12, 10, 1, -12 },
  { 757, 9, 12, 10, 0, -12 },
  { 771, 8, 9, 10, 1, -9 },
  { 780, 7, 9, 10, 1, -9 },
  { 788, 7, 9, 10, 1, -9 },
  { 796, 7, 12, 10, 1, -9 },
  { 807, 7, 12, 10, 1, -9 },
  { 818, 7, 9, 10, 2, -9 },
  { 826, 7, 9, 10, 1, -9 },
  { 834, 7, 11, 10, 1, -11 },
  { 844, 7, 9, 10, 1, -9 },
  { 852, 8, 9, 10, 1, -9 },
  { 861, 9, 9, 10, 0, -9 },
  { 872, 8, 9, 10, 1, -9 },
  { 881, 8, 12, 10, 1, -9 },
  { 893, 7, 9, 10, 1, -9 },
  { 901, 7, 15, 10, 1, -13 },
  { 915, 2, 15, 10, 4, -13 },
  { 919, 7, 15, 10, 1, -13 },
  { 933, 8, 3, 10, 1, -7 },
};

const GFXfont JetBrainsMono_Medium16pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Medium16pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Medium16pt7bGlyphs,
  0x20, 0x7E, 21
};

#endif // _JETBRAINSMONO_MEDIUM16PT7B_H_
