#ifndef _JETBRAINSMONO_MEDIUM27PT7B_H_
#define _JETBRAINSMONO_MEDIUM27PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Medium.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Medium27pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xF7, 0x77, 0x66, 0x66, 0x66, 0x00, 0x0F, 0xFF, 0xE7,
  0xE7, 0xE7, 0xE7, 0xE3, 0xE3, 0xE3, 0xE3, 0x06, 0x18, 0x38, 0x60, 0xC3,
  0x83, 0x0E, 0x0C, 0x31, 0xFF, 0xF7, 0xFF, 0xC7, 0x0C, 0x18, 0x70, 0x61,
  0x81, 0x86, 0x06, 0x18, 0x38, 0x63, 0xFF, 0xEF, 0xFF, 0x8C, 0x30, 0x30,
  0xC0, 0xC3, 0x07, 0x0C, 0x18, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0xF8,
  0x3F, 0xE7, 0xFE, 0x76, 0x7E, 0x67, 0xE6, 0x0E, 0x60, 0x76, 0x07, 0xE0,
  0x3F, 0x81, 0xFE, 0x07, 0xF0, 0x6F, 0x06, 0x70, 0x63, 0xE6, 0x7E, 0x67,
  0xFE, 0xF7, 0xFE, 0x3F, 0xC0, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x3C,
  0x03, 0x7E, 0x06, 0x67, 0x0E, 0xE3, 0x0C, 0xE3, 0x18, 0xE3, 0x30, 0xE3,
  0x70, 0x7F, 0x60, 0x3E, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x3C, 0x07,
  0x7E, 0x06, 0xE7, 0x0C, 0xC3, 0x1C, 0xC3, 0x18, 0xC3, 0x30, 0xE7, 0x60,
  0x7E, 0xE0, 0x3C, 0x0F, 0x80, 0x7F, 0x83, 0xFE, 0x0E, 0x1C, 0x30, 0x70,
  0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x01, 0xF8, 0x07, 0xF1, 0xF9, 0xC7,
  0xE3, 0xBB, 0x87, 0xEE, 0x1F, 0x38, 0x38, 0xE0, 0xF1, 0xC7, 0xE7, 0xFB,
  0x8F, 0xC7, 0xFF, 0xFF, 0xF6, 0x66, 0x01, 0x07, 0x0F, 0x1E, 0x38, 0x70,
  0x70, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0x70, 0x78, 0x3C, 0x1F, 0x0F, 0x03, 0x80, 0xE0, 0xF8, 0x7C,
  0x1C, 0x0E, 0x0F, 0x07, 0x07, 0x07, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x07, 0x07, 0x07, 0x07, 0x0E, 0x1E, 0x3C, 0xF8, 0xF0, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x10, 0xC3, 0xF3, 0x3F, 0xFF, 0xF3, 0xFF, 0x00, 0xC0,
  0x07, 0xC0, 0x33, 0x81, 0xCE, 0x0E, 0x1C, 0x38, 0x70, 0x40, 0x80, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x7F, 0xFF, 0xFF, 0xE0, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x3C, 0xF3, 0x9E, 0x71, 0xC7,
  0x38, 0xFF, 0xFF, 0x2F, 0xFF, 0xF0, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x0E,
  0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70,
  0x0F, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80,
  0x78, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x00, 0x1F, 0x83, 0xFC, 0x7F,
  0xEF, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE2, 0x7E, 0xF7, 0xEF,
  0x7E, 0x67, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x77, 0x8E, 0x7F,
  0xE1, 0xF8, 0x07, 0x80, 0xFC, 0x0F, 0xE1, 0xF7, 0x0E, 0x38, 0x61, 0xC2,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x87, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0x83, 0xFC, 0x7F, 0xEF, 0x0F, 0xE0, 0x7E, 0x07, 0x00, 0x70, 0x07, 0x00,
  0xE0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xE7, 0xFE, 0x7F, 0xE0, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x0F, 0xC0, 0xFE, 0x00, 0xE0, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x7E, 0x07, 0xE0, 0x7F, 0x1E, 0x7F, 0xE3, 0xF8, 0x01,
  0xE0, 0x1C, 0x03, 0x80, 0x78, 0x07, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x38,
  0x07, 0x87, 0x70, 0x7E, 0x07, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x7F, 0xE7, 0xFE, 0x7F, 0xE6, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x78, 0x6F, 0xE7, 0xFE, 0x70, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x7E, 0x07, 0xE0, 0x77, 0x9E, 0x7F, 0xE1, 0xF8, 0x03,
  0x80, 0x3C, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00,
  0x77, 0xC3, 0xFF, 0x3C, 0x3D, 0xC0, 0xEE, 0x07, 0x70, 0x1F, 0x80, 0xFC,
  0x0E, 0xE0, 0x73, 0xC7, 0x9F, 0xF8, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xEE, 0x07, 0x70, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x00,
  0x70, 0x07, 0x00, 0x38, 0x00, 0x1F, 0x83, 0xFC, 0x7F, 0xEF, 0x0F, 0xE0,
  0x7E, 0x07, 0xE0, 0x77, 0x0E, 0x3D, 0xC1, 0xF8, 0x3F, 0xC7, 0x9E, 0x70,
  0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x77, 0x8F, 0x7F, 0xE1, 0xFC, 0x1F,
  0x81, 0xFE, 0x1F, 0xF9, 0xE0, 0xEE, 0x07, 0x70, 0x1B, 0x80, 0xFC, 0x06,
  0xE0, 0x77, 0x87, 0x9F, 0xFC, 0x7F, 0xC0, 0x1E, 0x00, 0xE0, 0x0E, 0x00,
  0x70, 0x07, 0x00, 0x78, 0x03, 0x80, 0x38, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x3C, 0x78, 0xF9, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xE3, 0xC7, 0x0E, 0x3C, 0x70, 0xE3, 0x80, 0x00, 0x10, 0x07,
  0x03, 0xF0, 0xFC, 0x3F, 0x0F, 0xC0, 0xF0, 0x0E, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF0, 0x07, 0x01, 0xF0, 0x7C,
  0x1F, 0x0F, 0xC0, 0xF0, 0x0C, 0x00, 0xFC, 0x3F, 0xCF, 0xF8, 0x0F, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x03, 0xCF, 0xE3, 0xF0, 0xF0, 0x38, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0xF0, 0x07, 0xC0, 0x7F, 0xC3, 0xC7,
  0x9C, 0x07, 0x60, 0x1F, 0x80, 0x3E, 0x00, 0xF8, 0x7B, 0xE3, 0xFF, 0x9C,
  0x7E, 0x70, 0xF9, 0xC3, 0xE7, 0x0F, 0x9C, 0x3E, 0x70, 0xF9, 0xC3, 0xE3,
  0x9F, 0x8F, 0xBE, 0x08, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0xF0, 0x07,
  0xF0, 0x07, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0,
  0x3B, 0x00, 0xCE, 0x07, 0x38, 0x1C, 0xE0, 0x71, 0x81, 0x87, 0x0E, 0x1C,
  0x38, 0x70, 0xFF, 0xC3, 0xFF, 0x9C, 0x0E, 0x70, 0x39, 0xC0, 0xE6, 0x01,
  0xF8, 0x07, 0xFF, 0x07, 0xFE, 0x3F, 0xF9, 0xC1, 0xEE, 0x07, 0x70, 0x3B,
  0x81, 0xDC, 0x0E, 0xE3, 0xE7, 0xFC, 0x3F, 0xF9, 0xC1, 0xEE, 0x07, 0x70,
  0x1B, 0x80, 0xFC, 0x0E, 0xE0, 0x77, 0xFF, 0xBF, 0xF9, 0xFF, 0x00, 0x1F,
  0x83, 0xFE, 0x7F, 0xE7, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x07, 0xF0,
  0x77, 0x9F, 0x3F, 0xE1, 0xFC, 0xFF, 0x0F, 0xFC, 0xFF, 0xEE, 0x0F, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFF, 0xFE, 0xFF, 0xCF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xFF, 0xDF,
  0xFB, 0xFF, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x1F, 0x83, 0xFE,
  0x7F, 0xE7, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE3, 0xFE, 0x3F, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xF0, 0x77, 0x8F,
  0x3F, 0xE1, 0xFC, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0x87, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x1F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1F,
  0x80, 0xFC, 0x0E, 0xF0, 0x73, 0xC7, 0x8F, 0xF8, 0x3F, 0x80, 0xE0, 0x3F,
  0x03, 0xB8, 0x1D, 0xC1, 0xCE, 0x0E, 0x70, 0xE3, 0x87, 0x1C, 0x70, 0xFF,
  0x87, 0xFC, 0x3F, 0xE1, 0xC7, 0x0E, 0x3C, 0x70, 0xE3, 0x87, 0x9C, 0x1C,
  0xE0, 0xF7, 0x03, 0xB8, 0x1F, 0xC0, 0x70, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0,
  0x7F, 0x0F, 0xF0, 0xFF, 0x0F, 0xD8, 0xFD, 0x9B, 0xD9, 0xBD, 0xDB, 0xCF,
  0x3C, 0xF3, 0xCF, 0x3C, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xF0, 0x7F, 0x07, 0xF8, 0x7F, 0x87, 0xF8,
  0x7F, 0xC7, 0xEC, 0x7E, 0xC7, 0xEE, 0x7E, 0x67, 0xE6, 0x7E, 0x77, 0xE3,
  0x7E, 0x3F, 0xE3, 0xFE, 0x1B, 0xE1, 0xFE, 0x1F, 0xE0, 0xFE, 0x0F, 0x1F,
  0x83, 0xFC, 0x7F, 0xEF, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xF0,
  0x77, 0x9E, 0x7F, 0xE1, 0xF8, 0xFF, 0x87, 0xFF, 0x3F, 0xFD, 0xC0, 0xEE,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x7F, 0x0F, 0xBF, 0xF9, 0xFF,
  0x8E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x00, 0x1F, 0x83, 0xFC, 0x7F, 0xEF, 0x0F, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xF0, 0x77, 0x9E, 0x7F, 0xE1, 0xF8, 0x01, 0xC0, 0x1C, 0x00,
  0xE0, 0x0F, 0x00, 0x70, 0xFF, 0x07, 0xFE, 0x3F, 0xF9, 0xC1, 0xEE, 0x07,
  0x70, 0x1F, 0x80, 0xFC, 0x0E, 0xE0, 0x77, 0xFF, 0xBF, 0xF9, 0xFF, 0x0E,
  0x38, 0x70, 0xE3, 0x87, 0x1C, 0x1C, 0xE0, 0xE7, 0x07, 0xB8, 0x1D, 0xC0,
  0xF0, 0x1F, 0x83, 0xFE, 0x7F, 0xEF, 0x07, 0xE0, 0x7E, 0x00, 0xE0, 0x07,
  0x00, 0x7C, 0x03, 0xF8, 0x1F, 0xE0, 0x3F, 0x00, 0x70, 0x07, 0x00, 0x3E,
  0x07, 0xE0, 0x7F, 0x9F, 0x7F, 0xE3, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xF0, 0x77, 0x9E, 0x3F, 0xE1, 0xF8,
  0xE0, 0x1F, 0x80, 0x77, 0x01, 0x9C, 0x0E, 0x70, 0x39, 0xC0, 0xE3, 0x83,
  0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC1, 0xC6, 0x07, 0x38, 0x1C, 0xE0, 0x33,
  0x80, 0xEC, 0x03, 0xB0, 0x0F, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0xC3,
  0x8F, 0x87, 0x1F, 0x0E, 0x36, 0x3C, 0x6E, 0x78, 0xDC, 0xF1, 0xB9, 0xA7,
  0x73, 0x4E, 0xE4, 0x9C, 0xC9, 0xB9, 0x93, 0x73, 0x66, 0xC6, 0xCD, 0x8D,
  0x9B, 0x1F, 0x36, 0x3E, 0x2C, 0x7C, 0x58, 0xF0, 0xF0, 0xE1, 0xE1, 0xC3,
  0xC0, 0xF0, 0x1D, 0xC0, 0xE7, 0x83, 0x8E, 0x1C, 0x1C, 0x70, 0x73, 0x80,
  0xEE, 0x03, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xF0, 0x0F, 0xC0,
  0x3B, 0x81, 0xCE, 0x0F, 0x1C, 0x38, 0x71, 0xC0, 0xE7, 0x03, 0xB8, 0x07,
  0xE0, 0x1F, 0x80, 0x77, 0x03, 0x9C, 0x0E, 0x38, 0x70, 0xE1, 0xC1, 0xC7,
  0x07, 0x38, 0x0E, 0xE0, 0x3F, 0x00, 0x7C, 0x01, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x07,
  0x80, 0x70, 0x0E, 0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x07, 0x00, 0x70,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C,
  0x3F, 0xFF, 0xFE, 0xE0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0x80,
  0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x07, 0x00, 0x70, 0xFF, 0xFC, 0x38, 0x70, 0xE1, 0xC3, 0x87,
  0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1,
  0xFF, 0xFF, 0xFE, 0x07, 0x00, 0xF0, 0x0F, 0x01, 0xF8, 0x19, 0x83, 0x9C,
  0x38, 0xC7, 0x0E, 0x70, 0x66, 0x07, 0xE0, 0x70, 0xFF, 0xFF, 0xFF, 0xC0,
  0xE1, 0xC3, 0x87, 0x1F, 0x83, 0xFE, 0x79, 0xEF, 0x07, 0x00, 0x70, 0x07,
  0x1F, 0xF7, 0xFF, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xF0, 0xFF, 0xFF,
  0x3F, 0x70, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x7C, 0xEF,
  0xEF, 0xDE, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xF0, 0x7F, 0x9F, 0xEF, 0xEE, 0x7C, 0x1F, 0x83, 0xFE, 0x7D,
  0xFF, 0x07, 0xE0, 0x7E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x7F, 0x07, 0x79, 0xF7, 0xFE, 0x1F, 0xC0, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x71, 0xE7, 0x7F, 0x77, 0xFF, 0xF0, 0xFE, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xF7, 0x9F, 0x7F, 0xF3,
  0xF7, 0x1F, 0x83, 0xFE, 0x78, 0xEE, 0x07, 0xE0, 0x7E, 0x07, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x07, 0x70, 0xF3, 0xFE, 0x1F, 0x80,
  0x01, 0xF8, 0x3F, 0xC3, 0xFE, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x1F,
  0xFF, 0xFF, 0xF8, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x1F, 0x77, 0xF7,
  0x7F, 0xFF, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xF0, 0xF7, 0xDF, 0x7F, 0xF1, 0xE7, 0x00, 0x70, 0x07, 0x00, 0x73, 0xFE,
  0x3F, 0xE3, 0xF8, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x7C,
  0xEF, 0xEF, 0x9E, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0x07, 0x00, 0x7C,
  0x01, 0xC0, 0x04, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x7F, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xC0, 0x7C, 0x07,
  0x00, 0x40, 0x00, 0x00, 0x1F, 0xF3, 0xFE, 0x7F, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0xF7, 0xFC, 0xFF, 0x1F, 0xC0, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x1F, 0x81, 0xDC, 0x1E, 0xE0, 0xE7, 0x0E,
  0x38, 0xF1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0x8F, 0x1C, 0x38, 0xE0, 0xE7,
  0x07, 0xB8, 0x1D, 0xC0, 0x70, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1F,
  0xF0, 0x3F, 0xC0, 0x7F, 0xDC, 0xE7, 0xFF, 0xB9, 0xCD, 0x8C, 0x7C, 0x63,
  0xE3, 0x1F, 0x18, 0xF8, 0xC7, 0xC6, 0x3E, 0x31, 0xF1, 0x8F, 0x8C, 0x7C,
  0x63, 0xE3, 0x1F, 0x18, 0xE0, 0xE7, 0xCE, 0xFE, 0xFD, 0xEF, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x70, 0x1F, 0x83, 0xFE, 0x7F, 0xEF, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0x07, 0x79, 0xE7,
  0xFE, 0x1F, 0x80, 0xE7, 0xCE, 0xFE, 0xFD, 0xEF, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0x07, 0xF8, 0xFE, 0xFE,
  0xE7, 0xCE, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x1E, 0x77, 0xF7,
  0x7F, 0xFF, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7F, 0x0F, 0x79, 0xF7, 0xFF, 0x3F, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0xEF, 0x8F, 0xFC, 0xF9, 0xEE, 0x0E, 0xE0, 0x7E, 0x07,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x00, 0x1F, 0xC7, 0xFE, 0x79, 0xF6, 0x07, 0xE0, 0x07, 0x00, 0x7F,
  0x03, 0xFE, 0x07, 0xF0, 0x07, 0x00, 0x7E, 0x07, 0xF0, 0xF7, 0xFE, 0x3F,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE1, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x07, 0xF8, 0x3F, 0xC0, 0xFE, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7F, 0x07, 0x79, 0xE3, 0xFE, 0x1F, 0x80, 0xE0, 0x1D, 0xC0, 0x77, 0x03,
  0x9C, 0x0E, 0x38, 0x38, 0xE1, 0xC3, 0x87, 0x07, 0x1C, 0x1C, 0xE0, 0x73,
  0x80, 0xEE, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x78, 0x00, 0xC3, 0x0F,
  0x0E, 0x3E, 0x38, 0xF9, 0xE3, 0xE7, 0x9D, 0x9A, 0x76, 0x49, 0x99, 0x26,
  0x64, 0xD9, 0xF3, 0x67, 0xCD, 0x8F, 0x3E, 0x3C, 0x70, 0xE1, 0xC3, 0x87,
  0x00, 0xF0, 0x3D, 0xE0, 0xE3, 0x87, 0x07, 0x38, 0x1E, 0xE0, 0x3F, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0xC0, 0x3F, 0x01, 0xCE, 0x07, 0x3C, 0x38, 0x71,
  0xC0, 0xEF, 0x03, 0xC0, 0xF0, 0x1D, 0xC0, 0xE7, 0x03, 0x8E, 0x0E, 0x38,
  0x70, 0xE1, 0xC1, 0xC7, 0x07, 0x38, 0x0E, 0xE0, 0x3B, 0x80, 0xFC, 0x01,
  0xF0, 0x07, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0xE0, 0x03, 0x80, 0x7F, 0xF7, 0xFF, 0x7F, 0xF0, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x80, 0xF0, 0x1E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x01, 0xF0, 0x3F, 0x03, 0x80, 0x70, 0x03, 0x00, 0x30, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x38, 0x07, 0x0F, 0xF0, 0xFE, 0x0F, 0xF0, 0x07,
  0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x30, 0x07, 0x00, 0x38, 0x03,
  0xF0, 0x3F, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0xF8, 0x0F, 0xC0, 0x1E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0E, 0x00, 0x7F, 0x03, 0xF0, 0xFF, 0x0E,
  0x00, 0xC0, 0x0C, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0xFC,
  0x0F, 0xC0, 0xF0, 0x00, 0x7C, 0x3F, 0xF1, 0xF1, 0xCF, 0x8F, 0xEC, 0x3F,
  0x00,
};

const GFXglyph JetBrainsMono_Medium27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 4, 20, 16, 6, -20 },
  { 11, 8, 8, 16, 4, -20 },
  { 19, 14, 20, 16, 1, -20 },
  { 54, 12, 27, 16, 2, -23 },
  { 95, 16, 20, 16, 0, -20 },
  { 135, 14, 20, 16, 1, -20 },
  { 170, 4, 8, 16, 6, -20 },
  { 174, 8, 26, 16, 5, -23 },
  { 200, 8, 26, 16, 3, -23 },
  { 226, 14, 14, 16, 1, -16 },
  { 251, 13, 12, 16, 2, -15 },
  { 271, 6, 8, 16, 4, -4 },
  { 277, 8, 2, 16, 4, -10 },
  { 279, 4, 5, 16, 6, -5 },
  { 282, 12, 25, 16, 2, -22 },
  { 320, 12, 20, 16, 2, -20 },
  { 350, 13, 20, 16, 2, -20 },
  { 383, 12, 20, 16, 2, -20 },
  { 413, 12, 20, 16, 2, -20 },
  { 443, 12, 20, 16, 2, -20 },
  { 473, 12, 20, 16, 2, -20 },
  { 503, 13, 20, 16, 2, -20 },
  { 536, 13, 20, 16, 2, -20 },
  { 569, 12, 20, 16, 2, -20 },
  { 599, 13, 20, 16, 2, -20 },
  { 632, 4, 15, 16, 6, -15 },
  { 640, 7, 19, 16, 4, -15 },
  { 657, 12, 14, 16, 2, -16 },
  { 678, 12, 10, 16, 2, -14 },
  { 693, 12, 14, 16, 2, -16 },
  { 714, 10, 20, 16, 3, -20 },
  { 739, 14, 25, 16, 1, -20 },
  { 783, 14, 20, 16, 1, -20 },
  { 818, 13, 20, 16, 2, -20 },
  { 851, 12, 20, 16, 2, -20 },
  { 881, 12, 20, 16, 2, -20 },
  { 911, 11, 20, 16, 3, -20 },
  { 939, 12, 20, 16, 2, -20 },
  { 969, 12, 20, 16, 2, -20 },
  { 999, 12, 20, 16, 2, -20 },
  { 1029, 11, 20, 16, 3, -20 },
  { 1057, 13, 20, 16, 1, -20 },
  { 1090, 13, 20, 16, 2, -20 },
  { 1123, 11, 20, 16, 3, -20 },
  { 1151, 12, 20, 16, 2, -20 },
  { 1181, 12, 20, 16, 2, -20 },
  { 1211, 12, 20, 16, 2, -20 },
  { 1241, 13, 20, 16, 2, -20 },
  { 1274, 12, 25, 16, 2, -20 },
  { 1312, 13, 20, 16, 2, -20 },
  { 1345, 12, 20, 16, 2, -20 },
  { 1375, 14, 20, 16, 1, -20 },
  { 1410, 12, 20, 16, 2, -20 },
  { 1440, 14, 20, 16, 1, -20 },
  { 1475, 15, 20, 16, 1, -20 },
  { 1513, 14, 20, 16, 1, -20 },
  { 1548, 14, 20, 16, 1, -20 },
  { 1583, 12, 20, 16, 2, -20 },
  { 1613, 7, 25, 16, 5, -22 },
  { 1635, 12, 25, 16, 2, -22 },
  { 1673, 7, 25, 16, 4, -22 },
  { 1695, 12, 11, 16, 2, -20 },
  { 1712, 13, 2, 16, 2, 1 },
  { 1716, 6, 4, 16, 5, -21 },
  { 1719, 12, 15, 16, 2, -15 },
  { 1742, 12, 20, 16, 2, -20 },
  { 1772, 12, 15, 16, 2, -15 },
  { 1795, 12, 20, 16, 2, -20 },
  { 1825, 12, 15, 16, 2, -15 },
  { 1848, 13, 20, 16, 2, -20 },
  { 1881, 12, 20, 16, 2, -15 },
  { 1911, 12, 20, 16, 2, -20 },
  { 1941, 13, 21, 16, 2, -21 },
  { 1976, 11, 26, 16, 2, -21 },
  { 2012, 13, 20, 16, 2, -20 },
  { 2045, 14, 20, 16, 1, -20 },
  { 2080, 13, 15, 16, 2, -15 },
  { 2105, 12, 15, 16, 2, -15 },
  { 2128, 12, 15, 16, 2, -15 },
  { 2151, 12, 20, 16, 2, -15 },
  { 2181, 12, 20, 16, 2, -15 },
  { 2211, 12, 15, 16, 3, -15 },
  { 2234, 12, 15, 16, 2, -15 },
  { 2257, 13, 19, 16, 1, -19 },
  { 2288, 12, 15, 16, 2, -15 },
  { 2311, 14, 15, 16, 1, -15 },
  { 2338, 14, 15, 16, 1, -15 },
  { 2365, 14, 15, 16, 1, -15 },
  { 2392, 14, 20, 16, 1, -15 },
  { 2427, 12, 15, 16, 2, -15 },
  { 2450, 12, 25, 16, 2, -22 },
  { 2488, 3, 25, 16, 7, -22 },
  { 2498, 12, 25, 16, 2, -22 },
  { 2536, 13, 5, 16, 2, -12 },
};

const GFXfont JetBrainsMono_Medium27pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Medium27pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Medium27pt7bGlyphs,
  0x20, 0x7E, 36
};

#endif // _JETBRAINSMONO_MEDIUM27PT7B_H_
