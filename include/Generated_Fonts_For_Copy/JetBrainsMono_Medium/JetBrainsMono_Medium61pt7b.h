#ifndef _JETBRAINSMONO_MEDIUM61PT7B_H_
#define _JETBRAINSMONO_MEDIUM61PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Medium.ttf
// Size: 61pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Medium61pt7bBitmaps[] PROGMEM = {
  0x00, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F,
  0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xF9, 0xFF, 0x7F, 0xFF, 0xF7, 0xFD, 0xFF, 0x3F, 0x80, 0xFE, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0x7E, 0x07, 0xF7, 0xE0, 0x7F, 0x7E,
  0x03, 0xF7, 0xE0, 0x3F, 0x7E, 0x03, 0xF7, 0xE0, 0x3F, 0x7E, 0x03, 0xF7,
  0xE0, 0x3F, 0x7E, 0x03, 0xF7, 0xE0, 0x3F, 0x7E, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x07,
  0xC0, 0x1F, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x01, 0xF0, 0x07, 0xC0, 0x00,
  0xF8, 0x03, 0xE0, 0x00, 0x78, 0x01, 0xF0, 0x00, 0x7C, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x3E, 0x03,
  0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x7C, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x3E, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x03, 0xE0, 0x0F,
  0x80, 0x03, 0xE0, 0x07, 0x80, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0xF8, 0x03,
  0xE0, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFE, 0x03, 0xE0, 0x0F, 0x80, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0xF0,
  0x03, 0xC0, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x0F,
  0x80, 0x3E, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x01,
  0xF0, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0x1C, 0xFF, 0x87, 0xF0,
  0xE1, 0xFC, 0x7F, 0x07, 0x07, 0xF3, 0xF8, 0x38, 0x3F, 0x9F, 0xC1, 0xC1,
  0xFC, 0xFE, 0x0E, 0x0F, 0xE7, 0xF0, 0x70, 0x00, 0x3F, 0x83, 0x80, 0x01,
  0xFC, 0x1C, 0x00, 0x0F, 0xF0, 0xE0, 0x00, 0x3F, 0x87, 0x00, 0x01, 0xFF,
  0x38, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x0E, 0x3F, 0xE0, 0x00, 0x70, 0xFF, 0x00, 0x03, 0x83, 0xF8, 0x00, 0x1C,
  0x0F, 0xC0, 0x00, 0xE0, 0x7F, 0x00, 0x07, 0x03, 0xFF, 0xE0, 0x38, 0x1F,
  0xFF, 0x81, 0xC0, 0xFF, 0xFC, 0x0E, 0x07, 0xEF, 0xE0, 0x70, 0x7F, 0x3F,
  0x83, 0x83, 0xF9, 0xFE, 0x1C, 0x3F, 0x87, 0xFE, 0xEF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0xFF, 0xE0, 0x00, 0x3F, 0x1F, 0xFF,
  0x00, 0x03, 0xE3, 0xFF, 0xF8, 0x00, 0x7C, 0x3F, 0xFF, 0x80, 0x0F, 0xC7,
  0xE0, 0xFC, 0x00, 0xF8, 0x7C, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x7C, 0x03,
  0xE0, 0x7C, 0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07,
  0xC0, 0xF8, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0x7C, 0x07, 0xC1, 0xF0, 0x07,
  0xC0, 0x7C, 0x3E, 0x00, 0x7C, 0x07, 0xC7, 0xE0, 0x07, 0xE0, 0xFC, 0x7C,
  0x00, 0x3F, 0xFF, 0x8F, 0x80, 0x03, 0xFF, 0xF9, 0xF0, 0x00, 0x1F, 0xFF,
  0x1F, 0x00, 0x00, 0x7F, 0xC3, 0xE0, 0x00, 0x00, 0xE0, 0x7C, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x1F, 0xE0, 0x00, 0x07,
  0xC3, 0xFF, 0x80, 0x00, 0xFC, 0xFF, 0xFC, 0x00, 0x0F, 0x8F, 0xFF, 0xC0,
  0x01, 0xF1, 0xFC, 0x7E, 0x00, 0x3E, 0x1F, 0x03, 0xE0, 0x03, 0xE3, 0xF0,
  0x1F, 0x00, 0x7C, 0x3E, 0x01, 0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0x00, 0xF8,
  0x3E, 0x01, 0xF0, 0x1F, 0x03, 0xE0, 0x1F, 0x03, 0xE0, 0x3E, 0x01, 0xF0,
  0x3E, 0x03, 0xE0, 0x1F, 0x07, 0xC0, 0x3F, 0x01, 0xF0, 0xF8, 0x01, 0xF0,
  0x3E, 0x1F, 0x80, 0x1F, 0x87, 0xE1, 0xF0, 0x01, 0xFF, 0xFE, 0x3E, 0x00,
  0x0F, 0xFF, 0xC7, 0xC0, 0x00, 0x7F, 0xF8, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xF9, 0xFF, 0x80,
  0x1F, 0xE0, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0xC0,
  0x1F, 0x80, 0x0F, 0xC0, 0x1F, 0x80, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0x7F, 0x3F, 0x80, 0xFE, 0xFE, 0x1F, 0xC0, 0xFC, 0xFE, 0x0F, 0xE1, 0xFC,
  0xFC, 0x0F, 0xE3, 0xF8, 0xFC, 0x07, 0xF3, 0xF8, 0xFC, 0x03, 0xFF, 0xF0,
  0xFC, 0x03, 0xFF, 0xE0, 0xFC, 0x01, 0xFF, 0xE0, 0xFC, 0x00, 0xFF, 0xC0,
  0xFC, 0x00, 0x7F, 0xC0, 0xFC, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x3F, 0x80,
  0xFE, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0xFF, 0xE0,
  0x7F, 0x83, 0xFF, 0xF0, 0x7F, 0xFF, 0xFB, 0xF8, 0x3F, 0xFF, 0xFB, 0xF8,
  0x1F, 0xFF, 0xE1, 0xFC, 0x0F, 0xFF, 0xC0, 0xFE, 0x07, 0xFF, 0x00, 0x7F,
  0x00, 0x30, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x7C,
  0x00, 0x3F, 0x80, 0x1F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xE0,
  0x1F, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xE0, 0x1F,
  0xFE, 0x01, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x07, 0xE0, 0x00,
  0x1C, 0xC0, 0x00, 0x1F, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0xC0, 0x0F, 0xFC,
  0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x3F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0x7F, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x07,
  0xF0, 0x00, 0xF8, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x30, 0x03, 0xE0, 0x06, 0x1E, 0x01, 0xF0, 0x1F,
  0x1F, 0xE0, 0xF8, 0x3F, 0x8F, 0xF8, 0x78, 0x7F, 0xEF, 0xFF, 0x1C, 0x7F,
  0xF7, 0xFF, 0xCE, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x03, 0xF3,
  0xF0, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x01, 0xFC,
  0x1F, 0xC0, 0x01, 0xFC, 0x0F, 0xF0, 0x01, 0xFE, 0x03, 0xF8, 0x01, 0xFE,
  0x01, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x03,
  0x00, 0x06, 0x00, 0x00, 0x80, 0x02, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x7F, 0xC3, 0xFC, 0x1F, 0xE1,
  0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xF8, 0x3F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFE,
  0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0x0F, 0xF1, 0xFF, 0x7F, 0xEF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x7F, 0xC7, 0xF0, 0x10, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0x1F, 0xE0, 0x1F, 0xF7, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x1F,
  0xDF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x0F,
  0x83, 0xFF, 0xC3, 0xF8, 0x7F, 0xF8, 0x7F, 0x0F, 0xFF, 0x1F, 0xE1, 0xFF,
  0xE1, 0xFC, 0x3F, 0xFC, 0x3F, 0x87, 0xFF, 0x83, 0xE0, 0xFF, 0xF0, 0x10,
  0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFE,
  0x00, 0x3F, 0x9F, 0xE0, 0x0F, 0xF3, 0xFF, 0x07, 0xFC, 0x3F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFC, 0xFE, 0x00, 0xFF, 0x8F,
  0xE0, 0x0F, 0xF0, 0xFE, 0x00, 0xFC, 0x0F, 0xE0, 0x0F, 0x80, 0xFE, 0x00,
  0xF0, 0x0F, 0xE0, 0x0C, 0x00, 0xFE, 0x00, 0x80, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x3F, 0xC0, 0x3F, 0xC7, 0xF8, 0x01, 0xFE,
  0x7F, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x7E, 0xFE, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0xFE, 0x7F,
  0x80, 0x1F, 0xC3, 0xFE, 0x07, 0xFC, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00,
  0x01, 0x60, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0xFF,
  0x00, 0xFE, 0x3F, 0xC0, 0x1F, 0xC7, 0xF0, 0x03, 0xF9, 0xFC, 0x00, 0x7F,
  0x7F, 0x80, 0x0F, 0xEF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x7F,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x1F, 0xF0, 0x0F, 0xCF, 0xFF, 0x81,
  0xFB, 0xFF, 0xF8, 0x3F, 0x7F, 0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0xFF, 0xC3,
  0xFF, 0x1F, 0xE0, 0x0F, 0xF3, 0xF8, 0x00, 0xFE, 0x7E, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0xFD, 0xFC, 0x00, 0x3F, 0x9F, 0xC0, 0x0F, 0xF3, 0xFF,
  0x0F, 0xFC, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x06, 0x00, 0x07, 0xF3, 0xFF, 0x00, 0x3F, 0xBF, 0xFE, 0x03,
  0xFB, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x8F, 0xF8,
  0x07, 0xFC, 0x7F, 0x80, 0x0F, 0xF7, 0xF8, 0x00, 0x3F, 0xBF, 0x80, 0x01,
  0xFD, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xE7, 0xF0, 0x00,
  0x7F, 0x3F, 0x80, 0x07, 0xF9, 0xFF, 0x00, 0x7F, 0x87, 0xFE, 0x0F, 0xFC,
  0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0x40, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x3F, 0xBF, 0x80,
  0x01, 0xF9, 0xFC, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF,
  0xC0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFC, 0x3F, 0xC0, 0x3F, 0xC3, 0xF8, 0x01, 0xFE, 0x7F, 0x00,
  0x0F, 0xE7, 0xF0, 0x00, 0x7E, 0x7F, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x7E,
  0x7F, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xE3, 0xF8,
  0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xC1, 0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0xFF,
  0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0x0F,
  0xF8, 0x1F, 0xE0, 0x3F, 0xC3, 0xF8, 0x01, 0xFE, 0x7F, 0x00, 0x0F, 0xE7,
  0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x7F, 0xFE, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F,
  0x7F, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0xFF, 0x7F, 0x80, 0x1F, 0xE3, 0xFF,
  0x07, 0xFE, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0x00, 0xFF,
  0x8F, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x3F, 0xBF,
  0x80, 0x00, 0xFD, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFD, 0xFE, 0x00, 0x0F, 0xE7,
  0xF0, 0x00, 0xFF, 0x3F, 0xE0, 0x0F, 0xF8, 0xFF, 0xC1, 0xFF, 0x87, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xEF, 0xE0, 0x7F, 0xFE, 0xFE, 0x00, 0xFF, 0xEF,
  0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x0F, 0xFB, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFE, 0x3F, 0x80, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE1, 0xFE, 0x7F, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x7F, 0xC7, 0xF0, 0x10, 0x00, 0x07, 0xE0, 0x3F, 0xE1,
  0xFF, 0x87, 0xFF, 0x1F, 0xFC, 0x7F, 0xF1, 0xFF, 0x83, 0xFE, 0x07, 0xF0,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x04, 0x1F, 0xE0, 0xFF, 0x83, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC1, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0x7F, 0x03, 0xFC, 0x0F, 0xE0, 0x3F,
  0x80, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xF8, 0x0F, 0xC0, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF,
  0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F,
  0xFF, 0x80, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x07,
  0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFE, 0x00, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xF0,
  0x0F, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xE0, 0x7F,
  0x80, 0x07, 0xF0, 0x3F, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x7E, 0x1F,
  0x80, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x03, 0xE7,
  0xE0, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x78, 0x3F, 0xFC, 0x00, 0xFF, 0x9F, 0xFE, 0x00, 0xFF, 0xEF,
  0xFF, 0x00, 0xFF, 0xF3, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7E, 0x07,
  0xFF, 0xE0, 0x3F, 0x01, 0xFF, 0xF0, 0x3F, 0x00, 0x7F, 0xF8, 0x1F, 0x80,
  0x3F, 0xFC, 0x0F, 0xC0, 0x1F, 0xFE, 0x07, 0xE0, 0x0F, 0xFF, 0x03, 0xF0,
  0x07, 0xFF, 0x81, 0xF8, 0x03, 0xFF, 0xC0, 0xFC, 0x01, 0xFF, 0xE0, 0x7E,
  0x00, 0xFF, 0xF0, 0x3F, 0x00, 0x7F, 0xF8, 0x1F, 0x80, 0x3F, 0xFC, 0x0F,
  0xC0, 0x1F, 0xFE, 0x07, 0xE0, 0x0F, 0xFF, 0x03, 0xF0, 0x07, 0xFF, 0x80,
  0xFC, 0x07, 0xFF, 0xC0, 0x7E, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0x3F, 0xF8, 0x03, 0xFF, 0x9F, 0xFC, 0x00, 0xFF, 0x9F, 0xBE,
  0x00, 0x1C, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x7E, 0xFC, 0x00,
  0x00, 0xFD, 0xF8, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x07, 0xE7, 0xE0, 0x00,
  0x0F, 0xC7, 0xE0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x00,
  0xFC, 0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x0F,
  0xE0, 0xFC, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x7E,
  0x03, 0xF0, 0x01, 0xFC, 0x07, 0xE0, 0x03, 0xF0, 0x0F, 0xE0, 0x07, 0xE0,
  0x1F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0x7F, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xE0, 0xFE, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x3F,
  0x87, 0xE0, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0xFE,
  0x7E, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x03, 0xF7,
  0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xE0, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0xFE, 0x00, 0xFF, 0xCF, 0xE0, 0x03, 0xFC,
  0xFE, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xEF, 0xE0,
  0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x0F,
  0xEF, 0xE0, 0x00, 0xFC, 0xFE, 0x00, 0x1F, 0xCF, 0xE0, 0x03, 0xF8, 0xFE,
  0x00, 0x7F, 0x8F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x8F,
  0xE0, 0x03, 0xFC, 0xFE, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0xFE, 0xFE, 0x00,
  0x0F, 0xEF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x01, 0xFE, 0xFE, 0x00, 0x3F,
  0xEF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x1F, 0xF0, 0x1F, 0xF3, 0xF8, 0x00,
  0xFE, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0x9F, 0xE0, 0x0F, 0xF1, 0xFF, 0x8F,
  0xFC, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x3F, 0x81, 0xFF, 0xE7, 0xF0, 0x03,
  0xFC, 0xFE, 0x00, 0x3F, 0xDF, 0xC0, 0x03, 0xFB, 0xF8, 0x00, 0x3F, 0xFF,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03,
  0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0,
  0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00,
  0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xEF,
  0xE0, 0x01, 0xFD, 0xFC, 0x00, 0x7F, 0xBF, 0x80, 0x3F, 0xE7, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFB, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xFF, 0x00,
  0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0x1F, 0xF0, 0x1F, 0xF3, 0xF8, 0x00, 0xFE, 0xFF, 0x00, 0x1F, 0xFF,
  0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x03, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFE, 0xFE, 0x00,
  0x3F, 0x9F, 0xE0, 0x0F, 0xF1, 0xFF, 0x87, 0xFC, 0x3F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF,
  0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03,
  0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80,
  0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF,
  0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F,
  0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F,
  0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00,
  0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8,
  0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF,
  0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00,
  0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFC,
  0xFC, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x7F, 0x3F, 0xC0, 0x07, 0xF8, 0xFF,
  0x00, 0x7F, 0x87, 0xFE, 0x0F, 0xFC, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x03, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xBF,
  0x80, 0x01, 0xFD, 0xFC, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0xFE, 0x7F, 0x00,
  0x0F, 0xE3, 0xF8, 0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x3F,
  0x87, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x01, 0xFE, 0x0F,
  0xE0, 0x0F, 0xE0, 0x7F, 0x00, 0xFF, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x80, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x3F, 0xC0, 0x3F, 0x81, 0xFC,
  0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xF0,
  0x3F, 0x80, 0x3F, 0x81, 0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0,
  0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xC1, 0xFC,
  0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xE3, 0xF8, 0x00,
  0x7F, 0x1F, 0xC0, 0x03, 0xFC, 0xFE, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x7F,
  0xBF, 0x80, 0x01, 0xFD, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0x80,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0x00, 0x7B, 0xFF, 0x78, 0x07, 0xDF, 0xFB, 0xE0, 0x3E, 0xFF,
  0xDF, 0x01, 0xE7, 0xFE, 0xF8, 0x1F, 0x7F, 0xF3, 0xE0, 0xFB, 0xFF, 0x9F,
  0x07, 0xDF, 0xFC, 0xF8, 0x3C, 0xFF, 0xE3, 0xE3, 0xE7, 0xFF, 0x9F, 0x1F,
  0x3F, 0xFC, 0xF8, 0xF1, 0xFF, 0xE3, 0xCF, 0x8F, 0xFF, 0x1F, 0x7C, 0x7F,
  0xF8, 0xFB, 0xC3, 0xFF, 0xC3, 0xDE, 0x1F, 0xFE, 0x1F, 0xF0, 0xFF, 0xF0,
  0xFF, 0x87, 0xFF, 0x83, 0xF8, 0x7F, 0xFC, 0x1F, 0xC3, 0xFF, 0xE0, 0xFE,
  0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F,
  0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0x80, 0xFF,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0x00, 0x3F, 0xFB, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFE, 0xF8, 0x03, 0xFF, 0xDF, 0x00, 0x7F, 0xFB, 0xF0, 0x0F, 0xFF, 0x3E,
  0x01, 0xFF, 0xE7, 0xE0, 0x3F, 0xFC, 0xFC, 0x07, 0xFF, 0x8F, 0x80, 0xFF,
  0xF1, 0xF8, 0x1F, 0xFE, 0x3F, 0x03, 0xFF, 0xC3, 0xE0, 0x7F, 0xF8, 0x7E,
  0x0F, 0xFF, 0x07, 0xC1, 0xFF, 0xE0, 0xF8, 0x3F, 0xFC, 0x1F, 0x87, 0xFF,
  0x81, 0xF0, 0xFF, 0xF0, 0x3E, 0x1F, 0xFE, 0x07, 0xE3, 0xFF, 0xC0, 0x7C,
  0x7F, 0xF8, 0x0F, 0x8F, 0xFF, 0x01, 0xF9, 0xFF, 0xE0, 0x1F, 0x3F, 0xFC,
  0x03, 0xE7, 0xFF, 0x80, 0x7E, 0xFF, 0xF0, 0x07, 0xDF, 0xFE, 0x00, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0,
  0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0x1F, 0xF0, 0x1F, 0xE3, 0xF8, 0x01, 0xFE, 0xFE, 0x00,
  0x1F, 0xDF, 0xC0, 0x01, 0xFB, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0,
  0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80,
  0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xEF, 0xE0, 0x01, 0xFC,
  0xFE, 0x00, 0x3F, 0x9F, 0xE0, 0x0F, 0xF3, 0xFF, 0x8F, 0xFC, 0x3F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x18, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0xE3, 0xF8, 0x03, 0xFF, 0x9F, 0xC0, 0x03, 0xFE,
  0xFE, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0x80, 0x01, 0xFD, 0xFC, 0x00, 0x1F, 0xEF, 0xE0, 0x01, 0xFE, 0x7F,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8,
  0x7F, 0xC0, 0x7F, 0xC7, 0xF0, 0x03, 0xFC, 0xFE, 0x00, 0x1F, 0xCF, 0xE0,
  0x00, 0xFE, 0xFC, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0xFE, 0xFC, 0x00, 0x0F,
  0xEF, 0xC0, 0x00, 0xFE, 0xFC, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0xFE, 0xFC,
  0x00, 0x0F, 0xEF, 0xC0, 0x00, 0xFE, 0xFC, 0x00, 0x0F, 0xEF, 0xC0, 0x00,
  0xFE, 0xFC, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0xFE, 0xFC, 0x00, 0x0F, 0xEF,
  0xC0, 0x00, 0xFE, 0xFC, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0xFE, 0xFC, 0x00,
  0x0F, 0xEF, 0xC0, 0x00, 0xFE, 0xFC, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0xFE,
  0xFC, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0xFE, 0xFC, 0x00, 0x0F, 0xEF, 0xC0,
  0x00, 0xFE, 0xFC, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x0F,
  0xEF, 0xF0, 0x01, 0xFC, 0x7F, 0x80, 0x3F, 0xC7, 0xFE, 0x0F, 0xF8, 0x3F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0x80, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0xC3, 0xF8, 0x03, 0xFF, 0x1F, 0xC0, 0x07, 0xFC,
  0xFE, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x7F, 0x3F, 0x80, 0x01, 0xFD, 0xFC,
  0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x7F, 0x7F, 0x00, 0x03, 0xFB, 0xF8, 0x00,
  0x1F, 0xDF, 0xC0, 0x00, 0xFE, 0xFE, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x7F,
  0x3F, 0x80, 0x03, 0xF9, 0xFC, 0x00, 0x3F, 0xCF, 0xE0, 0x07, 0xFC, 0x7F,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFC, 0x0F, 0xE0,
  0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x1F,
  0xC0, 0x3F, 0x80, 0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0xF0, 0x3F, 0x80,
  0x3F, 0xC1, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF8, 0x7F, 0x00, 0x1F,
  0xC3, 0xF8, 0x00, 0xFF, 0x1F, 0xC0, 0x03, 0xF8, 0xFE, 0x00, 0x1F, 0xC7,
  0xF0, 0x00, 0x7F, 0x3F, 0x80, 0x03, 0xF9, 0xFC, 0x00, 0x1F, 0xEF, 0xE0,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xE0, 0xFF, 0x00, 0xFF, 0x87, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x07, 0xF3,
  0xF8, 0x00, 0x3F, 0x9F, 0xC0, 0x01, 0xFC, 0xFE, 0x00, 0x0F, 0xE7, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00,
  0x07, 0xEF, 0xE0, 0x00, 0x7F, 0x3F, 0x80, 0x03, 0xF9, 0xFE, 0x00, 0x7F,
  0x8F, 0xFF, 0x1F, 0xFC, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F,
  0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F,
  0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF,
  0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0x00, 0x07, 0xEF, 0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x3F, 0x9F,
  0xE0, 0x0F, 0xF3, 0xFF, 0x0F, 0xFC, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x03, 0xF7, 0xF0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x1F, 0xCF, 0xE0,
  0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0xFC, 0x3F, 0x00,
  0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xC1, 0xFC, 0x00,
  0x1F, 0x81, 0xF8, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x01,
  0xF8, 0x0F, 0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x07, 0xE0, 0x1F, 0x80, 0x1F,
  0xC0, 0x3F, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC,
  0x00, 0xFC, 0x03, 0xF8, 0x01, 0xFC, 0x07, 0xE0, 0x03, 0xF8, 0x0F, 0xC0,
  0x03, 0xF0, 0x1F, 0x80, 0x07, 0xE0, 0x7F, 0x00, 0x0F, 0xE0, 0xFC, 0x00,
  0x1F, 0xC1, 0xF8, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x3F, 0x0F, 0xE0, 0x00,
  0x7F, 0x1F, 0x80, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x01,
  0xF8, 0xFC, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFC, 0x03,
  0xF0, 0x07, 0xFF, 0x00, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0x80, 0xFD, 0xF0,
  0x0F, 0xE0, 0x3F, 0x7E, 0x03, 0xF8, 0x0F, 0xDF, 0x80, 0xFE, 0x03, 0xF7,
  0xE0, 0x3B, 0x80, 0xFD, 0xF8, 0x0E, 0xE0, 0x3F, 0x7E, 0x07, 0xB8, 0x0F,
  0x9F, 0x81, 0xEE, 0x03, 0xE7, 0xE0, 0x7B, 0xC0, 0xF9, 0xF8, 0x1E, 0xF0,
  0x3E, 0x3E, 0x07, 0xBC, 0x1F, 0x8F, 0x81, 0xEF, 0x07, 0xE3, 0xF0, 0x73,
  0xC1, 0xF8, 0xFC, 0x1C, 0xF0, 0x7E, 0x3F, 0x0F, 0x1C, 0x1F, 0x8F, 0xC3,
  0xC7, 0x07, 0xC3, 0xF0, 0xF1, 0xE1, 0xF0, 0xFC, 0x3C, 0x78, 0x7C, 0x3F,
  0x0F, 0x1E, 0x1F, 0x07, 0xC3, 0xC7, 0x87, 0xC1, 0xF0, 0xE1, 0xE3, 0xF0,
  0x7C, 0x38, 0x78, 0xFC, 0x1F, 0x1E, 0x1E, 0x3F, 0x07, 0xE7, 0x83, 0x8F,
  0xC1, 0xF9, 0xE0, 0xE3, 0xE0, 0x7E, 0x78, 0x3C, 0xF8, 0x1F, 0x9E, 0x0F,
  0x3E, 0x07, 0xE7, 0x83, 0xCF, 0x80, 0xF9, 0xE0, 0xF3, 0xE0, 0x3E, 0x70,
  0x3C, 0xF8, 0x0F, 0x9C, 0x0F, 0x3E, 0x03, 0xEF, 0x03, 0xDF, 0x80, 0xFB,
  0xC0, 0x77, 0xE0, 0x3E, 0xF0, 0x1D, 0xF0, 0x0F, 0xBC, 0x07, 0x7C, 0x03,
  0xFF, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x07, 0xF8, 0x07, 0xFC, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x7F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x3F, 0x87, 0xF8,
  0x00, 0x3F, 0x81, 0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x1F, 0xC0, 0x3F,
  0x80, 0x1F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x01,
  0xFC, 0x07, 0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x3F, 0x83, 0xF8, 0x00,
  0x1F, 0xC3, 0xF8, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x03, 0xF9, 0xFC, 0x00,
  0x00, 0xFE, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x03, 0xF3,
  0xF8, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x01, 0xFC,
  0x1F, 0xC0, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFE,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F,
  0x80, 0x0F, 0xE0, 0x3F, 0x80, 0x07, 0xF8, 0x1F, 0xC0, 0x01, 0xFC, 0x1F,
  0xC0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x1F, 0xEF,
  0xF0, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F,
  0x9F, 0xC0, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x0F,
  0xE1, 0xFC, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x03,
  0xF8, 0x0F, 0xC0, 0x03, 0xF8, 0x07, 0xF0, 0x01, 0xFC, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x7F, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x01, 0xFC,
  0x1F, 0x80, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0x0F,
  0xCF, 0xE0, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xDF, 0x80,
  0x01, 0xF3, 0xF0, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0x87, 0xE0, 0x03, 0xF0,
  0x7C, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x80, 0xF8, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x3F, 0x03, 0xE0, 0x07, 0xE0, 0xFC, 0x00,
  0x7E, 0x1F, 0x80, 0x0F, 0xC7, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0xBF,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0x00, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF,
  0xDF, 0xFC, 0x3F, 0xC0, 0x1F, 0xE3, 0xF8, 0x00, 0xFE, 0x7F, 0x00, 0x0F,
  0xE7, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7,
  0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F,
  0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xF7, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xF3, 0xFF, 0xFE, 0x7F, 0x1F, 0xFF, 0xC7,
  0xF0, 0x7F, 0xF8, 0x7F, 0x00, 0x78, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x07, 0xF8,
  0x0F, 0xE3, 0xFF, 0xC1, 0xFC, 0xFF, 0xFC, 0x3F, 0xBF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x9F, 0xF8, 0x0F, 0xFB, 0xFE, 0x00, 0x7F,
  0x7F, 0x80, 0x0F, 0xEF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80,
  0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF,
  0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0xFF, 0xFE, 0x00, 0x3F, 0xBF, 0xE0, 0x0F, 0xF7, 0xFF, 0x07, 0xFE, 0xFF,
  0xFF, 0xFF, 0x9F, 0xDF, 0xFF, 0xE3, 0xFB, 0xFF, 0xF8, 0x7F, 0x3F, 0xFE,
  0x0F, 0xE1, 0xFF, 0x80, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0x1F, 0xF0, 0x1F, 0xF3, 0xF8, 0x00, 0xFE, 0xFE,
  0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF,
  0xFC, 0x00, 0x7F, 0x3F, 0xC0, 0x1F, 0xE7, 0xFF, 0x0F, 0xFC, 0x7F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x07, 0xF8, 0x3F, 0x07, 0xFF,
  0x8F, 0xC3, 0xFF, 0xF3, 0xF1, 0xFF, 0xFE, 0xFC, 0xFF, 0xFF, 0xBF, 0x7F,
  0xFF, 0xFF, 0xDF, 0xE0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x7F,
  0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xF7, 0xF8,
  0x07, 0xFD, 0xFF, 0x87, 0xFF, 0x3F, 0xFF, 0xEF, 0xCF, 0xFF, 0xFB, 0xF1,
  0xFF, 0xFC, 0xFC, 0x3F, 0xFE, 0x3F, 0x03, 0xFF, 0x0F, 0xC0, 0x0C, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xC1, 0xFF, 0x1F, 0xE0, 0x0F,
  0xE3, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xDF, 0xC0, 0x01, 0xFB, 0xF0,
  0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x01, 0xFD, 0xF8, 0x00, 0x3F, 0x3F, 0x80, 0x0F, 0xE7,
  0xFC, 0x07, 0xFC, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x03,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFE, 0x0F, 0xC1, 0xFF, 0xE3, 0xF0, 0xFF, 0xFC, 0xFC, 0x7F,
  0xFF, 0xBF, 0x3F, 0xFF, 0xEF, 0xDF, 0xFF, 0xFF, 0xF7, 0xF8, 0x07, 0xFD,
  0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00,
  0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03,
  0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0x7F, 0x00, 0x3F, 0xDF, 0xF0,
  0x1F, 0xF7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xBF, 0x1F, 0xFF, 0xEF, 0xC3,
  0xFF, 0xF3, 0xF0, 0x7F, 0xF8, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x1F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0,
  0x07, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x07, 0xF8, 0x0F, 0xE3, 0xFF, 0xC1,
  0xFC, 0xFF, 0xFC, 0x3F, 0xBF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFB,
  0xFF, 0x9F, 0xF8, 0x0F, 0xFB, 0xFC, 0x00, 0xFF, 0x7F, 0x80, 0x0F, 0xEF,
  0xE0, 0x00, 0xFD, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00,
  0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03,
  0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0,
  0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFE,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x70, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x01, 0xFF, 0x9F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x81, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0x7F, 0x00, 0x07, 0xFB, 0xF8,
  0x00, 0x3F, 0x9F, 0xC0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0xC7, 0xF0, 0x01,
  0xFC, 0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x01, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0,
  0x7F, 0x00, 0xFF, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x00, 0xFE,
  0x07, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0,
  0x1F, 0xC0, 0xFF, 0x00, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x3F,
  0x80, 0x7F, 0x81, 0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x0F, 0xF0, 0x7F, 0x00,
  0x3F, 0xC3, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xF8, 0xFE, 0x00, 0x1F,
  0xE7, 0xF0, 0x00, 0x7F, 0x3F, 0x80, 0x03, 0xFD, 0xFC, 0x00, 0x0F, 0xEF,
  0xE0, 0x00, 0x7F, 0x80, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xF8, 0xFC, 0x0F, 0x87, 0xCF, 0xF1, 0xFF, 0x3E,
  0xFF, 0xDF, 0xF9, 0xF7, 0xFE, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0x7E, 0x0F,
  0xE1, 0xFF, 0xF0, 0x7E, 0x07, 0xFF, 0x81, 0xF0, 0x3F, 0xFC, 0x0F, 0x81,
  0xFF, 0xE0, 0x7C, 0x0F, 0xFF, 0x03, 0xE0, 0x7F, 0xF8, 0x1F, 0x03, 0xFF,
  0xC0, 0xF8, 0x1F, 0xFE, 0x07, 0xC0, 0xFF, 0xF0, 0x3E, 0x07, 0xFF, 0x81,
  0xF0, 0x3F, 0xFC, 0x0F, 0x81, 0xFF, 0xE0, 0x7C, 0x0F, 0xFF, 0x03, 0xE0,
  0x7F, 0xF8, 0x1F, 0x03, 0xFF, 0xC0, 0xF8, 0x1F, 0xFE, 0x07, 0xC0, 0xFF,
  0xF0, 0x3E, 0x07, 0xFF, 0x81, 0xF0, 0x3F, 0xFC, 0x0F, 0x81, 0xFF, 0xE0,
  0x7C, 0x0F, 0xFF, 0x03, 0xE0, 0x7F, 0xF8, 0x1F, 0x03, 0xFF, 0xC0, 0xF8,
  0x1F, 0xFE, 0x07, 0xC0, 0xFF, 0xF0, 0x3E, 0x07, 0xFF, 0x81, 0xF0, 0x3F,
  0xFC, 0x0F, 0x81, 0xFF, 0xE0, 0x7C, 0x0F, 0xC0, 0xFE, 0x0F, 0xF0, 0x1F,
  0xC7, 0xFF, 0x83, 0xF9, 0xFF, 0xF8, 0x7F, 0x7F, 0xFF, 0x8F, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0x3F, 0xF0, 0x1F, 0xF7, 0xF8, 0x01, 0xFE, 0xFF,
  0x00, 0x1F, 0xDF, 0xC0, 0x01, 0xFB, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0,
  0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80,
  0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF,
  0xC0, 0x01, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x1F,
  0xF0, 0x1F, 0xE3, 0xF8, 0x01, 0xFE, 0xFE, 0x00, 0x1F, 0xDF, 0xC0, 0x01,
  0xFB, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F,
  0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F,
  0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xF9, 0xFC, 0x00, 0x7F, 0x3F, 0xC0,
  0x1F, 0xE7, 0xFF, 0x1F, 0xF8, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x10,
  0x00, 0x00, 0xFE, 0x0F, 0xF0, 0x1F, 0xC7, 0xFF, 0x83, 0xF9, 0xFF, 0xF8,
  0x7F, 0x7F, 0xFF, 0x8F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F, 0xF0,
  0x1F, 0xF7, 0xFC, 0x00, 0xFE, 0xFF, 0x00, 0x1F, 0xDF, 0xC0, 0x01, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF,
  0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE,
  0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0x7F, 0xC0, 0x1F,
  0xEF, 0xFE, 0x0F, 0xFD, 0xFF, 0xFF, 0xFF, 0x3F, 0xBF, 0xFF, 0xC7, 0xF7,
  0xFF, 0xF8, 0xFE, 0x7F, 0xFC, 0x1F, 0xC3, 0xFF, 0x03, 0xF8, 0x0F, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFE,
  0x0F, 0xC1, 0xFF, 0xE3, 0xF0, 0xFF, 0xFC, 0xFC, 0x7F, 0xFF, 0xBF, 0x3F,
  0xFF, 0xEF, 0xDF, 0xFF, 0xFF, 0xF7, 0xF8, 0x07, 0xFD, 0xFC, 0x00, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xF0,
  0x03, 0xFD, 0xFE, 0x01, 0xFF, 0x7F, 0xE1, 0xFF, 0xCF, 0xFF, 0xFB, 0xF3,
  0xFF, 0xFE, 0xFC, 0x7F, 0xFF, 0x3F, 0x0F, 0xFF, 0x8F, 0xC0, 0xFF, 0xC3,
  0xF0, 0x03, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0xFE, 0x0F, 0xF0, 0x1F, 0xC7, 0xFF, 0x83, 0xF9, 0xFF, 0xF8, 0x7F,
  0x7F, 0xFF, 0x8F, 0xFF, 0xFF, 0xF9, 0xFF, 0xF7, 0xFF, 0xBF, 0xF0, 0x0F,
  0xF7, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xF8, 0xFF, 0xE3, 0xFF, 0x9F, 0xC0, 0x07, 0xF3, 0xF8, 0x00, 0x7F, 0x7E,
  0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xF7, 0xF8, 0x03, 0xFE, 0xFF, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0xBE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0xFE, 0x00, 0x0F, 0xFF, 0xC0,
  0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00,
  0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00,
  0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03,
  0xFF, 0xF0, 0x00, 0x7E, 0xFE, 0x00, 0x0F, 0xDF, 0xC0, 0x03, 0xF9, 0xFC,
  0x00, 0x7F, 0x3F, 0xC0, 0x1F, 0xC3, 0xFE, 0x1F, 0xF8, 0x7F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x38, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x01, 0xF9, 0xF8, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x0F, 0xE7, 0xF0, 0x00,
  0x1F, 0x87, 0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x01,
  0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x1F,
  0x80, 0x7E, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xF8,
  0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x1F, 0x80,
  0x0F, 0xE0, 0x3F, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x1F, 0xC1, 0xF8, 0x00,
  0x3F, 0x83, 0xF0, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x7F, 0x1F, 0x80, 0x00,
  0xFE, 0x3F, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x03,
  0xFB, 0xF0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xFC, 0x03,
  0xF0, 0x0F, 0xFF, 0x01, 0xF8, 0x07, 0xFF, 0x80, 0xFE, 0x03, 0xEF, 0xC0,
  0x7F, 0x01, 0xF7, 0xE0, 0x3F, 0x80, 0xF9, 0xF0, 0x1F, 0xC0, 0x7C, 0xF8,
  0x1E, 0xE0, 0x3E, 0x7C, 0x0F, 0x70, 0x3F, 0x3F, 0x07, 0xBC, 0x1F, 0x1F,
  0x83, 0xDE, 0x0F, 0x8F, 0xC1, 0xCF, 0x07, 0xC3, 0xE0, 0xE7, 0x83, 0xE1,
  0xF0, 0xF3, 0xC1, 0xF0, 0xF8, 0x78, 0xE0, 0xF8, 0x7C, 0x3C, 0x70, 0xFC,
  0x3F, 0x1E, 0x3C, 0x7C, 0x1F, 0x8F, 0x1E, 0x3E, 0x0F, 0xC7, 0x0F, 0x1F,
  0x03, 0xE3, 0x87, 0x8F, 0x81, 0xF3, 0xC1, 0xC7, 0xC0, 0xF9, 0xE0, 0xE3,
  0xE0, 0x7C, 0xF0, 0x7B, 0xE0, 0x3E, 0x78, 0x3D, 0xF0, 0x1F, 0xB8, 0x1E,
  0xF8, 0x07, 0xDC, 0x0F, 0x7C, 0x03, 0xFE, 0x07, 0xBE, 0x01, 0xFF, 0x01,
  0xDF, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x3F, 0xC0,
  0x3F, 0xC0, 0x0F, 0xE0, 0x1F, 0xE0, 0x07, 0xF0, 0x0F, 0xF0, 0x03, 0xF8,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0xFF, 0x00, 0x07, 0xF8, 0xFE,
  0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0xFF, 0x01, 0xFC,
  0x01, 0xFC, 0x03, 0xFC, 0x07, 0xF0, 0x03, 0xF8, 0x1F, 0xE0, 0x03, 0xF8,
  0x3F, 0x80, 0x03, 0xF8, 0xFE, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x07, 0xF7,
  0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x1F, 0xDF, 0x80, 0x00, 0x7F, 0xBF, 0x80, 0x00, 0xFE, 0x3F, 0x80,
  0x03, 0xF8, 0x7F, 0x80, 0x0F, 0xF0, 0x7F, 0x00, 0x1F, 0xC0, 0x7F, 0x00,
  0x7F, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0xFE, 0x03, 0xF8, 0x01, 0xFE, 0x0F,
  0xE0, 0x01, 0xFE, 0x3F, 0xC0, 0x01, 0xFC, 0x7F, 0x00, 0x03, 0xFD, 0xFC,
  0x00, 0x03, 0xFC, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xF9, 0xFC,
  0x00, 0x07, 0xF3, 0xF8, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x3F, 0x87, 0xF0,
  0x00, 0x7F, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0xC0,
  0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x01, 0xFC, 0x07,
  0xF0, 0x01, 0xFC, 0x0F, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF0, 0x7F,
  0x00, 0x07, 0xF1, 0xFC, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x0F, 0xC7, 0xE0,
  0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x3F, 0x7E, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x80,
  0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x0F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x80,
  0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x0F, 0xDF, 0xFF, 0x80, 0x7E, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFE, 0x1F, 0xC0, 0xFF, 0xF0, 0x7F,
  0x07, 0xFF, 0x01, 0xFC, 0x7F, 0xF8, 0x0F, 0xFF, 0xF7, 0xC0, 0x3F, 0xFF,
  0xBE, 0x00, 0xFF, 0xF9, 0xF0, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00,
};

const GFXglyph JetBrainsMono_Medium61pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 37, 0, -1 },
  { 1, 10, 45, 37, 13, -45 },
  { 58, 20, 19, 37, 8, -45 },
  { 106, 33, 45, 37, 2, -45 },
  { 292, 29, 62, 37, 4, -53 },
  { 517, 36, 45, 37, 0, -45 },
  { 720, 32, 46, 37, 3, -45 },
  { 904, 6, 19, 37, 15, -45 },
  { 919, 19, 58, 37, 11, -51 },
  { 1057, 19, 58, 37, 7, -51 },
  { 1195, 33, 32, 37, 2, -37 },
  { 1327, 29, 29, 37, 4, -35 },
  { 1433, 13, 19, 37, 10, -9 },
  { 1464, 19, 6, 37, 9, -23 },
  { 1479, 11, 11, 37, 13, -10 },
  { 1495, 28, 58, 37, 4, -51 },
  { 1698, 27, 46, 37, 5, -45 },
  { 1854, 28, 45, 37, 5, -45 },
  { 2012, 28, 45, 37, 4, -45 },
  { 2170, 28, 46, 37, 4, -45 },
  { 2331, 27, 45, 37, 4, -45 },
  { 2483, 27, 46, 37, 5, -45 },
  { 2639, 29, 46, 37, 4, -45 },
  { 2806, 29, 45, 37, 4, -45 },
  { 2970, 28, 46, 37, 4, -45 },
  { 3131, 29, 45, 37, 4, -45 },
  { 3295, 11, 35, 37, 13, -34 },
  { 3344, 14, 44, 37, 10, -34 },
  { 3421, 27, 33, 37, 5, -37 },
  { 3533, 26, 21, 37, 5, -31 },
  { 3602, 27, 33, 37, 5, -37 },
  { 3714, 22, 45, 37, 8, -45 },
  { 3838, 33, 56, 37, 2, -45 },
  { 4069, 31, 45, 37, 3, -45 },
  { 4244, 28, 45, 37, 5, -45 },
  { 4402, 27, 46, 37, 5, -45 },
  { 4558, 27, 45, 37, 5, -45 },
  { 4710, 26, 45, 37, 6, -45 },
  { 4857, 27, 45, 37, 5, -45 },
  { 5009, 27, 46, 37, 5, -45 },
  { 5165, 26, 45, 37, 5, -45 },
  { 5312, 25, 45, 37, 6, -45 },
  { 5453, 29, 46, 37, 2, -45 },
  { 5620, 29, 45, 37, 5, -45 },
  { 5784, 26, 45, 37, 7, -45 },
  { 5931, 29, 45, 37, 4, -45 },
  { 6095, 27, 45, 37, 5, -45 },
  { 6247, 27, 46, 37, 5, -45 },
  { 6403, 29, 45, 37, 5, -45 },
  { 6567, 28, 56, 37, 5, -45 },
  { 6763, 29, 45, 37, 5, -45 },
  { 6927, 29, 46, 37, 4, -45 },
  { 7094, 30, 45, 37, 3, -45 },
  { 7263, 27, 46, 37, 5, -45 },
  { 7419, 31, 45, 37, 3, -45 },
  { 7594, 34, 45, 37, 1, -45 },
  { 7786, 33, 45, 37, 2, -45 },
  { 7972, 33, 45, 37, 2, -45 },
  { 8158, 27, 45, 37, 5, -45 },
  { 8310, 16, 58, 37, 12, -51 },
  { 8426, 28, 58, 37, 4, -51 },
  { 8629, 16, 58, 37, 9, -51 },
  { 8745, 27, 24, 37, 5, -45 },
  { 8826, 29, 5, 37, 4, 2 },
  { 8845, 14, 9, 37, 10, -48 },
  { 8861, 28, 35, 37, 4, -34 },
  { 8984, 27, 46, 37, 5, -45 },
  { 9140, 27, 35, 37, 5, -34 },
  { 9259, 26, 46, 37, 5, -45 },
  { 9409, 27, 35, 37, 5, -34 },
  { 9528, 30, 45, 37, 3, -45 },
  { 9697, 26, 45, 37, 5, -34 },
  { 9844, 27, 45, 37, 5, -45 },
  { 9996, 29, 48, 37, 5, -48 },
  { 10170, 23, 59, 37, 5, -48 },
  { 10340, 29, 45, 37, 5, -45 },
  { 10504, 32, 45, 37, 2, -45 },
  { 10684, 29, 34, 37, 4, -34 },
  { 10808, 27, 34, 37, 5, -34 },
  { 10923, 27, 35, 37, 5, -34 },
  { 11042, 27, 45, 37, 5, -34 },
  { 11194, 26, 45, 37, 5, -34 },
  { 11341, 27, 34, 37, 6, -34 },
  { 11456, 27, 35, 37, 5, -34 },
  { 11575, 29, 43, 37, 3, -43 },
  { 11731, 27, 35, 37, 5, -34 },
  { 11850, 31, 34, 37, 3, -34 },
  { 11982, 33, 34, 37, 2, -34 },
  { 12123, 31, 34, 37, 3, -34 },
  { 12255, 31, 45, 37, 3, -34 },
  { 12430, 26, 34, 37, 5, -34 },
  { 12541, 27, 58, 37, 5, -51 },
  { 12737, 7, 58, 37, 15, -51 },
  { 12788, 27, 58, 37, 5, -51 },
  { 12984, 29, 13, 37, 4, -28 },
};

const GFXfont JetBrainsMono_Medium61pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Medium61pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Medium61pt7bGlyphs,
  0x20, 0x7E, 81
};

#endif // _JETBRAINSMONO_MEDIUM61PT7B_H_
