#ifndef _JETBRAINSMONO_MEDIUM14PT7B_H_
#define _JETBRAINSMONO_MEDIUM14PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Medium.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Medium14pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x54, 0xF0, 0xD9, 0x99, 0x12, 0x12, 0x7F, 0x7F, 0x24, 0x24,
  0xFF, 0x24, 0x64, 0x4C, 0x10, 0x47, 0xF5, 0xD3, 0x47, 0x87, 0x16, 0x5D,
  0xDE, 0x10, 0x40, 0x71, 0x92, 0x94, 0xF4, 0x08, 0x16, 0x3D, 0x29, 0x49,
  0xC7, 0x79, 0x9B, 0x02, 0x0E, 0x16, 0xE5, 0x46, 0x9D, 0xEC, 0xFD, 0x09,
  0xD8, 0x84, 0x63, 0x18, 0xC2, 0x18, 0xC3, 0x84, 0x8C, 0x63, 0x33, 0x33,
  0x33, 0x36, 0xC8, 0x18, 0x18, 0x49, 0xFF, 0x08, 0x1C, 0x66, 0x24, 0x30,
  0x60, 0xC7, 0xF3, 0x06, 0x0C, 0x00, 0x6D, 0x60, 0xF0, 0xF0, 0x04, 0x30,
  0xC2, 0x18, 0x61, 0x0C, 0x21, 0x86, 0x10, 0xC3, 0x00, 0x7F, 0x18, 0x61,
  0xB6, 0x58, 0x71, 0xCD, 0xE0, 0x31, 0xA2, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x11, 0xFC, 0x7F, 0x38, 0x41, 0x0C, 0x63, 0x18, 0xC3, 0xF0, 0xFC, 0x31,
  0x8C, 0x3C, 0x10, 0x61, 0xCD, 0xE0, 0x0C, 0x63, 0x18, 0x47, 0x18, 0x7F,
  0x04, 0x10, 0xFF, 0x0C, 0x36, 0xFC, 0x10, 0x41, 0xCD, 0xE0, 0x18, 0x60,
  0x83, 0x0F, 0xD8, 0xA1, 0xC2, 0xCC, 0xF0, 0xFF, 0x0A, 0x30, 0x60, 0x83,
  0x04, 0x18, 0x30, 0xC0, 0x7F, 0x3C, 0x53, 0x39, 0xBC, 0x61, 0xCD, 0xE0,
  0x7D, 0x8A, 0x1C, 0x3C, 0xCF, 0x82, 0x0C, 0x30, 0xC0, 0xF0, 0x0F, 0x6C,
  0x00, 0x1B, 0x58, 0x0C, 0xEE, 0x30, 0x70, 0x70, 0x40, 0xFC, 0x00, 0x3F,
  0xFC, 0xC1, 0xC1, 0xC1, 0x1D, 0xC8, 0x00, 0xF0, 0xC6, 0x37, 0x31, 0x00,
  0x47, 0x00, 0x7D, 0x8E, 0x0C, 0xDB, 0x76, 0x6C, 0xD9, 0x9F, 0x03, 0x03,
  0xC1, 0x80, 0x30, 0x70, 0xA3, 0x44, 0x89, 0xBF, 0x62, 0xC5, 0x0C, 0xFD,
  0x9B, 0x16, 0x2F, 0x99, 0xB1, 0x63, 0xCD, 0xF0, 0x7F, 0x1C, 0x70, 0xC3,
  0x0C, 0x31, 0xCD, 0xE0, 0xFB, 0x3C, 0x71, 0xC7, 0x1C, 0x71, 0xCF, 0xE0,
  0xFF, 0x0C, 0x30, 0xFF, 0x0C, 0x30, 0xC3, 0xF0, 0xFF, 0x0C, 0x30, 0xFF,
  0xFC, 0x30, 0xC3, 0x00, 0x7F, 0x1C, 0x70, 0xC3, 0x7C, 0x71, 0xCD, 0xE0,
  0xC7, 0x1C, 0x71, 0xFF, 0x1C, 0x71, 0xC7, 0x10, 0xFC, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x33, 0xF0, 0x3C, 0x10, 0x41, 0x04, 0x10, 0x63, 0xCD, 0xE0,
  0xC7, 0x9B, 0x26, 0xCF, 0x1B, 0x32, 0x66, 0xCD, 0x8C, 0x82, 0x08, 0x20,
  0x82, 0x08, 0x20, 0x83, 0xF0, 0xCF, 0x3A, 0xEB, 0xB6, 0xD8, 0x61, 0x86,
  0x10, 0xC7, 0x9A, 0x79, 0xF7, 0x5D, 0x77, 0xCF, 0x30, 0x7F, 0x3C, 0x71,
  0xC7, 0x1C, 0x71, 0xCD, 0xE0, 0xFD, 0x8F, 0x1E, 0x3C, 0xDF, 0x30, 0x60,
  0xC1, 0x80, 0x7F, 0x3C, 0x71, 0xC7, 0x1C, 0x71, 0xCD, 0xE0, 0x83, 0x04,
  0xFD, 0x8B, 0x1E, 0x3F, 0xDF, 0x36, 0x66, 0xCD, 0x8C, 0x7F, 0x1C, 0x30,
  0x78, 0x70, 0x61, 0xCD, 0xE0, 0xFE, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xCD, 0xE0, 0x87, 0x8B,
  0x12, 0x64, 0xCD, 0x1A, 0x1C, 0x38, 0x60, 0xD9, 0xD9, 0x59, 0x5B, 0x57,
  0x56, 0x56, 0x56, 0x66, 0x66, 0x63, 0x26, 0x34, 0x1C, 0x18, 0x18, 0x3C,
  0x26, 0x66, 0xC3, 0xC3, 0x62, 0x26, 0x34, 0x1C, 0x18, 0x18, 0x18, 0x18,
  0x18, 0xFC, 0x30, 0x86, 0x10, 0xC6, 0x10, 0xC3, 0xF0, 0xFE, 0x49, 0x24,
  0x92, 0x4F, 0xC0, 0xC3, 0x04, 0x18, 0x60, 0x83, 0x04, 0x18, 0x60, 0x83,
  0x0C, 0x10, 0xFF, 0x33, 0x33, 0x33, 0x33, 0x33, 0xFF, 0x30, 0xE6, 0x93,
  0xC4, 0xFF, 0xFC, 0xC3, 0x3B, 0xB0, 0x4F, 0xFE, 0x1C, 0xDD, 0xC3, 0x0F,
  0xBB, 0xC7, 0x1C, 0x71, 0xCF, 0xE0, 0x39, 0xFC, 0x70, 0xC3, 0x1C, 0xDE,
  0x04, 0x17, 0x7B, 0xC7, 0x1C, 0x71, 0xCD, 0xD0, 0x39, 0x3C, 0x7F, 0xFF,
  0x0C, 0x5E, 0x3E, 0x60, 0x87, 0xF2, 0x04, 0x08, 0x10, 0x20, 0x40, 0x77,
  0xBC, 0x71, 0xC7, 0x17, 0xC9, 0x05, 0xF7, 0x00, 0xC3, 0x0F, 0xBB, 0xC7,
  0x1C, 0x71, 0xC7, 0x10, 0x30, 0x70, 0x07, 0x8F, 0x02, 0x04, 0x08, 0x10,
  0x23, 0xF8, 0x18, 0x70, 0x1E, 0x78, 0x20, 0x82, 0x08, 0x20, 0x86, 0xFB,
  0x00, 0xC1, 0x83, 0x1E, 0x6C, 0x9F, 0x3E, 0x64, 0xCD, 0x8C, 0xF0, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x18, 0x0F, 0xED, 0x6E, 0x5C, 0xB9,
  0x72, 0xE5, 0xCB, 0xFB, 0xBC, 0x71, 0xC7, 0x1C, 0x71, 0x39, 0xFC, 0x71,
  0xC7, 0x1C, 0xDE, 0xFB, 0xBC, 0x71, 0xC7, 0x1C, 0xFE, 0xC3, 0x0C, 0x00,
  0x77, 0xBC, 0x71, 0xC7, 0x1C, 0xDD, 0x04, 0x10, 0x40, 0xD9, 0xDB, 0x1E,
  0x3C, 0x18, 0x30, 0x60, 0x7B, 0xBC, 0x1C, 0x3C, 0x1C, 0x5F, 0x20, 0x8F,
  0xFF, 0x20, 0x82, 0x08, 0x30, 0xF0, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0xDE,
  0x87, 0x8B, 0x12, 0x66, 0x8D, 0x0E, 0x18, 0xC9, 0x59, 0x5B, 0x5B, 0x56,
  0x56, 0x66, 0x26, 0xC6, 0x99, 0xA1, 0x83, 0x0F, 0x13, 0x63, 0x87, 0x89,
  0x32, 0x66, 0x87, 0x0C, 0x18, 0x30, 0x41, 0x80, 0xFF, 0xF0, 0x86, 0x31,
  0x8C, 0x3F, 0x0C, 0x71, 0x04, 0x10, 0x6F, 0x3C, 0x18, 0x41, 0x04, 0x1C,
  0x10, 0xFF, 0xFF, 0xFF, 0xF0, 0xC3, 0x83, 0x08, 0x20, 0x83, 0xCF, 0x20,
  0x82, 0x0C, 0xE3, 0x00, 0xF7, 0x38, 0x20,
};

const GFXglyph JetBrainsMono_Medium14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 2, 10, 8, 3, -10 },
  { 4, 4, 4, 8, 2, -10 },
  { 6, 8, 10, 8, 0, -10 },
  { 16, 6, 14, 8, 1, -12 },
  { 27, 8, 10, 8, 0, -10 },
  { 37, 7, 10, 8, 1, -10 },
  { 46, 2, 4, 8, 3, -10 },
  { 47, 5, 14, 8, 2, -12 },
  { 56, 4, 14, 8, 2, -12 },
  { 63, 8, 8, 8, 0, -9 },
  { 71, 7, 7, 8, 1, -8 },
  { 78, 3, 4, 8, 2, -2 },
  { 80, 4, 1, 8, 2, -5 },
  { 81, 2, 2, 8, 3, -2 },
  { 82, 6, 14, 8, 1, -12 },
  { 93, 6, 10, 8, 1, -10 },
  { 101, 7, 10, 8, 1, -10 },
  { 110, 6, 10, 8, 1, -10 },
  { 118, 6, 10, 8, 1, -10 },
  { 126, 6, 10, 8, 1, -10 },
  { 134, 6, 10, 8, 1, -10 },
  { 142, 7, 10, 8, 1, -10 },
  { 151, 7, 10, 8, 1, -10 },
  { 160, 6, 10, 8, 1, -10 },
  { 168, 7, 10, 8, 1, -10 },
  { 177, 2, 8, 8, 3, -8 },
  { 179, 3, 10, 8, 2, -8 },
  { 183, 6, 7, 8, 1, -8 },
  { 189, 6, 5, 8, 1, -7 },
  { 193, 6, 7, 8, 1, -8 },
  { 199, 5, 10, 8, 2, -10 },
  { 206, 7, 13, 8, 1, -10 },
  { 218, 7, 10, 8, 1, -10 },
  { 227, 7, 10, 8, 1, -10 },
  { 236, 6, 10, 8, 1, -10 },
  { 244, 6, 10, 8, 1, -10 },
  { 252, 6, 10, 8, 1, -10 },
  { 260, 6, 10, 8, 1, -10 },
  { 268, 6, 10, 8, 1, -10 },
  { 276, 6, 10, 8, 1, -10 },
  { 284, 6, 10, 8, 1, -10 },
  { 292, 6, 10, 8, 1, -10 },
  { 300, 7, 10, 8, 1, -10 },
  { 309, 6, 10, 8, 2, -10 },
  { 317, 6, 10, 8, 1, -10 },
  { 325, 6, 10, 8, 1, -10 },
  { 333, 6, 10, 8, 1, -10 },
  { 341, 7, 10, 8, 1, -10 },
  { 350, 6, 13, 8, 1, -10 },
  { 360, 7, 10, 8, 1, -10 },
  { 369, 6, 10, 8, 1, -10 },
  { 377, 7, 10, 8, 1, -10 },
  { 386, 6, 10, 8, 1, -10 },
  { 394, 7, 10, 8, 1, -10 },
  { 403, 8, 10, 8, 0, -10 },
  { 413, 8, 10, 8, 0, -10 },
  { 423, 8, 10, 8, 0, -10 },
  { 433, 6, 10, 8, 1, -10 },
  { 441, 3, 14, 8, 3, -12 },
  { 447, 6, 14, 8, 1, -12 },
  { 458, 4, 14, 8, 2, -12 },
  { 465, 6, 5, 8, 1, -10 },
  { 469, 7, 2, 8, 1, 0 },
  { 471, 4, 2, 8, 2, -11 },
  { 472, 6, 8, 8, 1, -8 },
  { 478, 6, 10, 8, 1, -10 },
  { 486, 6, 8, 8, 1, -8 },
  { 492, 6, 10, 8, 1, -10 },
  { 500, 6, 8, 8, 1, -8 },
  { 506, 7, 10, 8, 1, -10 },
  { 515, 6, 11, 8, 1, -8 },
  { 524, 6, 10, 8, 1, -10 },
  { 532, 7, 11, 8, 1, -11 },
  { 542, 6, 14, 8, 1, -11 },
  { 553, 7, 10, 8, 1, -10 },
  { 562, 8, 10, 8, 0, -10 },
  { 572, 7, 8, 8, 1, -8 },
  { 579, 6, 8, 8, 1, -8 },
  { 585, 6, 8, 8, 1, -8 },
  { 591, 6, 11, 8, 1, -8 },
  { 600, 6, 11, 8, 1, -8 },
  { 609, 7, 8, 8, 1, -8 },
  { 616, 6, 8, 8, 1, -8 },
  { 622, 6, 10, 8, 1, -10 },
  { 630, 6, 8, 8, 1, -8 },
  { 636, 7, 8, 8, 1, -8 },
  { 643, 8, 8, 8, 0, -8 },
  { 651, 7, 8, 8, 1, -8 },
  { 658, 7, 11, 8, 1, -8 },
  { 668, 6, 8, 8, 1, -8 },
  { 674, 6, 14, 8, 1, -12 },
  { 685, 2, 14, 8, 3, -12 },
  { 689, 6, 14, 8, 1, -12 },
  { 700, 7, 3, 8, 1, -6 },
};

const GFXfont JetBrainsMono_Medium14pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Medium14pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Medium14pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _JETBRAINSMONO_MEDIUM14PT7B_H_
