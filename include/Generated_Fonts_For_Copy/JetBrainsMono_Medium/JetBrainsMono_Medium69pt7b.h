#ifndef _JETBRAINSMONO_MEDIUM69PT7B_H_
#define _JETBRAINSMONO_MEDIUM69PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Medium.ttf
// Size: 69pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Medium69pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0xCF, 0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE,
  0x7F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F,
  0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xE0,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x3F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xC7, 0xF0, 0xFE, 0x03,
  0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF,
  0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8,
  0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x07,
  0xEF, 0xE0, 0x1F, 0xBF, 0x80, 0x7E, 0xFE, 0x01, 0xFB, 0xF8, 0x07, 0xEF,
  0xE0, 0x1F, 0xBF, 0x80, 0x7E, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x03, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x03, 0xF0,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xF0, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xF8, 0x1F, 0xF1, 0xE3, 0xFE, 0x0F, 0xF0, 0xF0, 0xFF, 0x0F,
  0xF0, 0x78, 0x3F, 0xC7, 0xF8, 0x3C, 0x1F, 0xE3, 0xF8, 0x1E, 0x07, 0xF1,
  0xFC, 0x0F, 0x03, 0xF8, 0xFE, 0x07, 0x81, 0xFC, 0x7F, 0x03, 0xC0, 0x00,
  0x3F, 0x81, 0xE0, 0x00, 0x1F, 0xE0, 0xF0, 0x00, 0x0F, 0xF0, 0x78, 0x00,
  0x07, 0xFC, 0x3C, 0x00, 0x01, 0xFF, 0x1E, 0x00, 0x00, 0xFF, 0xEF, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x03, 0xDF, 0xFC, 0x00, 0x01, 0xE3, 0xFF, 0x00, 0x00,
  0xF0, 0xFF, 0x80, 0x00, 0x78, 0x3F, 0xC0, 0x00, 0x3C, 0x0F, 0xF0, 0x00,
  0x1E, 0x07, 0xF8, 0x00, 0x0F, 0x03, 0xFE, 0x00, 0x07, 0x80, 0xFE, 0xFE,
  0x03, 0xC0, 0xFF, 0x7F, 0x01, 0xE0, 0x7F, 0xBF, 0x80, 0xF0, 0x3F, 0xDF,
  0xE0, 0x78, 0x1F, 0xCF, 0xF8, 0x3C, 0x1F, 0xE3, 0xFE, 0x1E, 0x1F, 0xF1,
  0xFF, 0xCF, 0x3F, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xC3, 0xFF, 0xF0, 0x00,
  0x0F, 0xC3, 0xFF, 0xFC, 0x00, 0x0F, 0xC3, 0xFF, 0xFE, 0x00, 0x07, 0xC1,
  0xFC, 0x7F, 0x80, 0x07, 0xE1, 0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x03,
  0xE0, 0x03, 0xE0, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x07,
  0xE0, 0xF8, 0x00, 0xFC, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x03, 0xF0, 0xFC,
  0x00, 0x3F, 0x81, 0xF8, 0x7C, 0x00, 0x0F, 0xFF, 0xFC, 0x7E, 0x00, 0x07,
  0xFF, 0xFC, 0x7E, 0x00, 0x01, 0xFF, 0xFC, 0x3E, 0x00, 0x00, 0x7F, 0xFC,
  0x3F, 0x00, 0x00, 0x0F, 0xF8, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0xF8, 0x00, 0x00, 0x0F, 0xC3, 0xFF, 0x80, 0x00, 0x07, 0xC3, 0xFF,
  0xE0, 0x00, 0x07, 0xE3, 0xFF, 0xF8, 0x00, 0x07, 0xE3, 0xFF, 0xFE, 0x00,
  0x07, 0xE1, 0xFC, 0x7F, 0x80, 0x03, 0xF1, 0xF8, 0x0F, 0xC0, 0x03, 0xF0,
  0xFC, 0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x01, 0xF0, 0x01, 0xF0, 0x3E, 0x00,
  0xF8, 0x01, 0xF8, 0x1F, 0x00, 0x7C, 0x01, 0xF8, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0xFC, 0x01,
  0xF0, 0x07, 0xC0, 0x7C, 0x00, 0xFC, 0x03, 0xE0, 0x7E, 0x00, 0x7E, 0x03,
  0xF0, 0x7E, 0x00, 0x3F, 0x83, 0xF8, 0x7E, 0x00, 0x0F, 0xFF, 0xF8, 0x3F,
  0x00, 0x07, 0xFF, 0xFC, 0x3F, 0x00, 0x01, 0xFF, 0xFC, 0x3F, 0x00, 0x00,
  0x7F, 0xFC, 0x3F, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F,
  0xFC, 0x1F, 0xF8, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xF7, 0xF8, 0xFE,
  0x00, 0xFE, 0x7F, 0x8F, 0xF0, 0x1F, 0xE7, 0xF0, 0x7F, 0x81, 0xFC, 0xFF,
  0x03, 0xFC, 0x3F, 0xCF, 0xF0, 0x1F, 0xC3, 0xF8, 0xFF, 0x01, 0xFE, 0x7F,
  0x8F, 0xF0, 0x0F, 0xF7, 0xF0, 0xFF, 0x00, 0x7F, 0xFF, 0x0F, 0xF0, 0x07,
  0xFF, 0xE0, 0xFF, 0x00, 0x3F, 0xFC, 0x0F, 0xF0, 0x01, 0xFF, 0xC0, 0xFF,
  0x00, 0x0F, 0xF8, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x07, 0xF8,
  0x0F, 0xF0, 0x00, 0xFF, 0xC0, 0x7F, 0x00, 0x1F, 0xFC, 0x07, 0xF8, 0x03,
  0xFF, 0xE0, 0x7F, 0xC0, 0x7F, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0x7F, 0x81, 0xFF, 0xFF, 0xE3, 0xFC, 0x0F, 0xFF, 0xFC, 0x1F,
  0xE0, 0x7F, 0xFF, 0x80, 0xFE, 0x01, 0xFF, 0xE0, 0x0F, 0xF0, 0x03, 0xE0,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x08, 0x00,
  0x03, 0xC0, 0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xFC,
  0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x03,
  0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xE0,
  0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xFF,
  0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFE, 0x00, 0x1F,
  0xC0, 0x00, 0xF8, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0x80, 0x07, 0xE0, 0x01, 0x0F, 0x00, 0x3F, 0x00, 0x78, 0x7F,
  0x01, 0xF0, 0x1F, 0xE7, 0xFE, 0x0F, 0x83, 0xFF, 0x3F, 0xFC, 0x3C, 0x3F,
  0xF9, 0xFF, 0xF1, 0xE7, 0xFF, 0xFF, 0xFF, 0xEE, 0x7F, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00,
  0x1F, 0x8F, 0xE0, 0x00, 0x01, 0xFC, 0x7F, 0x80, 0x00, 0x1F, 0xC1, 0xFC,
  0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x00, 0xFF,
  0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0x1C, 0x00,
  0x0C, 0x00, 0x00, 0x40, 0x00, 0x40, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF0, 0x7F, 0xE0, 0xFF, 0x81, 0xFF, 0x03,
  0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xC0, 0x7F, 0x81, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x04, 0x03, 0xF8, 0x7F, 0xCF, 0xFE, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x7F, 0xE3, 0xFC, 0x06, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0x1F, 0xFE, 0x1F, 0xF0, 0x07, 0xFE, 0x7F,
  0xC0, 0x03, 0xFC, 0xFF, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xC0, 0x70, 0x1F, 0xFF, 0x81, 0xF8, 0x3F, 0xFF, 0x07, 0xF8,
  0x7F, 0xFE, 0x1F, 0xF0, 0xFF, 0xFC, 0x3F, 0xE1, 0xFF, 0xF8, 0x7F, 0xC3,
  0xFF, 0xF0, 0x7F, 0x87, 0xFF, 0xE0, 0xFE, 0x0F, 0xFF, 0xC0, 0xF8, 0x1F,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x03, 0xFD, 0xFE,
  0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x3F, 0xE3, 0xFF, 0x00, 0xFF, 0x83, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xF7, 0xF8, 0x00, 0xFF, 0xC7,
  0xF8, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0xFC, 0x07,
  0xF8, 0x00, 0xF8, 0x07, 0xF8, 0x00, 0xE0, 0x07, 0xF8, 0x00, 0xC0, 0x07,
  0xF8, 0x00, 0x80, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xF0, 0x7F, 0xE0, 0x0F, 0xF8, 0x3F, 0xE0, 0x03, 0xFE, 0x3F,
  0xE0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x1F, 0xE7,
  0xF0, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00,
  0xFF, 0x7F, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x01,
  0xFE, 0x7F, 0xC0, 0x01, 0xFE, 0x3F, 0xE0, 0x03, 0xFE, 0x3F, 0xF0, 0x0F,
  0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x07, 0xF0, 0xFF, 0x00, 0x1F, 0xC7, 0xFC, 0x00, 0x7F, 0x1F,
  0xE0, 0x01, 0xFC, 0xFF, 0x00, 0x07, 0xF7, 0xFC, 0x00, 0x1F, 0xDF, 0xE0,
  0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x07, 0xFC, 0x00, 0xFE,
  0x3F, 0xFE, 0x01, 0xFD, 0xFF, 0xFE, 0x07, 0xFB, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFC, 0x1F, 0xFC, 0x7F, 0xE0,
  0x07, 0xFC, 0xFF, 0x80, 0x07, 0xF9, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF,
  0x7F, 0x00, 0x01, 0xFC, 0xFF, 0x00, 0x07, 0xF9, 0xFF, 0x00, 0x1F, 0xF1,
  0xFF, 0x80, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0xFF, 0x3F, 0xFC, 0x00, 0xFF, 0x7F,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFC, 0x03, 0xFF, 0x1F, 0xF8, 0x00, 0xFF, 0xCF, 0xF8,
  0x00, 0x3F, 0xE7, 0xF8, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0x01, 0xFE,
  0xFF, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0xFF,
  0x8F, 0xF8, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x01, 0xFE, 0xFE, 0x00,
  0x01, 0xFC, 0xFE, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0x9F,
  0xFE, 0x1F, 0xF0, 0x07, 0xFC, 0x7F, 0xC0, 0x07, 0xFC, 0xFF, 0x00, 0x07,
  0xF9, 0xFE, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x1F,
  0xCF, 0xE0, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0xFE,
  0x7F, 0x80, 0x03, 0xFC, 0x7F, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x1F, 0xE0,
  0xFF, 0x00, 0x7F, 0x80, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x8F, 0xFC, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF,
  0xE7, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x0F, 0xF8, 0x03, 0xFE, 0x1F, 0xE0,
  0x01, 0xFE, 0x7F, 0x80, 0x03, 0xFC, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x3F,
  0xE7, 0xFF, 0x00, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xF8, 0xFF,
  0xF0, 0x7F, 0xE0, 0x0F, 0xFC, 0x3F, 0xE0, 0x01, 0xFE, 0x3F, 0xE0, 0x00,
  0x7F, 0x9F, 0xE0, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x07, 0xFB, 0xFC,
  0x00, 0x03, 0xFD, 0xFE, 0x00, 0x03, 0xFC, 0xFF, 0x80, 0x03, 0xFE, 0x3F,
  0xF0, 0x03, 0xFF, 0x1F, 0xFE, 0x07, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xDF, 0xE0,
  0x03, 0xFF, 0x9F, 0xE0, 0x00, 0x1E, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x06, 0x03, 0xFC, 0x7F, 0xEF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFC, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x7F, 0xCF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFE,
  0x3F, 0xC0, 0xF0, 0x00, 0xE0, 0x03, 0xFC, 0x07, 0xFE, 0x0F, 0xFE, 0x0F,
  0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFE, 0x07, 0xFE, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0x03, 0xFE, 0x07, 0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xFC, 0x0F,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xE0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x80, 0x7F,
  0x00, 0x7F, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0,
  0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x01,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0x80, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8,
  0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFC,
  0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFD, 0xFF, 0xF0, 0x0F, 0xF8, 0x00, 0xFF, 0x81,
  0xFE, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x00,
  0xFE, 0x7F, 0x00, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x00, 0x7E, 0x7E, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xF0,
  0x3F, 0xFC, 0x00, 0x7F, 0xE3, 0xFF, 0xC0, 0x0F, 0xFF, 0x3F, 0xFC, 0x01,
  0xFF, 0xFB, 0xFF, 0xC0, 0x1F, 0xFF, 0x9F, 0xFC, 0x03, 0xFE, 0x1F, 0xFF,
  0xC0, 0x3F, 0x80, 0xFF, 0xFC, 0x07, 0xF0, 0x07, 0xFF, 0xC0, 0x7F, 0x00,
  0x7F, 0xFC, 0x07, 0xF0, 0x03, 0xFF, 0xC0, 0x7F, 0x00, 0x3F, 0xFC, 0x07,
  0xF0, 0x03, 0xFF, 0xC0, 0x7F, 0x00, 0x3F, 0xFC, 0x07, 0xF0, 0x03, 0xFF,
  0xC0, 0x7F, 0x00, 0x3F, 0xFC, 0x07, 0xF0, 0x03, 0xFF, 0xC0, 0x7F, 0x00,
  0x3F, 0xFC, 0x07, 0xF0, 0x03, 0xFF, 0xC0, 0x7F, 0x00, 0x3F, 0xFC, 0x07,
  0xF0, 0x03, 0xFF, 0xC0, 0x7F, 0x00, 0x3F, 0xFC, 0x07, 0xF0, 0x07, 0xFF,
  0xC0, 0x7F, 0x00, 0x7F, 0xFC, 0x03, 0xF0, 0x07, 0xFF, 0xC0, 0x3F, 0x80,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xBF, 0xFC, 0x00,
  0xFF, 0xFB, 0xFF, 0xC0, 0x07, 0xFF, 0x3F, 0xFC, 0x00, 0x3F, 0xC3, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x00,
  0x1F, 0xBF, 0x80, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x00, 0xFE, 0x7E, 0x00,
  0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x00, 0xFE, 0x3F,
  0x80, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0xFE,
  0x0F, 0xE0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00,
  0x7F, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x03, 0xF8, 0x0F, 0xE0,
  0x00, 0x7F, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x03, 0xFC, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xC0, 0x00, 0xFE, 0x07, 0xF0,
  0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x3F, 0x87,
  0xF8, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0xFF, 0x1F, 0xC0, 0x00, 0x1F,
  0xE7, 0xF8, 0x00, 0x01, 0xFC, 0xFF, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00,
  0x07, 0xFB, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x01, 0xFC, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0xFE, 0x3F, 0x80, 0x0F, 0xFE, 0x7F, 0x00, 0x07, 0xFC, 0xFE, 0x00,
  0x07, 0xF9, 0xFC, 0x00, 0x07, 0xFB, 0xF8, 0x00, 0x0F, 0xF7, 0xF0, 0x00,
  0x1F, 0xEF, 0xE0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x3F, 0xBF, 0x80, 0x00,
  0x7F, 0x7F, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x07,
  0xF3, 0xF8, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0xFF, 0x8F, 0xE0, 0x07, 0xFE,
  0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xC7,
  0xF0, 0x01, 0xFF, 0xCF, 0xE0, 0x00, 0xFF, 0x9F, 0xC0, 0x00, 0x7F, 0xBF,
  0x80, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFB, 0xF8, 0x00,
  0x3F, 0xF7, 0xF0, 0x07, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x1F, 0xF8, 0x07, 0xFE, 0x7F,
  0x80, 0x07, 0xFB, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xDF, 0xF0,
  0x03, 0xFE, 0x7F, 0xF0, 0x3F, 0xF8, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x8F, 0xE0, 0x1F, 0xFF, 0x3F, 0x80,
  0x07, 0xFC, 0xFE, 0x00, 0x0F, 0xFB, 0xF8, 0x00, 0x1F, 0xEF, 0xE0, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80,
  0x01, 0xFE, 0xFE, 0x00, 0x07, 0xFB, 0xF8, 0x00, 0x3F, 0xEF, 0xE0, 0x03,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF,
  0xCF, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFF, 0x1F, 0xF8, 0x07, 0xFE, 0x7F, 0x80, 0x07, 0xFB,
  0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xDF, 0xF0, 0x03, 0xFE, 0x7F,
  0xE0, 0x1F, 0xF8, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x01, 0xFE,
  0xFF, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x03, 0xFE, 0x7F, 0xC0, 0x07, 0xFC,
  0x3F, 0xF0, 0x1F, 0xFC, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0xFF,
  0x7F, 0x00, 0x00, 0xFF, 0x3F, 0x80, 0x00, 0x7F, 0x9F, 0xC0, 0x00, 0x7F,
  0x8F, 0xE0, 0x00, 0x3F, 0xC7, 0xF0, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x1F,
  0xE1, 0xFC, 0x00, 0x1F, 0xF0, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x0F,
  0xF8, 0x3F, 0x80, 0x07, 0xF8, 0x1F, 0xC0, 0x07, 0xFC, 0x0F, 0xE0, 0x03,
  0xFC, 0x07, 0xF0, 0x03, 0xFE, 0x03, 0xF8, 0x01, 0xFE, 0x01, 0xFC, 0x01,
  0xFF, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0xFF, 0x80, 0x3F, 0x80,
  0x7F, 0x80, 0x1F, 0xC0, 0x7F, 0xC0, 0x0F, 0xE0, 0x3F, 0xC0, 0x07, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F,
  0xC0, 0x7F, 0x80, 0x0F, 0xE0, 0x3F, 0xE0, 0x07, 0xF0, 0x0F, 0xF0, 0x03,
  0xF8, 0x07, 0xFC, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x80,
  0x7F, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x1F, 0xF0, 0x1F, 0xC0, 0x07, 0xF8,
  0x0F, 0xE0, 0x03, 0xFE, 0x07, 0xF0, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x7F,
  0x81, 0xFC, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x03,
  0xFC, 0x3F, 0x80, 0x01, 0xFE, 0x1F, 0xC0, 0x00, 0xFF, 0x8F, 0xE0, 0x00,
  0x3F, 0xC7, 0xF0, 0x00, 0x1F, 0xF3, 0xF8, 0x00, 0x07, 0xF9, 0xFC, 0x00,
  0x03, 0xFE, 0xFE, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0x7F, 0xC0, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x07,
  0xDF, 0xFF, 0xE0, 0x07, 0xDF, 0xFB, 0xE0, 0x0F, 0xFF, 0xFB, 0xF0, 0x0F,
  0xBF, 0xFB, 0xF0, 0x0F, 0xBF, 0xF9, 0xF0, 0x1F, 0xBF, 0xF9, 0xF0, 0x1F,
  0x3F, 0xFD, 0xF8, 0x1F, 0x3F, 0xFC, 0xF8, 0x1F, 0x3F, 0xFC, 0xF8, 0x3F,
  0x3F, 0xFC, 0xFC, 0x3E, 0x3F, 0xFC, 0x7C, 0x3E, 0x3F, 0xFC, 0x7C, 0x7E,
  0x3F, 0xFC, 0x7E, 0x7C, 0x7F, 0xFC, 0x3E, 0x7C, 0x7F, 0xFC, 0x3E, 0x7C,
  0x7F, 0xFC, 0x3E, 0xF8, 0x7F, 0xFC, 0x3F, 0xF8, 0x7F, 0xFC, 0x1F, 0xF8,
  0x7F, 0xFC, 0x1F, 0xF0, 0x7F, 0xFC, 0x1F, 0xF0, 0x7F, 0xFC, 0x0F, 0xF0,
  0x7F, 0xFC, 0x0F, 0xF0, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xDF,
  0x80, 0x1F, 0xFF, 0x7E, 0x00, 0x7F, 0xFD, 0xF8, 0x01, 0xFF, 0xF3, 0xF0,
  0x07, 0xFF, 0xCF, 0xC0, 0x1F, 0xFF, 0x3F, 0x80, 0x7F, 0xFC, 0x7E, 0x01,
  0xFF, 0xF1, 0xF8, 0x07, 0xFF, 0xC7, 0xF0, 0x1F, 0xFF, 0x0F, 0xC0, 0x7F,
  0xFC, 0x3F, 0x01, 0xFF, 0xF0, 0xFE, 0x07, 0xFF, 0xC1, 0xF8, 0x1F, 0xFF,
  0x07, 0xE0, 0x7F, 0xFC, 0x0F, 0xC1, 0xFF, 0xF0, 0x3F, 0x07, 0xFF, 0xC0,
  0xFC, 0x1F, 0xFF, 0x01, 0xF8, 0x7F, 0xFC, 0x07, 0xE1, 0xFF, 0xF0, 0x1F,
  0x87, 0xFF, 0xC0, 0x3F, 0x1F, 0xFF, 0x00, 0xFC, 0x7F, 0xFC, 0x03, 0xF9,
  0xFF, 0xF0, 0x07, 0xE7, 0xFF, 0xC0, 0x1F, 0x9F, 0xFF, 0x00, 0x7F, 0x7F,
  0xFC, 0x00, 0xFD, 0xFF, 0xF0, 0x03, 0xF7, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x00, 0x1F, 0xBF, 0xFC, 0x00, 0x7E, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0x1F, 0xF0, 0x07, 0xFC, 0x7F,
  0x80, 0x0F, 0xFB, 0xFC, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x3F, 0xBF, 0x80,
  0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x7F, 0x9F, 0xF0,
  0x03, 0xFE, 0x7F, 0xE0, 0x3F, 0xF0, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0xFE, 0x00, 0x3F, 0xFC,
  0xFE, 0x00, 0x07, 0xFE, 0xFE, 0x00, 0x03, 0xFE, 0xFE, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x03, 0xFE,
  0xFE, 0x00, 0x0F, 0xFE, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x3F, 0xE0, 0x0F, 0xFC,
  0x7F, 0xC0, 0x07, 0xFC, 0x7F, 0x80, 0x03, 0xFC, 0x7F, 0x00, 0x01, 0xFE,
  0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0xFE,
  0xFF, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0xFE,
  0xFF, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0xFE,
  0xFF, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0xFE,
  0xFF, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0xFE,
  0xFF, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0xFE,
  0xFF, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0xFE,
  0xFF, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0xFE,
  0xFF, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0xFE,
  0xFF, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFE,
  0x7F, 0x80, 0x01, 0xFE, 0x7F, 0x80, 0x03, 0xFC, 0x7F, 0xC0, 0x07, 0xFC,
  0x3F, 0xF0, 0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFE, 0x00, 0x3F, 0xF8, 0xFE, 0x00, 0x0F, 0xFC,
  0xFE, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x03, 0xFE, 0xFE, 0x00, 0x01, 0xFE,
  0xFE, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFE,
  0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFE,
  0xFE, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x03, 0xFE,
  0xFE, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x0F, 0xFC, 0xFE, 0x00, 0x3F, 0xF8,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0xFE, 0x03, 0xFC, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0xFE, 0x01, 0xFE, 0x00,
  0xFE, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x7F, 0x80,
  0xFE, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x3F, 0xC0,
  0xFE, 0x00, 0x3F, 0xE0, 0xFE, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x1F, 0xF0,
  0xFE, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x07, 0xF8,
  0xFE, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x03, 0xFC,
  0xFE, 0x00, 0x03, 0xFE, 0xFE, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xE0, 0x0F, 0xFC, 0x1F, 0xE0, 0x01,
  0xFE, 0x1F, 0xE0, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x3F, 0xC7, 0xF0, 0x00,
  0x0F, 0xE3, 0xF8, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x03, 0xF8, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00,
  0x7F, 0xBF, 0xC0, 0x00, 0x3F, 0x9F, 0xF0, 0x00, 0x3F, 0xC7, 0xFC, 0x00,
  0x3F, 0xE3, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFB, 0xFE, 0x00, 0x1F, 0xE7, 0xFC, 0x00,
  0xFF, 0x9F, 0xF8, 0x0F, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00,
  0x0F, 0xE7, 0xF8, 0x00, 0x01, 0xFC, 0xFF, 0x00, 0x00, 0x3F, 0x8F, 0xE0,
  0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x01, 0xFC, 0x3F, 0xC0, 0x00, 0x3F, 0x87,
  0xF8, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x3F,
  0x81, 0xFE, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x00, 0xFE, 0x03, 0xF8, 0x00,
  0x3F, 0xC0, 0x7F, 0x00, 0x07, 0xF0, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x07, 0xF8, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0xFF,
  0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x7F, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x1F,
  0xE0, 0x7F, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x3F, 0x81, 0xFC, 0x00,
  0x07, 0xF0, 0x7F, 0x00, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x0F, 0xE1, 0xFC,
  0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x07, 0xF1,
  0xFC, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x01,
  0xFC, 0xFC, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0xFC, 0x01, 0xFC, 0x01, 0xFD, 0xF8, 0x03, 0xFC,
  0x03, 0xFB, 0xF0, 0x07, 0xF8, 0x07, 0xF7, 0xF0, 0x0F, 0xF0, 0x0F, 0xCF,
  0xE0, 0x1F, 0xE0, 0x1F, 0x9F, 0xC0, 0x3F, 0xC0, 0x3F, 0x3F, 0x80, 0xFF,
  0x80, 0x7E, 0x7F, 0x01, 0xEF, 0x00, 0xFC, 0x7E, 0x03, 0xDE, 0x01, 0xF8,
  0xFC, 0x07, 0xBE, 0x07, 0xF1, 0xF8, 0x0F, 0x7C, 0x0F, 0xE3, 0xF0, 0x1E,
  0x78, 0x1F, 0xC7, 0xE0, 0x3C, 0xF0, 0x3F, 0x0F, 0xE0, 0x79, 0xE0, 0x7E,
  0x1F, 0xC1, 0xF3, 0xC0, 0xFC, 0x3F, 0x83, 0xE7, 0x81, 0xF8, 0x7F, 0x07,
  0x8F, 0x03, 0xF0, 0x7E, 0x0F, 0x1E, 0x07, 0xE0, 0xFC, 0x1E, 0x3E, 0x0F,
  0xC1, 0xF8, 0x3C, 0x7C, 0x3F, 0x83, 0xF0, 0x78, 0xF8, 0x7F, 0x07, 0xE0,
  0xF0, 0xF0, 0xFC, 0x0F, 0xC1, 0xE1, 0xE1, 0xF8, 0x1F, 0x87, 0xC3, 0xC3,
  0xF0, 0x3F, 0x8F, 0x87, 0x87, 0xE0, 0x7F, 0x1E, 0x0F, 0x0F, 0xC0, 0xFE,
  0x3C, 0x1E, 0x1F, 0x80, 0xFC, 0x78, 0x3E, 0x3F, 0x01, 0xF8, 0xF0, 0x7C,
  0x7E, 0x03, 0xF1, 0xE0, 0xF8, 0xFC, 0x07, 0xE3, 0xC0, 0xF3, 0xF0, 0x0F,
  0xCF, 0x81, 0xE7, 0xE0, 0x1F, 0x9F, 0x03, 0xCF, 0xC0, 0x3F, 0x3C, 0x07,
  0x9F, 0x80, 0x7E, 0x78, 0x0F, 0x3F, 0x00, 0xFE, 0xF0, 0x1E, 0x7E, 0x00,
  0xFD, 0xE0, 0x3E, 0xFC, 0x01, 0xFB, 0xC0, 0x7D, 0xF8, 0x03, 0xF7, 0x80,
  0xFB, 0xE0, 0x07, 0xFF, 0x00, 0xF7, 0xC0, 0x0F, 0xFE, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xF0,
  0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF1, 0xFF, 0x00, 0x00, 0xFF,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0xFF, 0x00,
  0x03, 0xFC, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x01, 0xFC, 0x00,
  0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x7F, 0x80, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x01, 0xFE, 0x3F, 0xC0,
  0x00, 0x07, 0xF9, 0xFE, 0x00, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x00, 0x3F, 0xCF, 0xE0, 0x00,
  0x03, 0xFC, 0x7F, 0x80, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x01, 0xFE, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x07,
  0xF8, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x1F, 0xE0,
  0x00, 0xFF, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x1F, 0xF0,
  0xFF, 0x00, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x03, 0xFE, 0x7F, 0x80, 0x00,
  0x0F, 0xF7, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x00, 0x07, 0xFB,
  0xFC, 0x00, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00,
  0x1F, 0xE3, 0xFC, 0x00, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x7F,
  0x80, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x3F,
  0x80, 0x3F, 0x80, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x00, 0xFF, 0x03,
  0xF8, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x00,
  0xFF, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0xFF, 0x00, 0x00, 0x1F, 0xE7, 0xF0,
  0x00, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x3F, 0x3F, 0x00,
  0x00, 0xFE, 0x7E, 0x00, 0x01, 0xF8, 0xFE, 0x00, 0x07, 0xF0, 0xFC, 0x00,
  0x0F, 0xC1, 0xFC, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x7F, 0x03, 0xF0, 0x00,
  0xFC, 0x07, 0xF0, 0x03, 0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x0F, 0xC0, 0x3F, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x1F, 0x81, 0xFC,
  0x00, 0x3F, 0x87, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7F, 0x3F, 0x80,
  0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x03, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFC, 0x1F, 0xF8, 0x07, 0xFE, 0x1F, 0xE0, 0x03, 0xFE, 0x3F,
  0xC0, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0xFF, 0x3F, 0x80, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFF, 0x7F, 0xE0, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0x7F,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0x7F, 0xC0, 0x07, 0xFF, 0x7F,
  0xF0, 0x1F, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0xFF, 0x1F,
  0xFF, 0xFC, 0xFF, 0x07, 0xFF, 0xF8, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0x00,
  0x3F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x7C, 0x00,
  0xFE, 0x0F, 0xFE, 0x03, 0xF8, 0xFF, 0xFE, 0x0F, 0xE7, 0xFF, 0xFC, 0x3F,
  0x9F, 0xFF, 0xF8, 0xFE, 0xFF, 0xFF, 0xF3, 0xFB, 0xFF, 0xFF, 0xCF, 0xFE,
  0x03, 0xFF, 0xBF, 0xF0, 0x03, 0xFE, 0xFF, 0x80, 0x07, 0xFB, 0xFC, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F,
  0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x1F, 0xEF, 0xFC, 0x00, 0xFF, 0xBF, 0xF8, 0x07, 0xFE,
  0xFE, 0xFF, 0xFF, 0xF3, 0xFB, 0xFF, 0xFF, 0xCF, 0xE7, 0xFF, 0xFE, 0x3F,
  0x9F, 0xFF, 0xF0, 0xFE, 0x3F, 0xFF, 0x83, 0xF8, 0x3F, 0xF8, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x1F, 0xF8, 0x0F, 0xFE, 0x3F, 0xE0,
  0x07, 0xFC, 0xFF, 0x80, 0x07, 0xFD, 0xFE, 0x00, 0x07, 0xFB, 0xF8, 0x00,
  0x0F, 0xF7, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFB,
  0xF8, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x3F, 0xDF,
  0xF0, 0x00, 0xFF, 0x9F, 0xF0, 0x03, 0xFE, 0x3F, 0xF0, 0x0F, 0xFC, 0x3F,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0xF0, 0x0F,
  0xF0, 0x1F, 0xFC, 0x1F, 0xE0, 0x7F, 0xFE, 0x3F, 0xC1, 0xFF, 0xFE, 0x7F,
  0x87, 0xFF, 0xFE, 0xFF, 0x1F, 0xFF, 0xFD, 0xFE, 0x7F, 0xFF, 0xFF, 0xFC,
  0xFF, 0xC0, 0x7F, 0xFB, 0xFE, 0x00, 0x3F, 0xF7, 0xF8, 0x00, 0x7F, 0xEF,
  0xF0, 0x00, 0x7F, 0xDF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xBF, 0x80, 0x00,
  0xFF, 0x7F, 0x80, 0x03, 0xFE, 0xFF, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x1F,
  0xF9, 0xFF, 0x80, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xBF,
  0xC3, 0xFF, 0xFF, 0x7F, 0x87, 0xFF, 0xFC, 0xFF, 0x03, 0xFF, 0xF1, 0xFE,
  0x03, 0xFF, 0x83, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0x0F, 0xFE, 0x1F,
  0xF0, 0x07, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0xFF, 0x00, 0x07, 0xF9, 0xFC,
  0x00, 0x07, 0xF3, 0xF8, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x7F, 0x9F, 0xE0, 0x01, 0xFE,
  0x3F, 0xE0, 0x07, 0xFC, 0x3F, 0xF8, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0xFE, 0x0F, 0xF0, 0x7F, 0xFE, 0x3F, 0xC3, 0xFF, 0xFC,
  0xFF, 0x1F, 0xFF, 0xFB, 0xFC, 0xFF, 0xFF, 0xEF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xDF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFD, 0xFF,
  0x80, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0xFF, 0x1F, 0xFF,
  0xFB, 0xFC, 0x3F, 0xFF, 0xCF, 0xF0, 0x7F, 0xFE, 0x3F, 0xC0, 0xFF, 0xF0,
  0xFF, 0x00, 0x3C, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x1F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x78, 0x00, 0xFE, 0x0F, 0xFE, 0x03, 0xF8,
  0xFF, 0xFE, 0x0F, 0xE7, 0xFF, 0xFC, 0x3F, 0x9F, 0xFF, 0xF8, 0xFE, 0xFF,
  0xFF, 0xF3, 0xFB, 0xFF, 0xFF, 0xCF, 0xFE, 0x03, 0xFF, 0xBF, 0xF0, 0x03,
  0xFE, 0xFF, 0x80, 0x07, 0xFB, 0xFC, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x0F, 0xFB, 0xF8, 0x00, 0x07, 0xF9, 0xFC, 0x00, 0x07, 0xF8, 0xFE,
  0x00, 0x07, 0xFC, 0x7F, 0x00, 0x03, 0xFC, 0x3F, 0x80, 0x03, 0xFC, 0x1F,
  0xC0, 0x03, 0xFE, 0x0F, 0xE0, 0x01, 0xFE, 0x07, 0xF0, 0x01, 0xFE, 0x03,
  0xF8, 0x01, 0xFF, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x00, 0xFF, 0x80, 0x3F, 0x80, 0x7F, 0x80, 0x1F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x3F, 0x80, 0x7F, 0x80, 0x1F, 0xC0, 0x3F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF0, 0x07, 0xFC, 0x03, 0xF8, 0x01, 0xFF, 0x01, 0xFC, 0x00,
  0x7F, 0x80, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0x00, 0x0F, 0xF8, 0x3F, 0x80,
  0x03, 0xFC, 0x1F, 0xC0, 0x01, 0xFF, 0x0F, 0xE0, 0x00, 0x7F, 0x87, 0xF0,
  0x00, 0x3F, 0xE3, 0xF8, 0x00, 0x0F, 0xF9, 0xFC, 0x00, 0x03, 0xFC, 0xFE,
  0x00, 0x01, 0xFF, 0x7F, 0x00, 0x00, 0x7F, 0xC0, 0xFF, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x0C, 0x00, 0x60, 0x7E, 0x3F, 0xC1,
  0xFE, 0x3F, 0x3F, 0xF1, 0xFF, 0x9F, 0xBF, 0xF9, 0xFF, 0xEF, 0xDF, 0xFE,
  0xFF, 0xF7, 0xEF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xE1, 0xFF, 0xFC, 0x0F,
  0xE0, 0x7F, 0xFE, 0x03, 0xF0, 0x3F, 0xFF, 0x01, 0xF8, 0x0F, 0xFF, 0x80,
  0xFC, 0x07, 0xFF, 0xC0, 0x7E, 0x03, 0xFF, 0xE0, 0x3F, 0x01, 0xFF, 0xF0,
  0x1F, 0x80, 0xFF, 0xF8, 0x0F, 0xC0, 0x7F, 0xFC, 0x07, 0xE0, 0x3F, 0xFE,
  0x03, 0xF0, 0x1F, 0xFF, 0x01, 0xF8, 0x0F, 0xFF, 0x80, 0xFC, 0x07, 0xFF,
  0xC0, 0x7E, 0x03, 0xFF, 0xE0, 0x3F, 0x01, 0xFF, 0xF0, 0x1F, 0x80, 0xFF,
  0xF8, 0x0F, 0xC0, 0x7F, 0xFC, 0x07, 0xE0, 0x3F, 0xFE, 0x03, 0xF0, 0x1F,
  0xFF, 0x01, 0xF8, 0x0F, 0xFF, 0x80, 0xFC, 0x07, 0xFF, 0xC0, 0x7E, 0x03,
  0xFF, 0xE0, 0x3F, 0x01, 0xFF, 0xF0, 0x1F, 0x80, 0xFF, 0xF8, 0x0F, 0xC0,
  0x7F, 0xFC, 0x07, 0xE0, 0x3F, 0xFE, 0x03, 0xF0, 0x1F, 0xFF, 0x01, 0xF8,
  0x0F, 0xFF, 0x80, 0xFC, 0x07, 0xFF, 0xC0, 0x7E, 0x03, 0xFF, 0xE0, 0x3F,
  0x01, 0xFF, 0xF0, 0x1F, 0x80, 0xFF, 0xF8, 0x0F, 0xC0, 0x7E, 0x00, 0x01,
  0xE0, 0x03, 0xF8, 0x3F, 0xF8, 0x0F, 0xE3, 0xFF, 0xF8, 0x3F, 0x9F, 0xFF,
  0xF0, 0xFE, 0x7F, 0xFF, 0xE3, 0xFB, 0xFF, 0xFF, 0xCF, 0xEF, 0xFF, 0xFF,
  0x3F, 0xF8, 0x0F, 0xFE, 0xFF, 0xC0, 0x0F, 0xFB, 0xFE, 0x00, 0x1F, 0xEF,
  0xF0, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0x40, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFE, 0x1F, 0xF8, 0x0F, 0xFC, 0x3F, 0xC0, 0x07, 0xFC,
  0xFF, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x0F, 0xF7,
  0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFB, 0xF8, 0x00,
  0x0F, 0xF7, 0xF0, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x3F, 0x9F, 0xE0, 0x00,
  0xFF, 0x1F, 0xE0, 0x03, 0xFE, 0x3F, 0xF0, 0x1F, 0xF8, 0x3F, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0xF0, 0x03, 0xF8, 0x3F, 0xF8, 0x0F, 0xE3, 0xFF, 0xF8, 0x3F,
  0x9F, 0xFF, 0xF0, 0xFE, 0x7F, 0xFF, 0xE3, 0xFB, 0xFF, 0xFF, 0xCF, 0xEF,
  0xFF, 0xFF, 0x3F, 0xFC, 0x0F, 0xFE, 0xFF, 0xC0, 0x0F, 0xFB, 0xFE, 0x00,
  0x1F, 0xEF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F,
  0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xBF, 0xF0, 0x03, 0xFE,
  0xFF, 0xE0, 0x1F, 0xFB, 0xFB, 0xFF, 0xFF, 0xCF, 0xEF, 0xFF, 0xFF, 0x3F,
  0x9F, 0xFF, 0xF8, 0xFE, 0x7F, 0xFF, 0xC3, 0xF8, 0xFF, 0xFE, 0x0F, 0xE0,
  0xFF, 0xE0, 0x3F, 0x80, 0x78, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0xFE, 0x0F, 0xF0, 0x7F, 0xFE, 0x3F, 0xC3,
  0xFF, 0xFC, 0xFF, 0x1F, 0xFF, 0xFB, 0xFC, 0xFF, 0xFF, 0xEF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xDF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF,
  0x7F, 0xE0, 0x3F, 0xFD, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xBF, 0xC7,
  0xFF, 0xFE, 0xFF, 0x0F, 0xFF, 0xF3, 0xFC, 0x1F, 0xFF, 0x8F, 0xF0, 0x3F,
  0xF8, 0x3F, 0xC0, 0x1F, 0x80, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xE0, 0x01, 0xFC, 0x1F, 0xFC, 0x03, 0xF8, 0xFF, 0xFE, 0x07,
  0xF3, 0xFF, 0xFE, 0x0F, 0xE7, 0xFF, 0xFE, 0x1F, 0xDF, 0xFF, 0xFE, 0x3F,
  0xBF, 0xFF, 0xFE, 0x7F, 0xF0, 0x0F, 0xFC, 0xFF, 0xC0, 0x07, 0xFD, 0xFF,
  0x00, 0x0F, 0xFB, 0xFC, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x1F, 0xEF, 0xF0,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC,
  0x3F, 0xE0, 0x07, 0xFC, 0x3F, 0xC0, 0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFE,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE,
  0x7F, 0x80, 0x01, 0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0xFE,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFE, 0xFF, 0x00, 0x07, 0xFB,
  0xFE, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0xFF, 0x9F, 0xF8, 0x0F, 0xFC, 0x3F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x03, 0xFD, 0xFE,
  0x00, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x03, 0xFC,
  0x7F, 0x80, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x03,
  0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x80,
  0x03, 0xFC, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x0F,
  0xE0, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xE0,
  0x03, 0xF8, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x0F,
  0xE0, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x03, 0xFC,
  0x0F, 0xE0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00,
  0xFF, 0x0F, 0xE0, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x01, 0xFC, 0x7F, 0x00,
  0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0x7F, 0x3F,
  0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xE0, 0x0F, 0xFF, 0x80,
  0x7F, 0x00, 0x7F, 0xFC, 0x03, 0xF8, 0x03, 0xF7, 0xE0, 0x1F, 0xE0, 0x1F,
  0xBF, 0x00, 0xFF, 0x00, 0xFD, 0xF8, 0x07, 0xF8, 0x0F, 0xCF, 0xC0, 0x7B,
  0xC0, 0x7E, 0x7E, 0x03, 0xDE, 0x03, 0xF3, 0xF8, 0x1E, 0xF0, 0x1F, 0x8F,
  0xC0, 0xF7, 0x80, 0xFC, 0x7E, 0x07, 0x9E, 0x07, 0xE3, 0xF0, 0x3C, 0xF0,
  0x3E, 0x1F, 0x83, 0xE7, 0x83, 0xF0, 0xFC, 0x1E, 0x3C, 0x1F, 0x87, 0xE0,
  0xF1, 0xE0, 0xFC, 0x3F, 0x87, 0x8F, 0x07, 0xE0, 0xFC, 0x3C, 0x7C, 0x3F,
  0x07, 0xE1, 0xE1, 0xE1, 0xF8, 0x3F, 0x0F, 0x0F, 0x0F, 0x81, 0xF8, 0xF0,
  0x78, 0xFC, 0x0F, 0xC7, 0x83, 0xC7, 0xE0, 0x7E, 0x3C, 0x1E, 0x3F, 0x01,
  0xF9, 0xE0, 0xF1, 0xF8, 0x0F, 0xCF, 0x07, 0xCF, 0xC0, 0x7E, 0x78, 0x1E,
  0x7C, 0x03, 0xF7, 0xC0, 0xF3, 0xE0, 0x1F, 0xBC, 0x07, 0xBF, 0x00, 0xFD,
  0xE0, 0x3D, 0xF8, 0x07, 0xEF, 0x01, 0xEF, 0xC0, 0x1F, 0x78, 0x0F, 0xFE,
  0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x3F, 0xE0,
  0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x03, 0xFE, 0x00,
  0x3F, 0xC0, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xE7, 0xF8, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x01, 0xFE, 0x0F, 0xF8,
  0x00, 0x7F, 0x80, 0xFF, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x3F, 0xE0, 0x01, 0xFE, 0x07, 0xF8,
  0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x03, 0xFC, 0x7F, 0xC0, 0x00, 0x3F, 0xCF,
  0xF0, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x1F,
  0xF3, 0xFC, 0x00, 0x03, 0xFC, 0x7F, 0xC0, 0x00, 0xFF, 0x07, 0xF8, 0x00,
  0x3F, 0xE0, 0x7F, 0x80, 0x07, 0xF8, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x0F, 0xF0, 0x01, 0xFF, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0xFF, 0x80, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x3F, 0xE7, 0xF8,
  0x00, 0x03, 0xFD, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x00, 0x1F,
  0xEF, 0xF0, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00,
  0x1F, 0xE3, 0xFC, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0xFF, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0xFF, 0x01,
  0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x3F,
  0xC0, 0xFF, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x00, 0x7F, 0x83, 0xF8, 0x00,
  0x0F, 0xF0, 0xFF, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x1F, 0xE7, 0xF8,
  0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x07, 0xF3,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x03, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xC7,
  0xFF, 0xC0, 0x07, 0xE7, 0xFF, 0xF0, 0x03, 0xF7, 0xFF, 0xFC, 0x01, 0xFB,
  0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x7F, 0xC0, 0x7F, 0xFC, 0x1F, 0xF0, 0x3F,
  0xFE, 0x07, 0xFC, 0x3F, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xDF, 0xC0, 0x1F, 0xFF, 0xEF, 0xE0, 0x07, 0xFF, 0xE7, 0xF0, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xC0,
};

const GFXglyph JetBrainsMono_Medium69pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 41, 0, -1 },
  { 1, 11, 50, 41, 15, -50 },
  { 70, 22, 20, 41, 10, -50 },
  { 125, 37, 50, 41, 2, -50 },
  { 357, 33, 70, 41, 4, -60 },
  { 646, 41, 51, 41, 0, -51 },
  { 908, 36, 52, 41, 3, -51 },
  { 1142, 7, 20, 41, 17, -50 },
  { 1160, 21, 66, 41, 12, -58 },
  { 1334, 21, 66, 41, 8, -58 },
  { 1508, 37, 36, 41, 2, -42 },
  { 1675, 33, 33, 41, 4, -39 },
  { 1812, 15, 21, 41, 11, -10 },
  { 1852, 22, 7, 41, 10, -26 },
  { 1872, 12, 13, 41, 15, -12 },
  { 1892, 32, 65, 41, 5, -57 },
  { 2152, 31, 52, 41, 5, -51 },
  { 2354, 32, 50, 41, 6, -50 },
  { 2554, 33, 51, 41, 4, -51 },
  { 2765, 32, 51, 41, 4, -50 },
  { 2969, 30, 50, 41, 5, -50 },
  { 3157, 31, 51, 41, 5, -50 },
  { 3355, 33, 51, 41, 4, -50 },
  { 3566, 32, 50, 41, 5, -50 },
  { 3766, 31, 52, 41, 5, -51 },
  { 3968, 33, 51, 41, 4, -51 },
  { 4179, 12, 40, 41, 15, -39 },
  { 4239, 16, 50, 41, 11, -39 },
  { 4339, 30, 37, 41, 6, -41 },
  { 4478, 30, 24, 41, 6, -35 },
  { 4568, 30, 37, 41, 6, -41 },
  { 4707, 25, 50, 41, 9, -50 },
  { 4864, 36, 63, 41, 3, -51 },
  { 5148, 35, 50, 41, 3, -50 },
  { 5367, 31, 50, 41, 6, -50 },
  { 5561, 30, 52, 41, 6, -51 },
  { 5756, 30, 50, 41, 6, -50 },
  { 5944, 30, 50, 41, 6, -50 },
  { 6132, 31, 50, 41, 6, -50 },
  { 6326, 30, 52, 41, 6, -51 },
  { 6521, 30, 50, 41, 6, -50 },
  { 6709, 28, 50, 41, 7, -50 },
  { 6884, 32, 51, 41, 3, -50 },
  { 7088, 33, 50, 41, 6, -50 },
  { 7295, 29, 50, 41, 8, -50 },
  { 7477, 32, 50, 41, 5, -50 },
  { 7677, 30, 50, 41, 6, -50 },
  { 7865, 30, 52, 41, 6, -51 },
  { 8060, 32, 50, 41, 6, -50 },
  { 8260, 32, 63, 41, 5, -51 },
  { 8512, 32, 50, 41, 6, -50 },
  { 8712, 33, 52, 41, 4, -51 },
  { 8927, 34, 50, 41, 4, -50 },
  { 9140, 30, 51, 41, 6, -50 },
  { 9332, 35, 50, 41, 3, -50 },
  { 9551, 39, 50, 41, 1, -50 },
  { 9795, 37, 50, 41, 2, -50 },
  { 10027, 37, 50, 41, 2, -50 },
  { 10259, 30, 50, 41, 6, -50 },
  { 10447, 19, 65, 41, 13, -57 },
  { 10602, 32, 65, 41, 5, -57 },
  { 10862, 18, 65, 41, 10, -57 },
  { 11009, 31, 27, 41, 5, -50 },
  { 11114, 33, 6, 41, 4, 2 },
  { 11139, 16, 10, 41, 12, -54 },
  { 11159, 32, 40, 41, 4, -39 },
  { 11319, 30, 51, 41, 6, -50 },
  { 11511, 31, 40, 41, 5, -39 },
  { 11666, 31, 51, 41, 5, -50 },
  { 11864, 31, 40, 41, 5, -39 },
  { 12019, 33, 50, 41, 4, -50 },
  { 12226, 30, 51, 41, 6, -39 },
  { 12418, 30, 50, 41, 6, -50 },
  { 12606, 32, 54, 41, 6, -54 },
  { 12822, 26, 66, 41, 6, -54 },
  { 13037, 33, 50, 41, 6, -50 },
  { 13244, 36, 50, 41, 2, -50 },
  { 13469, 33, 39, 41, 4, -39 },
  { 13630, 30, 39, 41, 6, -39 },
  { 13777, 31, 40, 41, 5, -39 },
  { 13932, 30, 51, 41, 6, -39 },
  { 14124, 30, 51, 41, 6, -39 },
  { 14316, 31, 39, 41, 7, -39 },
  { 14468, 32, 40, 41, 5, -39 },
  { 14628, 33, 49, 41, 3, -49 },
  { 14831, 30, 39, 41, 6, -38 },
  { 14978, 35, 38, 41, 3, -38 },
  { 15145, 37, 38, 41, 2, -38 },
  { 15321, 35, 38, 41, 3, -38 },
  { 15488, 35, 50, 41, 3, -38 },
  { 15707, 30, 38, 41, 6, -38 },
  { 15850, 30, 65, 41, 6, -57 },
  { 16094, 7, 65, 41, 17, -57 },
  { 16151, 30, 65, 41, 6, -57 },
  { 16395, 33, 15, 41, 4, -32 },
};

const GFXfont JetBrainsMono_Medium69pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Medium69pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Medium69pt7bGlyphs,
  0x20, 0x7E, 91
};

#endif // _JETBRAINSMONO_MEDIUM69PT7B_H_
