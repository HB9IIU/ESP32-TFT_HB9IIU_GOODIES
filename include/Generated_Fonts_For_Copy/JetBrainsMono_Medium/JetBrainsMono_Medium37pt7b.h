#ifndef _JETBRAINSMONO_MEDIUM37PT7B_H_
#define _JETBRAINSMONO_MEDIUM37PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Medium.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Medium37pt7bBitmaps[] PROGMEM = {
  0x00, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x38, 0xE3, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xF7, 0x80, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0x70, 0xF0, 0x01, 0xC1, 0xC0, 0x3C, 0x1C, 0x03, 0x81, 0xC0, 0x38,
  0x1C, 0x03, 0x83, 0x80, 0x38, 0x38, 0x03, 0x83, 0x87, 0xFF, 0xFF, 0x7F,
  0xFF, 0xF7, 0xFF, 0xFF, 0x07, 0x07, 0x00, 0x70, 0x70, 0x07, 0x07, 0x00,
  0xE0, 0x70, 0x0E, 0x07, 0x00, 0xE0, 0xF0, 0x0E, 0x0E, 0x0F, 0xFF, 0xFE,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x1C, 0x0E, 0x01, 0xC1, 0xC0, 0x1C, 0x1C,
  0x01, 0xC1, 0xC0, 0x38, 0x1C, 0x03, 0x81, 0xC0, 0x38, 0x3C, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x01, 0xFF,
  0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x3E, 0xDF, 0x9F, 0x31, 0xE7, 0x8C, 0x79,
  0xE3, 0x1E, 0x78, 0xC0, 0x1E, 0x30, 0x07, 0xCC, 0x00, 0xFB, 0x00, 0x3F,
  0xC0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x33,
  0xE0, 0x0C, 0x78, 0x03, 0x0F, 0x00, 0xC3, 0xFC, 0x30, 0xF7, 0x8C, 0x3D,
  0xE3, 0x1E, 0x7E, 0xDF, 0x8F, 0xFF, 0xC1, 0xFF, 0xE0, 0x1F, 0xF0, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x1F,
  0x80, 0x1C, 0xFF, 0x00, 0xE7, 0xFE, 0x07, 0x1C, 0x38, 0x3C, 0x70, 0xE0,
  0xE1, 0xC3, 0x87, 0x07, 0x0E, 0x3C, 0x1C, 0x38, 0xE0, 0x70, 0xE7, 0x01,
  0xFF, 0xB8, 0x03, 0xFC, 0xE0, 0x07, 0xE7, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x39, 0xF8, 0x01, 0xEF, 0xF8, 0x07, 0x3D,
  0xE0, 0x39, 0xC3, 0xC1, 0xC7, 0x07, 0x07, 0x1C, 0x1C, 0x38, 0x70, 0x71,
  0xC1, 0xC1, 0xC7, 0x07, 0x0F, 0x38, 0x0F, 0xF9, 0xC0, 0x3F, 0xEF, 0x00,
  0x7E, 0x00, 0x07, 0xF0, 0x03, 0xFF, 0x80, 0xFF, 0xF8, 0x1F, 0x1F, 0x03,
  0xC1, 0xE0, 0x70, 0x1E, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3E,
  0xF0, 0xFF, 0x8F, 0x1E, 0xF1, 0xF7, 0x9E, 0x1E, 0xF3, 0xC1, 0xFC, 0x78,
  0x1F, 0x8F, 0x03, 0xE1, 0xE0, 0x3C, 0x3C, 0x0F, 0xC7, 0xC3, 0xFC, 0x7F,
  0xFF, 0x8F, 0xFE, 0x78, 0x7F, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x60, 0x3C, 0x1F, 0x87, 0xF1, 0xF8, 0x7C, 0x0F, 0x03, 0xC0,
  0x78, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xE0, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7F, 0x07, 0xE0, 0x7C,
  0x03, 0x80, 0xC0, 0x0F, 0x00, 0xFC, 0x0F, 0xE0, 0x3F, 0x00, 0xF8, 0x07,
  0xC0, 0x3C, 0x03, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0xF8, 0x1F,
  0x8F, 0xF0, 0xFE, 0x0F, 0x80, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x04, 0x0F, 0x02, 0x78, 0x70,
  0xE7, 0xE6, 0x3E, 0xFF, 0x6F, 0xF3, 0xFF, 0xFC, 0x07, 0xFE, 0x00, 0x0F,
  0x00, 0x01, 0xF8, 0x00, 0x39, 0xC0, 0x07, 0x9E, 0x00, 0xF8, 0xF0, 0x0F,
  0x0F, 0x81, 0xE0, 0x78, 0x0E, 0x07, 0x00, 0x40, 0x20, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1F, 0x1F, 0x3E, 0x3E, 0x3C, 0x7C, 0x7C, 0x78, 0x78, 0xF0,
  0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7B, 0xFF, 0xFF, 0xFD,
  0xE0, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03,
  0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0,
  0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0xF0, 0x3F, 0xFC, 0x7F, 0xFE, 0x7C, 0x3E,
  0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF1, 0xC7, 0xF3, 0xC7, 0xF3, 0xC7, 0xF3, 0xC7, 0xF1, 0x87,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F,
  0xF8, 0x0F, 0x7C, 0x3E, 0x7F, 0xFE, 0x3F, 0xFC, 0x0F, 0xF0, 0x03, 0xE0,
  0x07, 0xF0, 0x07, 0xF8, 0x07, 0xFC, 0x0F, 0xDE, 0x07, 0xCF, 0x03, 0x87,
  0x81, 0x83, 0xC0, 0x81, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x81, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xF8, 0x07, 0xFF,
  0x83, 0xFF, 0xF0, 0xF8, 0x7C, 0x7C, 0x0F, 0x9E, 0x01, 0xEF, 0x80, 0x7B,
  0xC0, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xFF, 0xFF, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFC, 0x3F, 0xFF, 0x1F,
  0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE0, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x3F,
  0xF0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xFF, 0x00, 0x7B, 0xC0, 0x3D, 0xE0, 0x3E, 0xFC, 0x3E,
  0x3F, 0xFF, 0x0F, 0xFF, 0x01, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x0F,
  0x80, 0x0F, 0x00, 0x1F, 0x00, 0x3E, 0x0F, 0x3C, 0x0F, 0x7C, 0x0F, 0xF8,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF1, 0xF0, 0xF7, 0xFC, 0xF7,
  0xFE, 0xFF, 0xFE, 0xF8, 0x1F, 0xF8, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0x7C,
  0x3E, 0x7F, 0xFE, 0x3F, 0xFC, 0x0F, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE7, 0x00, 0xF7, 0xF8, 0x3F, 0xFF,
  0x1F, 0xEF, 0xE7, 0xC0, 0xF9, 0xE0, 0x1F, 0xF8, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x03, 0xDE, 0x01, 0xF7, 0xC0, 0x78, 0xF8,
  0x7E, 0x3F, 0xFF, 0x07, 0xFF, 0x80, 0x7F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0x80, 0x7B, 0xC0, 0x3D, 0xE0,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80,
  0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F,
  0x80, 0x07, 0x80, 0x07, 0xC0, 0x00, 0x0F, 0xF0, 0x1F, 0xFE, 0x1F, 0xFF,
  0x8F, 0x87, 0xCF, 0x81, 0xF7, 0x80, 0x7B, 0xC0, 0x3D, 0xE0, 0x1E, 0xF0,
  0x0F, 0x3C, 0x0F, 0x1F, 0x0F, 0x87, 0xFF, 0x80, 0xFF, 0x00, 0x7F, 0x80,
  0xFF, 0xF0, 0xF8, 0x7C, 0x78, 0x1F, 0x78, 0x07, 0xBC, 0x03, 0xDE, 0x00,
  0xEF, 0x00, 0x7F, 0x80, 0x7B, 0xE0, 0x3D, 0xF8, 0x7E, 0x7F, 0xFE, 0x1F,
  0xFE, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x07, 0xFF, 0x83, 0xFF, 0xF1, 0xF8,
  0x7E, 0x7C, 0x07, 0x9E, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x80, 0x3D, 0xE0, 0x1F, 0x7C, 0x0F, 0x8F, 0xFF, 0xE3,
  0xFF, 0xF8, 0x7F, 0xBC, 0x03, 0x9F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0x78, 0x00, 0x33, 0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x04, 0x7F, 0xFF, 0xFF, 0x7C, 0x0E, 0x3F, 0x3F,
  0x3F, 0x3F, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x1F, 0x3E, 0x3E, 0x3E, 0x3C, 0x7C, 0x78, 0x78, 0x78, 0xF0, 0xF0,
  0x00, 0x01, 0x00, 0x07, 0x00, 0x1F, 0x00, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x3F, 0xC0, 0xFF, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xFE, 0x00,
  0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x1F,
  0x00, 0x03, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0xF8, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x7F, 0x01, 0xFE, 0x07, 0xF8, 0x1F, 0xE0,
  0x7F, 0x80, 0xFE, 0x00, 0xF8, 0x00, 0xE0, 0x00, 0x80, 0x00, 0xFF, 0x07,
  0xFE, 0x3F, 0xF9, 0xFF, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x01, 0xF3, 0xFF, 0x1F, 0xF0, 0xFF, 0x07, 0xC0,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x7E, 0x03, 0xF0, 0x0F, 0x80, 0x03, 0xFE, 0x00, 0xFF, 0xF8, 0x1F,
  0xFF, 0xC3, 0xE0, 0x3E, 0x3C, 0x01, 0xE7, 0x80, 0x0E, 0x70, 0x00, 0xF7,
  0x00, 0x0F, 0x70, 0x00, 0x7F, 0x03, 0xE7, 0xF0, 0x7F, 0x7F, 0x0F, 0xFF,
  0xF0, 0xF0, 0xFF, 0x0E, 0x0F, 0xF0, 0xE0, 0xFF, 0x0E, 0x07, 0xF0, 0xE0,
  0x7F, 0x0E, 0x07, 0xF0, 0xE0, 0x7F, 0x0E, 0x0F, 0xF0, 0xE0, 0xFF, 0x0F,
  0x0F, 0xF0, 0xFF, 0xFF, 0x07, 0xF7, 0x70, 0x3E, 0x77, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xFC, 0x00,
  0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x03, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0x70, 0x01, 0xCE, 0x00,
  0x39, 0xE0, 0x0F, 0x3C, 0x01, 0xE7, 0x80, 0x3C, 0x70, 0x07, 0x0F, 0x01,
  0xE1, 0xE0, 0x3C, 0x3C, 0x07, 0x83, 0x80, 0xE0, 0x78, 0x3C, 0x0F, 0x07,
  0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7, 0x80, 0x78, 0xF0, 0x0F, 0x1E,
  0x00, 0xE7, 0xC0, 0x1E, 0xF0, 0x03, 0xDE, 0x00, 0x7B, 0xC0, 0x0F, 0x80,
  0xFF, 0xF0, 0x7F, 0xFE, 0x3F, 0xFF, 0x9E, 0x0F, 0xEF, 0x01, 0xF7, 0x80,
  0x7B, 0xC0, 0x3D, 0xE0, 0x1E, 0xF0, 0x0F, 0x78, 0x07, 0xBC, 0x07, 0x9F,
  0xFF, 0x8F, 0xFF, 0x87, 0xFF, 0xE3, 0xFF, 0xF9, 0xE0, 0x3E, 0xF0, 0x0F,
  0x78, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0xC0,
  0x3D, 0xE0, 0xFE, 0xFF, 0xFE, 0x7F, 0xFE, 0x3F, 0xFC, 0x00, 0x0F, 0xF0,
  0x1F, 0xFE, 0x1F, 0xFF, 0x8F, 0x87, 0xEF, 0x80, 0xF7, 0x80, 0x7B, 0xC0,
  0x3D, 0xE0, 0x1F, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x01, 0xFF, 0x00, 0xF7, 0x80, 0x7B, 0xE0, 0x3C, 0xF8,
  0x7E, 0x7F, 0xFE, 0x1F, 0xFE, 0x03, 0xFC, 0x00, 0xFF, 0xE0, 0xFF, 0xF8,
  0xFF, 0xFC, 0xFF, 0xFE, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0xFF, 0xF7,
  0xFF, 0xFB, 0xFF, 0xFD, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xF0, 0x1F, 0xFE, 0x1F, 0xFF,
  0x8F, 0x87, 0xEF, 0x80, 0xF7, 0x80, 0x7B, 0xC0, 0x3D, 0xE0, 0x1F, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x8F, 0xFF,
  0xC7, 0xFF, 0xE3, 0xFF, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0xF7, 0x80, 0x7B, 0xE0, 0x3C, 0xF8, 0x7E, 0x7F, 0xFE, 0x1F,
  0xFE, 0x03, 0xFC, 0x00, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x07,
  0xDE, 0x01, 0xE7, 0x80, 0xF9, 0xF8, 0x7E, 0x3F, 0xFF, 0x07, 0xFF, 0x80,
  0x7F, 0x80, 0xF0, 0x07, 0xFC, 0x03, 0xEF, 0x00, 0xF3, 0xC0, 0x7C, 0xF0,
  0x1E, 0x3C, 0x0F, 0x8F, 0x03, 0xC3, 0xC0, 0xF0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x0F, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFF, 0x03,
  0xC3, 0xC0, 0xF0, 0xF8, 0x3C, 0x1E, 0x0F, 0x07, 0xC3, 0xC0, 0xF0, 0xF0,
  0x3E, 0x3C, 0x07, 0x8F, 0x01, 0xF3, 0xC0, 0x3C, 0xF0, 0x0F, 0xBC, 0x01,
  0xEF, 0x00, 0x7C, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0x03, 0xFF, 0xC0, 0xFF, 0xB0, 0x3F, 0xEE, 0x1D, 0xFF, 0x87, 0x7F, 0xE1,
  0xDF, 0xDC, 0x67, 0xF7, 0x3B, 0xFD, 0xCE, 0xFF, 0x3B, 0xBF, 0xCF, 0xCF,
  0xF3, 0xF3, 0xFC, 0x7C, 0xFF, 0x1E, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3C, 0xF8, 0x0F,
  0xFC, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F, 0xFE, 0x0F, 0xEE, 0x0F, 0xEE, 0x0F,
  0xFF, 0x0F, 0xF7, 0x0F, 0xF7, 0x0F, 0xF7, 0x8F, 0xF3, 0x8F, 0xF3, 0x8F,
  0xF3, 0xCF, 0xF1, 0xCF, 0xF1, 0xCF, 0xF1, 0xE7, 0xF0, 0xE7, 0xF0, 0xF7,
  0xF0, 0x77, 0xF0, 0x77, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF0, 0x3F,
  0xF0, 0x1F, 0xF0, 0x1F, 0x0F, 0xF0, 0x3F, 0xFC, 0x7F, 0xFE, 0x7C, 0x3E,
  0xF8, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF8, 0x1F, 0x7C, 0x3E, 0x7F, 0xFE, 0x3F, 0xFC, 0x0F, 0xF0, 0xFF, 0xF0,
  0x3F, 0xFF, 0x0F, 0xFF, 0xF3, 0xFF, 0xFC, 0xF0, 0x0F, 0xBC, 0x01, 0xEF,
  0x00, 0x7B, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xEF, 0x00, 0x7B, 0xC0,
  0x3E, 0xF0, 0x3F, 0x3F, 0xFF, 0xCF, 0xFF, 0xE3, 0xFF, 0xE0, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0xF0, 0x1F, 0xFE, 0x1F, 0xFF, 0x8F, 0x87, 0xCF, 0x81, 0xF7, 0x80, 0x7B,
  0xC0, 0x3D, 0xE0, 0x1E, 0xF0, 0x0F, 0x78, 0x07, 0xBC, 0x03, 0xDE, 0x01,
  0xEF, 0x00, 0xF7, 0x80, 0x7B, 0xC0, 0x3D, 0xE0, 0x1E, 0xF0, 0x0F, 0x78,
  0x07, 0xBC, 0x03, 0xDE, 0x01, 0xEF, 0x00, 0xF7, 0x80, 0x7B, 0xE0, 0x7C,
  0xF8, 0x7E, 0x7F, 0xFE, 0x1F, 0xFE, 0x03, 0xFC, 0x00, 0x0F, 0x00, 0x07,
  0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0,
  0xFF, 0xF0, 0x7F, 0xFE, 0x3F, 0xFF, 0x9F, 0xFF, 0xEF, 0x01, 0xF7, 0x80,
  0x7F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x03, 0xFE,
  0x03, 0xEF, 0xFF, 0xF7, 0xFF, 0xF3, 0xFF, 0xF1, 0xFF, 0xE0, 0xF0, 0xF0,
  0x78, 0x3C, 0x3C, 0x1E, 0x1E, 0x07, 0x8F, 0x03, 0xC7, 0x81, 0xF3, 0xC0,
  0x79, 0xE0, 0x3E, 0xF0, 0x0F, 0x78, 0x07, 0xFC, 0x01, 0xE0, 0x07, 0xFC,
  0x07, 0xFF, 0x83, 0xFF, 0xF0, 0xF8, 0x7E, 0x7C, 0x07, 0x9E, 0x01, 0xE7,
  0x80, 0x79, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFF,
  0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0xFE, 0x00, 0x0F,
  0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0xF0, 0x03, 0xDE, 0x00, 0xF7,
  0x80, 0x79, 0xF8, 0x7E, 0x3F, 0xFF, 0x07, 0xFF, 0x80, 0x7F, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0x7C, 0x3E,
  0x7F, 0xFE, 0x3F, 0xFC, 0x0F, 0xF0, 0xF0, 0x03, 0xFE, 0x00, 0x7B, 0xC0,
  0x0F, 0x7C, 0x01, 0xE7, 0x80, 0x38, 0xF0, 0x0F, 0x1E, 0x01, 0xE3, 0xE0,
  0x3C, 0x3C, 0x07, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x0E, 0x07, 0x81, 0xE0,
  0xE0, 0x3C, 0x3C, 0x07, 0x87, 0x80, 0x70, 0xF0, 0x0F, 0x1C, 0x01, 0xE7,
  0x80, 0x3C, 0xF0, 0x03, 0x9E, 0x00, 0x7B, 0x80, 0x0F, 0x70, 0x01, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xE0,
  0xF0, 0x7E, 0x0F, 0x07, 0xF0, 0xF0, 0x7F, 0x0F, 0x07, 0xF0, 0xF8, 0xFF,
  0x0F, 0x8F, 0xF0, 0xF8, 0xF7, 0x1D, 0x8F, 0x71, 0xD8, 0xE7, 0x19, 0x8E,
  0x71, 0x98, 0xE7, 0x19, 0x8E, 0x79, 0x98, 0xE7, 0x99, 0xCE, 0x79, 0x9C,
  0xE7, 0xB9, 0xDE, 0x3B, 0x8D, 0xE3, 0xB8, 0xDC, 0x3B, 0x0D, 0xC3, 0xB0,
  0xDC, 0x3B, 0x0D, 0xC3, 0xB0, 0xDC, 0x3B, 0x0F, 0xC3, 0xB0, 0xFC, 0x3F,
  0x0F, 0xC1, 0xF0, 0x7C, 0x1E, 0x07, 0x80, 0x78, 0x01, 0xF3, 0xC0, 0x3E,
  0x3E, 0x03, 0xC1, 0xE0, 0x7C, 0x1F, 0x07, 0x80, 0xF0, 0xF0, 0x0F, 0x8F,
  0x00, 0x79, 0xE0, 0x07, 0xDE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x03,
  0xFC, 0x00, 0x3F, 0xE0, 0x07, 0x9E, 0x00, 0xF9, 0xF0, 0x0F, 0x0F, 0x01,
  0xF0, 0x78, 0x1E, 0x07, 0x83, 0xC0, 0x3C, 0x3C, 0x03, 0xE7, 0x80, 0x1E,
  0xF8, 0x01, 0xF0, 0xF0, 0x00, 0xF7, 0x80, 0x1E, 0x78, 0x01, 0xE3, 0xC0,
  0x3C, 0x3C, 0x03, 0xC1, 0xE0, 0x7C, 0x1E, 0x07, 0x80, 0xF0, 0x78, 0x0F,
  0x0F, 0x00, 0x78, 0xF0, 0x07, 0x9E, 0x00, 0x3D, 0xE0, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x3E, 0x00,
  0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03,
  0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xC0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xF0,
  0x0F, 0x70, 0x0E, 0x70, 0x1E, 0x78, 0x1C, 0x38, 0x3C, 0x3C, 0x3C, 0x1C,
  0x78, 0x1E, 0x78, 0x0E, 0x70, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xF8, 0x1E, 0x0F, 0x83, 0xE0, 0xF8, 0x00, 0xE0, 0x07,
  0xFE, 0x07, 0xFF, 0x87, 0xFF, 0xE3, 0xC0, 0xFB, 0xC0, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x87, 0xFF, 0xCF, 0xFF, 0xEF, 0xFF, 0xF7, 0x80,
  0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF8, 0x0F, 0xBC, 0x0F, 0xDF,
  0xFF, 0xE7, 0xFE, 0xF1, 0xFE, 0x78, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0xE0, 0xF3, 0xFC, 0xF7, 0xFE,
  0xFF, 0xFE, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF8, 0x1F, 0xFC, 0x3F, 0xFF, 0xFE, 0xF7, 0xFC, 0xF3, 0xF8,
  0x03, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0x7C, 0x1F, 0xF8, 0x0F,
  0xF0, 0x0F, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F, 0x7C, 0x3F,
  0x7F, 0xFE, 0x3F, 0xFC, 0x0F, 0xF0, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x07, 0x0F, 0x1F, 0xCF, 0x3F, 0xEF,
  0x7F, 0xFF, 0xF8, 0x3F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF8, 0x1F, 0x7C, 0x3F, 0x7F, 0xFF, 0x3F, 0xEF, 0x1F, 0xCF,
  0x03, 0xC0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0x78, 0x1F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x0F, 0x7C, 0x1F,
  0x7F, 0xFE, 0x3F, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x7F, 0xF0, 0x1F,
  0xFC, 0x0F, 0xFF, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x1F, 0xEF, 0x3F,
  0xEF, 0x7F, 0xFF, 0xF8, 0x3F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8,
  0x1F, 0xF8, 0x1F, 0x7F, 0xFF, 0x3F, 0xEF, 0x1F, 0xEF, 0x07, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x1F, 0xFE, 0x1F, 0xFE, 0x1F,
  0xFC, 0x1F, 0xC0, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0xE0, 0xF3, 0xFC, 0xF7, 0xFE, 0xFF, 0xFE, 0xFC,
  0x1F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x01, 0xC0, 0x00,
  0xF8, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x38, 0x01, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF7, 0xFF, 0xDF, 0xFF,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x7E, 0xFF,
  0xF3, 0xFF, 0x8F, 0xFC, 0x3F, 0x80, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x1E,
  0xF0, 0x0F, 0xBC, 0x07, 0xCF, 0x01, 0xE3, 0xC0, 0xF8, 0xF0, 0x7C, 0x3C,
  0x1E, 0x0F, 0x0F, 0x83, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0x0F,
  0x83, 0xC1, 0xE0, 0xF0, 0x7C, 0x3C, 0x0F, 0x0F, 0x03, 0xE3, 0xC0, 0x7C,
  0xF0, 0x0F, 0x3C, 0x03, 0xEF, 0x00, 0x7C, 0xFF, 0xE0, 0x0F, 0xFE, 0x00,
  0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0x00, 0x3F, 0xF0, 0x03, 0x06, 0x3F, 0xF7, 0xEF, 0xFD, 0xFB, 0xE7, 0xCF,
  0xF1, 0xE3, 0xFC, 0x38, 0xFF, 0x0E, 0x3F, 0xC3, 0x8F, 0xF0, 0xE3, 0xFC,
  0x38, 0xFF, 0x0E, 0x3F, 0xC3, 0x8F, 0xF0, 0xE3, 0xFC, 0x38, 0xFF, 0x0E,
  0x3F, 0xC3, 0x8F, 0xF0, 0xE3, 0xFC, 0x38, 0xFF, 0x0E, 0x3F, 0xC3, 0x8F,
  0xF0, 0xE3, 0xC0, 0x00, 0xE0, 0xF3, 0xFC, 0xF7, 0xFE, 0xFF, 0xFE, 0xFC,
  0x1F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x03, 0xC0, 0x1F,
  0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0x7C, 0x1F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0x7C, 0x3E, 0x7F, 0xFE, 0x3F,
  0xFC, 0x0F, 0xF0, 0x00, 0xE0, 0xF3, 0xFC, 0xF7, 0xFE, 0xFF, 0xFE, 0xFC,
  0x1F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8,
  0x1F, 0xFC, 0x3F, 0xF7, 0xFE, 0xF7, 0xFC, 0xF3, 0xF8, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x07,
  0x00, 0x1F, 0xCF, 0x3F, 0xEF, 0x7F, 0xFF, 0xF8, 0x3F, 0xF8, 0x1F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0x7C, 0x3F, 0x7F,
  0xFF, 0x3F, 0xEF, 0x1F, 0xCF, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0xE0, 0xF7, 0xF8, 0xFF,
  0xFC, 0xFF, 0xFE, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0x07, 0xE0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xE7, 0x80, 0xF7,
  0x80, 0x7B, 0xC0, 0x00, 0xF0, 0x00, 0x7E, 0x00, 0x3F, 0xF8, 0x0F, 0xFF,
  0x01, 0xFF, 0xC0, 0x07, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0xF0,
  0x0F, 0x7C, 0x0F, 0x9F, 0xFF, 0xC7, 0xFF, 0xC1, 0xFF, 0x80, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0xFE, 0x07,
  0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF8, 0x1F, 0x7C, 0x3E, 0x3F, 0xFE, 0x3F, 0xFC, 0x0F, 0xF0, 0xF0, 0x03,
  0xFC, 0x00, 0xF7, 0x80, 0x3D, 0xE0, 0x1E, 0x78, 0x07, 0x8F, 0x01, 0xE3,
  0xC0, 0xF0, 0xF0, 0x3C, 0x1E, 0x0F, 0x07, 0x87, 0x81, 0xE1, 0xE0, 0x3C,
  0x78, 0x0F, 0x3C, 0x03, 0xCF, 0x00, 0x7B, 0xC0, 0x1E, 0xE0, 0x07, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0xF0, 0xF0, 0x7F, 0x0F, 0x07,
  0xF0, 0xF0, 0xF7, 0x0F, 0x0F, 0x70, 0xF8, 0xE7, 0x0D, 0x8E, 0x71, 0xD8,
  0xE7, 0x99, 0x8E, 0x79, 0x98, 0xE3, 0x99, 0x9E, 0x39, 0x99, 0xC3, 0x99,
  0xDC, 0x3B, 0x8D, 0xC3, 0xB0, 0xDC, 0x3B, 0x0D, 0xC3, 0xF0, 0xDC, 0x1F,
  0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0x78, 0xF8, 0x07, 0xCF,
  0x81, 0xF0, 0xF0, 0x3C, 0x0F, 0x0F, 0x81, 0xF1, 0xE0, 0x1E, 0x78, 0x01,
  0xFF, 0x00, 0x3F, 0xC0, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03,
  0xFC, 0x00, 0x7F, 0xC0, 0x1E, 0x78, 0x07, 0xCF, 0x80, 0xF0, 0xF8, 0x3C,
  0x0F, 0x0F, 0x81, 0xF1, 0xE0, 0x1F, 0x78, 0x01, 0xF0, 0xF0, 0x03, 0xFF,
  0x00, 0x79, 0xE0, 0x1E, 0x3E, 0x03, 0xC3, 0xC0, 0x78, 0x78, 0x1E, 0x0F,
  0x83, 0xC0, 0xF0, 0xF8, 0x1E, 0x1E, 0x01, 0xE3, 0xC0, 0x3C, 0xF8, 0x07,
  0x9E, 0x00, 0x7B, 0xC0, 0x0F, 0x70, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0xFF,
  0x00, 0xFF, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xE0, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xE0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0x7F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x00,
  0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xFF, 0x00, 0xFF, 0x03, 0xFF,
  0x07, 0xFF, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80,
  0xFF, 0x80, 0xFF, 0x00, 0xFE, 0x00, 0xF8, 0x00, 0x1F, 0x01, 0xDF, 0xE0,
  0x77, 0xFC, 0x1F, 0xCF, 0x8F, 0xF1, 0xF3, 0xFC, 0x3F, 0xFF, 0x07, 0xFB,
  0xC0, 0xFC,
};

const GFXglyph JetBrainsMono_Medium37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 6, 27, 22, 8, -27 },
  { 22, 12, 11, 22, 5, -27 },
  { 39, 20, 27, 22, 1, -27 },
  { 107, 18, 37, 22, 2, -32 },
  { 191, 22, 27, 22, 0, -27 },
  { 266, 19, 27, 22, 2, -27 },
  { 331, 4, 11, 22, 9, -27 },
  { 337, 11, 35, 22, 7, -31 },
  { 386, 12, 35, 22, 4, -31 },
  { 439, 20, 20, 22, 1, -23 },
  { 489, 18, 18, 22, 2, -21 },
  { 530, 8, 12, 22, 6, -6 },
  { 542, 12, 4, 22, 5, -14 },
  { 548, 6, 6, 22, 8, -6 },
  { 553, 17, 35, 22, 3, -31 },
  { 628, 16, 27, 22, 3, -27 },
  { 682, 17, 27, 22, 3, -27 },
  { 740, 18, 27, 22, 2, -27 },
  { 801, 17, 27, 22, 2, -27 },
  { 859, 16, 27, 22, 3, -27 },
  { 913, 16, 27, 22, 3, -27 },
  { 967, 18, 27, 22, 2, -27 },
  { 1028, 17, 27, 22, 3, -27 },
  { 1086, 17, 27, 22, 3, -27 },
  { 1144, 18, 27, 22, 2, -27 },
  { 1205, 6, 21, 22, 8, -21 },
  { 1221, 8, 27, 22, 6, -21 },
  { 1248, 16, 20, 22, 3, -22 },
  { 1288, 16, 13, 22, 3, -19 },
  { 1314, 16, 20, 22, 3, -22 },
  { 1354, 13, 27, 22, 5, -27 },
  { 1398, 20, 34, 22, 1, -27 },
  { 1483, 19, 27, 22, 2, -27 },
  { 1548, 17, 27, 22, 3, -27 },
  { 1606, 17, 27, 22, 3, -27 },
  { 1664, 16, 27, 22, 3, -27 },
  { 1718, 16, 27, 22, 3, -27 },
  { 1772, 17, 27, 22, 3, -27 },
  { 1830, 17, 27, 22, 3, -27 },
  { 1888, 16, 27, 22, 3, -27 },
  { 1942, 15, 27, 22, 4, -27 },
  { 1993, 18, 27, 22, 1, -27 },
  { 2054, 18, 27, 22, 3, -27 },
  { 2115, 16, 27, 22, 4, -27 },
  { 2169, 18, 27, 22, 2, -27 },
  { 2230, 16, 27, 22, 3, -27 },
  { 2284, 16, 27, 22, 3, -27 },
  { 2338, 18, 27, 22, 3, -27 },
  { 2399, 17, 34, 22, 3, -27 },
  { 2472, 17, 27, 22, 3, -27 },
  { 2530, 18, 27, 22, 2, -27 },
  { 2591, 18, 27, 22, 2, -27 },
  { 2652, 16, 27, 22, 3, -27 },
  { 2706, 19, 27, 22, 2, -27 },
  { 2771, 20, 27, 22, 1, -27 },
  { 2839, 20, 27, 22, 1, -27 },
  { 2907, 20, 27, 22, 1, -27 },
  { 2975, 16, 27, 22, 3, -27 },
  { 3029, 10, 35, 22, 7, -31 },
  { 3073, 18, 35, 22, 2, -31 },
  { 3152, 10, 35, 22, 5, -31 },
  { 3196, 16, 14, 22, 3, -27 },
  { 3224, 18, 3, 22, 2, 1 },
  { 3231, 9, 5, 22, 6, -29 },
  { 3237, 17, 21, 22, 2, -21 },
  { 3282, 16, 27, 22, 3, -27 },
  { 3336, 16, 21, 22, 3, -21 },
  { 3378, 16, 27, 22, 3, -27 },
  { 3432, 16, 21, 22, 3, -21 },
  { 3474, 18, 27, 22, 2, -27 },
  { 3535, 16, 28, 22, 3, -21 },
  { 3591, 16, 27, 22, 3, -27 },
  { 3645, 18, 29, 22, 3, -29 },
  { 3711, 14, 36, 22, 3, -29 },
  { 3774, 18, 27, 22, 3, -27 },
  { 3835, 20, 27, 22, 1, -27 },
  { 3903, 18, 21, 22, 2, -21 },
  { 3951, 16, 21, 22, 3, -21 },
  { 3993, 16, 21, 22, 3, -21 },
  { 4035, 16, 28, 22, 3, -21 },
  { 4091, 16, 28, 22, 3, -21 },
  { 4147, 16, 21, 22, 4, -21 },
  { 4189, 17, 21, 22, 3, -21 },
  { 4234, 17, 26, 22, 2, -26 },
  { 4290, 16, 20, 22, 3, -20 },
  { 4330, 18, 20, 22, 2, -20 },
  { 4375, 20, 20, 22, 1, -20 },
  { 4425, 19, 20, 22, 2, -20 },
  { 4473, 19, 27, 22, 2, -20 },
  { 4538, 16, 20, 22, 3, -20 },
  { 4578, 16, 35, 22, 3, -31 },
  { 4648, 4, 35, 22, 9, -31 },
  { 4666, 16, 35, 22, 3, -31 },
  { 4736, 18, 8, 22, 2, -17 },
};

const GFXfont JetBrainsMono_Medium37pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Medium37pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Medium37pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _JETBRAINSMONO_MEDIUM37PT7B_H_
