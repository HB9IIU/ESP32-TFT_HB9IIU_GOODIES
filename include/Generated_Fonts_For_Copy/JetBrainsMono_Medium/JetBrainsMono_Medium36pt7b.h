#ifndef _JETBRAINSMONO_MEDIUM36PT7B_H_
#define _JETBRAINSMONO_MEDIUM36PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Medium.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Medium36pt7bBitmaps[] PROGMEM = {
  0x00, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xC7,
  0x1C, 0x71, 0xC0, 0x00, 0x00, 0x0F, 0xBF, 0xFD, 0xE0, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xEF, 0x0E, 0xF0, 0xEF, 0x0E,
  0xF0, 0xE0, 0x03, 0x81, 0xC0, 0x70, 0x30, 0x0E, 0x0E, 0x01, 0xC1, 0xC0,
  0x38, 0x38, 0x06, 0x07, 0x01, 0xC0, 0xE3, 0xFF, 0xFF, 0x7F, 0xFF, 0xE0,
  0xE0, 0xE0, 0x1C, 0x1C, 0x07, 0x03, 0x80, 0xE0, 0x60, 0x1C, 0x1C, 0x03,
  0x83, 0x80, 0x70, 0x70, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x0E,
  0x0E, 0x01, 0xC1, 0xC0, 0x38, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0xE0, 0x38,
  0x38, 0x07, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x1E, 0x00, 0x7F, 0xE0, 0x7F, 0xF8, 0x7F, 0xFE, 0x3C, 0xCF, 0x3C,
  0x63, 0xDE, 0x31, 0xEF, 0x18, 0x07, 0x8C, 0x03, 0xC6, 0x01, 0xF3, 0x00,
  0x7F, 0x80, 0x1F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x1F, 0xE0, 0x0D,
  0xF8, 0x06, 0x7C, 0x03, 0x1E, 0x01, 0x8F, 0xF0, 0xC7, 0xF8, 0x63, 0xDE,
  0x31, 0xEF, 0xDB, 0xE3, 0xFF, 0xF0, 0xFF, 0xF0, 0x3F, 0xE0, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x3F, 0x80, 0x3B,
  0xFE, 0x03, 0x9C, 0x70, 0x3C, 0xE1, 0xC1, 0xCE, 0x0E, 0x1C, 0x70, 0x71,
  0xC3, 0x83, 0x8E, 0x0E, 0x1C, 0xE0, 0x71, 0xEE, 0x03, 0xFE, 0x70, 0x0F,
  0xE7, 0x00, 0x08, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x8F,
  0x00, 0x39, 0xFE, 0x01, 0xDF, 0xF0, 0x1C, 0xE1, 0xC1, 0xC7, 0x0E, 0x0E,
  0x38, 0x70, 0xE1, 0xC3, 0x8E, 0x0E, 0x1C, 0x70, 0x70, 0xE7, 0x03, 0xFF,
  0x70, 0x0F, 0xF7, 0x80, 0x3F, 0x00, 0x03, 0xC0, 0x01, 0xFE, 0x00, 0x7F,
  0xF0, 0x1F, 0xFE, 0x03, 0xC1, 0xE0, 0xF0, 0x3C, 0x1E, 0x07, 0x81, 0xC0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xF0,
  0x00, 0xFF, 0x00, 0x3F, 0xF0, 0xF7, 0x9E, 0x1E, 0xF1, 0xE7, 0x9E, 0x1E,
  0xF3, 0xC3, 0xFC, 0x78, 0x3F, 0x0F, 0x03, 0xE1, 0xE0, 0x7C, 0x3C, 0x0F,
  0x87, 0xC3, 0xF8, 0x7F, 0xF7, 0x8F, 0xFC, 0xF0, 0x7F, 0x0F, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xEE, 0xE0, 0x00, 0x60, 0x3C, 0x0F, 0x83, 0xF0, 0xF8,
  0x3E, 0x0F, 0x81, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x03, 0xC0, 0x78, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xF0, 0x3F, 0x03, 0xF8,
  0x3F, 0x01, 0xE0, 0x0C, 0xC0, 0x1E, 0x03, 0xF0, 0x7F, 0x01, 0xF0, 0x1F,
  0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x03, 0xE0, 0xF8, 0x3E, 0x3F, 0x87, 0xE0,
  0xF8, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0E, 0x00, 0xC1, 0xC1, 0x9F, 0x38, 0xFF, 0xF3, 0x7F, 0x7F, 0xFF,
  0xE1, 0xFF, 0xE0, 0x03, 0x80, 0x00, 0xFC, 0x00, 0x3B, 0xC0, 0x0F, 0x3C,
  0x03, 0xC7, 0x80, 0x78, 0x78, 0x1E, 0x0F, 0x81, 0xC0, 0xE0, 0x10, 0x10,
  0x00, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0x3F, 0x3E, 0x3E, 0x3C, 0x7C, 0x78, 0x78, 0x70, 0xF0, 0xF0,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7B, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03,
  0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0x80, 0x1F, 0xF0, 0x3F, 0xFC, 0x7F, 0xFE, 0xF8, 0x3E, 0xF0,
  0x1F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE1,
  0x0F, 0xE3, 0xCF, 0xE3, 0xCF, 0xE3, 0xCF, 0xE3, 0x8F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1E, 0x7C,
  0x3E, 0x7F, 0xFC, 0x3F, 0xF8, 0x0F, 0xF0, 0x07, 0xE0, 0x07, 0xF0, 0x0F,
  0xF8, 0x0F, 0xFC, 0x0F, 0x9E, 0x07, 0x8F, 0x03, 0x87, 0x81, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x81, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x01, 0xE0, 0x07, 0xFC, 0x07, 0xFF, 0x87, 0xFF, 0xC7,
  0xC1, 0xF3, 0xC0, 0x79, 0xE0, 0x1F, 0xE0, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF,
  0xE0, 0x7F, 0xFF, 0x3F, 0xFF, 0x9F, 0xFF, 0xC0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xFE,
  0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7B, 0xC0, 0x79,
  0xF0, 0x7C, 0x7F, 0xFC, 0x1F, 0xFC, 0x07, 0xFC, 0x00, 0x00, 0x7C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xE0, 0xF7, 0xC1, 0xFF, 0x03, 0xFC,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x7F, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFE, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF3, 0xF8, 0xF7, 0xFC, 0xFF, 0xFE, 0xFC, 0x3E,
  0xF8, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x1E, 0xF8, 0x3E, 0x7F, 0xFC, 0x3F, 0xF8,
  0x0F, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F,
  0x7F, 0x07, 0xFF, 0xC7, 0xFF, 0xF3, 0xE0, 0xF9, 0xE0, 0x3F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF8, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xF7, 0x80, 0x7B, 0xC0,
  0x7D, 0xF8, 0x7C, 0x7F, 0xFE, 0x1F, 0xFC, 0x03, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1E,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78,
  0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0,
  0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00,
  0x1F, 0x00, 0x03, 0xC0, 0x1F, 0xF0, 0x3F, 0xFC, 0x7F, 0xFE, 0x78, 0x3E,
  0xF0, 0x1E, 0xF0, 0x0E, 0xF0, 0x0F, 0xF0, 0x1E, 0x78, 0x1E, 0x78, 0x3E,
  0x3E, 0x7C, 0x1F, 0xF8, 0x0F, 0xE0, 0x1F, 0xF8, 0x3E, 0x7C, 0x78, 0x3E,
  0xF0, 0x1E, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F,
  0xFC, 0x3E, 0x7F, 0xFE, 0x3F, 0xFC, 0x1F, 0xF0, 0x01, 0xE0, 0x07, 0xFC,
  0x07, 0xFF, 0x87, 0xFF, 0xE7, 0xC0, 0xF3, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x03, 0xF8, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0xF7, 0x80, 0xFB,
  0xF0, 0xFC, 0xFF, 0xFC, 0x3F, 0xDE, 0x07, 0xDE, 0x00, 0x1F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x7B, 0xFF, 0xFF, 0xF8, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0xFF, 0xFF, 0xFE, 0x1E, 0x3F, 0x3F,
  0x3F, 0x3E, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x3E, 0x3E, 0x3C, 0x7C, 0x78, 0x78, 0x78, 0xF0, 0xF0, 0xE0, 0x00,
  0x01, 0x00, 0x07, 0x00, 0x1F, 0x00, 0x7F, 0x01, 0xFE, 0x07, 0xF8, 0x1F,
  0xE0, 0x7F, 0x80, 0xFC, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x00,
  0x07, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x00,
  0x0F, 0x00, 0x3F, 0x00, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x80, 0xFE,
  0x00, 0xF8, 0x00, 0xE0, 0x00, 0x80, 0x00, 0xFF, 0x07, 0xFE, 0x3F, 0xF8,
  0x0F, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x3C, 0x0F, 0xE3, 0xFE, 0x1F, 0xE0, 0xFC, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x0F, 0xC0, 0x7E, 0x01,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0xFF, 0xC0, 0x3F, 0xFE, 0x0F, 0xC7, 0xE3,
  0xC0, 0x3C, 0xF0, 0x03, 0xDE, 0x00, 0x3B, 0x80, 0x07, 0x70, 0x00, 0xFE,
  0x03, 0x1F, 0xC1, 0xFB, 0xF8, 0x7F, 0xFF, 0x0F, 0x1F, 0xE1, 0xC1, 0xFC,
  0x78, 0x3F, 0x8F, 0x07, 0xF1, 0xE0, 0xFE, 0x3C, 0x1F, 0xC7, 0x83, 0xF8,
  0xF0, 0x7F, 0x1E, 0x0F, 0xE1, 0xC3, 0xFC, 0x3F, 0xFF, 0x83, 0xFF, 0xF0,
  0x3C, 0xEE, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0x78, 0x01, 0xDE, 0x00, 0x73,
  0x80, 0x3C, 0xE0, 0x0F, 0x3C, 0x03, 0x8F, 0x01, 0xE3, 0xC0, 0x78, 0x70,
  0x1E, 0x1E, 0x07, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x38, 0x3F, 0xFF, 0x0F,
  0xFF, 0xC7, 0xFF, 0xF1, 0xE0, 0x1C, 0x78, 0x07, 0x9E, 0x01, 0xEF, 0x00,
  0x7B, 0xC0, 0x0E, 0xF0, 0x03, 0xFC, 0x00, 0xF0, 0xFF, 0xF0, 0xFF, 0xFC,
  0xFF, 0xFE, 0xF0, 0x3E, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x1E, 0xF0, 0x7C, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xFC,
  0xF0, 0x3E, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x7E, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF0,
  0x01, 0x80, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0x78, 0x3E, 0xF0, 0x1F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0x7C, 0x3E,
  0x7F, 0xFC, 0x3F, 0xFC, 0x0F, 0xF0, 0xFF, 0xE0, 0xFF, 0xF8, 0xFF, 0xFC,
  0xF0, 0x7E, 0xF0, 0x1E, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F,
  0xF0, 0x3E, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFE, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x01, 0x80, 0x1F, 0xF8, 0x3F, 0xFC,
  0x7F, 0xFE, 0x78, 0x3E, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF1, 0xFF, 0xF1, 0xFF,
  0xF1, 0xFF, 0xF1, 0xFF, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF8, 0x1F, 0x7C, 0x3E, 0x7F, 0xFC, 0x3F, 0xFC, 0x0F, 0xF0,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xF7, 0x80, 0x7B, 0xC0,
  0x7D, 0xF8, 0x7C, 0x7F, 0xFC, 0x1F, 0xFC, 0x07, 0xFC, 0x00, 0xF0, 0x0F,
  0xF8, 0x07, 0xBC, 0x07, 0xDE, 0x03, 0xCF, 0x03, 0xE7, 0x81, 0xE3, 0xC1,
  0xF1, 0xE0, 0xF0, 0xF0, 0xF8, 0x78, 0x78, 0x3C, 0x7C, 0x1F, 0xFC, 0x0F,
  0xFE, 0x07, 0xFF, 0x03, 0xC7, 0xC1, 0xE1, 0xE0, 0xF0, 0xF8, 0x78, 0x3C,
  0x3C, 0x1F, 0x1E, 0x07, 0x8F, 0x03, 0xE7, 0x80, 0xF3, 0xC0, 0x7D, 0xE0,
  0x1E, 0xF0, 0x0F, 0xF8, 0x03, 0xC0, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0x0F, 0xFE, 0x07, 0xFF,
  0x03, 0x7D, 0x83, 0xFE, 0xE1, 0xFF, 0x70, 0xDF, 0xB8, 0xEF, 0xEE, 0x77,
  0xF7, 0x3B, 0xFB, 0x99, 0xFC, 0xDC, 0xFE, 0x7E, 0x7F, 0x3E, 0x3F, 0x8F,
  0x1F, 0xC7, 0x8F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xC0, 0xF8, 0x0F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F, 0xFC,
  0x0F, 0xEE, 0x0F, 0xEE, 0x0F, 0xEF, 0x0F, 0xE7, 0x0F, 0xE7, 0x0F, 0xE7,
  0x8F, 0xF3, 0x8F, 0xF3, 0x8F, 0xF3, 0xCF, 0xF1, 0xCF, 0xF1, 0xCF, 0xF1,
  0xEF, 0xF0, 0xEF, 0xF0, 0xEF, 0xF0, 0x7F, 0xF0, 0x7F, 0xF0, 0x7F, 0xF0,
  0x3F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF0, 0x1F, 0x03, 0x80, 0x1F, 0xF0, 0x3F,
  0xFC, 0x7F, 0xFE, 0x78, 0x3E, 0xF0, 0x1E, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF8, 0x1E, 0x7C, 0x3E, 0x7F, 0xFC, 0x3F, 0xF8, 0x0F,
  0xF0, 0xFF, 0xF8, 0x7F, 0xFE, 0x3F, 0xFF, 0x9E, 0x07, 0xEF, 0x00, 0xF7,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x03,
  0xFE, 0x03, 0xEF, 0xFF, 0xF7, 0xFF, 0xF3, 0xFF, 0xE1, 0xFF, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x1F,
  0xF0, 0x3F, 0xFC, 0x7F, 0xFE, 0xF8, 0x3E, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1E, 0x7C, 0x3E, 0x7F, 0xFC, 0x3F,
  0xF8, 0x0F, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x1F, 0xFF, 0xF0, 0x7F, 0xFE, 0x3F, 0xFF, 0x9E, 0x07, 0xEF,
  0x00, 0xF7, 0x80, 0x7B, 0xC0, 0x3D, 0xE0, 0x0E, 0xF0, 0x0F, 0x78, 0x07,
  0xBC, 0x07, 0xDE, 0x07, 0xCF, 0xFF, 0xE7, 0xFF, 0xE3, 0xFF, 0xC1, 0xE1,
  0xE0, 0xF0, 0xF0, 0x78, 0x3C, 0x3C, 0x1E, 0x1E, 0x07, 0x8F, 0x03, 0xC7,
  0x81, 0xF3, 0xC0, 0x79, 0xE0, 0x3E, 0xF0, 0x0F, 0x78, 0x07, 0xC0, 0x01,
  0xC0, 0x07, 0xFE, 0x07, 0xFF, 0x87, 0xFF, 0xE3, 0xC0, 0xF3, 0xC0, 0x3D,
  0xE0, 0x1E, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xE0,
  0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x01, 0xFE, 0x00, 0x1F, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3D, 0xE0, 0x1E,
  0xFC, 0x3E, 0x3F, 0xFF, 0x0F, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x1F, 0xF8, 0x1E, 0x7C, 0x3E, 0x7F, 0xFC, 0x3F, 0xF8, 0x0F, 0xF0,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x79, 0xC0, 0x1E, 0x78, 0x07, 0x9E,
  0x01, 0xE7, 0x80, 0x70, 0xE0, 0x3C, 0x3C, 0x0F, 0x0F, 0x03, 0xC3, 0xC0,
  0xE0, 0x70, 0x78, 0x1E, 0x1E, 0x07, 0x87, 0x81, 0xE1, 0xC0, 0x38, 0xF0,
  0x0F, 0x3C, 0x03, 0xCF, 0x00, 0xF3, 0x80, 0x1D, 0xE0, 0x07, 0x78, 0x01,
  0xFE, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0xE0,
  0xF0, 0xFE, 0x0F, 0x0F, 0xF0, 0xF0, 0xFF, 0x0F, 0x0E, 0xF1, 0xF0, 0xEF,
  0x1F, 0x0E, 0xF1, 0xB0, 0xE7, 0x1B, 0x8E, 0x71, 0xB8, 0xE7, 0x19, 0x9E,
  0x71, 0x99, 0xE7, 0x19, 0x9E, 0x71, 0x99, 0xC7, 0xB9, 0x9C, 0x7B, 0x99,
  0xC7, 0xB1, 0x9C, 0x3B, 0x1D, 0xC3, 0xB1, 0xDC, 0x3B, 0x0D, 0xC3, 0xB0,
  0xDC, 0x3B, 0x0F, 0xC3, 0xF0, 0xF8, 0x3F, 0x0F, 0x83, 0xE0, 0xF8, 0x3E,
  0x0F, 0x81, 0xE0, 0xF8, 0x78, 0x03, 0xE7, 0x80, 0x78, 0xF0, 0x1E, 0x0F,
  0x03, 0xC1, 0xF0, 0xF0, 0x1E, 0x1E, 0x03, 0xE7, 0x80, 0x3C, 0xF0, 0x07,
  0xBC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x00, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xE0, 0x07, 0xBC, 0x00, 0xF3, 0xC0, 0x3C,
  0x78, 0x07, 0x87, 0x81, 0xE0, 0xF0, 0x3C, 0x0F, 0x0F, 0x01, 0xE1, 0xE0,
  0x1E, 0x78, 0x03, 0xFF, 0x00, 0x3C, 0xF0, 0x01, 0xF7, 0x80, 0x1E, 0x78,
  0x03, 0xC3, 0xC0, 0x3C, 0x3C, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x0F, 0x00,
  0xF0, 0xF0, 0x0F, 0x0E, 0x00, 0x79, 0xE0, 0x07, 0x9C, 0x00, 0x3B, 0xC0,
  0x03, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00,
  0x7C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x0F, 0xE0, 0x0E, 0x70,
  0x1E, 0x70, 0x1C, 0x78, 0x3C, 0x38, 0x38, 0x3C, 0x38, 0x1C, 0x78, 0x1C,
  0x70, 0x1E, 0xF0, 0x0E, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xF8, 0x3C, 0x3E, 0x1E, 0x0F, 0x07, 0xF8, 0x07, 0xFE, 0x0F, 0xFF,
  0x87, 0xC3, 0xE7, 0x80, 0xF3, 0xC0, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x03,
  0xFF, 0x8F, 0xFF, 0xDF, 0xFF, 0xEF, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x1F, 0xE0, 0x1F, 0xF8, 0x1F, 0xBF, 0xFB, 0xCF, 0xFD, 0xE3, 0xFC,
  0xF0, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF3, 0xF0, 0xF7, 0xFC, 0xFF, 0xFC, 0xFC, 0x3E, 0xF8, 0x1E, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x1E, 0xFC, 0x3E, 0xFF,
  0xFE, 0xF7, 0xFC, 0xF3, 0xF8, 0x0F, 0xF0, 0x3F, 0xF8, 0x7F, 0xFC, 0x7C,
  0x3E, 0xF8, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8,
  0x1F, 0x7C, 0x3E, 0x7F, 0xFE, 0x3F, 0xFC, 0x0F, 0xF0, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x1F, 0x8F, 0x3F,
  0xEF, 0x7F, 0xEF, 0x7C, 0x7F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xFC, 0x3F, 0x7F, 0xEF, 0x3F, 0xEF, 0x1F,
  0xCF, 0x0F, 0xE0, 0x3F, 0xF8, 0x7F, 0xFC, 0x78, 0x3E, 0xF0, 0x1E, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x0F, 0x78, 0x1E, 0x7F,
  0xFE, 0x3F, 0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xE0,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0x1F, 0x8F, 0x3F, 0xEF, 0x7F, 0xEF, 0x7C, 0x7F, 0xF8, 0x1F, 0xF0,
  0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF8, 0x3F, 0x7F, 0xFF, 0x7F, 0xEF, 0x3F,
  0xCF, 0x0F, 0x8F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x1F,
  0xFE, 0x1F, 0xFC, 0x1F, 0xF8, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF3, 0xF0, 0xF7, 0xFC, 0xFF, 0xFC, 0xFC,
  0x3E, 0xF8, 0x1E, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x03, 0xC0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x78, 0x03,
  0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xF9, 0xFF, 0xE7, 0xFF, 0x9F, 0xFE, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x03, 0xE0, 0x1F, 0x3F, 0xFC, 0xFF, 0xE3, 0xFE, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x1F,
  0xE0, 0x1E, 0xF0, 0x1F, 0x78, 0x0F, 0x3C, 0x0F, 0x1E, 0x0F, 0x8F, 0x07,
  0x87, 0x87, 0x83, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF8, 0x3C,
  0x3E, 0x1E, 0x0F, 0x0F, 0x07, 0xC7, 0x81, 0xE3, 0xC0, 0x79, 0xE0, 0x3E,
  0xF0, 0x0F, 0x78, 0x07, 0xC0, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x7F, 0xF8,
  0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x07, 0xFC, 0xE7, 0x9F, 0x77, 0xEF, 0xFB,
  0xFF, 0xFE, 0x3C, 0x7F, 0x1C, 0x3F, 0x8E, 0x1F, 0xC7, 0x0F, 0xE3, 0x87,
  0xF1, 0xC3, 0xF8, 0xE1, 0xFC, 0x70, 0xFE, 0x38, 0x7F, 0x1C, 0x3F, 0x8E,
  0x1F, 0xC7, 0x0F, 0xE3, 0x87, 0xF1, 0xC3, 0xF8, 0xE1, 0xFC, 0x70, 0xFE,
  0x38, 0x70, 0xF3, 0xF0, 0xF7, 0xFC, 0xFF, 0xFC, 0xFC, 0x7E, 0xF8, 0x1E,
  0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x0F, 0xE0, 0x3F, 0xF8, 0x7F, 0xFC,
  0x7C, 0x7E, 0xF8, 0x1E, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x1E, 0x7C, 0x3E, 0x7F, 0xFC, 0x3F, 0xF8, 0x0F, 0xF0, 0xF3, 0xF0,
  0xF7, 0xFC, 0xFF, 0xFE, 0xFC, 0x3E, 0xF8, 0x1E, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x1E, 0xFC, 0x3E, 0xFF, 0xFE, 0xF7, 0xFC,
  0xF3, 0xF8, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x1F, 0x8F, 0x3F, 0xEF, 0x7F, 0xEF, 0x7C, 0x7F, 0xF8, 0x1F,
  0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xFC, 0x3F,
  0x7F, 0xEF, 0x3F, 0xEF, 0x1F, 0xCF, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0xE3, 0xF0, 0xE7, 0xF8, 0xEF, 0xFC,
  0xFC, 0x7E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x0F, 0xF0,
  0x3F, 0xFC, 0x7F, 0xFE, 0x7C, 0x3E, 0xF0, 0x0F, 0xF0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x7F, 0xC0, 0x3F, 0xF8, 0x1F, 0xFE, 0x01, 0xFE, 0x00, 0x1F,
  0x00, 0x0F, 0x00, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0x7F, 0xFE, 0x3F, 0xFC,
  0x1F, 0xF8, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1F,
  0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x1E, 0xF8, 0x1E, 0x7C, 0x3E, 0x7F, 0xFC, 0x3F, 0xF8, 0x0F, 0xF0,
  0xF0, 0x03, 0xFC, 0x00, 0xEF, 0x00, 0x79, 0xE0, 0x1E, 0x78, 0x07, 0x9E,
  0x03, 0xC3, 0xC0, 0xF0, 0xF0, 0x3C, 0x3C, 0x1E, 0x07, 0x87, 0x81, 0xE1,
  0xE0, 0x78, 0xF0, 0x0F, 0x3C, 0x03, 0xCF, 0x00, 0xF3, 0x80, 0x1F, 0xE0,
  0x07, 0xF8, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0xE0, 0xF0, 0xFE,
  0x0F, 0x0E, 0xF0, 0xF0, 0xE7, 0x0F, 0x0E, 0x71, 0xF0, 0xE7, 0x1B, 0x0E,
  0x71, 0xB0, 0xE7, 0x1B, 0x9C, 0x71, 0x99, 0xC7, 0x99, 0x9C, 0x39, 0x99,
  0xC3, 0xB9, 0x9C, 0x3B, 0x19, 0xC3, 0xB1, 0xF8, 0x3B, 0x1F, 0x83, 0xB0,
  0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x1E, 0x0F, 0x81, 0xE0, 0xF8, 0xF8,
  0x07, 0xDE, 0x03, 0xE3, 0xC0, 0xF0, 0xF8, 0x78, 0x1E, 0x3E, 0x03, 0xCF,
  0x00, 0xF7, 0x80, 0x1F, 0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3F, 0x00,
  0x1F, 0xC0, 0x07, 0xF8, 0x03, 0xDF, 0x01, 0xF3, 0xC0, 0x78, 0x78, 0x3C,
  0x1F, 0x1F, 0x03, 0xC7, 0x80, 0x7B, 0xC0, 0x1F, 0xF0, 0x03, 0xFC, 0x01,
  0xE7, 0x80, 0x79, 0xE0, 0x1E, 0x7C, 0x0F, 0x0F, 0x03, 0xC3, 0xC0, 0xF0,
  0x78, 0x78, 0x1E, 0x1E, 0x07, 0x87, 0x80, 0xF3, 0xC0, 0x3C, 0xF0, 0x07,
  0x38, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFE, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0x00, 0x7F, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x80, 0xFF,
  0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x07, 0xFF, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80,
  0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xF8, 0x00, 0x0C, 0x00, 0x0F, 0xC0,
  0xF7, 0xF8, 0x3F, 0xFF, 0x0F, 0xF1, 0xE3, 0xBC, 0x3F, 0xEF, 0x0F, 0xFB,
  0xC0, 0xF8,
};

const GFXglyph JetBrainsMono_Medium36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 6, 26, 22, 8, -26 },
  { 21, 12, 11, 22, 5, -26 },
  { 38, 19, 26, 22, 1, -26 },
  { 100, 17, 36, 22, 2, -31 },
  { 177, 21, 26, 22, 0, -26 },
  { 246, 19, 27, 22, 2, -27 },
  { 311, 4, 11, 22, 9, -26 },
  { 317, 11, 34, 22, 6, -30 },
  { 364, 11, 34, 22, 4, -30 },
  { 411, 19, 19, 22, 1, -22 },
  { 457, 17, 17, 22, 2, -20 },
  { 494, 8, 11, 22, 6, -5 },
  { 505, 12, 4, 22, 5, -14 },
  { 511, 6, 6, 22, 8, -6 },
  { 516, 17, 34, 22, 2, -30 },
  { 589, 16, 27, 22, 3, -27 },
  { 643, 17, 26, 22, 3, -26 },
  { 699, 17, 27, 22, 2, -27 },
  { 757, 17, 26, 22, 2, -26 },
  { 813, 15, 26, 22, 3, -26 },
  { 862, 16, 26, 22, 3, -26 },
  { 914, 17, 26, 22, 2, -26 },
  { 970, 16, 26, 22, 3, -26 },
  { 1022, 16, 27, 22, 3, -27 },
  { 1076, 17, 27, 22, 2, -27 },
  { 1134, 6, 20, 22, 8, -20 },
  { 1149, 8, 26, 22, 6, -20 },
  { 1175, 16, 20, 22, 3, -22 },
  { 1215, 16, 12, 22, 3, -18 },
  { 1239, 16, 20, 22, 3, -22 },
  { 1279, 13, 26, 22, 5, -26 },
  { 1322, 19, 33, 22, 1, -27 },
  { 1401, 18, 26, 22, 2, -26 },
  { 1460, 16, 26, 22, 3, -26 },
  { 1512, 16, 27, 22, 3, -27 },
  { 1566, 16, 26, 22, 3, -26 },
  { 1618, 16, 26, 22, 3, -26 },
  { 1670, 16, 26, 22, 3, -26 },
  { 1722, 16, 27, 22, 3, -27 },
  { 1776, 16, 26, 22, 3, -26 },
  { 1828, 14, 26, 22, 4, -26 },
  { 1874, 17, 26, 22, 1, -26 },
  { 1930, 17, 26, 22, 3, -26 },
  { 1986, 15, 26, 22, 4, -26 },
  { 2035, 17, 26, 22, 2, -26 },
  { 2091, 16, 26, 22, 3, -26 },
  { 2143, 16, 27, 22, 3, -27 },
  { 2197, 17, 26, 22, 3, -26 },
  { 2253, 16, 33, 22, 3, -27 },
  { 2319, 17, 26, 22, 3, -26 },
  { 2375, 17, 27, 22, 2, -27 },
  { 2433, 18, 26, 22, 2, -26 },
  { 2492, 16, 26, 22, 3, -26 },
  { 2544, 18, 26, 22, 2, -26 },
  { 2603, 20, 26, 22, 1, -26 },
  { 2668, 19, 26, 22, 1, -26 },
  { 2730, 20, 26, 22, 1, -26 },
  { 2795, 16, 26, 22, 3, -26 },
  { 2847, 9, 34, 22, 7, -30 },
  { 2886, 17, 34, 22, 2, -30 },
  { 2959, 10, 34, 22, 5, -30 },
  { 3002, 16, 14, 22, 3, -26 },
  { 3030, 17, 3, 22, 2, 1 },
  { 3037, 8, 5, 22, 6, -28 },
  { 3042, 17, 20, 22, 2, -20 },
  { 3085, 16, 26, 22, 3, -26 },
  { 3137, 16, 20, 22, 3, -20 },
  { 3177, 16, 26, 22, 3, -26 },
  { 3229, 16, 20, 22, 3, -20 },
  { 3269, 17, 26, 22, 2, -26 },
  { 3325, 16, 26, 22, 3, -20 },
  { 3377, 16, 26, 22, 3, -26 },
  { 3429, 17, 28, 22, 3, -28 },
  { 3489, 14, 34, 22, 3, -28 },
  { 3549, 17, 26, 22, 3, -26 },
  { 3605, 19, 26, 22, 1, -26 },
  { 3667, 17, 20, 22, 2, -20 },
  { 3710, 16, 20, 22, 3, -20 },
  { 3750, 16, 20, 22, 3, -20 },
  { 3790, 16, 26, 22, 3, -20 },
  { 3842, 16, 26, 22, 3, -20 },
  { 3894, 16, 20, 22, 4, -20 },
  { 3934, 16, 20, 22, 3, -20 },
  { 3974, 17, 25, 22, 2, -25 },
  { 4028, 16, 20, 22, 3, -20 },
  { 4068, 18, 20, 22, 2, -20 },
  { 4113, 20, 20, 22, 1, -20 },
  { 4163, 18, 20, 22, 2, -20 },
  { 4208, 18, 26, 22, 2, -20 },
  { 4267, 16, 20, 22, 3, -20 },
  { 4307, 16, 34, 22, 3, -30 },
  { 4375, 4, 34, 22, 9, -30 },
  { 4392, 16, 34, 22, 3, -30 },
  { 4460, 18, 8, 22, 2, -17 },
};

const GFXfont JetBrainsMono_Medium36pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Medium36pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Medium36pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _JETBRAINSMONO_MEDIUM36PT7B_H_
