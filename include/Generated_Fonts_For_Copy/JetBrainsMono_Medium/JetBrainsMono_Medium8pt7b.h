#ifndef _JETBRAINSMONO_MEDIUM8PT7B_H_
#define _JETBRAINSMONO_MEDIUM8PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Medium.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Medium8pt7bBitmaps[] PROGMEM = {
  0x00, 0xF4, 0xB6, 0x80, 0x53, 0xD4, 0xAF, 0x30, 0x5F, 0xE7, 0xFA, 0xCD,
  0xB8, 0x66, 0xCC, 0x62, 0x91, 0x79, 0x3C, 0xE0, 0x2A, 0x49, 0x11, 0x95,
  0x56, 0x27, 0xC8, 0xA0, 0x22, 0xF2, 0x60, 0xE0, 0x80, 0x25, 0x25, 0x24,
  0xF6, 0xFB, 0xC0, 0x59, 0x25, 0xC0, 0xF4, 0xA9, 0xC0, 0xE9, 0x1B, 0xC0,
  0x2A, 0x5E, 0x40, 0xF3, 0x93, 0xC0, 0x22, 0x65, 0x97, 0xF4, 0xA5, 0x80,
  0xF6, 0xFB, 0xC0, 0x79, 0x97, 0x26, 0x90, 0x41, 0x80, 0x3A, 0x32, 0xE3,
  0x80, 0x88, 0xE8, 0xC4, 0xA1, 0x80, 0x74, 0x6F, 0x5A, 0xD9, 0x80, 0x26,
  0x55, 0x79, 0xF7, 0xDB, 0xC0, 0xF6, 0x4B, 0xC0, 0xF6, 0xDB, 0xC0, 0xF3,
  0xC9, 0xC0, 0xF2, 0x79, 0x00, 0xF6, 0x7B, 0xC0, 0xB7, 0xDB, 0x40, 0xE9,
  0x25, 0xC0, 0x31, 0x11, 0x97, 0xAA, 0xCC, 0xAB, 0x92, 0x49, 0xC0, 0xB7,
  0xDB, 0x40, 0xB7, 0xFB, 0x40, 0xF6, 0xDB, 0xC0, 0xF6, 0xF9, 0x00, 0xF6,
  0xDB, 0xC8, 0xF6, 0xEB, 0x40, 0xF6, 0x3B, 0xC0, 0xF2, 0x22, 0x22, 0xB6,
  0xDB, 0xC0, 0x95, 0x55, 0x62, 0xAD, 0x7B, 0xE5, 0x28, 0xD2, 0x88, 0x45,
  0x6C, 0x9A, 0x94, 0x42, 0x10, 0xE5, 0x29, 0xC0, 0xEA, 0xAB, 0x92, 0x24,
  0x89, 0xD5, 0x57, 0x56, 0x80, 0xF0, 0xC0, 0x77, 0x97, 0x9A, 0xDB, 0xC0,
  0xF2, 0x70, 0x2E, 0xDB, 0xC0, 0xFE, 0x70, 0x32, 0xF2, 0x22, 0xF6, 0xFE,
  0x9A, 0xDB, 0x40, 0x51, 0x25, 0xC0, 0x78, 0x92, 0x70, 0x88, 0xAC, 0xAB,
  0xE2, 0x22, 0x23, 0xFB, 0xBB, 0xF6, 0xD0, 0xF6, 0xF0, 0xF6, 0xF8, 0xF6,
  0xF2, 0xF2, 0x40, 0xF8, 0xF0, 0x2F, 0x22, 0x23, 0xB6, 0xF0, 0xD5, 0x52,
  0xAF, 0x94, 0xA0, 0xD2, 0x6D, 0xD5, 0x62, 0x60, 0xEA, 0x70, 0x29, 0x2C,
  0x91, 0xFF, 0x89, 0x26, 0x94, 0x5B,
};

const GFXglyph JetBrainsMono_Medium8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 1, 6, 5, 2, -6 },
  { 2, 3, 3, 5, 1, -6 },
  { 4, 5, 6, 5, 0, -6 },
  { 8, 3, 8, 5, 1, -7 },
  { 11, 5, 6, 5, 0, -6 },
  { 15, 5, 6, 5, 0, -6 },
  { 19, 1, 3, 5, 2, -6 },
  { 20, 3, 8, 5, 1, -7 },
  { 23, 2, 8, 5, 1, -7 },
  { 25, 5, 4, 5, 0, -5 },
  { 28, 4, 4, 5, 0, -5 },
  { 30, 2, 2, 5, 1, -1 },
  { 31, 3, 1, 5, 1, -3 },
  { 32, 1, 1, 5, 2, -1 },
  { 33, 3, 8, 5, 1, -7 },
  { 36, 3, 6, 5, 1, -6 },
  { 39, 3, 6, 5, 1, -6 },
  { 42, 3, 6, 5, 1, -6 },
  { 45, 3, 6, 5, 1, -6 },
  { 48, 3, 6, 5, 1, -6 },
  { 51, 3, 6, 5, 1, -6 },
  { 54, 4, 6, 5, 0, -6 },
  { 57, 3, 6, 5, 1, -6 },
  { 60, 3, 6, 5, 1, -6 },
  { 63, 4, 6, 5, 0, -6 },
  { 66, 1, 4, 5, 2, -4 },
  { 67, 2, 5, 5, 1, -4 },
  { 69, 3, 5, 5, 1, -5 },
  { 71, 3, 3, 5, 1, -4 },
  { 73, 3, 5, 5, 1, -5 },
  { 75, 3, 6, 5, 1, -6 },
  { 78, 5, 7, 5, 0, -6 },
  { 83, 4, 6, 5, 0, -6 },
  { 86, 3, 6, 5, 1, -6 },
  { 89, 3, 6, 5, 1, -6 },
  { 92, 3, 6, 5, 1, -6 },
  { 95, 3, 6, 5, 1, -6 },
  { 98, 3, 6, 5, 1, -6 },
  { 101, 3, 6, 5, 1, -6 },
  { 104, 3, 6, 5, 1, -6 },
  { 107, 3, 6, 5, 1, -6 },
  { 110, 4, 6, 5, 0, -6 },
  { 113, 4, 6, 5, 1, -6 },
  { 116, 3, 6, 5, 1, -6 },
  { 119, 3, 6, 5, 1, -6 },
  { 122, 3, 6, 5, 1, -6 },
  { 125, 3, 6, 5, 1, -6 },
  { 128, 3, 6, 5, 1, -6 },
  { 131, 3, 7, 5, 1, -6 },
  { 134, 3, 6, 5, 1, -6 },
  { 137, 3, 6, 5, 1, -6 },
  { 140, 4, 6, 5, 0, -6 },
  { 143, 3, 6, 5, 1, -6 },
  { 146, 4, 6, 5, 0, -6 },
  { 149, 5, 6, 5, 0, -6 },
  { 153, 5, 6, 5, 0, -6 },
  { 157, 5, 6, 5, 0, -6 },
  { 161, 3, 6, 5, 1, -6 },
  { 164, 2, 8, 5, 2, -7 },
  { 166, 3, 8, 5, 1, -7 },
  { 169, 2, 8, 5, 1, -7 },
  { 171, 3, 3, 5, 1, -6 },
  { 173, 4, 1, 5, 0, 0 },
  { 174, 2, 1, 5, 1, -6 },
  { 175, 4, 4, 5, 0, -4 },
  { 177, 3, 6, 5, 1, -6 },
  { 180, 3, 4, 5, 1, -4 },
  { 182, 3, 6, 5, 1, -6 },
  { 185, 3, 4, 5, 1, -4 },
  { 187, 4, 6, 5, 0, -6 },
  { 190, 3, 5, 5, 1, -4 },
  { 192, 3, 6, 5, 1, -6 },
  { 195, 3, 6, 5, 1, -6 },
  { 198, 3, 7, 5, 1, -6 },
  { 201, 4, 6, 5, 1, -6 },
  { 204, 4, 6, 5, 0, -6 },
  { 207, 4, 4, 5, 0, -4 },
  { 209, 3, 4, 5, 1, -4 },
  { 211, 3, 4, 5, 1, -4 },
  { 213, 3, 5, 5, 1, -4 },
  { 215, 3, 5, 5, 1, -4 },
  { 217, 3, 4, 5, 1, -4 },
  { 219, 3, 4, 5, 1, -4 },
  { 221, 4, 6, 5, 0, -6 },
  { 224, 3, 4, 5, 1, -4 },
  { 226, 4, 4, 5, 0, -4 },
  { 228, 5, 4, 5, 0, -4 },
  { 231, 4, 4, 5, 0, -4 },
  { 233, 4, 5, 5, 0, -4 },
  { 236, 3, 4, 5, 1, -4 },
  { 238, 3, 8, 5, 1, -7 },
  { 241, 1, 8, 5, 2, -7 },
  { 242, 3, 8, 5, 1, -7 },
  { 245, 4, 2, 5, 0, -4 },
};

const GFXfont JetBrainsMono_Medium8pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Medium8pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Medium8pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _JETBRAINSMONO_MEDIUM8PT7B_H_
