#ifndef _JETBRAINSMONO_MEDIUM18PT7B_H_
#define _JETBRAINSMONO_MEDIUM18PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Medium.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Medium18pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x6D, 0x92, 0x40, 0x7E, 0xEF, 0xB4, 0xD3, 0x4C, 0x11, 0x18,
  0x8C, 0xDF, 0xFF, 0xF9, 0x10, 0x88, 0xC4, 0xFF, 0xFF, 0xD1, 0x08, 0x8C,
  0x40, 0x08, 0x04, 0x02, 0x07, 0xC7, 0xF3, 0x5B, 0x20, 0xD0, 0x78, 0x1F,
  0x03, 0xC1, 0x70, 0x9E, 0x5D, 0xFC, 0x7C, 0x08, 0x04, 0x02, 0x00, 0x78,
  0x79, 0x1B, 0x26, 0x64, 0x8F, 0xA0, 0xEC, 0x01, 0x00, 0x5E, 0x1A, 0x42,
  0xCC, 0x99, 0xB1, 0x2C, 0x3C, 0x3E, 0x33, 0x18, 0xCC, 0x06, 0x03, 0x83,
  0xE1, 0xB3, 0xCF, 0x63, 0xB1, 0x9D, 0xE7, 0x98, 0xFF, 0xC0, 0x0C, 0x73,
  0x18, 0x63, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0x61, 0x83, 0x0F, 0x0C, 0xC3,
  0x83, 0x06, 0x18, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x18, 0x63, 0x38, 0xC0,
  0x18, 0x0C, 0x22, 0x3D, 0x77, 0xF0, 0xC0, 0xD8, 0xEC, 0x63, 0x00, 0x18,
  0x0C, 0x06, 0x1F, 0xFF, 0xF8, 0xC0, 0x60, 0x30, 0x76, 0x6E, 0xCC, 0xFF,
  0xC0, 0xFF, 0x80, 0x03, 0x81, 0x80, 0xC0, 0xC0, 0x60, 0x30, 0x30, 0x18,
  0x18, 0x0C, 0x06, 0x06, 0x03, 0x01, 0x81, 0x80, 0xC0, 0xC0, 0x00, 0x3E,
  0x77, 0xC3, 0xC1, 0xC1, 0xC9, 0xDD, 0xC9, 0xC1, 0xC1, 0xC3, 0x7F, 0x3E,
  0x38, 0xF8, 0xD8, 0x98, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xFF,
  0xFF, 0x3E, 0x3B, 0xB0, 0xD8, 0x60, 0x30, 0x18, 0x18, 0x18, 0x1C, 0x1C,
  0x1C, 0x0F, 0xF7, 0xF8, 0x7F, 0x7F, 0x06, 0x0C, 0x18, 0x1E, 0x07, 0x03,
  0x03, 0xC3, 0xC3, 0x7F, 0x3E, 0x07, 0x0C, 0x0C, 0x18, 0x30, 0x33, 0x63,
  0xC3, 0xC3, 0xFF, 0x03, 0x03, 0x03, 0x7F, 0x7F, 0x60, 0x60, 0x6C, 0x7F,
  0x63, 0x03, 0x03, 0x03, 0xC3, 0x7F, 0x3E, 0x0E, 0x0E, 0x06, 0x06, 0x03,
  0x03, 0xF1, 0xDD, 0x87, 0xC1, 0xE0, 0xF0, 0xCF, 0xE3, 0xE0, 0xFF, 0xFF,
  0xF0, 0xD8, 0x60, 0x30, 0x30, 0x18, 0x18, 0x0C, 0x06, 0x06, 0x03, 0x03,
  0x00, 0x3E, 0x3B, 0x98, 0xC8, 0x66, 0x31, 0xF0, 0xF8, 0xCE, 0xC3, 0x60,
  0xF0, 0xCF, 0xE3, 0xE0, 0x3E, 0x3B, 0xB0, 0xD8, 0x3C, 0x1E, 0x1D, 0xFC,
  0x76, 0x06, 0x07, 0x03, 0x03, 0x03, 0x80, 0xFF, 0x00, 0x02, 0xFC, 0x77,
  0x60, 0x00, 0x07, 0x66, 0x6C, 0xC0, 0x01, 0x03, 0x0E, 0x38, 0xE0, 0xE0,
  0x78, 0x1E, 0x07, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x80, 0xE0,
  0x78, 0x1E, 0x03, 0x03, 0x0F, 0x38, 0xE0, 0x80, 0xF9, 0xF8, 0x18, 0x30,
  0x61, 0xCF, 0x10, 0x20, 0x00, 0x03, 0x87, 0x00, 0x3F, 0x31, 0xB0, 0x78,
  0x38, 0xEC, 0xEE, 0x67, 0x31, 0x98, 0xCC, 0x66, 0x71, 0xDC, 0x06, 0x01,
  0xC0, 0x78, 0x1C, 0x0E, 0x0D, 0x06, 0xC3, 0x61, 0xB1, 0x88, 0xC6, 0x7F,
  0x3F, 0xB0, 0xD8, 0x3C, 0x18, 0xFC, 0xFE, 0x86, 0x86, 0x86, 0xFC, 0xFC,
  0x86, 0x83, 0x83, 0x87, 0xFE, 0xFC, 0x3E, 0x77, 0x63, 0xC1, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC1, 0x63, 0x7F, 0x3E, 0xFE, 0xFF, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xFF, 0xFC, 0xFF, 0xFF, 0x06, 0x0C,
  0x1F, 0xFF, 0xE0, 0xC1, 0x83, 0x07, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0x80,
  0x80, 0x80, 0xFE, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x3E, 0x77, 0x63,
  0xC1, 0xC0, 0xC0, 0xCF, 0xCF, 0xC1, 0xC1, 0x63, 0x7F, 0x3E, 0x87, 0x0E,
  0x1C, 0x38, 0x7F, 0xFF, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x60, 0xFF, 0xFC,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC7, 0xFF, 0xE0, 0x1F, 0x1F,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0xC3, 0xC3, 0xFE, 0x7C, 0x83,
  0x86, 0x86, 0x8C, 0x8C, 0xF8, 0xF8, 0x9C, 0x8C, 0x8C, 0x86, 0x86, 0x83,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF,
  0xFF, 0xE3, 0xF1, 0xF9, 0xFE, 0xFD, 0x5E, 0xAF, 0x77, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x18, 0xE1, 0xE1, 0xF1, 0xD1, 0xD9, 0xD9, 0xC9, 0xCD,
  0xCD, 0xC5, 0xC7, 0xC7, 0xC3, 0x3E, 0x77, 0x63, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0x63, 0x7F, 0x3E, 0xFC, 0xFE, 0x83, 0x83, 0x83, 0x87,
  0xFE, 0xFC, 0x80, 0x80, 0x80, 0x80, 0x80, 0x3E, 0x3B, 0xB0, 0xD8, 0x2C,
  0x16, 0x0B, 0x05, 0x82, 0xC1, 0x60, 0xB8, 0xCF, 0xE3, 0xE0, 0x30, 0x1C,
  0x07, 0xFC, 0xFE, 0x87, 0x83, 0x83, 0x86, 0xFE, 0xF8, 0x8C, 0x8C, 0x86,
  0x86, 0x87, 0x3E, 0x3B, 0x98, 0xD8, 0x06, 0x03, 0xC0, 0xF8, 0x0E, 0x03,
  0x80, 0xF0, 0xEF, 0xE3, 0xE0, 0xFF, 0xFF, 0xC6, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x63, 0x7F, 0x3E, 0xC1, 0xE0, 0xF0,
  0xCC, 0x66, 0x33, 0x19, 0x98, 0x6C, 0x36, 0x1B, 0x0D, 0x03, 0x81, 0xC0,
  0xCC, 0x53, 0x94, 0xAD, 0x2B, 0x6A, 0xDA, 0xB6, 0xAD, 0xAB, 0x6A, 0x9C,
  0xA3, 0x38, 0xC6, 0x31, 0x80, 0xC1, 0xB1, 0x99, 0xC6, 0xC3, 0x40, 0xE0,
  0x70, 0x38, 0x36, 0x1B, 0x18, 0xDC, 0x6C, 0x18, 0xC1, 0xE0, 0xD8, 0xCC,
  0x63, 0x61, 0xB0, 0x70, 0x38, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x7F,
  0x7F, 0x03, 0x06, 0x0E, 0x0C, 0x18, 0x18, 0x30, 0x70, 0x60, 0xFF, 0xFF,
  0xFF, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x8F, 0xF0, 0xC0, 0x30, 0x18,
  0x0E, 0x03, 0x01, 0x80, 0x60, 0x30, 0x18, 0x06, 0x03, 0x01, 0xC0, 0x60,
  0x30, 0x0C, 0x06, 0x03, 0x80, 0xFF, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33,
  0x3F, 0xF0, 0x1C, 0x14, 0x36, 0x36, 0x62, 0x63, 0xC1, 0xFF, 0xFF, 0xC0,
  0xE7, 0x3E, 0x7F, 0x63, 0x03, 0x3F, 0x7F, 0xC3, 0xC3, 0xE7, 0x7F, 0x81,
  0x02, 0x05, 0xEB, 0xF8, 0xE1, 0xC3, 0x87, 0x0F, 0x1D, 0xFB, 0xC0, 0x3E,
  0x7F, 0x63, 0xC0, 0xC0, 0xC0, 0xC0, 0x63, 0x7F, 0x3E, 0x03, 0x03, 0x03,
  0x3F, 0x7F, 0x63, 0xC3, 0xC3, 0xC3, 0xC3, 0x63, 0x7F, 0x3F, 0x3E, 0x77,
  0x63, 0xC1, 0xFF, 0xFF, 0xC0, 0x43, 0x77, 0x3E, 0x0F, 0x8F, 0xC6, 0x03,
  0x0F, 0xFF, 0xFC, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x3F,
  0x7F, 0x63, 0xC3, 0xC3, 0xC3, 0xE3, 0x67, 0x7F, 0x03, 0x03, 0x07, 0x3E,
  0x81, 0x02, 0x05, 0xEB, 0xF8, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x60,
  0x1C, 0x0E, 0x00, 0x00, 0x07, 0xC3, 0xE0, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x8F, 0xFF, 0xFC, 0x0C, 0x30, 0x00, 0xFF, 0xF0, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xFF, 0xF8, 0xC0, 0xC0, 0xC0, 0xC3, 0xC6, 0xCC, 0xCC,
  0xF8, 0xF8, 0xCC, 0xCE, 0xC6, 0xC3, 0xF8, 0x7C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0xF0, 0xF8, 0xFF, 0x6E, 0xF2,
  0x79, 0x3C, 0x9E, 0x4F, 0x27, 0x93, 0xC9, 0xE4, 0xC0, 0xBD, 0x7F, 0x1C,
  0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0C, 0x3E, 0x7F, 0x63, 0xC3, 0xC3, 0xC3,
  0xC3, 0x63, 0x7F, 0x3E, 0xBD, 0x7F, 0x1C, 0x38, 0x70, 0xE1, 0xE3, 0xBF,
  0x7A, 0x04, 0x08, 0x00, 0x3F, 0x7F, 0x63, 0xC3, 0xC3, 0xC3, 0xC3, 0x63,
  0x7F, 0x3F, 0x03, 0x03, 0x03, 0xDC, 0xFE, 0xC3, 0xC3, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0x3E, 0x3F, 0x98, 0xCC, 0x07, 0xE0, 0xF8, 0x0D, 0x83,
  0x77, 0x1F, 0x00, 0x18, 0x18, 0x18, 0xFF, 0xFF, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x1F, 0x0F, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x63,
  0x7F, 0x3E, 0xC1, 0xE0, 0x98, 0xCC, 0x66, 0x21, 0xB0, 0xD8, 0x6C, 0x1C,
  0x0E, 0x00, 0xC4, 0x53, 0x14, 0xAD, 0xAB, 0x6A, 0xDA, 0xA6, 0xA8, 0xCA,
  0x32, 0x8C, 0x60, 0xC3, 0xB1, 0x8D, 0x87, 0xC1, 0xC0, 0xE0, 0xD8, 0xEC,
  0x63, 0x61, 0xC0, 0xC1, 0xE1, 0x98, 0xCC, 0x63, 0x61, 0xB0, 0xD8, 0x38,
  0x1C, 0x0E, 0x06, 0x03, 0x03, 0x00, 0xFF, 0xFC, 0x38, 0xE1, 0x86, 0x18,
  0x60, 0xFF, 0xFC, 0x07, 0x0F, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x1C, 0xF0,
  0x1C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0F, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xE0, 0xF0, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x0F, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0xF0, 0xF0, 0x71, 0xEC, 0xF3, 0xC0, 0xC0,
};

const GFXglyph JetBrainsMono_Medium18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 3, 13, 11, 4, -13 },
  { 6, 6, 5, 11, 2, -13 },
  { 10, 9, 13, 11, 1, -13 },
  { 25, 9, 19, 11, 1, -16 },
  { 47, 11, 13, 11, 0, -13 },
  { 65, 9, 13, 11, 1, -13 },
  { 80, 2, 5, 11, 4, -13 },
  { 82, 6, 17, 11, 3, -15 },
  { 95, 6, 17, 11, 2, -15 },
  { 108, 9, 9, 11, 1, -11 },
  { 119, 9, 8, 11, 1, -10 },
  { 128, 4, 6, 11, 3, -3 },
  { 131, 5, 2, 11, 3, -7 },
  { 133, 3, 3, 11, 4, -3 },
  { 135, 9, 17, 11, 1, -15 },
  { 155, 8, 13, 11, 1, -13 },
  { 168, 8, 13, 11, 2, -13 },
  { 181, 9, 13, 11, 1, -13 },
  { 196, 8, 13, 11, 1, -13 },
  { 209, 8, 13, 11, 1, -13 },
  { 222, 8, 13, 11, 1, -13 },
  { 235, 9, 13, 11, 1, -13 },
  { 250, 9, 13, 11, 1, -13 },
  { 265, 9, 13, 11, 1, -13 },
  { 280, 9, 13, 11, 1, -13 },
  { 295, 3, 10, 11, 4, -10 },
  { 299, 4, 13, 11, 3, -10 },
  { 306, 8, 10, 11, 1, -11 },
  { 316, 7, 6, 11, 2, -9 },
  { 322, 8, 10, 11, 1, -11 },
  { 332, 7, 13, 11, 2, -13 },
  { 344, 9, 16, 11, 1, -13 },
  { 362, 9, 13, 11, 1, -13 },
  { 377, 8, 13, 11, 2, -13 },
  { 390, 8, 13, 11, 1, -13 },
  { 403, 8, 13, 11, 1, -13 },
  { 416, 7, 13, 11, 2, -13 },
  { 428, 8, 13, 11, 2, -13 },
  { 441, 8, 13, 11, 1, -13 },
  { 454, 7, 13, 11, 2, -13 },
  { 466, 7, 13, 11, 2, -13 },
  { 478, 8, 13, 11, 1, -13 },
  { 491, 8, 13, 11, 2, -13 },
  { 504, 8, 13, 11, 2, -13 },
  { 517, 9, 13, 11, 1, -13 },
  { 532, 8, 13, 11, 1, -13 },
  { 545, 8, 13, 11, 1, -13 },
  { 558, 8, 13, 11, 2, -13 },
  { 571, 9, 16, 11, 1, -13 },
  { 589, 8, 13, 11, 2, -13 },
  { 602, 9, 13, 11, 1, -13 },
  { 617, 9, 13, 11, 1, -13 },
  { 632, 8, 13, 11, 1, -13 },
  { 645, 9, 13, 11, 1, -13 },
  { 660, 10, 13, 11, 0, -13 },
  { 677, 9, 13, 11, 1, -13 },
  { 692, 9, 13, 11, 1, -13 },
  { 707, 8, 13, 11, 1, -13 },
  { 720, 4, 17, 11, 4, -15 },
  { 729, 9, 17, 11, 1, -15 },
  { 749, 4, 17, 11, 3, -15 },
  { 758, 8, 7, 11, 1, -13 },
  { 765, 9, 2, 11, 1, 0 },
  { 768, 4, 2, 11, 3, -14 },
  { 769, 8, 10, 11, 1, -10 },
  { 779, 7, 13, 11, 2, -13 },
  { 791, 8, 10, 11, 1, -10 },
  { 801, 8, 13, 11, 1, -13 },
  { 814, 8, 10, 11, 1, -10 },
  { 824, 9, 13, 11, 1, -13 },
  { 839, 8, 13, 11, 1, -10 },
  { 852, 7, 13, 11, 2, -13 },
  { 864, 9, 14, 11, 1, -14 },
  { 880, 6, 17, 11, 2, -14 },
  { 893, 8, 13, 11, 2, -13 },
  { 906, 9, 13, 11, 1, -13 },
  { 921, 9, 10, 11, 1, -10 },
  { 933, 7, 10, 11, 2, -10 },
  { 942, 8, 10, 11, 1, -10 },
  { 952, 7, 13, 11, 2, -10 },
  { 964, 8, 13, 11, 1, -10 },
  { 977, 8, 10, 11, 2, -10 },
  { 987, 9, 10, 11, 1, -10 },
  { 999, 8, 13, 11, 1, -13 },
  { 1012, 8, 10, 11, 1, -10 },
  { 1022, 9, 10, 11, 1, -10 },
  { 1034, 10, 10, 11, 0, -10 },
  { 1047, 9, 10, 11, 1, -10 },
  { 1059, 9, 13, 11, 1, -10 },
  { 1074, 7, 10, 11, 2, -10 },
  { 1083, 8, 17, 11, 1, -15 },
  { 1100, 2, 17, 11, 4, -15 },
  { 1105, 8, 17, 11, 1, -15 },
  { 1122, 9, 4, 11, 1, -8 },
};

const GFXfont JetBrainsMono_Medium18pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Medium18pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Medium18pt7bGlyphs,
  0x20, 0x7E, 24
};

#endif // _JETBRAINSMONO_MEDIUM18PT7B_H_
