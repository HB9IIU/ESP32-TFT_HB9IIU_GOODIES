#ifndef _JETBRAINSMONO_MEDIUM40PT7B_H_
#define _JETBRAINSMONO_MEDIUM40PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Medium.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Medium40pt7bBitmaps[] PROGMEM = {
  0x00, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x9E, 0x00, 0x00, 0x00, 0x7B, 0xFF, 0xFF, 0x78, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0x01, 0xE0, 0xF0, 0x07, 0x03, 0xC0, 0x1C,
  0x0E, 0x00, 0x70, 0x38, 0x01, 0xC0, 0xE0, 0x0F, 0x03, 0x80, 0x38, 0x1E,
  0x0F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF0, 0x78, 0x1C, 0x01,
  0xE0, 0xF0, 0x07, 0x03, 0xC0, 0x1C, 0x0E, 0x00, 0x70, 0x38, 0x01, 0xC0,
  0xE0, 0x0F, 0x03, 0x80, 0x38, 0x1E, 0x0F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF0, 0x38, 0x1C, 0x01, 0xE0, 0x70, 0x07, 0x03, 0xC0, 0x1C,
  0x0E, 0x00, 0x70, 0x38, 0x01, 0xC0, 0xE0, 0x0F, 0x03, 0x80, 0x3C, 0x1E,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x38, 0x00, 0xFF, 0xC0, 0x7F, 0xFC, 0x3F, 0xFF, 0x1F, 0xB7, 0xE7,
  0x8C, 0x7F, 0xE3, 0x1F, 0xF8, 0xC3, 0xFE, 0x30, 0x0F, 0x8C, 0x03, 0xE3,
  0x00, 0x7C, 0xC0, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xF0, 0x0F, 0xFE,
  0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x03, 0x3F, 0x00, 0xC7, 0xC0, 0x30, 0xF0,
  0x0C, 0x3F, 0xC3, 0x0F, 0xF0, 0xC3, 0xFC, 0x30, 0xFF, 0x8C, 0x7D, 0xFF,
  0xFE, 0x7F, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x1F, 0xC0,
  0x0F, 0x3F, 0xE0, 0x1E, 0x7F, 0xE0, 0x1C, 0x70, 0xF0, 0x38, 0x70, 0x70,
  0x78, 0x70, 0x70, 0x70, 0x70, 0x70, 0xE0, 0x70, 0x71, 0xC0, 0x70, 0x73,
  0xC0, 0x70, 0xF3, 0x80, 0x7F, 0xE7, 0x00, 0x3F, 0xCF, 0x00, 0x0F, 0x8E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x71,
  0xF8, 0x00, 0xF7, 0xFC, 0x01, 0xE7, 0xFE, 0x01, 0xCF, 0x0E, 0x03, 0x8E,
  0x0E, 0x07, 0x8E, 0x0E, 0x07, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x1E, 0x0E,
  0x0E, 0x1C, 0x0F, 0x0E, 0x38, 0x07, 0xFE, 0x78, 0x07, 0xFC, 0xF0, 0x01,
  0xF8, 0x00, 0xC0, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x80, 0x3F, 0xFE, 0x03,
  0xE1, 0xF0, 0x1E, 0x07, 0xC0, 0xF0, 0x1E, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x01, 0xF9, 0xE0, 0xF7, 0x8F, 0x8F,
  0xBC, 0x3E, 0x79, 0xE0, 0xF7, 0xCF, 0x07, 0xFC, 0x78, 0x1F, 0xC3, 0xC0,
  0x7E, 0x1E, 0x01, 0xE0, 0xF0, 0x1F, 0x87, 0xC0, 0xFE, 0x3F, 0x1F, 0xF0,
  0xFF, 0xFB, 0xC3, 0xFF, 0x9F, 0x0F, 0xF0, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x10, 0x07, 0x01, 0xF0, 0x3F, 0x07, 0xF0, 0xFC, 0x1F,
  0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0x80, 0x78, 0x07, 0xC0, 0x3C,
  0x03, 0xE0, 0x1F, 0x01, 0xFC, 0x0F, 0xF0, 0x7F, 0x01, 0xF0, 0x07, 0x00,
  0x10, 0x80, 0x0E, 0x00, 0xF8, 0x0F, 0xC0, 0xFE, 0x03, 0xF0, 0x0F, 0x80,
  0x7C, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x1E, 0x01, 0xF0, 0x1F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xC0,
  0x7C, 0x0F, 0x83, 0xF8, 0xFF, 0x0F, 0xC0, 0xF8, 0x0E, 0x00, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x01, 0x81, 0xE0, 0x67, 0xC7, 0x8F, 0x9F, 0xCC, 0xFE, 0xFF, 0xB7,
  0xFC, 0xFF, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0xFC, 0x00,
  0x07, 0x38, 0x00, 0x3C, 0xF0, 0x01, 0xF3, 0xE0, 0x0F, 0x87, 0xC0, 0x7C,
  0x1F, 0x80, 0xF0, 0x3C, 0x01, 0x80, 0x60, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x8F, 0xC7, 0xC3, 0xE3,
  0xE1, 0xF0, 0xF8, 0x78, 0x7C, 0x3C, 0x1E, 0x1E, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x18, 0x7E, 0x7E, 0xFF, 0x7E, 0x7E, 0x7E, 0x00, 0x03,
  0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0,
  0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00,
  0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xE0,
  0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x7E, 0x1F, 0x9E, 0x01, 0xEF,
  0x80, 0x7F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x78, 0xFF, 0x1E, 0x3F, 0xCF, 0xCF, 0xF1, 0xE3,
  0xFC, 0x30, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x07, 0xDF, 0x03, 0xE7, 0xF3, 0xF8, 0xFF,
  0xFC, 0x1F, 0xFE, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x7F,
  0xE0, 0x1F, 0xFC, 0x07, 0xEF, 0x81, 0xF9, 0xF0, 0x3C, 0x3E, 0x07, 0x07,
  0xC0, 0xC0, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x01, 0xC0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC,
  0x7E, 0x3F, 0xBE, 0x03, 0xEF, 0x80, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0x9F, 0xFF, 0xE7, 0xFF, 0xF9, 0xFF, 0xFE, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x0F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0x7F, 0xC0, 0x1E, 0xF8, 0x0F, 0x9F, 0x8F, 0xE7, 0xFF, 0xF0,
  0xFF, 0xF8, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xE0, 0x79, 0xF0, 0x3D, 0xF0,
  0x1E, 0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x7F, 0xFF, 0x9F, 0xFF, 0xE7,
  0xFF, 0xF9, 0xFF, 0xFE, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x9F, 0xC1, 0xEF, 0xF8, 0x7F, 0xFF,
  0x1F, 0xDF, 0xE7, 0xC0, 0xF9, 0xE0, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0x00, 0x7F, 0xE0,
  0x1F, 0x7C, 0x0F, 0x9F, 0xCF, 0xE3, 0xFF, 0xF0, 0x7F, 0xF8, 0x0F, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF7, 0xE0, 0x3F, 0xFF, 0x03, 0xFF, 0xFC,
  0x7F, 0x9F, 0xC7, 0xE0, 0x7E, 0x7C, 0x03, 0xE7, 0x80, 0x1E, 0xF8, 0x01,
  0xEF, 0x80, 0x1F, 0xF8, 0x01, 0xF7, 0x80, 0x1E, 0x78, 0x01, 0xE7, 0xC0,
  0x3E, 0x7E, 0x07, 0xE3, 0xF9, 0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x3D, 0xE0, 0x07, 0xBC, 0x01, 0xF7, 0x80, 0x3C, 0x00, 0x0F, 0x80,
  0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00,
  0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x00,
  0xC0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x7E, 0x1F, 0x9F, 0x03,
  0xEF, 0x80, 0x7B, 0xE0, 0x1F, 0xF8, 0x07, 0xDE, 0x01, 0xE7, 0x80, 0x79,
  0xF0, 0x3E, 0x3E, 0x3F, 0x07, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xF0, 0x1F,
  0xFE, 0x0F, 0x87, 0xC7, 0xC0, 0xFB, 0xE0, 0x1F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x07, 0xFF, 0x03, 0xF7, 0xF3, 0xF8,
  0xFF, 0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0xE0,
  0x0F, 0xFF, 0x01, 0xFF, 0xF8, 0x3F, 0x0F, 0xC7, 0xC0, 0x3E, 0x7C, 0x03,
  0xE7, 0x80, 0x1E, 0xF8, 0x01, 0xEF, 0x80, 0x1F, 0xF8, 0x01, 0xF7, 0x80,
  0x1E, 0x78, 0x01, 0xE7, 0xC0, 0x3E, 0x7E, 0x07, 0xE3, 0xFF, 0xFC, 0x1F,
  0xFF, 0xC0, 0xFF, 0x7C, 0x03, 0xEF, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x7E, 0x7E,
  0xFF, 0x7E, 0x7E, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x7E, 0x7E, 0xFF, 0x7E, 0x7E, 0x3F, 0x1F, 0x9F, 0xEF,
  0xE3, 0xF0, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x1F, 0x8F, 0x87, 0xC3, 0xE3, 0xE1, 0xF0, 0xF0, 0x78,
  0x7C, 0x3C, 0x1E, 0x00, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00, 0x7C, 0x00,
  0x7F, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80,
  0x3F, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFC, 0x00,
  0x1F, 0x00, 0x01, 0xC0, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x80, 0x00, 0x38, 0x00, 0x0F, 0x80, 0x03, 0xF8, 0x00, 0x7F,
  0x80, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE0,
  0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x0F, 0xE0, 0x03, 0xE0, 0x00, 0xC0,
  0x00, 0x20, 0x00, 0x00, 0xFF, 0xC1, 0xFF, 0xE3, 0xFF, 0xE7, 0xFF, 0xC0,
  0x0F, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0xC3, 0xFF, 0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF0, 0x00, 0x00,
  0x30, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xE0, 0x3E,
  0x3C, 0x00, 0xF9, 0xE0, 0x03, 0xDE, 0x00, 0x0E, 0xF0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x02, 0x1F, 0xC0, 0xFE, 0xFE, 0x0F, 0xFF, 0xF0, 0x7C, 0xFF,
  0x83, 0xC3, 0xFC, 0x3C, 0x0F, 0xE1, 0xE0, 0x7F, 0x0F, 0x03, 0xF8, 0x78,
  0x1F, 0xC3, 0xC0, 0xFE, 0x1E, 0x07, 0xF0, 0xF0, 0x3F, 0x87, 0x81, 0xFC,
  0x1C, 0x0F, 0xE0, 0xF0, 0xFF, 0x07, 0xFF, 0xF8, 0x1F, 0xDF, 0xC0, 0x3C,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x07, 0x9E, 0x00, 0x79, 0xE0, 0x07, 0x9E, 0x00,
  0x79, 0xE0, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0xF0, 0xF0,
  0x1F, 0x0F, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x3F, 0xFF,
  0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7C, 0x03, 0xE7, 0x80,
  0x1E, 0x78, 0x01, 0xE7, 0x80, 0x1E, 0xF8, 0x01, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xF0, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF,
  0x80, 0xF9, 0xF0, 0x0F, 0xBE, 0x01, 0xF7, 0xC0, 0x1E, 0xF8, 0x03, 0xDF,
  0x00, 0xFB, 0xE0, 0x1E, 0x7C, 0x0F, 0xCF, 0xFF, 0xF1, 0xFF, 0xF0, 0x3F,
  0xFF, 0x87, 0xFF, 0xFC, 0xF8, 0x0F, 0x9F, 0x00, 0xFB, 0xE0, 0x0F, 0x7C,
  0x01, 0xEF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xF7, 0xC0, 0x3E, 0xF8,
  0x0F, 0xDF, 0xFF, 0xF3, 0xFF, 0xFC, 0x7F, 0xFF, 0x0F, 0xFF, 0x80, 0x00,
  0xC0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x7E, 0x1F, 0x9F, 0x01,
  0xEF, 0x80, 0x7F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x3F, 0xE0, 0x0F, 0x78, 0x07, 0xDF, 0x03, 0xE7, 0xFB, 0xF8,
  0xFF, 0xFC, 0x1F, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xF8, 0x3F, 0xFF, 0x0F,
  0xFF, 0xF3, 0xFF, 0xFC, 0xF8, 0x0F, 0xBE, 0x01, 0xEF, 0x80, 0x7F, 0xE0,
  0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03,
  0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x3E, 0xF8, 0x1F, 0xBF, 0xFF, 0xCF, 0xFF, 0xE3, 0xFF, 0xF0, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0xFE, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF,
  0xFE, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xC0, 0x03, 0xFF, 0x01, 0xFF, 0xE0,
  0xFF, 0xFC, 0x7E, 0x1F, 0x9F, 0x01, 0xEF, 0x80, 0x7F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFE, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE3, 0xFF, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF, 0x8F, 0xFF,
  0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0x78,
  0x07, 0xDF, 0x03, 0xE7, 0xFB, 0xF8, 0xFF, 0xFC, 0x1F, 0xFE, 0x01, 0xFF,
  0x00, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC,
  0x07, 0xFF, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xF8,
  0x0F, 0x9F, 0xDF, 0xE3, 0xFF, 0xF0, 0x7F, 0xF8, 0x0F, 0xF8, 0x00, 0xF8,
  0x03, 0xEF, 0x80, 0x3C, 0xF8, 0x07, 0xCF, 0x80, 0x78, 0xF8, 0x0F, 0x8F,
  0x80, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xC0,
  0xF8, 0x7C, 0x0F, 0x87, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF8,
  0x0F, 0xFF, 0x80, 0xF8, 0x7C, 0x0F, 0x87, 0xC0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x0F, 0x0F, 0x80, 0xF8, 0xF8,
  0x07, 0x8F, 0x80, 0x7C, 0xF8, 0x03, 0xCF, 0x80, 0x3E, 0xF8, 0x03, 0xF0,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC,
  0x0F, 0xFB, 0x87, 0x7E, 0xE1, 0xDF, 0xB8, 0x77, 0xE7, 0x3D, 0xF9, 0xCE,
  0x7E, 0x73, 0x9F, 0x9E, 0xE7, 0xE3, 0xF3, 0xFC, 0xFC, 0xFF, 0x3F, 0x3F,
  0xC7, 0x8F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xC0, 0xFC, 0x03, 0xFF, 0x00,
  0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F,
  0xDC, 0x0F, 0xF7, 0x83, 0xFC, 0xE0, 0xFF, 0x38, 0x3F, 0xCF, 0x0F, 0xF1,
  0xC3, 0xFC, 0x78, 0xFF, 0x1E, 0x3F, 0xC3, 0x8F, 0xF0, 0xF3, 0xFC, 0x3C,
  0xFF, 0x07, 0x3F, 0xC1, 0xEF, 0xF0, 0x7B, 0xFC, 0x0E, 0xFF, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xF0,
  0x0F, 0xC0, 0x00, 0xE0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x7E,
  0x1F, 0x9F, 0x03, 0xEF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0x9F, 0x03,
  0xE7, 0xFF, 0xF8, 0xFF, 0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xFC,
  0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF, 0x80, 0x7D, 0xF0, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07,
  0xFC, 0x01, 0xFF, 0x80, 0x7D, 0xF0, 0x7F, 0xBF, 0xFF, 0xE7, 0xFF, 0xF8,
  0xFF, 0xFE, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xE0, 0x03, 0xFF, 0x01,
  0xFF, 0xE0, 0xFF, 0xFC, 0x7E, 0x1F, 0x9F, 0x03, 0xEF, 0x80, 0x7F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xE0,
  0x1F, 0xF8, 0x07, 0xDF, 0x03, 0xE7, 0xF3, 0xF8, 0xFF, 0xFC, 0x1F, 0xFE,
  0x01, 0xFF, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0xFF, 0xFC, 0x1F, 0xFF, 0xC3,
  0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0x80, 0xFD, 0xF0, 0x0F, 0xBE, 0x00, 0xF7,
  0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0x7C, 0x03, 0xEF,
  0x80, 0xFD, 0xFF, 0xFF, 0x3F, 0xFF, 0xC7, 0xFF, 0xF0, 0xFF, 0xF8, 0x1F,
  0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x1F, 0x0F, 0x83, 0xE1, 0xF0, 0x3C, 0x3E,
  0x07, 0xC7, 0xC0, 0x78, 0xF8, 0x0F, 0x9F, 0x00, 0xF3, 0xE0, 0x1F, 0x7C,
  0x03, 0xEF, 0x80, 0x3E, 0x00, 0xE0, 0x03, 0xFF, 0x01, 0xFF, 0xF0, 0xFF,
  0xFC, 0x7E, 0x1F, 0x9E, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF8, 0x01,
  0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFE, 0x01, 0xF7, 0xFB, 0xF9, 0xFF, 0xFE, 0x3F, 0xFE, 0x03, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7D, 0xE0, 0x1E, 0x7C, 0x0F, 0x9F, 0xCF, 0xE3,
  0xFF, 0xF0, 0x7F, 0xF8, 0x0F, 0xFC, 0x00, 0xF0, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x01, 0xF7, 0x80, 0x1E, 0x78, 0x01, 0xE7, 0xC0, 0x1E, 0x7C, 0x03,
  0xE3, 0xC0, 0x3C, 0x3C, 0x03, 0xC3, 0xE0, 0x3C, 0x3E, 0x07, 0xC1, 0xE0,
  0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1F, 0x0F, 0x80, 0xF0, 0xF0, 0x0F,
  0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x9F, 0x00, 0x79, 0xE0, 0x07, 0x9E, 0x00,
  0x79, 0xE0, 0x07, 0xDE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x03, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0xF0, 0x78, 0x3F, 0xC1,
  0xE0, 0xFF, 0x07, 0x83, 0xFC, 0x1E, 0x0F, 0xF0, 0xFC, 0x3F, 0xC3, 0xF0,
  0xF7, 0x0F, 0xC3, 0x9C, 0x3F, 0x0E, 0x78, 0xCC, 0x39, 0xE3, 0x31, 0xE7,
  0x8C, 0xC7, 0x9E, 0x33, 0x1E, 0x78, 0xCE, 0x79, 0xE7, 0x39, 0xE7, 0x9C,
  0xE7, 0x8E, 0x73, 0x9C, 0x39, 0xCE, 0x70, 0xE6, 0x19, 0xC3, 0x98, 0x67,
  0x0F, 0x61, 0x9C, 0x3D, 0x86, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F,
  0xE1, 0xFC, 0x1F, 0x87, 0xE0, 0x7C, 0x1F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0xF8, 0x03, 0xC3, 0xE0, 0x1F,
  0x07, 0xC0, 0x78, 0x1F, 0x03, 0xE0, 0x3E, 0x1F, 0x00, 0xF8, 0x78, 0x01,
  0xF3, 0xE0, 0x03, 0xCF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xF3, 0xC0, 0x07,
  0xCF, 0x80, 0x1E, 0x1F, 0x00, 0xF8, 0x7C, 0x07, 0xC0, 0xF8, 0x1E, 0x03,
  0xE0, 0xF8, 0x07, 0xC3, 0xC0, 0x1F, 0x1F, 0x00, 0x3E, 0xF8, 0x00, 0xFC,
  0xF8, 0x00, 0x7D, 0xE0, 0x01, 0xE7, 0xC0, 0x0F, 0x8F, 0x00, 0x3C, 0x3E,
  0x01, 0xF0, 0x78, 0x07, 0x81, 0xF0, 0x3E, 0x03, 0xC0, 0xF0, 0x0F, 0x87,
  0xC0, 0x1E, 0x1E, 0x00, 0x7C, 0xF8, 0x00, 0xF3, 0xC0, 0x03, 0xCF, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x7F, 0xFF, 0x9F, 0xFF,
  0xE7, 0xFF, 0xF9, 0xFF, 0xFE, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00,
  0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xE0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00,
  0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00,
  0x03, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x01, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x07, 0xB8, 0x03,
  0xCF, 0x00, 0xF3, 0xC0, 0x38, 0x78, 0x1E, 0x1E, 0x07, 0x03, 0x83, 0xC0,
  0xF0, 0xF0, 0x3C, 0x78, 0x07, 0x9E, 0x01, 0xEF, 0x00, 0x3C, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0xE0, 0x7F, 0xFE, 0x1F, 0x87, 0xE3,
  0xE0, 0x3C, 0x78, 0x07, 0xD0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0xFF, 0xFC, 0x7F, 0xFF, 0x9F, 0xFF, 0xF7, 0xC0, 0x3E, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xEF, 0x00, 0xFD, 0xF0, 0x37, 0xBF,
  0xFE, 0xF3, 0xFF, 0x9E, 0x1F, 0xE3, 0xC0, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE7,
  0xF0, 0xFB, 0xFF, 0x3F, 0xFF, 0xCF, 0xF3, 0xFB, 0xF0, 0x3E, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xFC, 0x0F, 0xBF, 0xCF, 0xEF, 0xFF, 0xF3, 0xEF, 0xFC, 0xF9, 0xFC,
  0x00, 0x07, 0xFC, 0x07, 0xFF, 0x83, 0xFF, 0xF1, 0xFE, 0xFE, 0x7C, 0x0F,
  0xBE, 0x01, 0xFF, 0x80, 0x3F, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xE0,
  0x0F, 0xF8, 0x07, 0xDF, 0x03, 0xE7, 0xFB, 0xF8, 0xFF, 0xFC, 0x1F, 0xFE,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x3F, 0x9F, 0x3F, 0xF7, 0xCF,
  0xFF, 0xF7, 0xF3, 0xFD, 0xF0, 0x3F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F,
  0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0x7C, 0x0F, 0xDF,
  0xCF, 0xF3, 0xFF, 0xFC, 0xFF, 0xDF, 0x0F, 0xE7, 0xC0, 0x07, 0xF8, 0x07,
  0xFF, 0x83, 0xFF, 0xF1, 0xF8, 0x7E, 0x78, 0x07, 0xBE, 0x01, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x07, 0xDE,
  0x01, 0xE7, 0xE1, 0xF8, 0xFF, 0xFC, 0x1F, 0xFE, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0xE7, 0xCF, 0xFD, 0xF3, 0xFF, 0xFD, 0xFC, 0xFF, 0x7C, 0x0F, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7D, 0xF0, 0x3F,
  0x7E, 0x1F, 0xDF, 0xFF, 0xF3, 0xFF, 0x7C, 0x7F, 0x9F, 0x03, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x87, 0xFF, 0xE1, 0xFF,
  0xF0, 0x7F, 0xF8, 0x1F, 0xFC, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE7, 0xF0,
  0xFB, 0xFF, 0x3F, 0xFF, 0xCF, 0xF3, 0xFB, 0xF0, 0x3E, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x01,
  0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7F, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x3F, 0xFE,
  0x3F, 0xFE, 0x3F, 0xFE, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0xFF, 0xFC,
  0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xC0, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x3E, 0xF8, 0x03, 0xCF, 0x80, 0x7C, 0xF8, 0x0F, 0x8F, 0x80, 0xF0,
  0xF8, 0x1F, 0x0F, 0x83, 0xE0, 0xF8, 0x3C, 0x0F, 0x87, 0xC0, 0xFF, 0xF8,
  0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xF8, 0x7C, 0x0F, 0x83,
  0xE0, 0xF8, 0x1E, 0x0F, 0x81, 0xF0, 0xF8, 0x0F, 0x8F, 0x80, 0xF8, 0xF8,
  0x07, 0xCF, 0x80, 0x3E, 0xF8, 0x03, 0xF0, 0xFF, 0xF0, 0x07, 0xFF, 0x80,
  0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80,
  0xF7, 0xC7, 0xCF, 0x7E, 0xFE, 0xFF, 0xEF, 0xEF, 0x8F, 0x1E, 0xF0, 0xF0,
  0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xFF, 0x0F,
  0x0F, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF0,
  0xF0, 0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xFF,
  0x0F, 0x0F, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF9, 0xFC, 0x3E, 0xFF, 0xCF,
  0xFF, 0xF3, 0xFC, 0xFE, 0xFC, 0x0F, 0xBE, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xF0, 0x07, 0xF8, 0x07,
  0xFF, 0x83, 0xFF, 0xF1, 0xFF, 0xFE, 0x7C, 0x0F, 0xBE, 0x01, 0xFF, 0x80,
  0x7F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x1F, 0xF8, 0x07, 0xDF,
  0x03, 0xE7, 0xFF, 0xF8, 0xFF, 0xFC, 0x1F, 0xFE, 0x01, 0xFE, 0x00, 0xF9,
  0xFC, 0x3E, 0xFF, 0xCF, 0xFF, 0xF3, 0xFC, 0xFE, 0xFC, 0x0F, 0xBE, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFF, 0x03, 0xEF, 0xF3, 0xFB, 0xFF, 0xFC, 0xFB, 0xFF, 0x3E, 0x7F,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xE7, 0xCF, 0xFD, 0xF3, 0xFF, 0xFD,
  0xFC, 0xFF, 0x7C, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xDF, 0x03, 0xF7, 0xF3, 0xFC,
  0xFF, 0xFF, 0x3F, 0xF7, 0xC3, 0xF9, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0xF1,
  0xFC, 0x3D, 0xFF, 0x8F, 0x7F, 0xF3, 0xF8, 0xFE, 0xFC, 0x0F, 0xBE, 0x01,
  0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0xFC, 0x0F, 0xFF, 0xC3, 0xFF, 0xF9, 0xF8, 0x3E, 0x78, 0x07,
  0xDE, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xFE, 0x01,
  0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0xF0, 0x03, 0xFE, 0x01, 0xF7, 0xE0, 0xFD, 0xFF, 0xFE, 0x3F, 0xFF,
  0x03, 0xFF, 0x80, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00,
  0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0x78, 0x07,
  0x9F, 0x03, 0xE7, 0xF3, 0xF8, 0xFF, 0xFC, 0x1F, 0xFE, 0x01, 0xFE, 0x00,
  0xF0, 0x00, 0xFF, 0x80, 0x1F, 0x78, 0x01, 0xE7, 0x80, 0x1E, 0x7C, 0x03,
  0xE3, 0xC0, 0x3C, 0x3C, 0x03, 0xC3, 0xE0, 0x7C, 0x1E, 0x07, 0x81, 0xE0,
  0x78, 0x1F, 0x0F, 0x80, 0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0xF9, 0xF0, 0x07,
  0x9E, 0x00, 0x79, 0xE0, 0x07, 0xDE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xF0, 0x78, 0x3F, 0xC1, 0xE0,
  0xF7, 0x07, 0x83, 0x9C, 0x1E, 0x0E, 0x70, 0xFC, 0x39, 0xE3, 0xF0, 0xE7,
  0x8F, 0xC7, 0x9E, 0x33, 0x1E, 0x78, 0xCC, 0x78, 0xE3, 0x31, 0xC3, 0x8C,
  0xC7, 0x0E, 0x73, 0x9C, 0x3D, 0xCE, 0x70, 0xF6, 0x1B, 0xC3, 0xD8, 0x6F,
  0x07, 0x61, 0xB8, 0x1D, 0x86, 0xE0, 0x7E, 0x1F, 0x81, 0xF8, 0x7E, 0x07,
  0xE1, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x00, 0xF8, 0x01, 0xF7, 0xC0,
  0x3E, 0x3E, 0x07, 0xC1, 0xE0, 0x78, 0x1F, 0x0F, 0x80, 0xF9, 0xF0, 0x07,
  0x9E, 0x00, 0x7F, 0xE0, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0x9E, 0x00, 0xF9, 0xF0,
  0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x3E, 0x07, 0xC7, 0xC0, 0x3E, 0x7C, 0x03,
  0xEF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0x7C, 0x01, 0xE7, 0xC0,
  0x3E, 0x3C, 0x03, 0xE3, 0xE0, 0x3C, 0x3E, 0x07, 0xC1, 0xE0, 0x78, 0x1F,
  0x07, 0x80, 0xF0, 0xF8, 0x0F, 0x8F, 0x00, 0xF8, 0xF0, 0x07, 0x9F, 0x00,
  0x7D, 0xE0, 0x03, 0xDE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7F, 0xFF, 0x9F, 0xFF, 0xE7, 0xFF, 0xF9, 0xFF,
  0xFE, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xC0, 0x0F, 0xF0, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x03, 0xF0, 0x3F, 0xF8, 0x0F, 0xF8,
  0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0xF0, 0x07,
  0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFC, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x03, 0xF0, 0x00, 0x7F, 0xF0, 0x07, 0xFC, 0x07, 0xFF, 0x03, 0xFF,
  0xC0, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0xF7, 0xFC, 0x0F, 0x7F, 0xE0, 0xFF, 0x9F, 0x0F, 0xF0,
  0xF9, 0xFF, 0x07, 0xFE, 0xF0, 0x3F, 0xCF, 0x01, 0xF8,
};

const GFXglyph JetBrainsMono_Medium40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 24, 0, -1 },
  { 1, 6, 29, 24, 9, -29 },
  { 23, 12, 12, 24, 6, -29 },
  { 41, 22, 29, 24, 1, -29 },
  { 121, 18, 41, 24, 3, -35 },
  { 214, 24, 29, 24, 0, -29 },
  { 301, 21, 30, 24, 2, -30 },
  { 380, 4, 12, 24, 10, -29 },
  { 386, 12, 39, 24, 7, -34 },
  { 445, 12, 39, 24, 5, -34 },
  { 504, 22, 20, 24, 1, -24 },
  { 559, 20, 19, 24, 2, -23 },
  { 607, 9, 12, 24, 6, -6 },
  { 621, 12, 4, 24, 6, -15 },
  { 627, 8, 7, 24, 8, -7 },
  { 634, 18, 37, 24, 3, -33 },
  { 718, 18, 30, 24, 3, -30 },
  { 786, 19, 29, 24, 3, -29 },
  { 855, 18, 30, 24, 3, -30 },
  { 923, 18, 29, 24, 3, -29 },
  { 989, 17, 29, 24, 3, -29 },
  { 1051, 18, 29, 24, 3, -29 },
  { 1117, 20, 29, 24, 2, -29 },
  { 1190, 19, 29, 24, 3, -29 },
  { 1259, 18, 30, 24, 3, -30 },
  { 1327, 20, 30, 24, 2, -30 },
  { 1402, 8, 22, 24, 8, -22 },
  { 1424, 9, 28, 24, 7, -22 },
  { 1456, 18, 22, 24, 3, -24 },
  { 1506, 18, 14, 24, 3, -20 },
  { 1538, 18, 22, 24, 3, -24 },
  { 1588, 15, 29, 24, 5, -29 },
  { 1643, 21, 37, 24, 2, -30 },
  { 1741, 20, 29, 24, 2, -29 },
  { 1814, 19, 29, 24, 3, -29 },
  { 1883, 18, 30, 24, 3, -30 },
  { 1951, 18, 29, 24, 3, -29 },
  { 2017, 17, 29, 24, 4, -29 },
  { 2079, 17, 29, 24, 4, -29 },
  { 2141, 18, 30, 24, 3, -30 },
  { 2209, 18, 29, 24, 3, -29 },
  { 2275, 16, 29, 24, 4, -29 },
  { 2333, 18, 29, 24, 2, -29 },
  { 2399, 20, 29, 24, 3, -29 },
  { 2472, 17, 29, 24, 4, -29 },
  { 2534, 18, 29, 24, 3, -29 },
  { 2600, 18, 29, 24, 3, -29 },
  { 2666, 18, 30, 24, 3, -30 },
  { 2734, 19, 29, 24, 3, -29 },
  { 2803, 18, 37, 24, 3, -30 },
  { 2887, 19, 29, 24, 3, -29 },
  { 2956, 18, 30, 24, 3, -30 },
  { 3024, 20, 29, 24, 2, -29 },
  { 3097, 18, 29, 24, 3, -29 },
  { 3163, 20, 29, 24, 2, -29 },
  { 3236, 22, 29, 24, 1, -29 },
  { 3316, 22, 29, 24, 1, -29 },
  { 3396, 22, 29, 24, 1, -29 },
  { 3476, 18, 29, 24, 3, -29 },
  { 3542, 10, 37, 24, 8, -33 },
  { 3589, 18, 37, 24, 3, -33 },
  { 3673, 10, 37, 24, 6, -33 },
  { 3720, 18, 15, 24, 3, -29 },
  { 3754, 20, 4, 24, 2, 1 },
  { 3764, 9, 5, 24, 7, -31 },
  { 3770, 19, 22, 24, 2, -22 },
  { 3823, 18, 29, 24, 3, -29 },
  { 3889, 18, 22, 24, 3, -22 },
  { 3939, 18, 29, 24, 3, -29 },
  { 4005, 18, 22, 24, 3, -22 },
  { 4055, 20, 29, 24, 2, -29 },
  { 4128, 18, 29, 24, 3, -22 },
  { 4194, 18, 29, 24, 3, -29 },
  { 4260, 19, 31, 24, 3, -31 },
  { 4334, 16, 38, 24, 3, -31 },
  { 4410, 20, 29, 24, 3, -29 },
  { 4483, 21, 29, 24, 1, -29 },
  { 4560, 20, 22, 24, 2, -22 },
  { 4615, 18, 22, 24, 3, -22 },
  { 4665, 18, 22, 24, 3, -22 },
  { 4715, 18, 29, 24, 3, -22 },
  { 4781, 18, 29, 24, 3, -22 },
  { 4847, 18, 22, 24, 4, -22 },
  { 4897, 18, 22, 24, 3, -22 },
  { 4947, 19, 28, 24, 2, -28 },
  { 5014, 18, 22, 24, 3, -22 },
  { 5064, 20, 22, 24, 2, -22 },
  { 5119, 22, 22, 24, 1, -22 },
  { 5180, 20, 22, 24, 2, -22 },
  { 5235, 20, 29, 24, 2, -22 },
  { 5308, 18, 22, 24, 3, -22 },
  { 5358, 18, 37, 24, 3, -33 },
  { 5442, 4, 37, 24, 10, -33 },
  { 5461, 18, 37, 24, 3, -33 },
  { 5545, 20, 8, 24, 2, -18 },
};

const GFXfont JetBrainsMono_Medium40pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Medium40pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Medium40pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _JETBRAINSMONO_MEDIUM40PT7B_H_
