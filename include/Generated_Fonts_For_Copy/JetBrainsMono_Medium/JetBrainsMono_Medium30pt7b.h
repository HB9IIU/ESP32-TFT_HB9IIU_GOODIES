#ifndef _JETBRAINSMONO_MEDIUM30PT7B_H_
#define _JETBRAINSMONO_MEDIUM30PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Medium.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Medium30pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x66, 0x66, 0x60, 0x00, 0x6F, 0xFF,
  0xF3, 0xFC, 0xFF, 0x3F, 0xC7, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xC0,
  0x07, 0x0E, 0x06, 0x0C, 0x06, 0x0C, 0x06, 0x0C, 0x06, 0x1C, 0x0E, 0x1C,
  0x7F, 0xFF, 0x7F, 0xFF, 0x0C, 0x18, 0x0C, 0x38, 0x1C, 0x38, 0x1C, 0x38,
  0x1C, 0x30, 0x18, 0x30, 0xFF, 0xFE, 0xFF, 0xFE, 0x38, 0x70, 0x38, 0x70,
  0x30, 0x60, 0x30, 0x60, 0x30, 0x60, 0x70, 0xE0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x0F, 0xE0, 0xFF, 0xC7, 0xFF, 0x9C, 0xCE, 0x73, 0x3F,
  0xCC, 0x7F, 0x30, 0x1C, 0xC0, 0x7B, 0x00, 0xFC, 0x03, 0xFE, 0x03, 0xFC,
  0x03, 0xF8, 0x0D, 0xF0, 0x33, 0xC0, 0xC7, 0xE3, 0x1F, 0x8C, 0x7F, 0x33,
  0xDF, 0xFE, 0x3F, 0xF0, 0x7F, 0x80, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x3E, 0x01, 0xDF, 0xC0, 0xE7, 0x38, 0x33, 0x8E, 0x18, 0xE1, 0x8E,
  0x38, 0x63, 0x0E, 0x39, 0x81, 0xCE, 0xE0, 0x7F, 0x30, 0x0F, 0x98, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x01, 0x9E, 0x00, 0xEF, 0xE0, 0x77, 0xB8, 0x19,
  0xC7, 0x0C, 0x61, 0xC7, 0x18, 0x71, 0x86, 0x1C, 0xC1, 0xC6, 0x70, 0x3F,
  0xB8, 0x07, 0xC0, 0x0F, 0xE0, 0x1F, 0xF0, 0x3F, 0xF8, 0x38, 0x38, 0x38,
  0x38, 0x38, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x3F,
  0x00, 0x7F, 0x87, 0x73, 0x8E, 0xF1, 0xDE, 0xF1, 0xFC, 0xF0, 0xFC, 0xF0,
  0x78, 0xF0, 0x78, 0x70, 0x7C, 0x7F, 0xFC, 0x3F, 0xCE, 0x1F, 0x8F, 0xFF,
  0xFF, 0xFF, 0xEE, 0x60, 0x01, 0xC0, 0xF0, 0xFC, 0x7C, 0x3C, 0x0E, 0x07,
  0x81, 0xC0, 0x70, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0x70, 0x1E, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xF0, 0x7C, 0x0F, 0x00, 0x40, 0xE0, 0x3C, 0x0F, 0xC0, 0xF8, 0x0F, 0x01,
  0xC0, 0x78, 0x0E, 0x03, 0x80, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0E, 0x03, 0x81, 0xE0, 0x70, 0x3C, 0x1E,
  0x3F, 0x0F, 0x83, 0xC0, 0x80, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x01, 0x80, 0x61, 0x86, 0xF9, 0x9F, 0xFF, 0xFF, 0x1F, 0xF8, 0x01, 0x80,
  0x07, 0xE0, 0x0E, 0x70, 0x0E, 0x70, 0x1C, 0x38, 0x3C, 0x3C, 0x18, 0x18,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x3C, 0xF3, 0xDE, 0x79, 0xC7, 0x3C, 0xE3, 0x80, 0xFF, 0xFF, 0xFF,
  0xFC, 0x79, 0xEF, 0xFF, 0x78, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x1E,
  0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x1C,
  0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x38,
  0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x78,
  0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0x0F, 0xC0, 0xFF, 0xC7, 0xFF, 0x9C,
  0x0E, 0xF0, 0x3F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x8C, 0x7E,
  0x79, 0xF9, 0xE7, 0xE3, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0xC0, 0xF7, 0x03, 0x9F, 0xFE, 0x3F, 0xF0, 0x7F, 0x80, 0x0F, 0x80, 0xFC,
  0x1F, 0xE1, 0xFF, 0x0E, 0x78, 0x63, 0xC2, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xC0, 0xFF,
  0xC7, 0xFF, 0x9C, 0x1E, 0xF0, 0x3B, 0x80, 0xF0, 0x03, 0xC0, 0x0E, 0x00,
  0x38, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x1F, 0xFF, 0x7F, 0xFD, 0xFF, 0xF0,
  0x7F, 0xF9, 0xFF, 0xE7, 0xFF, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0F, 0xC0, 0x3F, 0x80, 0xFF, 0x00, 0x1E, 0x00, 0x38, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0xE0, 0x3F, 0x80, 0xEF, 0x07, 0x9F, 0xFE, 0x3F,
  0xF0, 0x7F, 0x00, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x07, 0x80, 0x38, 0x03,
  0xC0, 0x3C, 0x01, 0xC0, 0x1E, 0x01, 0xE1, 0xCE, 0x0E, 0xF0, 0x7F, 0x03,
  0xF0, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x7F, 0xF9, 0xFF, 0xE7, 0xFF, 0x9C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x77, 0xE1, 0xFF, 0xC7, 0xCF, 0x9C, 0x0E,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3F, 0xC0, 0xF7, 0x03,
  0x9F, 0xFE, 0x3F, 0xF0, 0x7F, 0x80, 0x01, 0xE0, 0x0F, 0x00, 0x38, 0x01,
  0xE0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0x00, 0x38, 0x81, 0xFF, 0xC7,
  0xFF, 0xBE, 0x1E, 0xF0, 0x3F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0xC0, 0xF7, 0x03, 0x9F, 0xFE, 0x3F, 0xF0, 0x7F, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0xE0, 0x03, 0x80, 0x1C, 0x00,
  0x70, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00,
  0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x00,
  0x0F, 0xC0, 0xFF, 0xC7, 0xFF, 0x9E, 0x1E, 0x70, 0x39, 0xC0, 0xE7, 0x03,
  0x9C, 0x0E, 0x38, 0x70, 0xFF, 0x80, 0xFC, 0x07, 0xF8, 0x3C, 0xF1, 0xC1,
  0xEF, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0xFF, 0x03, 0xDF, 0xFE, 0x3F,
  0xF0, 0x7F, 0x80, 0x0F, 0xC0, 0xFF, 0xC7, 0xFF, 0x9C, 0x0E, 0xF0, 0x3F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0xF7, 0x87, 0xDF, 0xFE,
  0x3F, 0xF8, 0x11, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x38,
  0x01, 0xC0, 0x0F, 0x00, 0x78, 0x00, 0x31, 0xEF, 0xDE, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xEF, 0xFF, 0x78, 0x18, 0x79, 0xFB, 0xF3, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE7, 0x8F, 0x1C, 0x78, 0xF1, 0xC7,
  0x8E, 0x1C, 0x00, 0x00, 0x04, 0x00, 0x70, 0x0F, 0xC0, 0xFE, 0x0F, 0xE0,
  0xFC, 0x0F, 0xC0, 0x3C, 0x00, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0,
  0x03, 0xF0, 0x03, 0xF0, 0x03, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03,
  0x80, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F,
  0x00, 0x3C, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x0F, 0x00,
  0x30, 0x00, 0xFE, 0x1F, 0xF3, 0xFF, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x38,
  0x07, 0x01, 0xE0, 0x78, 0xFF, 0x1F, 0xC3, 0xE0, 0x70, 0x0E, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0xE0, 0x3E, 0x07, 0xC0, 0x70, 0x00, 0x07, 0xF0, 0x1F,
  0xFC, 0x3E, 0x3E, 0x78, 0x0E, 0x70, 0x07, 0x60, 0x07, 0xE0, 0x07, 0xE0,
  0x67, 0xE1, 0xFF, 0xE3, 0xFF, 0xE3, 0x87, 0xE3, 0x87, 0xE3, 0x87, 0xE3,
  0x87, 0xE3, 0x87, 0xE3, 0x87, 0xE3, 0x87, 0xE3, 0x87, 0xE1, 0xFB, 0xE1,
  0xF7, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x1F,
  0xE0, 0x07, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x1E, 0x78, 0x1C,
  0x38, 0x1C, 0x38, 0x1C, 0x38, 0x3C, 0x3C, 0x3F, 0xFC, 0x3F, 0xFC, 0x38,
  0x1C, 0x78, 0x1E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0xF0, 0x0F, 0xFF,
  0x87, 0xFF, 0x3F, 0xFD, 0xC1, 0xEE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0E,
  0xE0, 0xF7, 0xFF, 0x3F, 0xE1, 0xFF, 0xCE, 0x0F, 0x70, 0x3F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x1F, 0xFF, 0xEF, 0xFE, 0x7F, 0xC0, 0x0F,
  0xE0, 0xFF, 0xC7, 0xFF, 0x9E, 0x0E, 0x70, 0x3F, 0xC0, 0x7F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x1D, 0xC0, 0xF7, 0x83, 0x9F, 0xFE, 0x3F, 0xF0,
  0x7F, 0x80, 0xFF, 0x83, 0xFF, 0x8F, 0xFF, 0x3C, 0x1E, 0xF0, 0x3B, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xEF, 0x07, 0xBF,
  0xFC, 0xFF, 0xE3, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0xFF, 0xBF, 0xFD, 0xFF,
  0xEE, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x3F, 0xFD, 0xFF,
  0xEF, 0xFF, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x00, 0x0F, 0xE0, 0xFF, 0xC7, 0xFF, 0x9E, 0x0E,
  0x70, 0x3F, 0xC0, 0x7F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0xFF, 0xF3, 0xFF, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1D, 0xC0,
  0xF7, 0x83, 0x9F, 0xFE, 0x3F, 0xF0, 0x7F, 0x80, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0xE0, 0x1F, 0xC0, 0xF7, 0x03, 0xDF,
  0xFE, 0x3F, 0xF0, 0x7F, 0x80, 0xE0, 0x3F, 0x81, 0xEE, 0x07, 0xB8, 0x3C,
  0xE0, 0xF3, 0x87, 0x8E, 0x1E, 0x38, 0x70, 0xE3, 0xC3, 0xFE, 0x0F, 0xF8,
  0x3F, 0xE0, 0xE3, 0x83, 0x8F, 0x0E, 0x1C, 0x38, 0x78, 0xE0, 0xE3, 0x83,
  0xCE, 0x07, 0x38, 0x1E, 0xE0, 0x3B, 0x80, 0xF0, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0x3F, 0xC0, 0xFF,
  0x87, 0xF6, 0x1B, 0xD8, 0x6F, 0xF3, 0xFE, 0xCD, 0xFB, 0x37, 0xEE, 0xDF,
  0x9F, 0x7E, 0x79, 0xF9, 0xE7, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x70, 0xF8,
  0x1F, 0xE0, 0x7F, 0x81, 0xFF, 0x07, 0xFC, 0x1F, 0xB0, 0x7E, 0xE1, 0xFB,
  0x87, 0xE6, 0x1F, 0x9C, 0x7E, 0x71, 0xF8, 0xE7, 0xE3, 0x9F, 0x86, 0x7E,
  0x1D, 0xF8, 0x77, 0xE0, 0xDF, 0x83, 0xFE, 0x0F, 0xF8, 0x1F, 0xE0, 0x7F,
  0x81, 0xF0, 0x0F, 0xC0, 0xFF, 0xC7, 0xFF, 0x9E, 0x1E, 0x70, 0x3B, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3D, 0xC0, 0xE7, 0x07, 0x9F,
  0xFE, 0x3F, 0xF0, 0x7F, 0x80, 0xFF, 0x83, 0xFF, 0x8F, 0xFF, 0x38, 0x1E,
  0xE0, 0x3B, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3B, 0x81, 0xEF, 0xFF,
  0xBF, 0xFC, 0xFF, 0xC3, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x0F, 0xC0, 0xFF, 0xC7,
  0xFF, 0x9E, 0x1E, 0xF0, 0x3F, 0xC0, 0xFE, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x3F, 0xC0, 0xF7, 0x03, 0x9F, 0xFE, 0x3F, 0xF0, 0x7F, 0x80, 0x1E,
  0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0xFF, 0x83, 0xFF, 0x8F,
  0xFF, 0x38, 0x3E, 0xE0, 0x7B, 0x80, 0xEE, 0x03, 0xB8, 0x0E, 0xE0, 0x7B,
  0x81, 0xEF, 0xFF, 0x3F, 0xF8, 0xFF, 0x83, 0x8F, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xE3, 0x83, 0x8E, 0x0F, 0x38, 0x1C, 0xE0, 0x7B, 0x80, 0xF0, 0x0F,
  0xE0, 0xFF, 0xC7, 0xFF, 0x9C, 0x0E, 0x70, 0x3F, 0xC0, 0x7F, 0x00, 0x1C,
  0x00, 0x78, 0x00, 0xFC, 0x03, 0xFE, 0x03, 0xFC, 0x01, 0xF8, 0x01, 0xF0,
  0x03, 0xC0, 0x07, 0xE0, 0x1F, 0x80, 0x7F, 0x03, 0xDF, 0xFE, 0x3F, 0xF0,
  0x7F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3D, 0xC0,
  0xE7, 0x87, 0x9F, 0xFE, 0x3F, 0xF0, 0x7F, 0x80, 0xF0, 0x0F, 0x70, 0x0E,
  0x70, 0x0E, 0x70, 0x0E, 0x78, 0x1E, 0x38, 0x1C, 0x38, 0x1C, 0x38, 0x1C,
  0x3C, 0x3C, 0x1C, 0x38, 0x1C, 0x38, 0x1C, 0x38, 0x1E, 0x78, 0x0E, 0x70,
  0x0E, 0x70, 0x0E, 0x70, 0x0F, 0x70, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x03, 0xC0, 0xE3, 0xC7, 0xE3, 0xC7, 0xE3, 0xC7, 0xE3, 0xC7,
  0xE3, 0xC7, 0xE3, 0xC7, 0xE3, 0xC7, 0xE3, 0x47, 0x62, 0x66, 0x66, 0x66,
  0x76, 0x66, 0x76, 0x6E, 0x76, 0x6E, 0x76, 0x6E, 0x76, 0x6E, 0x76, 0x6E,
  0x74, 0x2E, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0xF0, 0x0F, 0x78, 0x1E, 0x38, 0x1C, 0x3C, 0x3C, 0x1C, 0x38, 0x1E, 0x78,
  0x0E, 0x70, 0x0F, 0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x07, 0xE0, 0x07, 0xE0, 0x0E, 0xF0, 0x0E, 0x70, 0x1C, 0x78, 0x3C, 0x3C,
  0x38, 0x3C, 0x78, 0x1E, 0x70, 0x0E, 0xF0, 0x0F, 0xE0, 0x07, 0x70, 0x0E,
  0x70, 0x0E, 0x78, 0x1E, 0x38, 0x1C, 0x3C, 0x3C, 0x1C, 0x38, 0x1E, 0x78,
  0x0E, 0x70, 0x0F, 0x70, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x7F, 0xF9, 0xFF, 0xE7, 0xFF, 0x80, 0x0E, 0x00,
  0x78, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x78, 0x01,
  0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0,
  0x01, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0, 0x07,
  0x00, 0x1E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0,
  0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0x80, 0x0F,
  0xFF, 0xFF, 0xFF, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0xFF, 0xFF, 0xFF, 0x07, 0x80, 0x1E, 0x00, 0xFC, 0x03, 0xF0, 0x0C,
  0xE0, 0x73, 0x81, 0x86, 0x0E, 0x1C, 0x38, 0x71, 0xC0, 0xE7, 0x03, 0xB8,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0xF0, 0xE0, 0xE0, 0xE0,
  0x07, 0xC0, 0x7F, 0xC3, 0xFF, 0x9E, 0x1E, 0x70, 0x38, 0x00, 0xF0, 0x03,
  0xC3, 0xFF, 0x3F, 0xFD, 0xFF, 0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80,
  0xFF, 0x8F, 0xDF, 0xFF, 0x3F, 0xBC, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x73, 0xC3, 0xBF, 0x9F, 0xFE, 0xF0, 0xF7, 0x03, 0xB8, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xFC,
  0x1D, 0xFF, 0xEF, 0xFE, 0x77, 0xE0, 0x07, 0x80, 0x7F, 0xC3, 0xFF, 0x9E,
  0x1E, 0x70, 0x3F, 0xC0, 0xFF, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x07, 0xF0, 0x3D, 0xC0, 0xE7, 0xFF, 0x8F, 0xFC, 0x1F, 0xE0,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x87, 0x9C, 0xFE, 0xEF,
  0xFF, 0x78, 0x7B, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0,
  0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xDC, 0x1E, 0xFF, 0xF3, 0xFF, 0x8F, 0xDC,
  0x07, 0x80, 0x7F, 0x83, 0xFF, 0x1E, 0x1E, 0x70, 0x3B, 0xC0, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x38, 0x00, 0xF0, 0x05, 0xC0,
  0xE7, 0xCF, 0x8F, 0xFC, 0x1F, 0xE0, 0x01, 0xFC, 0x1F, 0xF0, 0x7F, 0xC3,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x0F, 0x39, 0xFD,
  0xDF, 0xFE, 0xF0, 0xF7, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F,
  0x81, 0xFC, 0x0E, 0xE0, 0x77, 0x87, 0xBF, 0xFC, 0xFE, 0xE3, 0xE7, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF1, 0xFF, 0x0F, 0xF0, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x73, 0xC3, 0xBF, 0x9F, 0xFE, 0xF0, 0xF7,
  0x03, 0xB8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3C, 0x07, 0x80, 0x0F,
  0x80, 0x1F, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xE0, 0x7C, 0x07, 0x80, 0x60, 0x00,
  0x00, 0x3F, 0xF7, 0xFE, 0xFF, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x03, 0xDF, 0xFB, 0xFE, 0x7F, 0x80, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0xFE, 0x07, 0xB8, 0x1C, 0xE0, 0xF3,
  0x87, 0x8E, 0x1C, 0x38, 0xF0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x38, 0xF0,
  0xE1, 0xC3, 0x87, 0x8E, 0x0F, 0x38, 0x1C, 0xE0, 0x7B, 0x80, 0xF0, 0xFF,
  0x80, 0xFF, 0x80, 0xFF, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0xCE, 0x33, 0x7D, 0xED, 0xFF,
  0xF9, 0xC7, 0xE3, 0x1F, 0x8C, 0x7E, 0x31, 0xF8, 0xC7, 0xE3, 0x1F, 0x8C,
  0x7E, 0x31, 0xF8, 0xC7, 0xE3, 0x1F, 0x8C, 0x7E, 0x31, 0xF8, 0xC7, 0xE3,
  0x1C, 0xE7, 0x87, 0x7F, 0x3F, 0xFD, 0xE1, 0xEE, 0x07, 0x70, 0x3F, 0x81,
  0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F,
  0x81, 0xFC, 0x0F, 0xE0, 0x78, 0x07, 0x80, 0x7F, 0x83, 0xFF, 0x1E, 0x1E,
  0x70, 0x3B, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3D, 0xC0, 0xE7, 0xFF, 0x8F, 0xFC, 0x1F, 0xE0, 0xE7,
  0x87, 0x7F, 0x3F, 0xFD, 0xE1, 0xEE, 0x07, 0x70, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF8, 0x3B, 0xFF, 0xDF,
  0xFC, 0xEF, 0xC7, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x00, 0x0F,
  0x39, 0xFD, 0xDF, 0xFE, 0xF0, 0xF7, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xB8, 0x3D, 0xFF, 0xE7,
  0xFF, 0x1F, 0xB8, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0xE3,
  0x87, 0x7F, 0x3B, 0xFD, 0xF0, 0xFF, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x00, 0x0F, 0xC0, 0xFF, 0xC7, 0xFF, 0x9E, 0x0E, 0x70, 0x3D,
  0xC0, 0x07, 0x80, 0x1F, 0xE0, 0x3F, 0xF0, 0x1F, 0xE0, 0x07, 0xC0, 0x07,
  0x00, 0x1F, 0xC0, 0xF7, 0xCF, 0x8F, 0xFE, 0x1F, 0xF0, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x1F,
  0xC0, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0x70, 0x39,
  0xE1, 0xE7, 0xFF, 0x8F, 0xFC, 0x1F, 0xC0, 0xF0, 0x0F, 0x70, 0x0E, 0x70,
  0x0E, 0x78, 0x1E, 0x38, 0x1C, 0x38, 0x1C, 0x3C, 0x3C, 0x1C, 0x38, 0x1C,
  0x38, 0x1E, 0x78, 0x0E, 0x70, 0x0E, 0x70, 0x0F, 0x70, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x03, 0xC0, 0xE1, 0x87, 0xE3, 0xC7, 0xE3, 0xC7, 0xE3,
  0xC7, 0xE3, 0xC7, 0x63, 0xC6, 0x62, 0x46, 0x72, 0x4E, 0x76, 0x6E, 0x76,
  0x6E, 0x76, 0x6E, 0x36, 0x6C, 0x36, 0x6C, 0x34, 0x2C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x70, 0x0E, 0x78, 0x1E, 0x3C, 0x3C, 0x1C, 0x38, 0x1E,
  0x78, 0x0F, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xC0, 0x07, 0xE0, 0x07,
  0xE0, 0x0F, 0xF0, 0x1E, 0x78, 0x1C, 0x38, 0x3C, 0x3C, 0x78, 0x1E, 0xF0,
  0x0F, 0xF0, 0x0F, 0x70, 0x0E, 0x78, 0x1E, 0x38, 0x1E, 0x38, 0x1C, 0x3C,
  0x3C, 0x1C, 0x38, 0x1E, 0x38, 0x0E, 0x78, 0x0E, 0x70, 0x0F, 0x70, 0x07,
  0xF0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x03, 0x80, 0x78, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x7C, 0x03, 0xF0, 0x1F, 0xC0, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x07, 0x83, 0xFC, 0x0F,
  0xF0, 0x3F, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0xF0, 0x1F, 0xC0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0xF0, 0x3F, 0xC1, 0xFF, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x03, 0xF8, 0x0F,
  0xE0, 0x3E, 0x00, 0x3C, 0x1D, 0xF8, 0x7F, 0xF1, 0xF9, 0xE7, 0xE3, 0xFF,
  0x87, 0xE0, 0x06, 0x00,
};

const GFXglyph JetBrainsMono_Medium30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 4, 22, 18, 7, -22 },
  { 12, 10, 9, 18, 4, -22 },
  { 24, 16, 22, 18, 1, -22 },
  { 68, 14, 30, 18, 2, -26 },
  { 121, 18, 22, 18, 0, -22 },
  { 171, 16, 22, 18, 1, -22 },
  { 215, 4, 9, 18, 7, -22 },
  { 220, 10, 29, 18, 5, -25 },
  { 257, 10, 29, 18, 3, -25 },
  { 294, 16, 15, 18, 1, -18 },
  { 324, 14, 14, 18, 2, -17 },
  { 349, 6, 10, 18, 5, -5 },
  { 357, 10, 3, 18, 4, -11 },
  { 361, 6, 5, 18, 6, -5 },
  { 365, 14, 28, 18, 2, -25 },
  { 414, 14, 22, 18, 2, -22 },
  { 453, 13, 22, 18, 3, -22 },
  { 489, 14, 22, 18, 2, -22 },
  { 528, 14, 22, 18, 2, -22 },
  { 567, 13, 22, 18, 2, -22 },
  { 603, 14, 22, 18, 2, -22 },
  { 642, 14, 22, 18, 2, -22 },
  { 681, 14, 22, 18, 2, -22 },
  { 720, 14, 22, 18, 2, -22 },
  { 759, 14, 22, 18, 2, -22 },
  { 798, 6, 17, 18, 6, -17 },
  { 811, 7, 22, 18, 5, -17 },
  { 831, 14, 16, 18, 2, -18 },
  { 859, 12, 10, 18, 3, -15 },
  { 874, 14, 16, 18, 2, -18 },
  { 902, 11, 22, 18, 4, -22 },
  { 933, 16, 27, 18, 1, -22 },
  { 987, 16, 22, 18, 1, -22 },
  { 1031, 13, 22, 18, 3, -22 },
  { 1067, 14, 22, 18, 2, -22 },
  { 1106, 14, 22, 18, 2, -22 },
  { 1145, 13, 22, 18, 3, -22 },
  { 1181, 13, 22, 18, 3, -22 },
  { 1217, 14, 22, 18, 2, -22 },
  { 1256, 12, 22, 18, 3, -22 },
  { 1289, 12, 22, 18, 3, -22 },
  { 1322, 14, 22, 18, 1, -22 },
  { 1361, 14, 22, 18, 3, -22 },
  { 1400, 13, 22, 18, 3, -22 },
  { 1436, 14, 22, 18, 2, -22 },
  { 1475, 14, 22, 18, 2, -22 },
  { 1514, 14, 22, 18, 2, -22 },
  { 1553, 14, 22, 18, 3, -22 },
  { 1592, 14, 27, 18, 2, -22 },
  { 1640, 14, 22, 18, 3, -22 },
  { 1679, 14, 22, 18, 2, -22 },
  { 1718, 14, 22, 18, 2, -22 },
  { 1757, 14, 22, 18, 2, -22 },
  { 1796, 16, 22, 18, 1, -22 },
  { 1840, 16, 22, 18, 1, -22 },
  { 1884, 16, 22, 18, 1, -22 },
  { 1928, 16, 22, 18, 1, -22 },
  { 1972, 14, 22, 18, 2, -22 },
  { 2011, 8, 28, 18, 6, -25 },
  { 2039, 14, 28, 18, 2, -25 },
  { 2088, 8, 28, 18, 4, -25 },
  { 2116, 14, 12, 18, 2, -22 },
  { 2137, 14, 3, 18, 2, 1 },
  { 2143, 7, 5, 18, 5, -24 },
  { 2148, 14, 17, 18, 2, -17 },
  { 2178, 13, 22, 18, 3, -22 },
  { 2214, 14, 17, 18, 2, -17 },
  { 2244, 13, 22, 18, 2, -22 },
  { 2280, 14, 17, 18, 2, -17 },
  { 2310, 14, 22, 18, 2, -22 },
  { 2349, 13, 22, 18, 2, -17 },
  { 2385, 13, 22, 18, 3, -22 },
  { 2421, 15, 23, 18, 2, -23 },
  { 2465, 11, 28, 18, 3, -23 },
  { 2504, 14, 22, 18, 3, -22 },
  { 2543, 16, 22, 18, 1, -22 },
  { 2587, 14, 17, 18, 2, -17 },
  { 2617, 13, 17, 18, 3, -17 },
  { 2645, 14, 17, 18, 2, -17 },
  { 2675, 13, 22, 18, 3, -17 },
  { 2711, 13, 22, 18, 2, -17 },
  { 2747, 13, 17, 18, 3, -17 },
  { 2775, 14, 17, 18, 2, -17 },
  { 2805, 15, 21, 18, 1, -21 },
  { 2845, 14, 17, 18, 2, -17 },
  { 2875, 16, 17, 18, 1, -17 },
  { 2909, 16, 17, 18, 1, -17 },
  { 2943, 16, 17, 18, 1, -17 },
  { 2977, 16, 22, 18, 1, -17 },
  { 3021, 12, 17, 18, 3, -17 },
  { 3047, 14, 28, 18, 2, -25 },
  { 3096, 4, 28, 18, 7, -25 },
  { 3110, 14, 28, 18, 2, -25 },
  { 3159, 14, 7, 18, 2, -14 },
};

const GFXfont JetBrainsMono_Medium30pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Medium30pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Medium30pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _JETBRAINSMONO_MEDIUM30PT7B_H_
