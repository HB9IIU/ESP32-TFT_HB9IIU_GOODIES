#ifndef _JETBRAINSMONO_MEDIUM31PT7B_H_
#define _JETBRAINSMONO_MEDIUM31PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Medium.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Medium31pt7bBitmaps[] PROGMEM = {
  0x00, 0xF7, 0xBD, 0xEF, 0x79, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x00,
  0x00, 0xEF, 0xFF, 0xC0, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F,
  0x1D, 0xC7, 0x61, 0xD8, 0x70, 0x07, 0x06, 0x03, 0x87, 0x01, 0xC3, 0x80,
  0xC1, 0xC0, 0x60, 0xC0, 0x30, 0x61, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF,
  0x86, 0x0E, 0x03, 0x06, 0x03, 0x83, 0x01, 0xC3, 0x80, 0xE1, 0xC0, 0x70,
  0xE1, 0xFF, 0xFE, 0xFF, 0xFF, 0x1C, 0x18, 0x0E, 0x1C, 0x07, 0x0E, 0x03,
  0x07, 0x01, 0x83, 0x01, 0xC1, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x7C, 0x03, 0xFE, 0x0F, 0xFE, 0x3D, 0x9E, 0x73, 0x1C, 0xE6,
  0x39, 0xCC, 0x03, 0x98, 0x07, 0xB0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF8,
  0x07, 0xF8, 0x07, 0xF8, 0x0C, 0xF0, 0x18, 0xE0, 0x31, 0xFC, 0x63, 0xFC,
  0xC7, 0x79, 0x9E, 0x7F, 0xFC, 0x7F, 0xF0, 0x7F, 0x80, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x00, 0x1E, 0x00, 0xDF, 0xC0, 0x77, 0xF8, 0x3B,
  0x86, 0x0C, 0xE1, 0x87, 0x38, 0x63, 0x8E, 0x18, 0xC1, 0x8E, 0x70, 0x7F,
  0xB8, 0x0F, 0xCC, 0x00, 0x86, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x67,
  0xC0, 0x3B, 0xF8, 0x1C, 0xC7, 0x06, 0x70, 0xC3, 0x9C, 0x31, 0xC7, 0x0C,
  0x61, 0xC3, 0x30, 0x39, 0xDC, 0x0F, 0xEE, 0x01, 0xF0, 0x0F, 0x80, 0x3F,
  0xE0, 0x3F, 0xF0, 0x78, 0x70, 0x70, 0x78, 0x70, 0x78, 0x70, 0x00, 0x78,
  0x00, 0x38, 0x00, 0x3C, 0x00, 0x7E, 0x00, 0xFE, 0x01, 0xF7, 0x0E, 0xE7,
  0x9E, 0xE3, 0xDC, 0xE1, 0xFC, 0xE1, 0xF8, 0xE0, 0xF0, 0xE0, 0x70, 0xE0,
  0xF8, 0xFF, 0xFC, 0x7F, 0xDE, 0x3F, 0x0F, 0xFF, 0xFF, 0xFF, 0x77, 0x77,
  0x00, 0xC0, 0xF0, 0x7C, 0x3E, 0x1E, 0x0F, 0x03, 0x81, 0xE0, 0x70, 0x1C,
  0x07, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0xC0, 0xFC, 0x1F, 0x01,
  0xC0, 0x10, 0x80, 0x70, 0x3E, 0x0F, 0x83, 0xE0, 0xF0, 0x3C, 0x0E, 0x07,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x78, 0x3C, 0x1C, 0x1E, 0x1E, 0x1F, 0x3F, 0x1E, 0x0E, 0x04, 0x00,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x04, 0x1C, 0x13, 0x8C,
  0x7B, 0xF6, 0x7C, 0xFD, 0xFF, 0x0F, 0xF8, 0x01, 0xE0, 0x01, 0xD8, 0x01,
  0xEE, 0x00, 0xE7, 0x80, 0xF1, 0xE0, 0xF0, 0x70, 0x10, 0x30, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x00, 0x3E, 0x78, 0xF1, 0xE7, 0x8F, 0x1C, 0x78, 0xE1, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFC, 0xF7, 0xFF, 0xFF, 0x00, 0x00, 0x1C, 0x00, 0x70,
  0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0,
  0x03, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0,
  0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0,
  0x0F, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x00, 0x07,
  0xC0, 0x7F, 0xC3, 0xFF, 0x9E, 0x1F, 0x70, 0x3F, 0xC0, 0x7F, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x39, 0xF9, 0xE7, 0xE3, 0x9F, 0x84, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x7F, 0x01, 0xDE, 0x0F, 0x7F, 0xF8,
  0xFF, 0xC0, 0xFE, 0x00, 0x07, 0x80, 0x7E, 0x03, 0xF8, 0x1E, 0xE0, 0xF3,
  0x83, 0x8E, 0x08, 0x38, 0x20, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xC0, 0x7F,
  0xC7, 0xFF, 0x9E, 0x1E, 0xF0, 0x3F, 0xC0, 0x7E, 0x01, 0xC0, 0x07, 0x00,
  0x3C, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0x7F, 0xFD, 0xFF, 0xF7,
  0xFF, 0xC0, 0x7F, 0xF9, 0xFF, 0xE7, 0xFF, 0x80, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x1F, 0x80, 0x7F, 0x01, 0xFE, 0x00,
  0x3C, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x1F, 0x80, 0x7F, 0x03, 0xFC,
  0x0F, 0x7F, 0xF8, 0xFF, 0xC1, 0xFE, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x0E,
  0x00, 0x78, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0x78,
  0x03, 0xC3, 0xDE, 0x0F, 0x78, 0x3F, 0xC0, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x7F, 0xF9, 0xFF, 0xE7, 0xFF, 0x9C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x73, 0xE1, 0xDF, 0xC7, 0xFF, 0x9E, 0x1F, 0x70, 0x3C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x77, 0x01, 0xDE, 0x0F, 0x7F,
  0xF8, 0xFF, 0xC0, 0xFE, 0x00, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x3C,
  0x00, 0x78, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x77, 0xC1,
  0xFF, 0xE3, 0xFF, 0xCF, 0x83, 0xDE, 0x03, 0xB8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0xC0, 0x73, 0xC1, 0xE7, 0xFF, 0x87, 0xFE, 0x03, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFE, 0x01, 0xDC, 0x03,
  0xB8, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E,
  0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x00, 0x0F, 0xC0, 0x7F,
  0xC3, 0xFF, 0x9E, 0x1E, 0x70, 0x3D, 0xC0, 0x77, 0x01, 0xDC, 0x0F, 0x78,
  0x38, 0xF3, 0xE1, 0xFE, 0x03, 0xF0, 0x1F, 0xF0, 0xF1, 0xE7, 0x03, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xDE, 0x0F, 0x7F, 0xFC, 0xFF, 0xE1,
  0xFE, 0x00, 0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xC3, 0xEF, 0x01, 0xDE,
  0x03, 0xB8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0xF3, 0xE3,
  0xE3, 0xFF, 0xC3, 0xFF, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0,
  0x0F, 0x00, 0x1C, 0x00, 0x78, 0x01, 0xE0, 0x07, 0xC0, 0x00, 0xF7, 0xFF,
  0xF6, 0x00, 0x00, 0x00, 0x00, 0x06, 0x7F, 0xFF, 0xF0, 0x3C, 0x7C, 0xF9,
  0xF0, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE7, 0xCF, 0x1E, 0x78,
  0xF1, 0xC3, 0x8F, 0x1C, 0x00, 0x00, 0x08, 0x00, 0xC0, 0x1E, 0x03, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x1F, 0x00, 0xE0, 0x07, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0x00, 0x08, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x80, 0x06, 0x00, 0x3C, 0x01, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x1F, 0x00, 0x38, 0x03, 0xC0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x03, 0xE0, 0x1C, 0x00, 0x80, 0x00, 0xF8, 0x1F, 0xF3, 0xFF, 0x7F,
  0xF0, 0x1E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x3C, 0x1F, 0x9F, 0xE3,
  0xF8, 0x70, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x07, 0xC0,
  0xF8, 0x0F, 0x00, 0x03, 0xF0, 0x07, 0xFE, 0x0F, 0xFF, 0x87, 0x01, 0xE7,
  0x00, 0x73, 0x80, 0x3B, 0x80, 0x0D, 0xC0, 0x07, 0xE0, 0xFB, 0xF0, 0xFD,
  0xF8, 0x71, 0xFC, 0x70, 0x7E, 0x38, 0x3F, 0x1C, 0x1F, 0x8E, 0x0F, 0xC7,
  0x07, 0xE3, 0x83, 0xF1, 0xC1, 0xF8, 0x71, 0xFC, 0x3F, 0xFE, 0x0F, 0xBF,
  0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x07, 0xF8,
  0x01, 0xFC, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07,
  0xE0, 0x07, 0x70, 0x07, 0x70, 0x07, 0x70, 0x0E, 0x70, 0x0E, 0x78, 0x0E,
  0x38, 0x1E, 0x38, 0x1C, 0x38, 0x1C, 0x3C, 0x1C, 0x1C, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFE, 0x38, 0x0E, 0x78, 0x0E, 0x78, 0x0E, 0x70, 0x0F, 0x70,
  0x07, 0xF0, 0x07, 0xFE, 0x03, 0xFF, 0x8F, 0xFF, 0x38, 0x3E, 0xE0, 0x7B,
  0x80, 0xEE, 0x03, 0xB8, 0x0E, 0xE0, 0x7B, 0x83, 0xCF, 0xFE, 0x3F, 0xF8,
  0xFF, 0xF3, 0x81, 0xEE, 0x03, 0xB8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03,
  0xB8, 0x1E, 0xFF, 0xFB, 0xFF, 0xCF, 0xFC, 0x00, 0x07, 0xC0, 0x7F, 0xC3,
  0xFF, 0x9E, 0x1F, 0x70, 0x3D, 0xC0, 0x7F, 0x01, 0xFC, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x01, 0xC0, 0x77, 0x01, 0xDE, 0x0F, 0x7F, 0xF8, 0xFF, 0xC0, 0xFE,
  0x00, 0xFF, 0x07, 0xFE, 0x3F, 0xF9, 0xC7, 0xEE, 0x07, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0xC1, 0xEF, 0xFF, 0x7F,
  0xF3, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x3F, 0xFD, 0xFF, 0xEF, 0xFF,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x00, 0x07, 0xC0, 0x7F, 0xC3, 0xFF,
  0x9E, 0x1F, 0x70, 0x3D, 0xC0, 0x7F, 0x01, 0xFC, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x7F, 0xF1, 0xFF, 0xC7, 0xFF, 0x01, 0xFC, 0x07, 0xF0,
  0x1D, 0xC0, 0x77, 0x01, 0xDE, 0x0F, 0x7F, 0xF8, 0xFF, 0xC0, 0xFE, 0x00,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x73, 0xC1, 0xE7, 0xFF, 0x87, 0xFF, 0x03, 0xF8, 0x00,
  0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xB8, 0x1E, 0xE0, 0x73, 0x83, 0xCE, 0x0E,
  0x38, 0x78, 0xE1, 0xC3, 0x8F, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0xC3, 0x8F,
  0x0E, 0x1C, 0x38, 0x78, 0xE0, 0xE3, 0x83, 0xCE, 0x07, 0x38, 0x1E, 0xE0,
  0x3B, 0x80, 0xFE, 0x03, 0xC0, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x3F,
  0xF0, 0x7F, 0xE0, 0xFE, 0xC3, 0xFF, 0x87, 0xFF, 0x8D, 0xFB, 0x1B, 0xF6,
  0x77, 0xEE, 0xCF, 0xCD, 0x9F, 0x9F, 0x3F, 0x3C, 0xFE, 0x39, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0x80, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xF0,
  0x7F, 0x83, 0xEE, 0x1F, 0x70, 0xFF, 0x87, 0xEE, 0x3F, 0x71, 0xF9, 0x8F,
  0xCE, 0x7E, 0x73, 0xF1, 0x9F, 0x8E, 0xFC, 0x77, 0xE1, 0xBF, 0x0F, 0xF8,
  0x7F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x81, 0xE0, 0x0F, 0xC0, 0x7F, 0xC3,
  0xFF, 0x9E, 0x1E, 0x70, 0x3D, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x1D, 0xC0, 0x77, 0x03, 0xDE, 0x0F, 0x7F, 0xF8, 0xFF, 0xC0, 0xFE,
  0x00, 0xFF, 0x03, 0xFF, 0x8F, 0xFF, 0xB8, 0x3E, 0xE0, 0x3F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xFE, 0x07, 0xBF, 0xFE, 0xFF, 0xF3,
  0xFF, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3,
  0xC3, 0xE7, 0x03, 0xDE, 0x03, 0xBC, 0x07, 0x78, 0x0E, 0xF0, 0x1D, 0xE0,
  0x3B, 0xC0, 0x77, 0x80, 0xEF, 0x01, 0xDE, 0x03, 0xBC, 0x07, 0x78, 0x0E,
  0xF0, 0x1D, 0xE0, 0x3B, 0xC0, 0x73, 0xC1, 0xE7, 0xFF, 0x87, 0xFE, 0x03,
  0xF8, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0xFF, 0x03, 0xFF, 0x8F, 0xFF, 0x38, 0x3E, 0xE0, 0x7B, 0x80, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xEE, 0x0F, 0xBF, 0xFC, 0xFF, 0xE3,
  0xFF, 0x0E, 0x3C, 0x38, 0x78, 0xE1, 0xE3, 0x83, 0x8E, 0x0F, 0x38, 0x1C,
  0xE0, 0x7B, 0x80, 0xEE, 0x03, 0xC0, 0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3,
  0xC3, 0xE7, 0x01, 0xCE, 0x03, 0x9C, 0x00, 0x38, 0x00, 0x78, 0x00, 0xFC,
  0x00, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x1F, 0x80, 0x0F, 0x00, 0x0E,
  0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x77, 0x81, 0xE7, 0xFF, 0xC7, 0xFF, 0x07,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0xE0, 0xFF, 0xFF, 0x3F, 0xF0, 0x7F, 0x00,
  0xF0, 0x07, 0x70, 0x07, 0x70, 0x0F, 0x78, 0x0E, 0x78, 0x0E, 0x38, 0x0E,
  0x38, 0x1E, 0x3C, 0x1C, 0x3C, 0x1C, 0x1C, 0x1C, 0x1C, 0x3C, 0x1C, 0x38,
  0x1E, 0x38, 0x0E, 0x38, 0x0E, 0x38, 0x0E, 0x70, 0x0F, 0x70, 0x07, 0x70,
  0x07, 0x70, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0xE1, 0xC3,
  0xF0, 0xE1, 0xF8, 0x70, 0xFC, 0x78, 0x7E, 0x34, 0x3F, 0x1A, 0x1B, 0x8D,
  0x9D, 0xC6, 0xCE, 0x63, 0x67, 0x39, 0xB3, 0x9C, 0xD9, 0xCE, 0xCC, 0xE7,
  0x66, 0x73, 0xB3, 0x31, 0xD8, 0x98, 0xEC, 0x6C, 0x76, 0x3E, 0x1B, 0x1F,
  0x0D, 0x8F, 0x86, 0x87, 0xC3, 0xC3, 0xE1, 0xE1, 0xF0, 0xF0, 0xF0, 0xF0,
  0x0F, 0x3C, 0x07, 0x8E, 0x07, 0x87, 0x83, 0x81, 0xC3, 0xC0, 0xF1, 0xC0,
  0x39, 0xE0, 0x1E, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x78,
  0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x1E, 0xE0, 0x0E, 0x78, 0x0F,
  0x1E, 0x07, 0x0F, 0x07, 0x83, 0xC7, 0x81, 0xE3, 0xC0, 0x7B, 0xC0, 0x3E,
  0xE0, 0x07, 0xF8, 0x03, 0x9C, 0x03, 0xCF, 0x01, 0xC3, 0x81, 0xE1, 0xE0,
  0xE0, 0x70, 0xF0, 0x3C, 0x70, 0x0E, 0x38, 0x07, 0xB8, 0x01, 0xDC, 0x00,
  0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x07,
  0x80, 0x38, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x00,
  0x70, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xC0, 0x07,
  0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xE0,
  0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x0F,
  0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0xFF,
  0xFF, 0xFF, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0x80, 0x1E, 0x00,
  0x7C, 0x03, 0xB0, 0x0E, 0xE0, 0x73, 0x81, 0xC7, 0x06, 0x1C, 0x38, 0x38,
  0xE0, 0xE7, 0x03, 0xBC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF8,
  0x70, 0x70, 0xF0, 0x0F, 0xE0, 0xFF, 0xE7, 0xEF, 0x9E, 0x0F, 0x70, 0x1C,
  0x00, 0x70, 0x01, 0xC7, 0xFF, 0x7F, 0xFD, 0xE0, 0x7F, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0xC0, 0xFF, 0x8F, 0xDF, 0xF7, 0x3F, 0x9C, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x9F, 0x9D, 0xFE, 0xFF, 0xF7,
  0x83, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xE0, 0xFF, 0xFF, 0x77, 0xFB, 0x9F, 0x80, 0x0F,
  0xE0, 0xFF, 0xE7, 0xFF, 0x9E, 0x0F, 0x70, 0x1F, 0xC0, 0x7F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x07, 0x70, 0x1D, 0xE0, 0xF7,
  0xFF, 0x8F, 0xFE, 0x0F, 0xE0, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x71, 0xF9, 0xCF, 0xF7, 0x7F, 0xDD, 0xE0, 0xF7, 0x03,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x77, 0x03, 0xDE, 0x0F, 0x7F, 0xDC, 0xFF, 0x71, 0xF9, 0xC0, 0x0F, 0xE0,
  0xFF, 0xC7, 0xCF, 0x9C, 0x0F, 0x70, 0x1F, 0xC0, 0x7F, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0xF7, 0xEF,
  0x8F, 0xFE, 0x0F, 0xE0, 0x00, 0x7E, 0x07, 0xFC, 0x1F, 0xF8, 0x3C, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x00,
  0x1F, 0x9C, 0xFF, 0x77, 0xFD, 0xDE, 0x0F, 0x70, 0x3F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x77, 0x01, 0xDC, 0x0F, 0x78, 0x7D, 0xFF,
  0x73, 0xFD, 0xC3, 0xC7, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x1F, 0x1F,
  0xF8, 0x7F, 0xC1, 0xF8, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0xBF, 0x9D, 0xFE, 0xFF, 0xF7, 0x83, 0xF8, 0x1F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF8,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0xFF, 0x83, 0xFE,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x83, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x7F, 0xEF, 0xFC, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xE0,
  0x3B, 0xFF, 0x7F, 0xCF, 0xF1, 0xE0, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x03, 0xF8, 0x0E, 0xE0, 0x7B, 0x83,
  0xCE, 0x0E, 0x38, 0x78, 0xE3, 0xC3, 0xFE, 0x0F, 0xF8, 0x3F, 0xF0, 0xE1,
  0xC3, 0x87, 0x8E, 0x0F, 0x38, 0x3C, 0xE0, 0x7B, 0x80, 0xFE, 0x03, 0xC0,
  0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x03, 0x80, 0x03, 0xC0, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0xEF, 0x7D,
  0xFE, 0xFB, 0x9E, 0x7F, 0x1C, 0x7E, 0x38, 0xFC, 0x71, 0xF8, 0xE3, 0xF1,
  0xC7, 0xE3, 0x8F, 0xC7, 0x1F, 0x8E, 0x3F, 0x1C, 0x7E, 0x38, 0xFC, 0x71,
  0xF8, 0xE3, 0xF1, 0xC7, 0xE3, 0x8E, 0xEF, 0xE7, 0x7F, 0xBF, 0xFD, 0xE0,
  0xFE, 0x07, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x38, 0x0F, 0xE0,
  0xFF, 0xC7, 0xFF, 0x9E, 0x0F, 0x70, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0x70, 0x1D, 0xE0, 0xF7, 0xFF,
  0x8F, 0xFC, 0x0F, 0xE0, 0xE7, 0xE7, 0x7F, 0xBF, 0xFD, 0xE0, 0xFE, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF8, 0x3F, 0xFF, 0xDD, 0xFE, 0xE7, 0xE7, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x00, 0x1F, 0x9C, 0xFF, 0x77, 0xFD, 0xDE,
  0x0F, 0x70, 0x3F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0x70, 0x3D, 0xE0, 0xF7, 0xFD, 0xCF, 0xF7, 0x1F, 0x9C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0xE7,
  0xE3, 0xBF, 0xCE, 0xFF, 0xBC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x00, 0x1F, 0xF0, 0xFF, 0xE7, 0xEF, 0xDC, 0x07,
  0x70, 0x01, 0xC0, 0x07, 0xC0, 0x0F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF0, 0x03,
  0xC0, 0x07, 0x80, 0x1D, 0xC0, 0x77, 0xFF, 0xCF, 0xFE, 0x1F, 0xF0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xFF, 0x07, 0xFC,
  0x07, 0xF0, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xF8,
  0x3D, 0xFF, 0xCF, 0xFC, 0x1F, 0xC0, 0xF0, 0x07, 0x70, 0x0F, 0x78, 0x0E,
  0x38, 0x0E, 0x38, 0x1E, 0x3C, 0x1C, 0x1C, 0x1C, 0x1C, 0x3C, 0x1E, 0x38,
  0x0E, 0x38, 0x0E, 0x78, 0x0F, 0x70, 0x07, 0x70, 0x07, 0x70, 0x07, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0xE1, 0xC3, 0xF0, 0xE1, 0xB8, 0xF0, 0xDC, 0x78,
  0xE6, 0x34, 0x73, 0x1B, 0x39, 0xCD, 0x9C, 0xE6, 0xCE, 0x72, 0x66, 0x3B,
  0x33, 0x1D, 0x9B, 0x86, 0xC7, 0xC3, 0x63, 0xE1, 0xF1, 0xF0, 0xF0, 0xF0,
  0x78, 0x78, 0x3C, 0x3C, 0x00, 0x78, 0x0F, 0x3C, 0x1E, 0x3C, 0x3C, 0x1E,
  0x3C, 0x0E, 0x78, 0x0F, 0x70, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07,
  0xE0, 0x07, 0xF0, 0x0F, 0x78, 0x1E, 0x78, 0x1C, 0x3C, 0x3C, 0x1E, 0x78,
  0x1E, 0xF0, 0x0F, 0xF0, 0x0F, 0x78, 0x0F, 0x78, 0x0E, 0x38, 0x1E, 0x3C,
  0x1E, 0x1C, 0x1C, 0x1E, 0x3C, 0x1E, 0x38, 0x0E, 0x38, 0x0F, 0x78, 0x07,
  0x70, 0x07, 0x70, 0x07, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xC0, 0x01,
  0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x78, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x78, 0x0F, 0xC0, 0xFE, 0x07, 0x80,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x78, 0x7F, 0x83, 0xF8, 0x1F, 0xE0, 0x0F, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xFE, 0x03, 0xF0, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xE0, 0x07, 0xC0, 0x3F, 0x00, 0x7C, 0x01, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00,
  0xE0, 0x07, 0xFC, 0x1F, 0xE0, 0xFF, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x3F, 0x81,
  0xF8, 0x0F, 0x80, 0x00, 0x7E, 0x0F, 0xFE, 0x1F, 0xFE, 0x3F, 0x1E, 0xFE,
  0x1F, 0xDC, 0x1F, 0x00,
};

const GFXglyph JetBrainsMono_Medium31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 5, 23, 19, 7, -23 },
  { 16, 10, 10, 19, 4, -23 },
  { 29, 17, 23, 19, 1, -23 },
  { 78, 15, 31, 19, 2, -27 },
  { 137, 18, 23, 19, 0, -23 },
  { 189, 16, 23, 19, 2, -23 },
  { 235, 4, 10, 19, 7, -23 },
  { 240, 10, 30, 19, 5, -26 },
  { 278, 9, 30, 19, 4, -26 },
  { 312, 17, 16, 19, 1, -19 },
  { 346, 15, 15, 19, 2, -18 },
  { 375, 7, 10, 19, 5, -5 },
  { 384, 10, 3, 19, 4, -12 },
  { 388, 5, 5, 19, 7, -5 },
  { 392, 14, 29, 19, 2, -26 },
  { 443, 14, 23, 19, 2, -23 },
  { 484, 14, 23, 19, 3, -23 },
  { 525, 14, 23, 19, 2, -23 },
  { 566, 14, 23, 19, 2, -23 },
  { 607, 14, 23, 19, 2, -23 },
  { 648, 14, 23, 19, 2, -23 },
  { 689, 15, 23, 19, 2, -23 },
  { 733, 15, 23, 19, 2, -23 },
  { 777, 14, 23, 19, 2, -23 },
  { 818, 15, 23, 19, 2, -23 },
  { 862, 5, 17, 19, 7, -17 },
  { 873, 7, 22, 19, 5, -17 },
  { 893, 13, 17, 19, 3, -19 },
  { 921, 13, 11, 19, 3, -16 },
  { 939, 13, 17, 19, 3, -19 },
  { 967, 11, 23, 19, 4, -23 },
  { 999, 17, 29, 19, 1, -23 },
  { 1061, 16, 23, 19, 1, -23 },
  { 1107, 14, 23, 19, 3, -23 },
  { 1148, 14, 23, 19, 2, -23 },
  { 1189, 13, 23, 19, 3, -23 },
  { 1227, 13, 23, 19, 3, -23 },
  { 1265, 13, 23, 19, 3, -23 },
  { 1303, 14, 23, 19, 2, -23 },
  { 1344, 13, 23, 19, 3, -23 },
  { 1382, 13, 23, 19, 3, -23 },
  { 1420, 15, 23, 19, 1, -23 },
  { 1464, 14, 23, 19, 3, -23 },
  { 1505, 14, 23, 19, 3, -23 },
  { 1546, 15, 23, 19, 2, -23 },
  { 1590, 13, 23, 19, 3, -23 },
  { 1628, 14, 23, 19, 2, -23 },
  { 1669, 14, 23, 19, 3, -23 },
  { 1710, 15, 29, 19, 2, -23 },
  { 1765, 14, 23, 19, 3, -23 },
  { 1806, 15, 23, 19, 2, -23 },
  { 1850, 15, 23, 19, 2, -23 },
  { 1894, 13, 23, 19, 3, -23 },
  { 1932, 16, 23, 19, 1, -23 },
  { 1978, 17, 23, 19, 1, -23 },
  { 2027, 17, 23, 19, 1, -23 },
  { 2076, 17, 23, 19, 1, -23 },
  { 2125, 13, 23, 19, 3, -23 },
  { 2163, 8, 29, 19, 6, -26 },
  { 2192, 14, 29, 19, 2, -26 },
  { 2243, 9, 29, 19, 4, -26 },
  { 2276, 14, 12, 19, 2, -23 },
  { 2297, 15, 3, 19, 2, 1 },
  { 2303, 7, 4, 19, 5, -24 },
  { 2307, 14, 17, 19, 2, -17 },
  { 2337, 13, 23, 19, 3, -23 },
  { 2375, 14, 17, 19, 2, -17 },
  { 2405, 14, 23, 19, 2, -23 },
  { 2446, 14, 17, 19, 2, -17 },
  { 2476, 15, 23, 19, 2, -23 },
  { 2520, 14, 23, 19, 2, -17 },
  { 2561, 13, 23, 19, 3, -23 },
  { 2599, 14, 24, 19, 3, -24 },
  { 2641, 11, 30, 19, 3, -24 },
  { 2683, 14, 23, 19, 3, -23 },
  { 2724, 16, 23, 19, 1, -23 },
  { 2770, 15, 17, 19, 2, -17 },
  { 2802, 13, 17, 19, 3, -17 },
  { 2830, 14, 17, 19, 2, -17 },
  { 2860, 13, 23, 19, 3, -17 },
  { 2898, 14, 23, 19, 2, -17 },
  { 2939, 14, 17, 19, 3, -17 },
  { 2969, 14, 17, 19, 2, -17 },
  { 2999, 14, 22, 19, 2, -22 },
  { 3038, 13, 17, 19, 3, -17 },
  { 3066, 16, 17, 19, 1, -17 },
  { 3100, 17, 17, 19, 1, -17 },
  { 3137, 16, 17, 19, 1, -17 },
  { 3171, 16, 23, 19, 1, -17 },
  { 3217, 13, 17, 19, 3, -17 },
  { 3245, 13, 29, 19, 3, -26 },
  { 3293, 3, 29, 19, 8, -26 },
  { 3304, 13, 29, 19, 3, -26 },
  { 3352, 15, 6, 19, 2, -14 },
};

const GFXfont JetBrainsMono_Medium31pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Medium31pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Medium31pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _JETBRAINSMONO_MEDIUM31PT7B_H_
