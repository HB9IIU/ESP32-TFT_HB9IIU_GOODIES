#ifndef _JETBRAINSMONO_MEDIUM44PT7B_H_
#define _JETBRAINSMONO_MEDIUM44PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Medium.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Medium44pt7bBitmaps[] PROGMEM = {
  0x00, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xEF, 0xFF, 0xFF, 0x3E, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F,
  0xF8, 0x7F, 0xE1, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83,
  0xDE, 0x0F, 0x78, 0x3C, 0x00, 0xF0, 0x3C, 0x00, 0xF0, 0x3C, 0x00, 0xE0,
  0x38, 0x00, 0xE0, 0x38, 0x01, 0xE0, 0x38, 0x01, 0xE0, 0x78, 0x01, 0xE0,
  0x78, 0x01, 0xC0, 0x78, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0x03, 0xC0, 0xF0, 0x03, 0x80, 0xE0, 0x03, 0x80,
  0xE0, 0x07, 0x80, 0xE0, 0x07, 0x81, 0xE0, 0x07, 0x81, 0xE0, 0x07, 0x01,
  0xE0, 0x07, 0x01, 0xC0, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0x0E, 0x03, 0xC0, 0x0E, 0x03, 0x80, 0x1E, 0x03,
  0x80, 0x1E, 0x07, 0x80, 0x1E, 0x07, 0x80, 0x1E, 0x07, 0x80, 0x1C, 0x07,
  0x00, 0x3C, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x1F, 0xF8, 0x01, 0xFF,
  0xF0, 0x1F, 0xFF, 0xC1, 0xFF, 0xFF, 0x1F, 0x9C, 0xF8, 0xF8, 0xE3, 0xE7,
  0xC7, 0x1F, 0x3C, 0x38, 0xF9, 0xE1, 0xC0, 0x0F, 0x8E, 0x00, 0x7C, 0x70,
  0x03, 0xF3, 0x80, 0x0F, 0xDC, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0x9F,
  0x80, 0x1C, 0x7C, 0x00, 0xE3, 0xE0, 0x07, 0x0F, 0x80, 0x38, 0x7F, 0xE1,
  0xC3, 0xDF, 0x0E, 0x3E, 0xFC, 0x71, 0xF3, 0xF3, 0x9F, 0x9F, 0xFF, 0xF8,
  0x7F, 0xFF, 0x81, 0xFF, 0xF8, 0x03, 0xFF, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x1F, 0xC0, 0x03, 0xCF, 0xFC, 0x01, 0xE7, 0xFF, 0x00, 0x71, 0xE1, 0xE0,
  0x3C, 0x70, 0x78, 0x1E, 0x1C, 0x0E, 0x07, 0x07, 0x03, 0x83, 0xC1, 0xC0,
  0xE1, 0xE0, 0x70, 0x38, 0x70, 0x1C, 0x1E, 0x3C, 0x07, 0x87, 0x9E, 0x01,
  0xFF, 0xCF, 0x00, 0x3F, 0xF3, 0x80, 0x07, 0xF9, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x04, 0x00, 0x03,
  0x8F, 0xE0, 0x01, 0xE7, 0xFC, 0x00, 0xF3, 0xFF, 0x80, 0x79, 0xE0, 0xF0,
  0x1C, 0x78, 0x3C, 0x0F, 0x1E, 0x0F, 0x07, 0x87, 0x83, 0xC1, 0xC1, 0xE0,
  0xF0, 0xF0, 0x78, 0x3C, 0x78, 0x1E, 0x0F, 0x1C, 0x03, 0xC7, 0x8F, 0x00,
  0xFF, 0xE7, 0x80, 0x1F, 0xF3, 0xC0, 0x03, 0xF8, 0x00, 0x20, 0x00, 0x07,
  0xFC, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFD, 0xFC, 0x07, 0xE0,
  0xF8, 0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x7F,
  0xE3, 0xE1, 0xF7, 0xC7, 0xC3, 0xEF, 0x87, 0xCF, 0x9F, 0x07, 0xDF, 0x3E,
  0x07, 0xFC, 0x7C, 0x0F, 0xF0, 0xF8, 0x0F, 0xE1, 0xF0, 0x0F, 0x83, 0xE0,
  0x1F, 0x07, 0xC0, 0x7F, 0x07, 0xC1, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xBE, 0x1F, 0xFE, 0x3E, 0x0F, 0xF0, 0x3E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x08, 0x03, 0xC0, 0x3E, 0x07, 0xF0, 0x7F, 0x87, 0xF0,
  0x7E, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFE, 0x07, 0xFC, 0x0F, 0xE0, 0x3F, 0x00, 0x78, 0x00, 0xC0, 0xC0,
  0x03, 0xC0, 0x0F, 0xC0, 0x3F, 0x80, 0xFF, 0x00, 0xFE, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x07, 0x80, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x0F, 0xC0, 0x7E,
  0x03, 0xF8, 0x1F, 0xC3, 0xFE, 0x0F, 0xF0, 0x3F, 0x00, 0xF8, 0x03, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x20, 0x3C, 0x06, 0x7C, 0x3C,
  0x3E, 0x7F, 0x1C, 0x7E, 0x7F, 0x99, 0xFF, 0xFF, 0xFB, 0xFE, 0x0F, 0xFF,
  0xF0, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF7, 0x00, 0x01, 0xE7,
  0x80, 0x03, 0xE7, 0xC0, 0x03, 0xE3, 0xE0, 0x07, 0xC3, 0xE0, 0x0F, 0xC1,
  0xF0, 0x0F, 0x81, 0xF8, 0x07, 0x00, 0xE0, 0x03, 0x00, 0x40, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xC7, 0xE1, 0xF8, 0x7E, 0x3F,
  0x0F, 0xC3, 0xE0, 0xF8, 0x7C, 0x1F, 0x07, 0xC1, 0xE0, 0xF8, 0x3C, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3E, 0x7F, 0xFF,
  0xFF, 0xFF, 0x7F, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F,
  0xFF, 0xE7, 0xE0, 0x7E, 0x7C, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x70, 0xFF, 0x8F, 0x8F, 0xF9, 0xF8, 0xFF, 0x9F, 0x8F, 0xF8, 0xF8,
  0xFF, 0x86, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0x78, 0x01, 0xF7, 0xC0, 0x3F, 0x7E,
  0x07, 0xE3, 0xFF, 0xFE, 0x1F, 0xFF, 0xC0, 0xFF, 0xF8, 0x07, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xF8,
  0x0F, 0xCF, 0x80, 0xF8, 0xF8, 0x0F, 0x0F, 0x80, 0xC0, 0xF8, 0x08, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x30, 0x00, 0x7F,
  0xE0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xE7, 0xE0, 0x7E, 0xFC,
  0x03, 0xEF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0xFF, 0x7F,
  0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE,
  0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x03, 0xFE, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xFC, 0x03, 0xE7, 0xE0, 0x7E, 0x7F, 0xFF, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xC0, 0x79, 0xF0, 0x0F, 0x7E, 0x01, 0xEF, 0x80, 0x3F, 0xE0, 0x07,
  0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE,
  0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xCF,
  0xE0, 0x7D, 0xFF, 0x87, 0xFF, 0xFC, 0x7F, 0xFF, 0xE7, 0xF0, 0x7E, 0x7C,
  0x03, 0xF7, 0xC0, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF7, 0x80, 0x1F,
  0x7C, 0x03, 0xE7, 0xE0, 0x7E, 0x3F, 0xFF, 0xE3, 0xFF, 0xFC, 0x0F, 0xFF,
  0x80, 0x7F, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF3,
  0xE0, 0x1F, 0x7F, 0xC1, 0xF7, 0xFF, 0x0F, 0xFF, 0xFC, 0x7E, 0x07, 0xE7,
  0xE0, 0x1F, 0xBE, 0x00, 0x7D, 0xF0, 0x01, 0xEF, 0x80, 0x0F, 0xF8, 0x00,
  0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xF7, 0xC0, 0x0F, 0x9F,
  0x00, 0x7C, 0xFC, 0x0F, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x3F, 0xFE,
  0x00, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x3E,
  0xF8, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x60, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x83, 0xFF,
  0xFC, 0x3F, 0xFF, 0xE7, 0xE0, 0x7E, 0x7C, 0x03, 0xE7, 0xC0, 0x1F, 0x78,
  0x01, 0xF7, 0x80, 0x1F, 0x7C, 0x01, 0xE7, 0xC0, 0x3E, 0x3E, 0x07, 0xE3,
  0xF0, 0xFC, 0x1F, 0xFF, 0x80, 0x7F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0xF0,
  0x1F, 0xDF, 0x83, 0xF0, 0x7C, 0x7E, 0x03, 0xE7, 0xC0, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xF7, 0xC0,
  0x1F, 0x7E, 0x07, 0xF7, 0xFF, 0xFE, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x07,
  0xFE, 0x00, 0x00, 0x20, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0xE0, 0x7F, 0xFF,
  0x83, 0xFF, 0xFE, 0x3F, 0x01, 0xF3, 0xF0, 0x07, 0xDF, 0x00, 0x3E, 0xF8,
  0x00, 0xF7, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xCF, 0x80, 0x7E, 0x7F, 0x07, 0xF1, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF8, 0x1F, 0xEF, 0x80, 0x3C, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x18, 0x7E, 0x7F, 0xFF, 0xFF, 0x7F, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x7E, 0x7F, 0xFF, 0xFF, 0x7F, 0x7E, 0x06, 0x07, 0xE3, 0xFC, 0xFF, 0x3F,
  0xC7, 0xF1, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x7F, 0x1F, 0x87, 0xE1, 0xF0, 0xFC,
  0x3E, 0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x1E, 0x07, 0x83, 0xE0, 0x00, 0x00,
  0x60, 0x00, 0x3C, 0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x07, 0xFC, 0x03, 0xFE,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xE0, 0x03, 0xE0, 0x00,
  0x70, 0x00, 0x0F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7E,
  0x00, 0x03, 0xC0, 0x00, 0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x00, 0x1C, 0x00, 0x03, 0xE0, 0x00,
  0x7F, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0xF0, 0x00, 0x7E,
  0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x07, 0xFE, 0x03,
  0xFF, 0x00, 0x7F, 0x80, 0x0F, 0x80, 0x01, 0xC0, 0x00, 0x20, 0x00, 0x00,
  0xFF, 0xC0, 0xFF, 0xF0, 0xFF, 0xF8, 0xFF, 0xFC, 0x01, 0xFE, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x3E, 0x00, 0x7E, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xF8, 0x1F, 0xE0,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x80,
  0x3F, 0x00, 0x3F, 0x00, 0x00, 0x10, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF,
  0x80, 0xFF, 0xFF, 0x83, 0xF8, 0x1F, 0x87, 0xC0, 0x0F, 0x9F, 0x00, 0x0F,
  0x3C, 0x00, 0x1E, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x01, 0xF9, 0xFE, 0x07, 0xFB, 0xFC, 0x1F, 0xFF, 0xF8,
  0x3C, 0x1F, 0xF0, 0xF8, 0x1F, 0xE1, 0xE0, 0x3F, 0xC3, 0xC0, 0x7F, 0x87,
  0x80, 0xFF, 0x0F, 0x01, 0xFE, 0x1E, 0x03, 0xFC, 0x3C, 0x07, 0xF8, 0x78,
  0x0F, 0xF0, 0xF0, 0x1F, 0xE1, 0xF0, 0x3F, 0xC1, 0xE0, 0xFF, 0x83, 0xFF,
  0xFF, 0x03, 0xFD, 0xFE, 0x03, 0xFB, 0xFC, 0x00, 0x80, 0x78, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3D, 0xE0, 0x00, 0xFB, 0xC0, 0x01, 0xE7,
  0x80, 0x03, 0xCF, 0x80, 0x07, 0x9F, 0x00, 0x1F, 0x1E, 0x00, 0x3E, 0x3C,
  0x00, 0x78, 0x7C, 0x00, 0xF0, 0xF8, 0x03, 0xE0, 0xF0, 0x07, 0xC1, 0xE0,
  0x0F, 0x03, 0xE0, 0x1E, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0xF8, 0x0F, 0x01,
  0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3E,
  0x00, 0xF8, 0x78, 0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x03, 0xC7, 0xC0,
  0x07, 0xCF, 0x00, 0x0F, 0xBE, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xF0, 0x0F, 0xCF, 0x00,
  0x7E, 0xF0, 0x03, 0xEF, 0x00, 0x3E, 0xF0, 0x03, 0xEF, 0x00, 0x3E, 0xF0,
  0x03, 0xEF, 0x00, 0x7C, 0xF0, 0x0F, 0xCF, 0xFF, 0xF8, 0xFF, 0xFE, 0x0F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x8F, 0x01, 0xFC, 0xF0, 0x07, 0xEF, 0x00, 0x3E,
  0xF0, 0x01, 0xEF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0x3E, 0xF0, 0x03, 0xEF, 0x00, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF,
  0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0x80, 0x00, 0x60, 0x01, 0xFF, 0x80, 0x7F,
  0xFC, 0x1F, 0xFF, 0xC7, 0xFF, 0xFD, 0xF8, 0x1F, 0xBE, 0x00, 0xFF, 0xC0,
  0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x03,
  0xFF, 0xC0, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFC,
  0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0x01,
  0xFD, 0xE0, 0x0F, 0xBC, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00,
  0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01,
  0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03,
  0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0x78, 0x1F, 0xEF, 0xFF, 0xF9, 0xFF, 0xFE,
  0x3F, 0xFF, 0x87, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFB, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x60, 0x01, 0xFF, 0x80, 0x7F, 0xFC, 0x1F, 0xFF, 0xC7, 0xFF,
  0xFD, 0xF8, 0x1F, 0xBE, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xFE, 0x00,
  0x7F, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x7F,
  0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03,
  0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0xC0, 0xFC, 0xFF, 0xFF,
  0x8F, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFC, 0x00, 0xF0, 0x03, 0xFE, 0x00,
  0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07,
  0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F,
  0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0x00, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x03, 0xE7, 0xE0, 0x7E, 0x7F, 0xFF,
  0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0x7F, 0xE0, 0xF0, 0x01, 0xF7, 0x80,
  0x1F, 0xBC, 0x00, 0xF9, 0xE0, 0x0F, 0xCF, 0x00, 0x7C, 0x78, 0x07, 0xE3,
  0xC0, 0x3E, 0x1E, 0x01, 0xF0, 0xF0, 0x1F, 0x07, 0x80, 0xF8, 0x3C, 0x0F,
  0x81, 0xE0, 0x7C, 0x0F, 0x07, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x1F,
  0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x3C, 0x1F, 0x01, 0xE0, 0x7C,
  0x0F, 0x03, 0xE0, 0x78, 0x1F, 0x83, 0xC0, 0x7C, 0x1E, 0x03, 0xF0, 0xF0,
  0x0F, 0x87, 0x80, 0x7E, 0x3C, 0x01, 0xF1, 0xE0, 0x0F, 0xCF, 0x00, 0x3E,
  0x78, 0x01, 0xFB, 0xC0, 0x07, 0xDE, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFE, 0xE0,
  0x7F, 0xF7, 0x83, 0xBF, 0xFC, 0x1D, 0xFE, 0xE1, 0xEF, 0xF7, 0x0E, 0x7F,
  0xBC, 0x73, 0xFC, 0xE7, 0x9F, 0xE7, 0x3D, 0xFF, 0x3D, 0xCF, 0xF8, 0xEE,
  0x7F, 0xC7, 0xF3, 0xFE, 0x3F, 0x1F, 0xF1, 0xF8, 0xFF, 0x87, 0xC7, 0xFC,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F,
  0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F,
  0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xF7, 0x83, 0xFE, 0xF0, 0x7F,
  0xDE, 0x0F, 0xF9, 0xE1, 0xFF, 0x3C, 0x3F, 0xE7, 0x87, 0xFC, 0x78, 0xFF,
  0x8F, 0x1F, 0xF1, 0xE3, 0xFE, 0x1E, 0x7F, 0xC3, 0xCF, 0xF8, 0x79, 0xFF,
  0x07, 0x9F, 0xE0, 0xF3, 0xFC, 0x0E, 0x7F, 0x81, 0xEF, 0xF0, 0x3D, 0xFE,
  0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC,
  0x03, 0xFF, 0x80, 0x3F, 0x00, 0x60, 0x01, 0xFF, 0x80, 0x7F, 0xFC, 0x1F,
  0xFF, 0xC7, 0xFF, 0xFD, 0xF8, 0x1F, 0xBE, 0x01, 0xF7, 0xC0, 0x1F, 0xF0,
  0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0,
  0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0,
  0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80,
  0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xEF, 0xC0,
  0xFC, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFC, 0x00, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0xF0, 0x0F, 0xEF,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x07,
  0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFE, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x30, 0x00, 0x3F, 0xF0,
  0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFE, 0x3F, 0x03, 0xF1, 0xF0,
  0x0F, 0xDF, 0x00, 0x3E, 0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0x7D,
  0xF0, 0x03, 0xEF, 0x80, 0x1F, 0x7C, 0x00, 0xFB, 0xE0, 0x07, 0xDF, 0x00,
  0x3E, 0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0x7D, 0xF0, 0x03, 0xEF,
  0x80, 0x1F, 0x7C, 0x00, 0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x01,
  0xF7, 0xC0, 0x0F, 0x9F, 0x00, 0x7C, 0xF8, 0x07, 0xE7, 0xE0, 0x7E, 0x1F,
  0xFF, 0xF0, 0x7F, 0xFF, 0x01, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xF0, 0x0F, 0xEF, 0x00, 0x3E, 0xF0, 0x03,
  0xEF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00,
  0x1F, 0xF0, 0x03, 0xEF, 0x00, 0x7E, 0xF0, 0x1F, 0xCF, 0xFF, 0xFC, 0xFF,
  0xFF, 0x8F, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0x07, 0xC0, 0xF0, 0x3E, 0x0F,
  0x03, 0xE0, 0xF0, 0x1F, 0x0F, 0x01, 0xF0, 0xF0, 0x1F, 0x8F, 0x00, 0xF8,
  0xF0, 0x0F, 0xCF, 0x00, 0x7C, 0xF0, 0x07, 0xEF, 0x00, 0x3E, 0xF0, 0x03,
  0xFF, 0x00, 0x1F, 0x00, 0x70, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F,
  0xFF, 0x83, 0xFF, 0xFE, 0x3F, 0x01, 0xF1, 0xF0, 0x07, 0xCF, 0x00, 0x3E,
  0x78, 0x01, 0xF3, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xBE,
  0x00, 0x7D, 0xF8, 0x03, 0xE7, 0xE0, 0x3F, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x03, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0xF0, 0x03,
  0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07,
  0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F,
  0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F,
  0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F,
  0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x1F, 0x7E, 0x07, 0xE7, 0xFF, 0xF8, 0x7F, 0xFF, 0x07, 0xFF, 0xC0,
  0x7F, 0xE0, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xF9, 0xE0, 0x01, 0xF3, 0xE0,
  0x03, 0xE7, 0xC0, 0x07, 0x8F, 0x80, 0x1F, 0x0F, 0x00, 0x3E, 0x1F, 0x00,
  0x7C, 0x3E, 0x00, 0xF0, 0x7C, 0x03, 0xE0, 0x78, 0x07, 0xC0, 0xF8, 0x0F,
  0x81, 0xF0, 0x1E, 0x03, 0xE0, 0x7C, 0x03, 0xC0, 0xF8, 0x07, 0xC1, 0xF0,
  0x0F, 0x83, 0xC0, 0x1F, 0x07, 0x80, 0x1E, 0x1F, 0x00, 0x3E, 0x3E, 0x00,
  0x7C, 0x78, 0x00, 0xF8, 0xF0, 0x00, 0xF3, 0xE0, 0x01, 0xE7, 0xC0, 0x03,
  0xEF, 0x00, 0x07, 0xDE, 0x00, 0x07, 0xBC, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0xF0, 0x3E,
  0x0F, 0xF0, 0x3E, 0x0F, 0xF0, 0x3E, 0x0F, 0xF8, 0x3E, 0x0F, 0xF8, 0x3E,
  0x0F, 0x78, 0x7E, 0x0F, 0x78, 0x76, 0x0F, 0x78, 0x76, 0x0F, 0x78, 0x76,
  0x0F, 0x78, 0x77, 0x1E, 0x78, 0x77, 0x1E, 0x78, 0x67, 0x1E, 0x78, 0x67,
  0x1E, 0x78, 0xE7, 0x1E, 0x3C, 0xE7, 0x1E, 0x3C, 0xE3, 0x1E, 0x3C, 0xE3,
  0x1E, 0x3C, 0xE3, 0x1E, 0x3C, 0xE3, 0x9C, 0x3C, 0xC3, 0xBC, 0x3C, 0xC3,
  0xBC, 0x3D, 0xC3, 0xBC, 0x3D, 0xC3, 0xBC, 0x3D, 0xC3, 0xBC, 0x1D, 0xC1,
  0xBC, 0x1F, 0xC1, 0xBC, 0x1F, 0xC1, 0xBC, 0x1F, 0x81, 0xF8, 0x1F, 0x81,
  0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x7E, 0x00,
  0x3E, 0x3E, 0x00, 0x7C, 0x3F, 0x00, 0x7C, 0x1F, 0x00, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x81, 0xF0, 0x07, 0xC1, 0xF0, 0x07, 0xC3, 0xE0, 0x03, 0xE3,
  0xE0, 0x03, 0xE7, 0xC0, 0x01, 0xF7, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xF7,
  0xC0, 0x03, 0xE7, 0xC0, 0x03, 0xE3, 0xE0, 0x07, 0xC3, 0xE0, 0x07, 0xC1,
  0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x80, 0xF8, 0x1F, 0x00, 0xF8, 0x3F, 0x00,
  0x7C, 0x3E, 0x00, 0x7E, 0x7C, 0x00, 0x3E, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x1F, 0x7C, 0x00, 0x3E, 0x3C, 0x00, 0x3E, 0x3E, 0x00, 0x3C, 0x3E, 0x00,
  0x7C, 0x1F, 0x00, 0x78, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x81,
  0xF0, 0x07, 0xC1, 0xF0, 0x07, 0xC3, 0xE0, 0x03, 0xE3, 0xE0, 0x03, 0xE7,
  0xC0, 0x01, 0xF7, 0xC0, 0x01, 0xF7, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xDE,
  0x00, 0x7D, 0xE0, 0x07, 0x9E, 0x00, 0x78, 0xF0, 0x0F, 0x0F, 0x00, 0xF0,
  0x78, 0x1E, 0x07, 0x81, 0xE0, 0x7C, 0x3E, 0x03, 0xC3, 0xC0, 0x3E, 0x7C,
  0x01, 0xE7, 0x80, 0x1E, 0xF8, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x3F, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x81, 0xFF,
  0xFC, 0x3F, 0x9F, 0xE7, 0xE0, 0x3E, 0x7C, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0xFF, 0xFF, 0x3F, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xFF, 0xE1, 0xFF, 0x7F, 0xFD,
  0xF3, 0xFF, 0xDF, 0x1F, 0xF1, 0xF0, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x81,
  0xC0, 0xF1, 0xFE, 0x1E, 0x7F, 0xE3, 0xDF, 0xFE, 0x7B, 0xFF, 0xEF, 0xC0,
  0x7D, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xFE, 0x00,
  0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x07,
  0xEF, 0x7F, 0xFD, 0xEF, 0xFF, 0x3C, 0xFF, 0xC7, 0x8F, 0xF0, 0x00, 0xF0,
  0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xE7, 0xE0,
  0x3E, 0x7C, 0x01, 0xF7, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x1F,
  0x7E, 0x07, 0xE3, 0xFF, 0xFE, 0x1F, 0xFF, 0xC0, 0xFF, 0xF8, 0x07, 0xFE,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x18, 0x1F, 0x0F, 0xF9, 0xF1,
  0xFF, 0xDF, 0x3F, 0xFD, 0xF7, 0xFF, 0xFF, 0x7E, 0x07, 0xF7, 0xC0, 0x3F,
  0x78, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x03, 0xF7, 0xE0, 0x7F, 0x3F,
  0xFF, 0xF3, 0xFF, 0xDF, 0x1F, 0xFD, 0xF0, 0xFF, 0x1F, 0x00, 0x70, 0x00,
  0x7F, 0xE0, 0x0F, 0xFF, 0x81, 0xFF, 0xFC, 0x3F, 0x0F, 0xE7, 0xC0, 0x3E,
  0x7C, 0x01, 0xF7, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x1F, 0x7E,
  0x03, 0xE3, 0xFD, 0xFE, 0x1F, 0xFF, 0xC0, 0xFF, 0xF8, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0x80, 0x03, 0xFE, 0x7C, 0xFF, 0xEF, 0xBF, 0xFD, 0xF7, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F,
  0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF,
  0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xF0, 0x3F, 0xBF, 0xFF, 0xF7,
  0xFF, 0xBE, 0x7F, 0xF7, 0xC7, 0xF8, 0xF8, 0x08, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x3F, 0xFF, 0x87,
  0xFF, 0xE0, 0xFF, 0xF8, 0x1F, 0xFC, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x81, 0xC0, 0xF1, 0xFE, 0x1E, 0x7F, 0xE3, 0xDF, 0xFE, 0x7B, 0xDF, 0xEF,
  0xC0, 0xFD, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xFE,
  0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8,
  0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0x01,
  0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x7F, 0xFF,
  0x7F, 0xFF, 0x7F, 0xFF, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E,
  0x00, 0x7E, 0x03, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0x80,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x01, 0xF7,
  0xC0, 0x1F, 0xBE, 0x01, 0xF9, 0xF0, 0x0F, 0x8F, 0x80, 0xFC, 0x7C, 0x0F,
  0xC3, 0xE0, 0x7C, 0x1F, 0x07, 0xE0, 0xF8, 0x3E, 0x07, 0xC3, 0xE0, 0x3F,
  0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xE1, 0xF8,
  0x1F, 0x07, 0xC0, 0xF8, 0x1F, 0x07, 0xC0, 0xFC, 0x3E, 0x03, 0xE1, 0xF0,
  0x0F, 0x8F, 0x80, 0x7E, 0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0xDF, 0x00, 0x3F,
  0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xFF, 0xE0,
  0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0x01, 0x01, 0x87, 0xBF,
  0x3F, 0x3F, 0xFB, 0xFD, 0xFF, 0xFF, 0xEF, 0x0F, 0x8F, 0xF8, 0x78, 0x7F,
  0xC3, 0xC1, 0xFE, 0x1E, 0x0F, 0xF0, 0xF0, 0x7F, 0x87, 0x83, 0xFC, 0x3C,
  0x1F, 0xE1, 0xE0, 0xFF, 0x0F, 0x07, 0xF8, 0x78, 0x3F, 0xC3, 0xC1, 0xFE,
  0x1E, 0x0F, 0xF0, 0xF0, 0x7F, 0x87, 0x83, 0xFC, 0x3C, 0x1F, 0xE1, 0xE0,
  0xFF, 0x0F, 0x07, 0xF8, 0x78, 0x3F, 0xC3, 0xC1, 0xFE, 0x1E, 0x0F, 0xF0,
  0xF0, 0x78, 0x00, 0x38, 0x1E, 0x3F, 0xC3, 0xCF, 0xFC, 0x7B, 0xFF, 0xCF,
  0x7F, 0xFD, 0xF8, 0x1F, 0xBE, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFE,
  0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8,
  0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0,
  0x03, 0xE0, 0x00, 0x60, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x81, 0xFF, 0xFC,
  0x3F, 0xFF, 0xE7, 0xE0, 0x7E, 0x7C, 0x03, 0xF7, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xF7, 0x80, 0x1F, 0x7C,
  0x01, 0xF7, 0xC0, 0x3E, 0x7E, 0x07, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0,
  0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x00, 0x38, 0x1E, 0x3F, 0xC3, 0xCF, 0xFC,
  0x7B, 0xFF, 0xCF, 0x7F, 0xFD, 0xF8, 0x0F, 0xBE, 0x01, 0xFF, 0xC0, 0x1F,
  0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F,
  0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0xC0, 0xFD, 0xEF, 0xFF, 0xBD, 0xFF, 0xE7,
  0x9F, 0xF8, 0xF1, 0xFE, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0x00, 0x03, 0xFE, 0x7C, 0xFF, 0xEF, 0xBF, 0xFD, 0xF7, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F,
  0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF,
  0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF,
  0xC0, 0xFE, 0xFF, 0xFF, 0xDF, 0xFE, 0xF9, 0xFF, 0xDF, 0x1F, 0xE3, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x38, 0x0F, 0x9F, 0xF0,
  0xFB, 0xFF, 0x8F, 0xBF, 0xFC, 0xFF, 0x9F, 0xEF, 0xE0, 0x3E, 0xFC, 0x03,
  0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x70,
  0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0x8F, 0xE7, 0xC0,
  0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0xC0, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF7, 0x80, 0x1F,
  0x7C, 0x01, 0xF7, 0xFF, 0xFF, 0x3F, 0xFF, 0xE1, 0xFF, 0xFC, 0x07, 0xFF,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00,
  0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x7F, 0xE0, 0xF0,
  0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0,
  0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0,
  0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80,
  0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0x7E, 0x07, 0xE7, 0xFF,
  0xF8, 0x7F, 0xFF, 0x07, 0xFF, 0x80, 0x7F, 0xE0, 0xF8, 0x00, 0x7D, 0xE0,
  0x01, 0xF7, 0xC0, 0x07, 0x9F, 0x00, 0x3E, 0x3C, 0x00, 0xF8, 0xF8, 0x03,
  0xC3, 0xE0, 0x1F, 0x07, 0x80, 0x7C, 0x1F, 0x01, 0xE0, 0x7C, 0x0F, 0x80,
  0xF0, 0x3E, 0x03, 0xE0, 0xF0, 0x0F, 0x83, 0xC0, 0x1E, 0x1F, 0x00, 0x7C,
  0x78, 0x01, 0xF1, 0xE0, 0x03, 0xCF, 0x80, 0x0F, 0xBC, 0x00, 0x3E, 0xF0,
  0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0x78, 0x3E, 0x0F, 0x78,
  0x3E, 0x0F, 0x78, 0x7E, 0x0E, 0x78, 0x7E, 0x1E, 0x78, 0x76, 0x1E, 0x78,
  0x76, 0x1E, 0x38, 0x67, 0x1E, 0x3C, 0x67, 0x1E, 0x3C, 0x67, 0x1C, 0x3C,
  0xE7, 0x1C, 0x3C, 0xE3, 0x3C, 0x3C, 0xE3, 0x3C, 0x3C, 0xE3, 0x3C, 0x1C,
  0xC3, 0xBC, 0x1E, 0xC3, 0xBC, 0x1F, 0xC3, 0xB8, 0x1F, 0xC3, 0xB8, 0x1F,
  0xC1, 0xF8, 0x1F, 0xC1, 0xF8, 0x0F, 0x81, 0xF8, 0x0F, 0x81, 0xF8, 0x0F,
  0x81, 0xF0, 0xFC, 0x00, 0xFC, 0x7C, 0x03, 0xF0, 0xFC, 0x07, 0xC0, 0xF8,
  0x1F, 0x80, 0xF8, 0x3E, 0x01, 0xF8, 0xF8, 0x01, 0xF3, 0xE0, 0x01, 0xF7,
  0xC0, 0x03, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xC0, 0x01, 0xF7, 0xC0,
  0x07, 0xCF, 0x80, 0x1F, 0x8F, 0x80, 0x3E, 0x1F, 0x80, 0xF8, 0x1F, 0x03,
  0xF0, 0x1F, 0x07, 0xC0, 0x3F, 0x1F, 0x00, 0x3E, 0x7E, 0x00, 0x3F, 0xFC,
  0x00, 0x7D, 0xF0, 0x01, 0xF7, 0xC0, 0x0F, 0x8F, 0x80, 0x3E, 0x3E, 0x00,
  0xF8, 0xF8, 0x07, 0xC1, 0xF0, 0x1F, 0x07, 0xC0, 0x7C, 0x1F, 0x03, 0xE0,
  0x3E, 0x0F, 0x80, 0xF8, 0x3C, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x1F,
  0x1E, 0x00, 0x3E, 0xF8, 0x00, 0xFB, 0xE0, 0x01, 0xEF, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0xE0, 0x01, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE,
  0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x7F, 0xF8, 0x0F,
  0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xF8, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x00,
  0x1F, 0xE0, 0x00, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE0, 0x00, 0x1F, 0xC0, 0x03,
  0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x01, 0xFF, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0,
  0x7F, 0xF8, 0x1F, 0x80, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x7F,
  0x80, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x00, 0x00, 0x3F,
  0x80, 0x7B, 0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xF7, 0xE0, 0xFF, 0x0F, 0x8F,
  0xF8, 0x7F, 0xFF, 0xC1, 0xFF, 0xDE, 0x07, 0xFC, 0xF0, 0x1F, 0xC0,
};

const GFXglyph JetBrainsMono_Medium44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 26, 0, -1 },
  { 1, 7, 32, 26, 10, -32 },
  { 29, 14, 13, 26, 6, -32 },
  { 52, 24, 32, 26, 1, -32 },
  { 148, 21, 44, 26, 3, -38 },
  { 264, 26, 32, 26, 0, -32 },
  { 368, 23, 33, 26, 2, -33 },
  { 463, 4, 13, 26, 11, -32 },
  { 470, 13, 42, 26, 8, -37 },
  { 539, 14, 42, 26, 5, -37 },
  { 613, 24, 23, 26, 1, -27 },
  { 682, 21, 21, 26, 3, -25 },
  { 738, 10, 14, 26, 7, -7 },
  { 756, 14, 5, 26, 6, -17 },
  { 765, 8, 7, 26, 9, -7 },
  { 772, 20, 42, 26, 3, -37 },
  { 877, 20, 33, 26, 3, -33 },
  { 960, 20, 32, 26, 4, -32 },
  { 1040, 20, 33, 26, 3, -33 },
  { 1123, 20, 32, 26, 3, -32 },
  { 1203, 19, 32, 26, 3, -32 },
  { 1279, 20, 32, 26, 3, -32 },
  { 1359, 21, 32, 26, 3, -32 },
  { 1443, 21, 32, 26, 3, -32 },
  { 1527, 20, 33, 26, 3, -33 },
  { 1610, 21, 33, 26, 3, -33 },
  { 1697, 8, 25, 26, 9, -25 },
  { 1722, 10, 32, 26, 7, -25 },
  { 1762, 19, 23, 26, 4, -26 },
  { 1817, 19, 15, 26, 4, -22 },
  { 1853, 19, 23, 26, 4, -26 },
  { 1908, 16, 32, 26, 6, -32 },
  { 1972, 23, 41, 26, 2, -33 },
  { 2090, 23, 32, 26, 2, -32 },
  { 2182, 20, 32, 26, 4, -32 },
  { 2262, 19, 33, 26, 4, -33 },
  { 2341, 19, 32, 26, 4, -32 },
  { 2417, 19, 32, 26, 4, -32 },
  { 2493, 19, 32, 26, 4, -32 },
  { 2569, 19, 33, 26, 4, -33 },
  { 2648, 19, 32, 26, 4, -32 },
  { 2724, 18, 32, 26, 4, -32 },
  { 2796, 20, 32, 26, 2, -32 },
  { 2876, 21, 32, 26, 4, -32 },
  { 2960, 19, 32, 26, 5, -32 },
  { 3036, 21, 32, 26, 3, -32 },
  { 3120, 19, 32, 26, 4, -32 },
  { 3196, 19, 33, 26, 4, -33 },
  { 3275, 20, 32, 26, 4, -32 },
  { 3355, 21, 41, 26, 3, -33 },
  { 3463, 20, 32, 26, 4, -32 },
  { 3543, 21, 33, 26, 3, -33 },
  { 3630, 22, 32, 26, 2, -32 },
  { 3718, 19, 32, 26, 4, -32 },
  { 3794, 23, 32, 26, 2, -32 },
  { 3886, 24, 32, 26, 1, -32 },
  { 3982, 24, 32, 26, 1, -32 },
  { 4078, 24, 32, 26, 1, -32 },
  { 4174, 19, 32, 26, 4, -32 },
  { 4250, 11, 42, 26, 9, -37 },
  { 4308, 20, 42, 26, 3, -37 },
  { 4413, 12, 42, 26, 6, -37 },
  { 4476, 20, 17, 26, 3, -32 },
  { 4519, 21, 4, 26, 3, 1 },
  { 4530, 10, 7, 26, 8, -35 },
  { 4539, 20, 25, 26, 3, -25 },
  { 4602, 19, 32, 26, 4, -32 },
  { 4678, 20, 25, 26, 3, -25 },
  { 4741, 20, 32, 26, 3, -32 },
  { 4821, 20, 25, 26, 3, -25 },
  { 4884, 21, 32, 26, 3, -32 },
  { 4968, 19, 33, 26, 4, -25 },
  { 5047, 19, 32, 26, 4, -32 },
  { 5123, 20, 34, 26, 4, -34 },
  { 5208, 16, 42, 26, 4, -34 },
  { 5292, 21, 32, 26, 4, -32 },
  { 5376, 23, 32, 26, 1, -32 },
  { 5468, 21, 25, 26, 3, -25 },
  { 5534, 19, 25, 26, 4, -25 },
  { 5594, 20, 25, 26, 3, -25 },
  { 5657, 19, 33, 26, 4, -25 },
  { 5736, 19, 33, 26, 4, -25 },
  { 5815, 20, 25, 26, 4, -25 },
  { 5878, 20, 25, 26, 3, -25 },
  { 5941, 21, 31, 26, 2, -31 },
  { 6023, 19, 24, 26, 4, -24 },
  { 6080, 22, 24, 26, 2, -24 },
  { 6146, 24, 24, 26, 1, -24 },
  { 6218, 23, 24, 26, 2, -24 },
  { 6287, 22, 32, 26, 2, -24 },
  { 6375, 19, 24, 26, 4, -24 },
  { 6432, 19, 42, 26, 4, -37 },
  { 6532, 5, 42, 26, 11, -37 },
  { 6559, 19, 42, 26, 4, -37 },
  { 6659, 21, 9, 26, 3, -20 },
};

const GFXfont JetBrainsMono_Medium44pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Medium44pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Medium44pt7bGlyphs,
  0x20, 0x7E, 58
};

#endif // _JETBRAINSMONO_MEDIUM44PT7B_H_
