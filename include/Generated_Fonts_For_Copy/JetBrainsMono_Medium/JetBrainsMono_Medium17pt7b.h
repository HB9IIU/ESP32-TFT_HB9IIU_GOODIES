#ifndef _JETBRAINSMONO_MEDIUM17PT7B_H_
#define _JETBRAINSMONO_MEDIUM17PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Medium.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Medium17pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0x0F, 0xCF, 0x3C, 0xF3, 0x4C, 0x33, 0x19, 0x88, 0x9F,
  0xF2, 0x21, 0x31, 0x99, 0xFE, 0xFF, 0x22, 0x11, 0x19, 0x80, 0x08, 0x08,
  0x18, 0x7E, 0x6B, 0xCB, 0xC8, 0x68, 0x3C, 0x0E, 0x0B, 0x0B, 0xCB, 0x7F,
  0x3E, 0x08, 0x08, 0x20, 0x1E, 0x3C, 0x9B, 0x24, 0xCA, 0x1D, 0x80, 0x40,
  0x24, 0x1F, 0xC5, 0x92, 0x65, 0x9B, 0xC3, 0x80, 0x18, 0x3E, 0x19, 0x88,
  0x06, 0x03, 0x03, 0xC3, 0xB6, 0xCB, 0x67, 0x31, 0x99, 0xE7, 0xB8, 0xFF,
  0xC0, 0x19, 0xD8, 0xCC, 0x63, 0x18, 0xC6, 0x31, 0x86, 0x38, 0xE1, 0xC7,
  0x0C, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x33, 0x9B, 0x90, 0x18, 0x0C, 0x36,
  0xDD, 0xF1, 0x81, 0xE1, 0x98, 0xCC, 0x18, 0x18, 0x18, 0x18, 0xFF, 0x18,
  0x18, 0x18, 0x76, 0x6C, 0xC8, 0xFC, 0xDF, 0x00, 0x03, 0x02, 0x06, 0x06,
  0x0C, 0x0C, 0x0C, 0x18, 0x18, 0x10, 0x30, 0x30, 0x60, 0x60, 0x60, 0xC0,
  0x18, 0x7E, 0x63, 0xC3, 0xC3, 0xC3, 0xDB, 0xDB, 0xC3, 0xC3, 0xC3, 0x66,
  0x3C, 0x3C, 0x6C, 0xCC, 0x8C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0xFF,
  0xFF, 0x18, 0x7E, 0xE7, 0xC3, 0x03, 0x03, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xFF, 0xFF, 0x7E, 0x06, 0x0C, 0x18, 0x1C, 0x1E, 0x03, 0x03, 0x03, 0xC3,
  0x66, 0x3C, 0x0E, 0x0C, 0x18, 0x30, 0x30, 0x63, 0xC3, 0xC3, 0xFF, 0x03,
  0x03, 0x03, 0x7E, 0x40, 0x40, 0x40, 0x5E, 0x67, 0x03, 0x03, 0x03, 0xC3,
  0x66, 0x3E, 0x0C, 0x18, 0x30, 0x30, 0x6C, 0x7E, 0xC3, 0xC3, 0xC3, 0xC3,
  0x67, 0x3E, 0xFF, 0xC3, 0xC3, 0x06, 0x06, 0x04, 0x0C, 0x0C, 0x18, 0x18,
  0x10, 0x30, 0x18, 0x7E, 0x63, 0xC3, 0x43, 0x66, 0x3C, 0x7E, 0xC3, 0xC3,
  0xC3, 0x67, 0x3E, 0x18, 0x7E, 0xE3, 0xC3, 0xC3, 0xC3, 0xE7, 0x7E, 0x06,
  0x0C, 0x0C, 0x18, 0x30, 0x5F, 0x00, 0x02, 0xF8, 0x27, 0x60, 0x00, 0x07,
  0x66, 0xCC, 0x80, 0x03, 0x0F, 0x3C, 0xF0, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x0F,
  0x38, 0xE0, 0x80, 0xF8, 0x30, 0xC1, 0x0D, 0xF7, 0x18, 0x00, 0x07, 0x1C,
  0x18, 0x3F, 0x30, 0xD8, 0x38, 0x1C, 0xFE, 0x67, 0x33, 0x99, 0xCC, 0xE6,
  0x71, 0xF8, 0x06, 0x01, 0xC0, 0x78, 0x1C, 0x3C, 0x3C, 0x34, 0x26, 0x66,
  0x66, 0x7E, 0x7F, 0xC3, 0xC3, 0xC3, 0xFE, 0xC7, 0xC3, 0xC3, 0xC6, 0xFC,
  0xC7, 0xC3, 0xC3, 0xC3, 0xFF, 0xFE, 0x18, 0x7E, 0x63, 0xC3, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC3, 0x76, 0x3E, 0xFE, 0xC6, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xFE, 0xFC, 0xFF, 0x02, 0x04, 0x08, 0x1F,
  0xA0, 0x40, 0x81, 0x03, 0xFF, 0xF0, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF,
  0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x18, 0x7E, 0x63, 0xC3, 0xC0, 0xC0,
  0xC0, 0xCF, 0xC3, 0xC3, 0xC3, 0x76, 0x3E, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xFF, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xFE, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x63, 0xFF, 0xF0, 0x1F, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x83, 0xC6, 0xEE, 0x7C, 0xC3, 0x61, 0xB1, 0x98, 0xCC, 0xC7,
  0xE3, 0x31, 0x98, 0xC6, 0x63, 0x30, 0xD8, 0x70, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0xFF, 0xF0, 0xE3, 0xA7, 0xE5, 0xF5, 0xDF,
  0xDB, 0xDB, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xE3, 0xE3, 0xF3, 0xD3, 0xD3,
  0xDB, 0xCB, 0xCB, 0xCF, 0xC7, 0xC7, 0xC7, 0x18, 0x7E, 0x67, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x76, 0x3C, 0xFE, 0xC3, 0xC3, 0xC1,
  0xC3, 0xFF, 0xFE, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x18, 0x7E, 0x67, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x76, 0x3E, 0x06, 0x06, 0x03,
  0xFE, 0xC7, 0xC3, 0xC3, 0xC3, 0xFE, 0xFC, 0xCC, 0xC6, 0xC6, 0xC3, 0xC3,
  0x18, 0x7E, 0x63, 0xC3, 0xC0, 0x60, 0x3C, 0x0E, 0x03, 0x03, 0xC3, 0x77,
  0x3E, 0xFF, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x76,
  0x3E, 0xC3, 0xC3, 0xC3, 0x62, 0x66, 0x66, 0x66, 0x34, 0x3C, 0x3C, 0x3C,
  0x18, 0xCC, 0xD3, 0x34, 0xCD, 0x32, 0x4E, 0x9A, 0xA7, 0x29, 0xCE, 0x73,
  0x9C, 0xE3, 0x38, 0xCE, 0xC3, 0x33, 0x19, 0x87, 0x83, 0xC0, 0xC0, 0x70,
  0x78, 0x26, 0x33, 0x30, 0xD8, 0x70, 0xE1, 0xD8, 0x63, 0x30, 0xCC, 0x1A,
  0x07, 0x80, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0xFF, 0x03, 0x06,
  0x0C, 0x0C, 0x18, 0x18, 0x30, 0x60, 0x60, 0xFF, 0xFF, 0xFF, 0xF1, 0x8C,
  0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0xFF, 0xC0, 0x60, 0x60, 0x60, 0x30,
  0x30, 0x18, 0x18, 0x18, 0x0C, 0x0C, 0x0C, 0x06, 0x06, 0x03, 0x03, 0xFF,
  0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8F, 0xFF, 0x18, 0x3C, 0x34,
  0x66, 0x62, 0xC3, 0xFF, 0xFF, 0xE7, 0x08, 0x7E, 0x63, 0x83, 0x03, 0x7F,
  0xC3, 0xC3, 0xE7, 0x7B, 0xC0, 0xC0, 0xC8, 0xDE, 0xE7, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xF7, 0xDE, 0x08, 0x7E, 0x67, 0xC3, 0xC0, 0xC0, 0xC0, 0xC3,
  0x77, 0x3E, 0x03, 0x03, 0x13, 0x7F, 0x67, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0x67, 0x7B, 0x08, 0x7E, 0x63, 0xC3, 0xC3, 0xFF, 0xC0, 0xC0, 0x67, 0x3E,
  0x1F, 0x18, 0x10, 0x10, 0xFF, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x7F, 0x67, 0xC3, 0xC3, 0xC3, 0xC3, 0x67, 0x7F, 0x03, 0x03, 0x3E,
  0x3E, 0xC0, 0xC0, 0xC8, 0xDE, 0xE7, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0x1C, 0x1C, 0x00, 0x00, 0x78, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08,
  0xFF, 0xFF, 0x0E, 0x1C, 0x00, 0x07, 0xE0, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xBF, 0x7C, 0xC0, 0x60, 0x30, 0x38, 0x6C, 0x66, 0x33, 0xF1,
  0xF8, 0xCC, 0x63, 0x30, 0xD8, 0x70, 0xF8, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x03, 0xE0, 0xF0, 0x12, 0xFF, 0xD9, 0xD9,
  0xD9, 0xD9, 0xD9, 0xD9, 0xD9, 0xD9, 0x08, 0xDE, 0xE7, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0x08, 0x7E, 0x67, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0x76, 0x3C, 0x08, 0xDE, 0xE7, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xF6, 0xDE,
  0xC0, 0xC0, 0xC0, 0x10, 0x7F, 0x67, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x67,
  0x7B, 0x03, 0x03, 0x03, 0x09, 0xFB, 0x1E, 0x3C, 0x78, 0x30, 0x60, 0xC1,
  0x80, 0x08, 0x7E, 0x63, 0x40, 0x78, 0x3E, 0x03, 0x83, 0x67, 0x7E, 0x30,
  0x30, 0x30, 0xFF, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x1F, 0x1F, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x66, 0x3C, 0xC3, 0xC3, 0x62, 0x66,
  0x66, 0x34, 0x3C, 0x3C, 0x18, 0xCC, 0xD3, 0x24, 0xC9, 0xB2, 0x6A, 0x9C,
  0xE3, 0x38, 0xCC, 0x33, 0x00, 0xE3, 0x66, 0x3C, 0x1C, 0x18, 0x3C, 0x66,
  0x66, 0xC3, 0xC3, 0x43, 0x66, 0x66, 0x36, 0x3C, 0x3C, 0x1C, 0x18, 0x18,
  0x10, 0x30, 0x7F, 0x06, 0x0E, 0x0C, 0x18, 0x30, 0x60, 0xFF, 0xFF, 0x07,
  0x0F, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0xF8, 0xF8, 0x0C, 0x0C, 0x0C, 0x0C,
  0x0C, 0x0F, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x10, 0x10, 0x10,
  0x30, 0x10, 0x1F, 0x1F, 0x10, 0x30, 0x10, 0x10, 0x10, 0xF0, 0xE0, 0x71,
  0xF9, 0xCF, 0xC6,
};

const GFXglyph JetBrainsMono_Medium17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 2, 12, 10, 4, -12 },
  { 4, 6, 5, 10, 2, -12 },
  { 8, 9, 12, 10, 1, -12 },
  { 22, 8, 17, 10, 1, -15 },
  { 39, 10, 13, 10, 0, -13 },
  { 56, 9, 13, 10, 1, -13 },
  { 71, 2, 5, 10, 4, -12 },
  { 73, 5, 16, 10, 3, -14 },
  { 83, 5, 16, 10, 2, -14 },
  { 93, 9, 8, 10, 1, -10 },
  { 102, 8, 8, 10, 1, -10 },
  { 110, 4, 6, 10, 3, -3 },
  { 113, 6, 1, 10, 2, -6 },
  { 114, 3, 3, 10, 4, -3 },
  { 116, 8, 16, 10, 1, -14 },
  { 132, 8, 13, 10, 1, -13 },
  { 145, 8, 12, 10, 1, -12 },
  { 157, 8, 13, 10, 1, -13 },
  { 170, 8, 12, 10, 1, -12 },
  { 182, 8, 12, 10, 1, -12 },
  { 194, 8, 12, 10, 1, -12 },
  { 206, 8, 12, 10, 1, -12 },
  { 218, 8, 12, 10, 1, -12 },
  { 230, 8, 13, 10, 1, -13 },
  { 243, 8, 13, 10, 1, -13 },
  { 256, 3, 10, 10, 4, -10 },
  { 260, 4, 13, 10, 3, -10 },
  { 267, 8, 9, 10, 1, -10 },
  { 276, 8, 6, 10, 1, -9 },
  { 282, 8, 9, 10, 1, -10 },
  { 291, 6, 12, 10, 2, -12 },
  { 300, 9, 16, 10, 1, -13 },
  { 318, 8, 12, 10, 1, -12 },
  { 330, 8, 12, 10, 1, -12 },
  { 342, 8, 13, 10, 1, -13 },
  { 355, 8, 12, 10, 1, -12 },
  { 367, 7, 12, 10, 2, -12 },
  { 378, 8, 12, 10, 1, -12 },
  { 390, 8, 13, 10, 1, -13 },
  { 403, 8, 12, 10, 1, -12 },
  { 415, 7, 12, 10, 2, -12 },
  { 426, 8, 12, 10, 1, -12 },
  { 438, 9, 12, 10, 1, -12 },
  { 452, 7, 12, 10, 2, -12 },
  { 463, 8, 12, 10, 1, -12 },
  { 475, 8, 12, 10, 1, -12 },
  { 487, 8, 13, 10, 1, -13 },
  { 500, 8, 12, 10, 1, -12 },
  { 512, 8, 16, 10, 1, -13 },
  { 528, 8, 12, 10, 1, -12 },
  { 540, 8, 13, 10, 1, -13 },
  { 553, 8, 12, 10, 1, -12 },
  { 565, 8, 12, 10, 1, -12 },
  { 577, 8, 12, 10, 1, -12 },
  { 589, 10, 12, 10, 0, -12 },
  { 604, 9, 12, 10, 1, -12 },
  { 618, 10, 12, 10, 0, -12 },
  { 633, 8, 12, 10, 1, -12 },
  { 645, 5, 16, 10, 3, -14 },
  { 655, 8, 16, 10, 1, -14 },
  { 671, 5, 16, 10, 2, -14 },
  { 681, 8, 6, 10, 1, -12 },
  { 687, 8, 2, 10, 1, 0 },
  { 689, 4, 2, 10, 3, -13 },
  { 690, 8, 10, 10, 1, -10 },
  { 700, 8, 12, 10, 1, -12 },
  { 712, 8, 10, 10, 1, -10 },
  { 722, 8, 12, 10, 1, -12 },
  { 734, 8, 10, 10, 1, -10 },
  { 744, 8, 12, 10, 1, -12 },
  { 756, 8, 13, 10, 1, -10 },
  { 769, 8, 12, 10, 1, -12 },
  { 781, 8, 13, 10, 1, -13 },
  { 794, 7, 16, 10, 1, -13 },
  { 808, 9, 12, 10, 1, -12 },
  { 822, 9, 12, 10, 0, -12 },
  { 836, 8, 10, 10, 1, -10 },
  { 846, 8, 10, 10, 1, -10 },
  { 856, 8, 10, 10, 1, -10 },
  { 866, 8, 13, 10, 1, -10 },
  { 879, 8, 13, 10, 1, -10 },
  { 892, 7, 10, 10, 2, -10 },
  { 901, 8, 10, 10, 1, -10 },
  { 911, 8, 12, 10, 1, -12 },
  { 923, 8, 9, 10, 1, -9 },
  { 932, 8, 9, 10, 1, -9 },
  { 941, 10, 9, 10, 0, -9 },
  { 953, 8, 9, 10, 1, -9 },
  { 962, 8, 12, 10, 1, -9 },
  { 974, 8, 9, 10, 1, -9 },
  { 983, 8, 16, 10, 1, -14 },
  { 999, 2, 16, 10, 4, -14 },
  { 1003, 8, 16, 10, 1, -14 },
  { 1019, 8, 4, 10, 1, -8 },
};

const GFXfont JetBrainsMono_Medium17pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Medium17pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Medium17pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _JETBRAINSMONO_MEDIUM17PT7B_H_
