#ifndef _JETBRAINSMONO_MEDIUM62PT7B_H_
#define _JETBRAINSMONO_MEDIUM62PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Medium.ttf
// Size: 62pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Medium62pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F,
  0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8,
  0x3E, 0x0F, 0x83, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x07, 0xF3, 0xFE, 0xFF, 0xBF, 0xFF, 0xFB, 0xFE, 0x7F, 0x00, 0xFE, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0,
  0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7E, 0xFC,
  0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF,
  0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0x00, 0x1F, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x3E, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x07, 0xC0, 0x0F, 0x80,
  0x03, 0xE0, 0x0F, 0x80, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0xF8, 0x03, 0xE0,
  0x00, 0x7C, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x3E, 0x03, 0xFF, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xFF, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0xF8, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x3E, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x01, 0xF0,
  0x07, 0xC0, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0x7C,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFE, 0x03,
  0xE0, 0x0F, 0x80, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0xF8, 0x03, 0xE0, 0x00,
  0xF8, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x07, 0xC0, 0x1F, 0x00,
  0x07, 0xC0, 0x0F, 0x80, 0x03, 0xE0, 0x0F, 0x80, 0x01, 0xF0, 0x07, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xDE, 0xFF, 0x87, 0xF8, 0xF1, 0xFE, 0x3F,
  0x87, 0x87, 0xF3, 0xF8, 0x3C, 0x3F, 0x9F, 0xC1, 0xE0, 0xFC, 0xFE, 0x0F,
  0x07, 0xF7, 0xF0, 0x78, 0x00, 0x3F, 0x83, 0xC0, 0x01, 0xFC, 0x1E, 0x00,
  0x0F, 0xF0, 0xF0, 0x00, 0x3F, 0x87, 0x80, 0x01, 0xFE, 0x3C, 0x00, 0x0F,
  0xFD, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0x7F, 0xE0,
  0x00, 0x78, 0xFF, 0x00, 0x03, 0xC3, 0xFC, 0x00, 0x1E, 0x0F, 0xE0, 0x00,
  0xF0, 0x7F, 0x00, 0x07, 0x83, 0xF8, 0x00, 0x3C, 0x1F, 0xFF, 0x81, 0xE0,
  0x7F, 0xFC, 0x0F, 0x07, 0xFF, 0xE0, 0x78, 0x3F, 0xFF, 0x83, 0xC1, 0xFD,
  0xFC, 0x1E, 0x1F, 0xCF, 0xF8, 0xF1, 0xFE, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xC3,
  0xFF, 0xC0, 0x00, 0x7C, 0x3F, 0xFF, 0x00, 0x07, 0xC3, 0xFF, 0xFC, 0x00,
  0x7C, 0x3F, 0x07, 0xE0, 0x07, 0xE1, 0xF0, 0x1F, 0x00, 0x3E, 0x0F, 0x80,
  0xF8, 0x03, 0xE0, 0x7C, 0x07, 0xE0, 0x3F, 0x03, 0xE0, 0x3F, 0x01, 0xF0,
  0x1F, 0x01, 0xF8, 0x1F, 0x00, 0xF8, 0x0F, 0xC1, 0xF0, 0x07, 0xC0, 0x7E,
  0x0F, 0x80, 0x3E, 0x03, 0xF0, 0xF8, 0x01, 0xF0, 0x1F, 0x0F, 0x80, 0x0F,
  0xC0, 0xF8, 0xFC, 0x00, 0x3F, 0x1F, 0xC7, 0xC0, 0x01, 0xFF, 0xFC, 0x7C,
  0x00, 0x07, 0xFF, 0xE7, 0xE0, 0x00, 0x1F, 0xFC, 0x3E, 0x00, 0x00, 0x3F,
  0xC3, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0xF8, 0x7F, 0xC0, 0x00, 0x0F, 0x8F, 0xFF, 0x80,
  0x00, 0xFC, 0xFF, 0xFE, 0x00, 0x07, 0xC7, 0xFF, 0xF0, 0x00, 0x7C, 0x7E,
  0x0F, 0xC0, 0x07, 0xE3, 0xE0, 0x3E, 0x00, 0x3E, 0x1F, 0x01, 0xF0, 0x03,
  0xE0, 0xF8, 0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x7C, 0x01, 0xF0, 0x3E, 0x03,
  0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0x7C, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0x3E, 0x0F, 0x80, 0x1F, 0x01, 0xF0,
  0xFC, 0x00, 0xFE, 0x3F, 0x87, 0xC0, 0x03, 0xFF, 0xF8, 0x7C, 0x00, 0x0F,
  0xFF, 0x87, 0xE0, 0x00, 0x3F, 0xF8, 0x7E, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x0F,
  0xE0, 0x3F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F,
  0x80, 0x0F, 0xC0, 0x1F, 0x80, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F,
  0xBF, 0x80, 0x7F, 0xFF, 0x1F, 0xC0, 0xFE, 0xFE, 0x1F, 0xC0, 0xFE, 0xFE,
  0x0F, 0xE1, 0xFC, 0xFE, 0x07, 0xF1, 0xF8, 0xFE, 0x03, 0xFB, 0xF8, 0xFE,
  0x03, 0xFB, 0xF0, 0xFE, 0x01, 0xFF, 0xF0, 0xFE, 0x00, 0xFF, 0xE0, 0xFE,
  0x00, 0xFF, 0xE0, 0xFE, 0x00, 0x7F, 0xC0, 0xFE, 0x00, 0x3F, 0xC0, 0xFE,
  0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x7F, 0xE0, 0x7F,
  0x00, 0xFF, 0xF0, 0x7F, 0x83, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF9, 0xFC, 0x1F, 0xFF, 0xF0, 0xFE, 0x0F, 0xFF, 0xC0, 0xFE, 0x03,
  0xFF, 0x80, 0x7F, 0x00, 0x70, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x7C, 0xF8, 0x00,
  0x00, 0x60, 0x00, 0x7C, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x07, 0xFE, 0x01,
  0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF,
  0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x1F, 0x00,
  0x03, 0xF8, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC,
  0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xE0,
  0x03, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x07, 0xFE, 0x07,
  0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x1F,
  0x80, 0x03, 0x80, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x20, 0x03, 0xE0, 0x01, 0x1C, 0x01, 0xF0, 0x07, 0x1F, 0xC0,
  0xF8, 0x1F, 0xCF, 0xF8, 0x7C, 0x3F, 0xE7, 0xFE, 0x1E, 0x3F, 0xF7, 0xFF,
  0xCE, 0x7F, 0xFF, 0xFF, 0xF7, 0x7F, 0xFE, 0x3F, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x01, 0xFB, 0xF0, 0x00,
  0x01, 0xF8, 0xFC, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x01, 0xFC, 0x1F, 0xC0,
  0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFF, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x1F, 0x80, 0x07, 0x80, 0x0F,
  0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0xFF, 0x83, 0xFC, 0x1F, 0xF0,
  0x7F, 0x81, 0xFE, 0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xF8, 0x0F, 0xE0,
  0x7F, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0x8F, 0xF9, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0x7F, 0xC7, 0xF0, 0x10, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xFF,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xF8, 0x7F, 0xC0, 0x7F, 0xC7, 0xF8, 0x01, 0xFC, 0xFF, 0x00,
  0x0F, 0xEF, 0xE0, 0x00, 0xFE, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7E,
  0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07,
  0xFF, 0xC0, 0xE0, 0x7F, 0xFC, 0x1F, 0x87, 0xFF, 0xC3, 0xF8, 0x7F, 0xFC,
  0x3F, 0x87, 0xFF, 0xC3, 0xFC, 0x7F, 0xFC, 0x3F, 0x87, 0xFF, 0xC3, 0xF8,
  0x7F, 0xFC, 0x1F, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7E,
  0xFE, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0xFE, 0xFF, 0x00, 0x1F, 0xE7, 0xF8,
  0x03, 0xFC, 0x7F, 0xE0, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0,
  0x01, 0xFF, 0xBF, 0x80, 0x1F, 0xF9, 0xFC, 0x00, 0xFF, 0x0F, 0xE0, 0x07,
  0xF0, 0x7F, 0x00, 0x3F, 0x03, 0xF8, 0x01, 0xE0, 0x1F, 0xC0, 0x0E, 0x00,
  0xFE, 0x00, 0x60, 0x07, 0xF0, 0x02, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xC1, 0xFF,
  0x8F, 0xF8, 0x03, 0xFC, 0x7F, 0x80, 0x0F, 0xF3, 0xF8, 0x00, 0x3F, 0xBF,
  0x80, 0x01, 0xFD, 0xFC, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x7F, 0x7F, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0x7F, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0xFE, 0x7F,
  0x80, 0x1F, 0xE3, 0xFF, 0x0F, 0xFC, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x68, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0x1F, 0xC0, 0x0F, 0xCF,
  0xF0, 0x03, 0xF3, 0xF8, 0x00, 0xFD, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x0F,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0x9F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x1F, 0x00,
  0x7E, 0x3F, 0xFC, 0x0F, 0xCF, 0xFF, 0xC1, 0xFB, 0xFF, 0xFC, 0x3F, 0x7F,
  0xFF, 0xC7, 0xFF, 0xFF, 0xFC, 0xFF, 0xC0, 0xFF, 0x9F, 0xE0, 0x07, 0xFB,
  0xF8, 0x00, 0xFF, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFE,
  0x00, 0x3F, 0xDF, 0xE0, 0x0F, 0xF3, 0xFF, 0x8F, 0xFE, 0x3F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x07,
  0xF3, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x03, 0xFB, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xF1, 0xFF, 0xC1, 0xFF, 0x8F, 0xF8, 0x03, 0xFE, 0x7F, 0x80, 0x0F,
  0xF7, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0xFF, 0xFC, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x7F, 0xBF, 0xC0, 0x07, 0xF8,
  0xFF, 0x00, 0x7F, 0xC7, 0xFE, 0x0F, 0xFC, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x01, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xBF, 0x80, 0x01, 0xFD, 0xFC, 0x00, 0x1F,
  0xCF, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF,
  0x80, 0xFF, 0x87, 0xF8, 0x03, 0xFC, 0x3F, 0x80, 0x0F, 0xE3, 0xF8, 0x00,
  0x3F, 0x9F, 0xC0, 0x01, 0xFC, 0xFE, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x7F,
  0x3F, 0x80, 0x03, 0xF8, 0xFC, 0x00, 0x1F, 0xC7, 0xF0, 0x01, 0xFC, 0x3F,
  0x80, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x0F, 0xF1,
  0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xEF, 0xFC, 0x07,
  0xFC, 0x1F, 0xF0, 0x3F, 0x80, 0x3F, 0xC3, 0xF8, 0x00, 0xFE, 0x3F, 0x80,
  0x03, 0xF9, 0xFC, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x7E, 0x7E, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xF7,
  0xE0, 0x00, 0x3F, 0xBF, 0x80, 0x03, 0xF9, 0xFE, 0x00, 0x1F, 0xCF, 0xF8,
  0x03, 0xFE, 0x3F, 0xF8, 0x7F, 0xE0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xE0, 0xFF, 0x80, 0xFF, 0x8F, 0xF0, 0x01, 0xFE, 0x7F, 0x00, 0x07,
  0xF3, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0xFF, 0xFE, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x7F, 0xBF, 0xC0, 0x07, 0xF9,
  0xFF, 0x00, 0x7F, 0xC7, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0x7F, 0x01, 0xFF, 0xF7, 0xF0, 0x07, 0xFF, 0x3F, 0x80, 0x03, 0xC3,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0E, 0x07, 0xF1, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0x7F, 0xC3, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x3F, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xF8, 0xFE, 0x02, 0x00, 0x03, 0xC0, 0x1F, 0xE0, 0xFF, 0x87, 0xFF,
  0x1F, 0xFC, 0x7F, 0xF1, 0xFF, 0xC3, 0xFF, 0x0F, 0xF8, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xC1, 0xFE, 0x0F, 0xF8, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x1F, 0xE0, 0x7F, 0x81, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x03,
  0xF8, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xF0,
  0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF,
  0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F,
  0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80,
  0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x03, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0, 0x07, 0xF8, 0x3F, 0x80,
  0x01, 0xFC, 0x3F, 0x80, 0x00, 0x7F, 0x1F, 0x80, 0x00, 0x1F, 0x8F, 0xC0,
  0x00, 0x07, 0xCF, 0xC0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x01, 0xFB, 0xF0,
  0x00, 0x00, 0xFD, 0xF0, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0x0F, 0xFE, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0xFF, 0xFB, 0xFF,
  0x80, 0x7F, 0xFD, 0xFF, 0xC0, 0x7F, 0x87, 0xFF, 0xE0, 0x3F, 0x01, 0xFF,
  0xF0, 0x1F, 0x80, 0x7F, 0xF8, 0x0F, 0x80, 0x3F, 0xFC, 0x07, 0xC0, 0x1F,
  0xFE, 0x03, 0xE0, 0x0F, 0xFF, 0x01, 0xF0, 0x07, 0xFF, 0x80, 0xF8, 0x03,
  0xFF, 0xC0, 0x7C, 0x01, 0xFF, 0xE0, 0x3E, 0x00, 0xFF, 0xF0, 0x1F, 0x00,
  0x7F, 0xF8, 0x0F, 0x80, 0x3F, 0xFC, 0x07, 0xC0, 0x1F, 0xFE, 0x03, 0xE0,
  0x0F, 0xFF, 0x01, 0xF0, 0x07, 0xFF, 0x80, 0xFC, 0x03, 0xFF, 0xC0, 0x7E,
  0x01, 0xFF, 0xE0, 0x3F, 0x81, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xDF, 0xFC, 0x01, 0xFF, 0xCF, 0xBE, 0x00, 0x7F, 0xC7, 0xDF, 0x00,
  0x02, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC,
  0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0xFC, 0x7E,
  0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x01, 0xFC, 0x3F,
  0x00, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x3F,
  0x80, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF0, 0x1F, 0x80, 0x03, 0xF0, 0x1F,
  0x80, 0x03, 0xF0, 0x1F, 0xC0, 0x07, 0xF0, 0x1F, 0xC0, 0x07, 0xF0, 0x0F,
  0xC0, 0x07, 0xE0, 0x0F, 0xC0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x01,
  0xF8, 0x3F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x01,
  0xFC, 0x7F, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00,
  0xFE, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0xFE, 0x00,
  0x3F, 0xCF, 0xE0, 0x01, 0xFE, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFE,
  0xFE, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x7E, 0xFE, 0x00, 0x07, 0xEF, 0xE0,
  0x00, 0x7E, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x1F,
  0xCF, 0xE0, 0x03, 0xFC, 0xFE, 0x01, 0xFF, 0x8F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xF8, 0xFE, 0x00, 0xFF, 0xCF, 0xE0, 0x03, 0xFE, 0xFE, 0x00, 0x0F, 0xEF,
  0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0,
  0x01, 0xFE, 0xFE, 0x00, 0x3F, 0xEF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8,
  0x3F, 0xE0, 0x7F, 0xC7, 0xF8, 0x01, 0xFE, 0x7F, 0x00, 0x0F, 0xEF, 0xE0,
  0x00, 0xFE, 0xFE, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xEF, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x1F, 0xE7, 0xF8, 0x03, 0xFC, 0x3F,
  0xF9, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x3F, 0x80, 0x3F, 0xF7,
  0xF0, 0x01, 0xFE, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF,
  0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC,
  0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F,
  0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00,
  0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xBF, 0x80, 0x3F, 0xF7,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFC, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x3F, 0xE0,
  0x7F, 0xC7, 0xF8, 0x01, 0xFE, 0x7F, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFE,
  0xFE, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xEF, 0xF0,
  0x00, 0xFE, 0x7F, 0x00, 0x1F, 0xE7, 0xF8, 0x03, 0xFC, 0x3F, 0xF1, 0xFF,
  0xC3, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00, 0xFE, 0x00,
  0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00,
  0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03,
  0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00,
  0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00,
  0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x03,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0xFE, 0xFE, 0x00,
  0x07, 0xF7, 0xF0, 0x00, 0x7F, 0xBF, 0xC0, 0x03, 0xF8, 0xFF, 0x00, 0x7F,
  0xC7, 0xFF, 0x0F, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x1F, 0xEF, 0xE0, 0x00,
  0x7F, 0x3F, 0x80, 0x03, 0xFC, 0xFE, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x7F,
  0x8F, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xF0, 0xFE, 0x00, 0x3F, 0x83,
  0xF8, 0x01, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x3F, 0xC0, 0xFE,
  0x00, 0xFE, 0x03, 0xF8, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0xFF, 0x00, 0xFE, 0x03, 0xF8, 0x03, 0xF8, 0x1F, 0xE0, 0x0F, 0xE0, 0x7F,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03,
  0xF8, 0x1F, 0xE0, 0x0F, 0xE0, 0x3F, 0x80, 0x3F, 0x80, 0xFF, 0x00, 0xFE,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF8, 0x0F, 0xE0, 0x0F, 0xE0, 0x3F, 0x80,
  0x3F, 0xC0, 0xFE, 0x00, 0x7F, 0x03, 0xF8, 0x01, 0xFE, 0x0F, 0xE0, 0x07,
  0xF8, 0x3F, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x7F,
  0x0F, 0xE0, 0x01, 0xFE, 0x3F, 0x80, 0x03, 0xF8, 0xFE, 0x00, 0x0F, 0xF3,
  0xF8, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x7F, 0xBF, 0x80, 0x00, 0xFE, 0xFE,
  0x00, 0x03, 0xFC, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xEF, 0x00, 0x7F, 0xFF, 0x7C, 0x03, 0xDF, 0xFB,
  0xE0, 0x3E, 0xFF, 0xCF, 0x01, 0xF7, 0xFE, 0x7C, 0x0F, 0x3F, 0xF3, 0xE0,
  0xF9, 0xFF, 0xDF, 0x07, 0xCF, 0xFE, 0x7C, 0x3E, 0x7F, 0xF3, 0xE3, 0xE3,
  0xFF, 0x9F, 0x1F, 0x3F, 0xFC, 0x7C, 0xF9, 0xFF, 0xE3, 0xE7, 0x8F, 0xFF,
  0x1F, 0x7C, 0x7F, 0xF8, 0x7B, 0xE3, 0xFF, 0xC3, 0xFE, 0x1F, 0xFE, 0x1F,
  0xF0, 0xFF, 0xF0, 0x7F, 0x87, 0xFF, 0x83, 0xF8, 0x3F, 0xFC, 0x1F, 0xC1,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x1F, 0x80, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF,
  0xF7, 0xC0, 0x1F, 0xFE, 0xFC, 0x03, 0xFF, 0xDF, 0x80, 0x7F, 0xF9, 0xF0,
  0x0F, 0xFF, 0x3F, 0x01, 0xFF, 0xE7, 0xE0, 0x3F, 0xFC, 0x7C, 0x07, 0xFF,
  0x8F, 0xC0, 0xFF, 0xF0, 0xF8, 0x1F, 0xFE, 0x1F, 0x03, 0xFF, 0xC3, 0xF0,
  0x7F, 0xF8, 0x3E, 0x0F, 0xFF, 0x07, 0xC1, 0xFF, 0xE0, 0xFC, 0x3F, 0xFC,
  0x0F, 0x87, 0xFF, 0x81, 0xF0, 0xFF, 0xF0, 0x3F, 0x1F, 0xFE, 0x03, 0xE3,
  0xFF, 0xC0, 0x7E, 0x7F, 0xF8, 0x0F, 0xCF, 0xFF, 0x00, 0xF9, 0xFF, 0xE0,
  0x1F, 0xBF, 0xFC, 0x03, 0xF7, 0xFF, 0x80, 0x3E, 0xFF, 0xF0, 0x07, 0xFF,
  0xFE, 0x00, 0xFD, 0xFF, 0xC0, 0x0F, 0xBF, 0xF8, 0x01, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF,
  0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x1F, 0xF8, 0x3F, 0xF3, 0xFC, 0x01,
  0xFE, 0x7F, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01,
  0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F,
  0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F,
  0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xDF, 0xC0, 0x07, 0xF3, 0xFC, 0x01,
  0xFE, 0x3F, 0xF9, 0xFF, 0xC7, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF3, 0xF8,
  0x00, 0x7F, 0xDF, 0xC0, 0x01, 0xFE, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFE,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00,
  0x1F, 0xEF, 0xE0, 0x03, 0xFF, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF8, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x7F, 0xE0, 0x7F, 0xC7, 0xF8, 0x03,
  0xFC, 0xFF, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xEF,
  0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F,
  0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x7E, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFE, 0xFF, 0x00,
  0x1F, 0xE7, 0xF8, 0x03, 0xFC, 0x7F, 0xF0, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xE3, 0xF8, 0x00, 0xFF, 0x9F, 0xC0, 0x01, 0xFE, 0xFE, 0x00,
  0x0F, 0xF7, 0xF0, 0x00, 0x3F, 0xBF, 0x80, 0x01, 0xFD, 0xFC, 0x00, 0x07,
  0xEF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xDF,
  0xC0, 0x00, 0xFE, 0xFE, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x3F, 0xBF, 0x80,
  0x03, 0xF9, 0xFC, 0x00, 0x7F, 0xCF, 0xE0, 0x1F, 0xFC, 0x7F, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x80, 0x3F, 0x81, 0xFC, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xE0,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x1F,
  0xC0, 0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0xF8, 0x3F, 0x80, 0x1F, 0xC1,
  0xFC, 0x00, 0xFF, 0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xE3, 0xF8,
  0x00, 0x7F, 0x1F, 0xC0, 0x03, 0xFC, 0xFE, 0x00, 0x0F, 0xE7, 0xF0, 0x00,
  0x7F, 0xBF, 0x80, 0x03, 0xFD, 0xFC, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xC0, 0xFF, 0x87, 0xF8, 0x01, 0xFE, 0x3F, 0x80, 0x07, 0xF3, 0xF8, 0x00,
  0x3F, 0x9F, 0xC0, 0x00, 0xFC, 0xFE, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFD, 0xFC, 0x00, 0x1F, 0xCF, 0xF8,
  0x01, 0xFE, 0x3F, 0xFC, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0,
  0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80,
  0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF,
  0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE,
  0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0x9F, 0xE0, 0x0F, 0xF1, 0xFF,
  0x8F, 0xFE, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFE, 0x7E,
  0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x01, 0xFC, 0x7F,
  0x00, 0x01, 0xFC, 0x3F, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xF8, 0x3F,
  0x80, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x1F, 0x80, 0x03, 0xF8, 0x1F,
  0xC0, 0x03, 0xF0, 0x1F, 0xC0, 0x03, 0xF0, 0x1F, 0xC0, 0x07, 0xF0, 0x0F,
  0xC0, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xC0, 0x07,
  0xF0, 0x0F, 0xC0, 0x07, 0xF0, 0x1F, 0xC0, 0x03, 0xF0, 0x1F, 0xC0, 0x03,
  0xF8, 0x1F, 0x80, 0x03, 0xF8, 0x1F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x01,
  0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x01,
  0xFC, 0x7F, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00,
  0xFE, 0x7E, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00,
  0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0xFC,
  0x01, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0x00, 0xFD, 0xF8, 0x0F, 0xE0, 0x1F,
  0xBF, 0x01, 0xFC, 0x03, 0xE7, 0xE0, 0x3F, 0x80, 0x7C, 0xFC, 0x07, 0xF0,
  0x1F, 0x9F, 0x80, 0xEF, 0x03, 0xF3, 0xF0, 0x1D, 0xE0, 0x7E, 0x7E, 0x03,
  0xBC, 0x0F, 0xCF, 0xC0, 0xF7, 0x81, 0xF9, 0xF8, 0x1E, 0xF0, 0x3F, 0x1F,
  0x03, 0xDE, 0x07, 0xE3, 0xF0, 0x7B, 0xC0, 0xF8, 0x7E, 0x0F, 0x38, 0x1F,
  0x0F, 0xC1, 0xE7, 0x03, 0xE1, 0xF8, 0x3C, 0xF0, 0x7C, 0x3F, 0x07, 0x1E,
  0x1F, 0x87, 0xE1, 0xE3, 0xC3, 0xF0, 0xFC, 0x3C, 0x78, 0x7E, 0x1F, 0x87,
  0x8F, 0x0F, 0xC1, 0xF0, 0xF1, 0xE1, 0xF8, 0x3E, 0x1E, 0x3C, 0x3E, 0x07,
  0xC3, 0xC3, 0x87, 0xC0, 0xFC, 0x78, 0x78, 0xF8, 0x1F, 0x8E, 0x0F, 0x1F,
  0x03, 0xF1, 0xC1, 0xE3, 0xE0, 0x7E, 0x78, 0x3C, 0xFC, 0x0F, 0xCF, 0x07,
  0x9F, 0x81, 0xF9, 0xE0, 0xF3, 0xF0, 0x1F, 0x3C, 0x1E, 0x7E, 0x03, 0xE7,
  0x83, 0xCF, 0x80, 0x7C, 0xF0, 0x39, 0xF0, 0x0F, 0x9E, 0x07, 0xBE, 0x01,
  0xF3, 0x80, 0xF7, 0xC0, 0x3F, 0xF0, 0x1E, 0xF8, 0x07, 0xFE, 0x03, 0xDF,
  0x00, 0xFF, 0xC0, 0x7B, 0xE0, 0x1F, 0xF8, 0x0F, 0x7C, 0x01, 0xFF, 0x01,
  0xFF, 0x80, 0x3F, 0xE0, 0x3F, 0xE0, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x7F, 0x80, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x7F,
  0x0F, 0xF0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x1F,
  0xC0, 0x7F, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x03, 0xF8, 0x0F, 0xF0, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x7F, 0x07,
  0xF0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x07, 0xF1,
  0xFC, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xEF, 0xE0, 0x00,
  0x07, 0xF7, 0xF0, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x03, 0xF8, 0xFE, 0x00,
  0x01, 0xFC, 0x7F, 0x80, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFE, 0x0F, 0xF0,
  0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x0F, 0xF0, 0x3F, 0x80, 0x03,
  0xF8, 0x1F, 0xC0, 0x01, 0xFE, 0x1F, 0xC0, 0x00, 0x7F, 0x1F, 0xE0, 0x00,
  0x3F, 0xCF, 0xE0, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x07, 0xF8, 0xFE, 0x00,
  0x00, 0x3F, 0xBF, 0x80, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x1F, 0xC7, 0xE0,
  0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x07, 0xF0, 0x7F,
  0x00, 0x07, 0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x0F, 0xE0, 0x03, 0xF8, 0x07,
  0xF0, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x7E, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x07, 0xF0, 0x3F, 0x00,
  0x03, 0xF8, 0x3F, 0x80, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x7F, 0x1F, 0xC0,
  0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x03, 0xF7, 0xF0,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xBE, 0x00, 0x01, 0xFB, 0xF0, 0x00,
  0x1F, 0x9F, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x3F, 0x1F, 0x80, 0x03, 0xE0,
  0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x07, 0xE0,
  0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x3F, 0x03, 0xF0,
  0x01, 0xF8, 0x3F, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x0F,
  0xC7, 0xE0, 0x00, 0xFE, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFE, 0x01, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x1F, 0xE0, 0x3F, 0xE3, 0xFC,
  0x00, 0xFE, 0x3F, 0x80, 0x07, 0xF3, 0xF0, 0x00, 0x7F, 0x40, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0x80, 0x07, 0xFF,
  0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xBF, 0x7F, 0xFF, 0xFB, 0xF3, 0xFF,
  0xFF, 0xBF, 0x3F, 0xFF, 0xF3, 0xF0, 0xFF, 0xFE, 0x3F, 0x07, 0xFF, 0x83,
  0xF0, 0x07, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x0F, 0x80, 0x7F, 0x0F, 0xFC, 0x0F, 0xE7, 0xFF, 0xE1,
  0xFC, 0xFF, 0xFE, 0x3F, 0xBF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0xFF, 0xE0,
  0xFF, 0xDF, 0xF0, 0x07, 0xFB, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF,
  0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00,
  0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01,
  0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xE0, 0x0F, 0xF7, 0xFF, 0x87, 0xFE, 0xFF, 0xFF, 0xFF, 0x9F, 0xDF,
  0xFF, 0xF3, 0xF9, 0xFF, 0xFC, 0x7F, 0x1F, 0xFF, 0x0F, 0xE1, 0xFF, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xFC, 0x7F, 0xF0, 0xFF, 0xC7, 0xF8, 0x03, 0xFE, 0x7F, 0x00, 0x0F, 0xEF,
  0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7E, 0xFE,
  0x00, 0x0F, 0xE7, 0xF0, 0x01, 0xFE, 0x7F, 0x80, 0x3F, 0xE3, 0xFF, 0x0F,
  0xFC, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x01, 0xF0, 0x3F, 0x81,
  0xFF, 0x87, 0xF0, 0xFF, 0xFC, 0xFE, 0x3F, 0xFF, 0xDF, 0xCF, 0xFF, 0xFB,
  0xF9, 0xFF, 0xFF, 0xFF, 0x7F, 0xE0, 0xFF, 0xEF, 0xF0, 0x07, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80,
  0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00,
  0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF,
  0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xDF, 0xE0, 0x0F, 0xFB, 0xFF, 0x8F,
  0xFF, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFD, 0xFC, 0x7F, 0xFF, 0xBF, 0x87,
  0xFF, 0xE7, 0xF0, 0x3F, 0xF0, 0xFE, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x0F, 0xF0, 0x0F, 0xF3, 0xF8, 0x00,
  0xFE, 0x7E, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFE,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x3F, 0xBF, 0x80, 0x07, 0xF7, 0xF8, 0x01, 0xFE,
  0x7F, 0x80, 0x7F, 0x8F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7F, 0xE1, 0xFC, 0x3F, 0xFF, 0x3F, 0x8F, 0xFF, 0xF7, 0xF3, 0xFF, 0xFE,
  0xFE, 0x7F, 0xFF, 0xFF, 0xDF, 0xF8, 0x3F, 0xFB, 0xFC, 0x01, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0,
  0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80,
  0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xEF, 0xF0, 0x07, 0xFD,
  0xFF, 0x01, 0xFF, 0x9F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xDF, 0xC3, 0xFF, 0xF3, 0xF8, 0x3F, 0xFC, 0x7F, 0x00, 0xFC, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x07,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x0F, 0x00, 0x7F, 0x0F, 0xFC,
  0x0F, 0xE7, 0xFF, 0xE1, 0xFD, 0xFF, 0xFE, 0x3F, 0xBF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFC, 0xFF, 0xE0, 0x7F, 0xDF, 0xF0, 0x07, 0xFB, 0xFC, 0x00, 0x7F,
  0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80,
  0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF,
  0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE,
  0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFB, 0xF8, 0x00, 0x3F, 0xCF,
  0xE0, 0x00, 0xFE, 0x3F, 0x80, 0x07, 0xF8, 0xFE, 0x00, 0x3F, 0xC3, 0xF8,
  0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF8, 0x3F, 0x80, 0x3F, 0xC0, 0xFE, 0x00,
  0xFE, 0x03, 0xF8, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0x3F, 0x80, 0xFE,
  0x00, 0xFE, 0x07, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F,
  0xE0, 0x7F, 0x80, 0x3F, 0x80, 0xFF, 0x00, 0xFE, 0x03, 0xFC, 0x03, 0xF8,
  0x07, 0xF8, 0x0F, 0xE0, 0x0F, 0xE0, 0x3F, 0x80, 0x3F, 0xC0, 0xFE, 0x00,
  0x7F, 0x83, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xFC, 0x3F, 0x80, 0x07,
  0xF0, 0xFE, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x7F,
  0x3F, 0x80, 0x01, 0xFE, 0xFE, 0x00, 0x03, 0xFC, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x38, 0x03, 0x83,
  0xE3, 0xF8, 0x7F, 0x8F, 0x9F, 0xF3, 0xFF, 0x3E, 0xFF, 0xCF, 0xFC, 0xFB,
  0xFF, 0xFF, 0xFB, 0xF8, 0xFF, 0x8F, 0xEF, 0xC1, 0xFC, 0x1F, 0xBF, 0x03,
  0xE0, 0x7E, 0xFC, 0x0F, 0x80, 0xFF, 0xF0, 0x3E, 0x03, 0xFF, 0xC0, 0xF8,
  0x0F, 0xFF, 0x03, 0xE0, 0x3F, 0xFC, 0x0F, 0x80, 0xFF, 0xF0, 0x3E, 0x03,
  0xFF, 0xC0, 0xF8, 0x0F, 0xFF, 0x03, 0xE0, 0x3F, 0xFC, 0x0F, 0x80, 0xFF,
  0xF0, 0x3E, 0x03, 0xFF, 0xC0, 0xF8, 0x0F, 0xFF, 0x03, 0xE0, 0x3F, 0xFC,
  0x0F, 0x80, 0xFF, 0xF0, 0x3E, 0x03, 0xFF, 0xC0, 0xF8, 0x0F, 0xFF, 0x03,
  0xE0, 0x3F, 0xFC, 0x0F, 0x80, 0xFF, 0xF0, 0x3E, 0x03, 0xFF, 0xC0, 0xF8,
  0x0F, 0xFF, 0x03, 0xE0, 0x3F, 0xFC, 0x0F, 0x80, 0xFF, 0xF0, 0x3E, 0x03,
  0xFF, 0xC0, 0xF8, 0x0F, 0xFF, 0x03, 0xE0, 0x3F, 0xFC, 0x0F, 0x80, 0xFF,
  0xF0, 0x3E, 0x03, 0xFF, 0xC0, 0xF8, 0x0F, 0xC0, 0x00, 0x03, 0xC0, 0x1F,
  0xC3, 0xFF, 0x03, 0xF9, 0xFF, 0xF8, 0x7F, 0x7F, 0xFF, 0x8F, 0xEF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0x3F, 0xF8, 0x3F, 0xF7, 0xFC, 0x01, 0xFE, 0xFF,
  0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0,
  0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80,
  0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF,
  0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0x0F, 0xFC, 0x7F, 0xF3, 0xFC, 0x01, 0xFE, 0x7F, 0x00,
  0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF8,
  0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xF7, 0xF8, 0x03, 0xFC, 0x7F, 0xF3, 0xFF,
  0x8F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x1F, 0xC3, 0xFF, 0x03, 0xF9, 0xFF, 0xF8, 0x7F, 0x3F, 0xFF, 0x8F, 0xEF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xBF, 0xFC, 0x3F, 0xF7, 0xFC, 0x01, 0xFE,
  0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF,
  0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF,
  0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x01,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x03, 0xFD, 0xFF,
  0xE1, 0xFF, 0xBF, 0xFF, 0xFF, 0xE7, 0xF7, 0xFF, 0xFC, 0xFE, 0x7F, 0xFF,
  0x1F, 0xC7, 0xFF, 0xC3, 0xF8, 0x7F, 0xE0, 0x7F, 0x01, 0xC0, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7F, 0xE1, 0xFC, 0x3F, 0xFF, 0x3F, 0x8F, 0xFF, 0xF7, 0xF3, 0xFF,
  0xFE, 0xFE, 0x7F, 0xFF, 0xFF, 0xDF, 0xF8, 0x3F, 0xFB, 0xFC, 0x01, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF,
  0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01,
  0xFF, 0xF8, 0x00, 0x7F, 0xBF, 0x80, 0x0F, 0xF7, 0xF8, 0x03, 0xFE, 0xFF,
  0xE3, 0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0x7F, 0x1F, 0xFF, 0xEF,
  0xE1, 0xFF, 0xF9, 0xFC, 0x0F, 0xFC, 0x3F, 0x80, 0x1C, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xE0,
  0x0F, 0xE1, 0xFF, 0xC0, 0xFE, 0x7F, 0xFE, 0x0F, 0xEF, 0xFF, 0xF0, 0xFE,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0xFF, 0xE0, 0x7F, 0xEF, 0xF8, 0x01,
  0xFE, 0xFF, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x7F, 0xC0, 0x3F,
  0xE7, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xE7, 0xFC, 0x03, 0xFE, 0x7F, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFC, 0x00, 0x02, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0xFE, 0x00,
  0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00,
  0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03,
  0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xEF, 0xE0,
  0x01, 0xFD, 0xFC, 0x00, 0x7F, 0x3F, 0xC0, 0x1F, 0xE3, 0xFE, 0x1F, 0xF8,
  0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x38, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x0F,
  0xE7, 0xF0, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0xFE,
  0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0x80, 0x03, 0xF0, 0x3F, 0x80, 0x0F, 0xE0,
  0x7F, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x7E, 0x01,
  0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF8, 0x07, 0xE0, 0x07,
  0xF0, 0x1F, 0xC0, 0x07, 0xE0, 0x3F, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x1F,
  0xC1, 0xFC, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x7F,
  0x1F, 0xC0, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x01, 0xFC,
  0xFC, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xF8, 0x03, 0xF0,
  0x0F, 0xFE, 0x01, 0xF8, 0x07, 0xFF, 0x01, 0xFC, 0x03, 0xFF, 0x80, 0xFE,
  0x03, 0xFF, 0xC0, 0x7F, 0x01, 0xFB, 0xE0, 0x3F, 0x80, 0xFD, 0xF0, 0x1D,
  0xC0, 0x7C, 0xF8, 0x0E, 0xF0, 0x3E, 0x7E, 0x0F, 0x78, 0x1F, 0x3F, 0x07,
  0xBC, 0x0F, 0x9F, 0x83, 0xDE, 0x0F, 0xC7, 0xC1, 0xE7, 0x07, 0xE3, 0xE0,
  0xE3, 0x83, 0xE1, 0xF0, 0x71, 0xE1, 0xF0, 0xF8, 0x38, 0xF0, 0xF8, 0x7E,
  0x3C, 0x78, 0x7C, 0x3F, 0x1E, 0x3C, 0x3E, 0x1F, 0x8F, 0x1E, 0x3F, 0x07,
  0xC7, 0x87, 0x1F, 0x83, 0xE3, 0x83, 0x8F, 0x81, 0xF1, 0xC1, 0xE7, 0xC0,
  0xF9, 0xE0, 0xF3, 0xE0, 0x7E, 0xF0, 0x79, 0xF0, 0x3F, 0x78, 0x3C, 0xF8,
  0x0F, 0xBC, 0x0E, 0xFC, 0x07, 0xDC, 0x07, 0x7C, 0x03, 0xEE, 0x03, 0xFE,
  0x01, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x7F,
  0xC0, 0x3F, 0xE0, 0x3F, 0xE0, 0x0F, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x07,
  0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x7F, 0x80,
  0x03, 0xFC, 0x3F, 0xC0, 0x07, 0xF8, 0x1F, 0xC0, 0x07, 0xF0, 0x0F, 0xE0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x1F, 0xC0, 0x03, 0xF8,
  0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0xFE,
  0xFF, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x01, 0xFE,
  0x7F, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x03, 0xFC, 0x3F, 0x80, 0x07, 0xF8,
  0x3F, 0xC0, 0x07, 0xF0, 0x1F, 0xC0, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0xC0, 0x03, 0xF8, 0x7F, 0x80,
  0x03, 0xFC, 0x7F, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x07, 0xF3, 0xFC, 0x00,
  0x0F, 0xE3, 0xF8, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x7F, 0x0F, 0xF0, 0x00,
  0xFE, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0x1F, 0xC0, 0x0F,
  0xE0, 0x3F, 0x80, 0x1F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0xFE,
  0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xE0,
  0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF0, 0xFE, 0x00,
  0x07, 0xE3, 0xF8, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x1F, 0xCF, 0xC0, 0x00,
  0x1F, 0x9F, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x01,
  0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF,
  0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x80, 0x00, 0x1F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x03, 0xF3, 0xFF, 0xC0, 0x0F, 0xDF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xC3, 0xFC,
  0x0F, 0xFF, 0x07, 0xF8, 0x7E, 0xF8, 0x0F, 0xF3, 0xFB, 0xE0, 0x1F, 0xFF,
  0xEF, 0x80, 0x3F, 0xFF, 0x3E, 0x00, 0x7F, 0xF8, 0xF8, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFC, 0x00,
};

const GFXglyph JetBrainsMono_Medium62pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 37, 0, -1 },
  { 1, 10, 45, 37, 14, -45 },
  { 58, 20, 18, 37, 9, -45 },
  { 103, 33, 45, 37, 2, -45 },
  { 289, 29, 63, 37, 4, -54 },
  { 518, 37, 46, 37, 0, -46 },
  { 731, 32, 47, 37, 3, -46 },
  { 919, 7, 18, 37, 15, -45 },
  { 935, 19, 59, 37, 11, -52 },
  { 1076, 19, 59, 37, 7, -52 },
  { 1217, 33, 32, 37, 2, -38 },
  { 1349, 29, 29, 37, 4, -35 },
  { 1455, 14, 19, 37, 10, -9 },
  { 1489, 20, 7, 37, 9, -24 },
  { 1507, 11, 11, 37, 13, -10 },
  { 1523, 29, 58, 37, 4, -51 },
  { 1734, 28, 47, 37, 5, -46 },
  { 1899, 29, 45, 37, 5, -45 },
  { 2063, 29, 46, 37, 4, -46 },
  { 2230, 28, 46, 37, 4, -45 },
  { 2391, 26, 45, 37, 5, -45 },
  { 2538, 27, 46, 37, 5, -45 },
  { 2694, 29, 46, 37, 4, -45 },
  { 2861, 29, 45, 37, 4, -45 },
  { 3025, 29, 47, 37, 4, -46 },
  { 3196, 29, 46, 37, 4, -46 },
  { 3363, 11, 36, 37, 13, -35 },
  { 3413, 14, 45, 37, 10, -35 },
  { 3492, 27, 33, 37, 5, -37 },
  { 3604, 27, 21, 37, 5, -31 },
  { 3675, 27, 33, 37, 5, -37 },
  { 3787, 23, 45, 37, 8, -45 },
  { 3917, 33, 57, 37, 2, -46 },
  { 4153, 32, 45, 37, 3, -45 },
  { 4333, 28, 45, 37, 5, -45 },
  { 4491, 28, 47, 37, 5, -46 },
  { 4656, 27, 45, 37, 5, -45 },
  { 4808, 26, 45, 37, 6, -45 },
  { 4955, 28, 45, 37, 5, -45 },
  { 5113, 28, 47, 37, 5, -46 },
  { 5278, 27, 45, 37, 5, -45 },
  { 5430, 25, 45, 37, 6, -45 },
  { 5571, 29, 46, 37, 2, -45 },
  { 5738, 30, 45, 37, 5, -45 },
  { 5907, 26, 45, 37, 7, -45 },
  { 6054, 29, 45, 37, 4, -45 },
  { 6218, 27, 45, 37, 5, -45 },
  { 6370, 27, 47, 37, 5, -46 },
  { 6529, 29, 45, 37, 5, -45 },
  { 6693, 28, 57, 37, 5, -46 },
  { 6893, 29, 45, 37, 5, -45 },
  { 7057, 29, 47, 37, 4, -46 },
  { 7228, 31, 45, 37, 3, -45 },
  { 7403, 27, 46, 37, 5, -45 },
  { 7559, 32, 45, 37, 3, -45 },
  { 7739, 35, 45, 37, 1, -45 },
  { 7936, 33, 45, 37, 2, -45 },
  { 8122, 33, 45, 37, 2, -45 },
  { 8308, 27, 45, 37, 5, -45 },
  { 8460, 16, 58, 37, 12, -51 },
  { 8576, 29, 58, 37, 4, -51 },
  { 8787, 16, 58, 37, 9, -51 },
  { 8903, 28, 24, 37, 5, -45 },
  { 8987, 29, 5, 37, 4, 2 },
  { 9006, 14, 9, 37, 11, -49 },
  { 9022, 28, 36, 37, 4, -35 },
  { 9148, 27, 46, 37, 5, -45 },
  { 9304, 28, 36, 37, 5, -35 },
  { 9430, 27, 46, 37, 5, -45 },
  { 9586, 27, 36, 37, 5, -35 },
  { 9708, 29, 45, 37, 4, -45 },
  { 9872, 27, 46, 37, 5, -35 },
  { 10028, 27, 45, 37, 5, -45 },
  { 10180, 29, 48, 37, 5, -48 },
  { 10354, 24, 59, 37, 5, -48 },
  { 10531, 30, 45, 37, 5, -45 },
  { 10700, 32, 45, 37, 2, -45 },
  { 10880, 30, 35, 37, 4, -35 },
  { 11012, 27, 35, 37, 5, -35 },
  { 11131, 27, 36, 37, 5, -35 },
  { 11253, 27, 46, 37, 5, -35 },
  { 11409, 27, 46, 37, 5, -35 },
  { 11565, 28, 35, 37, 6, -35 },
  { 11688, 28, 36, 37, 5, -35 },
  { 11814, 29, 44, 37, 3, -44 },
  { 11974, 27, 35, 37, 5, -34 },
  { 12093, 31, 34, 37, 3, -34 },
  { 12225, 33, 34, 37, 2, -34 },
  { 12366, 32, 34, 37, 3, -34 },
  { 12502, 31, 45, 37, 3, -34 },
  { 12677, 27, 34, 37, 5, -34 },
  { 12792, 27, 58, 37, 5, -51 },
  { 12988, 7, 58, 37, 15, -51 },
  { 13039, 27, 58, 37, 5, -51 },
  { 13235, 30, 14, 37, 4, -29 },
};

const GFXfont JetBrainsMono_Medium62pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Medium62pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Medium62pt7bGlyphs,
  0x20, 0x7E, 82
};

#endif // _JETBRAINSMONO_MEDIUM62PT7B_H_
