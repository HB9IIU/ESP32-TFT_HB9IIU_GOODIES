#ifndef _JETBRAINSMONO_MEDIUM55PT7B_H_
#define _JETBRAINSMONO_MEDIUM55PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Medium.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Medium55pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F,
  0x9F, 0xCF, 0xE7, 0xF1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x1F, 0xDF, 0xFF, 0xFF, 0xFD, 0xFC, 0xFE, 0xFC, 0x1F,
  0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0,
  0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFE, 0x03, 0xFF, 0x01, 0xFF,
  0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0x00, 0x7C, 0x03, 0xE0,
  0x03, 0xE0, 0x1E, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0xF0, 0x07, 0x80, 0x07,
  0x80, 0x7C, 0x00, 0x3C, 0x03, 0xE0, 0x03, 0xE0, 0x1E, 0x00, 0x1F, 0x00,
  0xF0, 0x00, 0xF0, 0x07, 0x80, 0x07, 0x80, 0x7C, 0x0F, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0x07,
  0x80, 0x3C, 0x00, 0x3C, 0x03, 0xE0, 0x01, 0xE0, 0x1F, 0x00, 0x1F, 0x00,
  0xF8, 0x00, 0xF8, 0x07, 0x80, 0x07, 0x80, 0x3C, 0x00, 0x3C, 0x03, 0xE0,
  0x01, 0xE0, 0x1F, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0xF8, 0x07, 0x80, 0x07,
  0xC0, 0x3C, 0x07, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF0, 0x3E, 0x01, 0xE0,
  0x01, 0xE0, 0x0F, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x78, 0x07, 0xC0, 0x07,
  0xC0, 0x3C, 0x00, 0x3E, 0x01, 0xE0, 0x01, 0xE0, 0x0F, 0x00, 0x0F, 0x00,
  0xF8, 0x00, 0x78, 0x07, 0xC0, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xE3, 0xFC, 0xE3, 0xF9, 0xF8, 0x70, 0xFC, 0xFC, 0x38, 0x7F, 0x7E,
  0x1C, 0x1F, 0xBE, 0x0E, 0x0F, 0xDF, 0x07, 0x00, 0x0F, 0xC3, 0x80, 0x07,
  0xE1, 0xC0, 0x03, 0xF0, 0xE0, 0x01, 0xFC, 0x70, 0x00, 0x7F, 0xB8, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3B,
  0xFE, 0x00, 0x1C, 0x7F, 0x80, 0x0E, 0x1F, 0xC0, 0x07, 0x07, 0xE0, 0x03,
  0x83, 0xF0, 0x01, 0xC1, 0xFF, 0xC0, 0xE0, 0x7F, 0xF0, 0x70, 0x7F, 0xF8,
  0x38, 0x3F, 0xFC, 0x1C, 0x1F, 0xFF, 0x0E, 0x1F, 0xDF, 0xE7, 0x1F, 0xCF,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0,
  0x07, 0xFF, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0x8F, 0xFE, 0x00, 0x0F,
  0x8F, 0xFF, 0x80, 0x0F, 0x8F, 0xFF, 0xE0, 0x07, 0x87, 0xC1, 0xF0, 0x07,
  0xC3, 0xC0, 0x78, 0x07, 0xC1, 0xE0, 0x3C, 0x03, 0xC0, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x03, 0xE0, 0x3C, 0x07, 0x83, 0xE0, 0x1E, 0x03, 0xC1,
  0xE0, 0x0F, 0x01, 0xE1, 0xF0, 0x07, 0xC0, 0xF1, 0xF0, 0x03, 0xF0, 0xF8,
  0xF0, 0x00, 0xFF, 0xFC, 0xF8, 0x00, 0x7F, 0xFC, 0xF8, 0x00, 0x1F, 0xFC,
  0x78, 0x00, 0x03, 0xF8, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x3E, 0x1F, 0xC0, 0x00, 0x1E, 0x3F, 0xF8, 0x00, 0x1F, 0x3F, 0xFE, 0x00,
  0x1F, 0x3F, 0xFF, 0x00, 0x0F, 0x1F, 0x07, 0xC0, 0x0F, 0x8F, 0x03, 0xE0,
  0x0F, 0x87, 0x80, 0xF0, 0x07, 0x83, 0xC0, 0x78, 0x07, 0x81, 0xE0, 0x3C,
  0x07, 0xC0, 0xF0, 0x1E, 0x07, 0xC0, 0x78, 0x0F, 0x03, 0xC0, 0x3C, 0x07,
  0x83, 0xE0, 0x1E, 0x07, 0xC3, 0xE0, 0x0F, 0x83, 0xE1, 0xE0, 0x07, 0xFF,
  0xE1, 0xF0, 0x01, 0xFF, 0xF1, 0xF0, 0x00, 0x7F, 0xF1, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x01, 0xFE, 0x3F, 0xC0, 0x1F, 0x80,
  0xFE, 0x03, 0xF0, 0x07, 0xE0, 0x3F, 0x00, 0x7E, 0x03, 0xF0, 0x07, 0xE0,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F,
  0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x7E, 0x07, 0xEF, 0xC3, 0xF0,
  0x7E, 0xFC, 0x3F, 0x8F, 0xCF, 0x81, 0xF8, 0xFC, 0xF8, 0x0F, 0xDF, 0x8F,
  0x80, 0xFF, 0xF8, 0xF8, 0x07, 0xFF, 0x0F, 0x80, 0x3F, 0xF0, 0xF8, 0x01,
  0xFE, 0x0F, 0x80, 0x1F, 0xE0, 0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0xE0,
  0xFC, 0x01, 0xFF, 0x0F, 0xE0, 0x7F, 0xF0, 0x7F, 0xFF, 0xFF, 0x87, 0xFF,
  0xFE, 0xFC, 0x3F, 0xFF, 0xCF, 0xE1, 0xFF, 0xF0, 0x7E, 0x0F, 0xFE, 0x03,
  0xF0, 0x04, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7D, 0xF7, 0xDF, 0x00, 0x03, 0x80, 0x07, 0xC0, 0x0F, 0xE0, 0x0F,
  0xF0, 0x1F, 0xF8, 0x1F, 0xFC, 0x1F, 0xF0, 0x1F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0xFF,
  0x80, 0x3F, 0xC0, 0x07, 0xE0, 0x00, 0xF0, 0x00, 0x08, 0xE0, 0x00, 0x7C,
  0x00, 0x3F, 0x80, 0x1F, 0xF0, 0x0F, 0xFC, 0x07, 0xFF, 0x00, 0x7F, 0xC0,
  0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7E,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x81, 0xFF,
  0x81, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0x00, 0x1E, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x70, 0x0F, 0x80, 0x73, 0xE0,
  0x7C, 0x0F, 0x9F, 0xC1, 0xC1, 0xFD, 0xFF, 0x8E, 0x3F, 0xFF, 0xFE, 0x77,
  0xFF, 0xBF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00,
  0xFB, 0xE0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0xFC, 0x7E, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x7F, 0x01, 0xFC,
  0x01, 0xF0, 0x07, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x18, 0x00, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0xF0, 0xFE, 0x1F, 0xE1, 0xFC, 0x1F, 0xC1,
  0xFC, 0x3F, 0x83, 0xF8, 0x3F, 0x03, 0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x07,
  0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3E, 0x3F, 0xBF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x04, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC1, 0xFF, 0xBF, 0xF1, 0xFE, 0x03, 0xFC,
  0xFC, 0x00, 0x7E, 0xFE, 0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xFF, 0x00, 0x07,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00,
  0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x0E, 0x0F, 0xFF, 0x0F,
  0x87, 0xFF, 0x8F, 0xE3, 0xFF, 0xC7, 0xF1, 0xFF, 0xE3, 0xF8, 0xFF, 0xF1,
  0xFC, 0x7F, 0xF8, 0x7C, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF,
  0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF,
  0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x1F,
  0x9F, 0xC0, 0x1F, 0xCF, 0xF0, 0x1F, 0xE3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x04,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x01,
  0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x03, 0xFC, 0xFC, 0x01,
  0xFC, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0x78, 0x1F, 0x80, 0x38, 0x0F, 0xC0,
  0x18, 0x07, 0xE0, 0x08, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x01, 0xFF,
  0xE0, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xF1, 0xFE, 0x03, 0xF8, 0xFC, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0x7E,
  0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFC,
  0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0xFF, 0xF0, 0x00, 0xFD, 0xF8, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0x7F,
  0x00, 0x3F, 0x9F, 0xC0, 0x3F, 0x8F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x00, 0x14, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x3F, 0x1F, 0xC0, 0x3F, 0x3F, 0x80,
  0x3F, 0x3F, 0x00, 0x3F, 0x7F, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xE3, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0xFF, 0x80,
  0xFD, 0xFF, 0xF0, 0x7E, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0x8F, 0xF0, 0x1F, 0xE7, 0xF0, 0x07, 0xF3, 0xF0, 0x01, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x7F, 0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x9F,
  0xE0, 0x3F, 0xC7, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x00, 0x08, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x3E, 0x00, 0x1F, 0xDF, 0xF8, 0x03, 0xF7, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFC, 0x07, 0xF8, 0xFF, 0x00, 0x7F,
  0x1F, 0xC0, 0x07, 0xF3, 0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x0F, 0xDF, 0x80,
  0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F,
  0xF8, 0x00, 0x0F, 0xDF, 0x80, 0x03, 0xF3, 0xF0, 0x00, 0x7E, 0x7F, 0x00,
  0x1F, 0xC7, 0xE0, 0x03, 0xF0, 0xFF, 0x01, 0xFE, 0x0F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x04, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0x3F, 0x00,
  0x0F, 0xCF, 0xC0, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC1, 0xFF, 0xBF, 0xF1, 0xFE, 0x03,
  0xFC, 0xFE, 0x00, 0xFE, 0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x9F, 0x80,
  0x0F, 0xCF, 0xC0, 0x07, 0xE7, 0xE0, 0x03, 0xF3, 0xF0, 0x01, 0xF9, 0xFC,
  0x01, 0xFC, 0x7E, 0x01, 0xFC, 0x1F, 0xC1, 0xFC, 0x07, 0xF3, 0xFC, 0x01,
  0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFF, 0x80,
  0x3F, 0xFF, 0xE0, 0x3F, 0xC7, 0xF8, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0x3F,
  0x9F, 0x80, 0x0F, 0xDF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00,
  0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0x00,
  0x1F, 0xDF, 0x80, 0x0F, 0xCF, 0xF0, 0x1F, 0xE3, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xF7, 0xFE, 0x0F,
  0xE0, 0x1F, 0xE3, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0xCF, 0xC0, 0x01,
  0xF9, 0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8,
  0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x0F,
  0xCF, 0xC0, 0x01, 0xF9, 0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x1F, 0xE3, 0xFE,
  0x0F, 0xF8, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFD, 0xF8,
  0x03, 0xFF, 0x7F, 0x00, 0x07, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1E, 0x3F,
  0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x7F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFC, 0x30, 0x07, 0xC0,
  0xFE, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF0, 0xFE, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x0F, 0xF0,
  0xFE, 0x1F, 0xE1, 0xFC, 0x1F, 0xC1, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x03,
  0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0xFC, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F,
  0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0,
  0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F,
  0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00,
  0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xFE, 0x0F, 0xFF,
  0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00,
  0x1F, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x0F,
  0xF0, 0x0F, 0xF0, 0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7E, 0x3E, 0x00,
  0x01, 0xF3, 0xF0, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x03, 0xE3, 0xFF,
  0x00, 0x7F, 0x9F, 0xF8, 0x07, 0xFE, 0x7F, 0xC0, 0x7F, 0xFB, 0xFE, 0x03,
  0xF0, 0xFF, 0xF0, 0x3F, 0x03, 0xFF, 0x81, 0xF0, 0x0F, 0xFC, 0x0F, 0x80,
  0x7F, 0xE0, 0x7C, 0x03, 0xFF, 0x03, 0xE0, 0x1F, 0xF8, 0x1F, 0x00, 0xFF,
  0xC0, 0xF8, 0x07, 0xFE, 0x07, 0xC0, 0x3F, 0xF0, 0x3E, 0x01, 0xFF, 0x81,
  0xF0, 0x0F, 0xFC, 0x0F, 0x80, 0x7F, 0xE0, 0x7C, 0x03, 0xFF, 0x03, 0xE0,
  0x1F, 0xF8, 0x1F, 0x81, 0xFF, 0xC0, 0xFE, 0x1F, 0xFE, 0x03, 0xFF, 0xDF,
  0xF0, 0x0F, 0xFC, 0xFF, 0x80, 0x3F, 0xE7, 0xFC, 0x00, 0xFC, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x01, 0xF7, 0xC0, 0x00,
  0x0F, 0xBE, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x3E,
  0x3E, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0xFC, 0x7E,
  0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xF0, 0x7E, 0x00,
  0x1F, 0x83, 0xF0, 0x00, 0xF8, 0x0F, 0x80, 0x07, 0xC0, 0x7C, 0x00, 0x7E,
  0x03, 0xF0, 0x03, 0xF0, 0x1F, 0x80, 0x1F, 0x80, 0xFC, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x7E,
  0x00, 0x3F, 0x03, 0xE0, 0x00, 0xF8, 0x3F, 0x00, 0x07, 0xE1, 0xF8, 0x00,
  0x3F, 0x0F, 0xC0, 0x01, 0xF8, 0xFE, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x3F,
  0x3F, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xC7, 0xC0, 0x1F, 0xF3, 0xE0, 0x03, 0xF9, 0xF0, 0x00, 0xFC,
  0xF8, 0x00, 0x7F, 0x7C, 0x00, 0x1F, 0xBE, 0x00, 0x0F, 0xDF, 0x00, 0x07,
  0xEF, 0x80, 0x03, 0xE7, 0xC0, 0x03, 0xF3, 0xE0, 0x01, 0xF9, 0xF0, 0x01,
  0xF8, 0xF8, 0x07, 0xF8, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE3, 0xE0, 0x07, 0xF9, 0xF0,
  0x00, 0xFC, 0xF8, 0x00, 0x3F, 0x7C, 0x00, 0x1F, 0xBE, 0x00, 0x0F, 0xDF,
  0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xF0, 0x00, 0x7E, 0xF8, 0x00, 0x7F, 0x7C, 0x00, 0x7F, 0xBE, 0x00, 0xFF,
  0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0xFE,
  0x03, 0xFC, 0xFE, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0xBF, 0x00, 0x0F, 0xFF,
  0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xBF,
  0x00, 0x1F, 0xDF, 0xC0, 0x1F, 0xC7, 0xF0, 0x1F, 0xE3, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0x00, 0x04, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFC, 0x0F, 0xFC, 0xFC, 0x01,
  0xFE, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFE, 0xFC, 0x01, 0xFE, 0xFC, 0x1F,
  0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0xFE,
  0x03, 0xFC, 0xFE, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0xBF, 0x00, 0x0F, 0xFF,
  0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0,
  0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xBF,
  0x00, 0x1F, 0xDF, 0xC0, 0x1F, 0xC7, 0xF0, 0x1F, 0xE3, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0x00, 0x04, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFB, 0xF8,
  0x00, 0x7E, 0x7E, 0x00, 0x1F, 0x9F, 0xC0, 0x0F, 0xE7, 0xF8, 0x07, 0xF0,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0x80, 0x07, 0xFF, 0x80, 0x00, 0x08, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xFF,
  0x00, 0x0F, 0xEF, 0xC0, 0x03, 0xF3, 0xF0, 0x01, 0xFC, 0xFC, 0x00, 0x7E,
  0x3F, 0x00, 0x3F, 0x8F, 0xC0, 0x0F, 0xC3, 0xF0, 0x07, 0xF0, 0xFC, 0x01,
  0xF8, 0x3F, 0x00, 0xFE, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x1F, 0xC0, 0xFC,
  0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x7F, 0x00,
  0xFC, 0x1F, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xC1, 0xFC, 0x03, 0xF0,
  0x3F, 0x00, 0xFC, 0x0F, 0xE0, 0x3F, 0x03, 0xF8, 0x0F, 0xC0, 0x7F, 0x03,
  0xF0, 0x1F, 0xC0, 0xFC, 0x03, 0xF8, 0x3F, 0x00, 0xFE, 0x0F, 0xC0, 0x1F,
  0xC3, 0xF0, 0x07, 0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x8F, 0xC0,
  0x07, 0xE3, 0xF0, 0x01, 0xFC, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xEF,
  0xC0, 0x01, 0xFB, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xDE, 0x03, 0xDF, 0xEF,
  0x01, 0xEF, 0xF7, 0xC1, 0xF7, 0xF9, 0xE0, 0xF3, 0xFC, 0xF0, 0x79, 0xFE,
  0x7C, 0x3C, 0xFF, 0x9E, 0x3C, 0xFF, 0xCF, 0x1E, 0x7F, 0xE7, 0xCF, 0x3F,
  0xF3, 0xEF, 0x9F, 0xF8, 0xF7, 0x8F, 0xFC, 0x7B, 0xC7, 0xFE, 0x3F, 0xE3,
  0xFF, 0x0F, 0xE1, 0xFF, 0x87, 0xF0, 0xFF, 0xC3, 0xF8, 0x7F, 0xE0, 0xF8,
  0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x00, 0x7F, 0xF7, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0,
  0x0F, 0xFF, 0x7C, 0x07, 0xFF, 0xBE, 0x03, 0xFF, 0xDF, 0x01, 0xFF, 0xE7,
  0xC0, 0xFF, 0xF3, 0xE0, 0x7F, 0xF8, 0xF0, 0x3F, 0xFC, 0x7C, 0x1F, 0xFE,
  0x3E, 0x0F, 0xFF, 0x0F, 0x07, 0xFF, 0x87, 0xC3, 0xFF, 0xC3, 0xE1, 0xFF,
  0xE0, 0xF8, 0xFF, 0xF0, 0x7C, 0x7F, 0xF8, 0x3E, 0x3F, 0xFC, 0x0F, 0x9F,
  0xFE, 0x07, 0xCF, 0xFF, 0x03, 0xE7, 0xFF, 0x80, 0xFB, 0xFF, 0xC0, 0x7D,
  0xFF, 0xE0, 0x3E, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xDF, 0xFC, 0x03,
  0xEF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0x00,
  0x1E, 0x00, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF1, 0xFE, 0x03, 0xFC, 0xFE, 0x00, 0xFE,
  0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xFF, 0x80, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F,
  0xF8, 0x00, 0x7F, 0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x9F, 0xC0, 0x1F,
  0xC7, 0xF0, 0x1F, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x04, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFE, 0x3F, 0x00, 0x7F, 0xCF, 0xC0, 0x07, 0xF3, 0xF0, 0x00,
  0xFE, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xEF, 0xC0, 0x01, 0xFB, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xEF, 0xC0, 0x01, 0xFB,
  0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0xBF, 0x00, 0x1F, 0xCF, 0xC0, 0x3F,
  0xF3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xF1, 0xFE, 0x03, 0xFC, 0xFE, 0x00, 0xFE, 0xFE, 0x00,
  0x3F, 0x7E, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xBF, 0x00, 0x1F, 0x9F, 0xC0, 0x1F, 0xCF, 0xF0,
  0x1F, 0xE3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xE0, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xE7, 0xE0, 0x1F, 0xF3, 0xF0, 0x03, 0xFD, 0xF8,
  0x00, 0xFE, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFD,
  0xF8, 0x00, 0x7E, 0xFC, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x3F, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0x00, 0xFC, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x7F, 0x07, 0xE0, 0x1F, 0x83, 0xF0,
  0x0F, 0xE1, 0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xFC, 0x7E, 0x00, 0x7E, 0x3F,
  0x00, 0x3F, 0x9F, 0x80, 0x0F, 0xCF, 0xC0, 0x07, 0xF7, 0xE0, 0x03, 0xFB,
  0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0xF0,
  0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xF1, 0xFE, 0x01, 0xFC, 0xFE, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0xBF, 0x00,
  0x0F, 0xDF, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80,
  0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xEF, 0xF0, 0x1F, 0xE7, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x03,
  0xFF, 0xE0, 0x00, 0x04, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x1F,
  0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01,
  0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFD, 0xF8, 0x00, 0xFC, 0xFC, 0x00,
  0x7E, 0x7E, 0x00, 0x3F, 0x3F, 0x80, 0x3F, 0x8F, 0xE0, 0x3F, 0x87, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x03,
  0xFF, 0x80, 0x00, 0x08, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFB, 0xF0, 0x00,
  0x1F, 0x9F, 0x80, 0x00, 0xFC, 0xFC, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x3E,
  0x1F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFC, 0x1F,
  0x80, 0x07, 0xC0, 0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x00,
  0x1F, 0x80, 0xFC, 0x00, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x3F, 0x01, 0xF8, 0x01,
  0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0x3E, 0x03, 0xE0, 0x01, 0xF8,
  0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xF0, 0x7C,
  0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x03, 0xF1, 0xF8, 0x00,
  0x0F, 0x8F, 0x80, 0x00, 0x7E, 0x7C, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x1F,
  0xBF, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0xFC, 0x07, 0xC0, 0x3F, 0xF8,
  0x0F, 0xC0, 0xFF, 0xF0, 0x1F, 0x81, 0xFB, 0xE0, 0x7F, 0x03, 0xE7, 0xC0,
  0xFE, 0x07, 0xCF, 0x81, 0xDC, 0x0F, 0x9F, 0x03, 0xB8, 0x1F, 0x3E, 0x07,
  0x70, 0x3E, 0x7C, 0x0E, 0xE0, 0x7C, 0xF8, 0x1D, 0xC0, 0xF9, 0xF0, 0x3B,
  0xC1, 0xF3, 0xF0, 0xF7, 0x83, 0xE3, 0xE1, 0xEF, 0x0F, 0x87, 0xC3, 0xCE,
  0x1F, 0x0F, 0x87, 0x1C, 0x3E, 0x1F, 0x0E, 0x38, 0x7C, 0x3E, 0x1C, 0x70,
  0xF8, 0x7C, 0x38, 0xE1, 0xF0, 0xF8, 0x71, 0xC3, 0xE1, 0xF1, 0xE3, 0xC7,
  0xC3, 0xE3, 0xC7, 0x8F, 0x83, 0xE7, 0x8F, 0x1E, 0x07, 0xCF, 0x0E, 0x7C,
  0x0F, 0x9C, 0x1C, 0xF8, 0x1F, 0x38, 0x39, 0xF0, 0x3E, 0x70, 0x73, 0xE0,
  0x7C, 0xE0, 0xE7, 0xC0, 0xF9, 0xC1, 0xCF, 0x81, 0xF7, 0x83, 0xDF, 0x03,
  0xEF, 0x07, 0xBE, 0x07, 0xDE, 0x0F, 0x78, 0x07, 0xB8, 0x0E, 0xF0, 0x0F,
  0x70, 0x1D, 0xE0, 0x1F, 0xE0, 0x3B, 0xC0, 0x3F, 0xC0, 0x7F, 0x80, 0x7F,
  0x80, 0xFF, 0x00, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xFC,
  0x07, 0xF8, 0x07, 0xF8, 0x0F, 0xE0, 0x7F, 0x00, 0x03, 0xF3, 0xF8, 0x00,
  0x3F, 0x8F, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0xFC,
  0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x07, 0xE0, 0x07,
  0xF0, 0x7F, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x03, 0xF1,
  0xF8, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7E, 0x7F, 0x00, 0x03, 0xF1, 0xF8, 0x00,
  0x3F, 0x0F, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0xFC,
  0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0xFE, 0x00, 0xFE, 0x07, 0xE0, 0x03,
  0xF0, 0x7F, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x7E, 0x3F, 0x80, 0x03, 0xF9,
  0xF8, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x1F, 0xDF, 0x80, 0x00, 0xFC, 0xFC, 0x00, 0x07, 0xE3, 0xF0, 0x00,
  0x7E, 0x1F, 0x80, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x03, 0xF0, 0x01, 0xF8,
  0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x0F, 0xC0, 0x0F,
  0xC0, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xE1,
  0xF8, 0x00, 0x3F, 0x1F, 0x80, 0x01, 0xFC, 0xFC, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0x3F, 0x7E, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0x78, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xDF, 0x00, 0x07, 0xC7,
  0xC0, 0x03, 0xE3, 0xE0, 0x03, 0xF0, 0xF8, 0x01, 0xF0, 0x7C, 0x01, 0xF8,
  0x3F, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x7C, 0x01, 0xF0, 0x3E,
  0x00, 0xF8, 0x3F, 0x00, 0x7E, 0x1F, 0x00, 0x1F, 0x1F, 0x80, 0x0F, 0xCF,
  0x80, 0x03, 0xEF, 0xC0, 0x01, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0xFE, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0xFF, 0x07, 0xF8, 0xFE,
  0x00, 0xFE, 0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x07, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0xE0, 0x07,
  0xDF, 0xC0, 0x03, 0xEF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0x7F, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xBF, 0x80,
  0x3F, 0xDF, 0xE0, 0x7B, 0xE7, 0xFF, 0xFD, 0xF3, 0xFF, 0xFC, 0xF8, 0xFF,
  0xFC, 0x7C, 0x1F, 0xFC, 0x3E, 0x00, 0x40, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x1F, 0x00, 0xFC, 0x7F, 0xE0, 0xFD, 0xFF, 0xF0, 0xF9, 0xFF, 0xF8, 0xFB,
  0xFF, 0xFC, 0xFB, 0xEF, 0xFC, 0xFB, 0x01, 0xFE, 0xFE, 0x00, 0x7E, 0xFC,
  0x00, 0x7E, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7E, 0xFE,
  0x00, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFD,
  0xFF, 0xF8, 0xFC, 0xFF, 0xF0, 0xFC, 0x7F, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x3F, 0x00, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xE1, 0xFF, 0xBF, 0xF1, 0xFE, 0x01, 0xFC, 0xFE, 0x00, 0x7E,
  0x7E, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0xFD, 0xF8, 0x00, 0x7E, 0xFC,
  0x00, 0x7F, 0x7F, 0x00, 0x3F, 0x3F, 0xC0, 0x7F, 0x8F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0xF8, 0x3F, 0x07, 0xFE, 0x3F,
  0x0F, 0xFF, 0x9F, 0x1F, 0xFF, 0x9F, 0x3F, 0xFF, 0xDF, 0x3F, 0xF7, 0xDF,
  0x7F, 0x80, 0xDF, 0x7E, 0x00, 0x7F, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7F, 0x00, 0x7F, 0x7F, 0x80, 0xFF,
  0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xBF, 0x0F, 0xFF, 0x3F,
  0x03, 0xFE, 0x3F, 0x00, 0x30, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFF, 0xF0,
  0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC1, 0xFE, 0x07,
  0xF1, 0xFC, 0x01, 0xFC, 0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0x7E, 0x00,
  0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x3F,
  0x1F, 0x80, 0x3F, 0x8F, 0xF8, 0x7F, 0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xFE, 0x3F, 0x0F, 0xFF, 0xBF, 0x1F, 0xFF,
  0xBF, 0x3F, 0xFF, 0xFF, 0x3F, 0xF7, 0xFF, 0x7F, 0x80, 0xFF, 0x7F, 0x00,
  0x7F, 0x7E, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0xC1,
  0xDF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xBF, 0x07, 0xFF,
  0x3F, 0x01, 0xFC, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0xFF, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x07, 0xFF,
  0xF0, 0x07, 0xFF, 0x80, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x3E, 0x03, 0xF1, 0xFF, 0x87,
  0xEF, 0xFF, 0x8F, 0xDF, 0xFF, 0x9F, 0xFF, 0xFF, 0xBF, 0xF1, 0xFF, 0x7F,
  0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01,
  0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F,
  0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x9F, 0xFF, 0xF8, 0xFF, 0xFF, 0x87, 0xFF, 0xFC,
  0x3F, 0xFF, 0x81, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0xFE,
  0xFC, 0x00, 0x7F, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x0F, 0xE3, 0xF0, 0x07,
  0xF0, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0xFE, 0x0F, 0xC0, 0x7F, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x0F, 0xE0, 0x3F, 0x07, 0xF0, 0x0F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC,
  0x03, 0xF0, 0x7F, 0x00, 0xFC, 0x0F, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7F, 0x03, 0xF0, 0x0F, 0xE0, 0xFC, 0x03, 0xF8, 0x3F, 0x00, 0x7F, 0x0F,
  0xC0, 0x0F, 0xE3, 0xF0, 0x03, 0xF8, 0xFC, 0x00, 0x7F, 0x3F, 0x00, 0x0F,
  0xCF, 0xC0, 0x03, 0xFB, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0x00, 0x70, 0x1E, 0x1F, 0x3F, 0x8F, 0xE3, 0xEF, 0xFB,
  0xFE, 0x7D, 0xFF, 0x7F, 0xEF, 0xBF, 0xEF, 0xFD, 0xF8, 0x3E, 0x0F, 0xFF,
  0x07, 0xC1, 0xFF, 0xE0, 0xF8, 0x3F, 0xFC, 0x1F, 0x07, 0xFF, 0x83, 0xE0,
  0xFF, 0xF0, 0x7C, 0x1F, 0xFE, 0x0F, 0x83, 0xFF, 0xC1, 0xF0, 0x7F, 0xF8,
  0x3E, 0x0F, 0xFF, 0x07, 0xC1, 0xFF, 0xE0, 0xF8, 0x3F, 0xFC, 0x1F, 0x07,
  0xFF, 0x83, 0xE0, 0xFF, 0xF0, 0x7C, 0x1F, 0xFE, 0x0F, 0x83, 0xFF, 0xC1,
  0xF0, 0x7F, 0xF8, 0x3E, 0x0F, 0xFF, 0x07, 0xC1, 0xFF, 0xE0, 0xF8, 0x3F,
  0xFC, 0x1F, 0x07, 0xFF, 0x83, 0xE0, 0xFF, 0xF0, 0x7C, 0x1F, 0xFE, 0x0F,
  0x83, 0xFF, 0xC1, 0xF0, 0x7F, 0xF8, 0x3E, 0x0F, 0xFF, 0x07, 0xC1, 0xF8,
  0x00, 0x1F, 0x01, 0xF8, 0xFF, 0xC3, 0xF7, 0xFF, 0xC7, 0xEF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xDF, 0xFD, 0xFF, 0xBF, 0xC0, 0x7F, 0xFF, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00,
  0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03,
  0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F,
  0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF,
  0x80, 0x07, 0xFF, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0xF0,
  0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC1, 0xFF, 0xBF,
  0xF1, 0xFE, 0x03, 0xFC, 0xFE, 0x00, 0xFE, 0x7E, 0x00, 0x3F, 0x7E, 0x00,
  0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0,
  0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0xE0, 0x00, 0xFD, 0xF8, 0x00, 0xFC, 0xFC, 0x00, 0x7E, 0x7F, 0x00, 0x7F,
  0x1F, 0xC0, 0x7F, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x00, 0x10, 0x00, 0x00, 0x1F,
  0x00, 0xFC, 0x7F, 0xE0, 0xFD, 0xFF, 0xF0, 0xFD, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFC, 0xFF, 0xEF, 0xFC, 0xFF, 0x00, 0xFE, 0xFE, 0x00, 0x7E, 0xFC, 0x00,
  0x7E, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7E, 0xFE, 0x00,
  0xFE, 0xFB, 0x01, 0xFE, 0xFB, 0xFF, 0xFC, 0xFB, 0xFF, 0xFC, 0xF9, 0xFF,
  0xF8, 0xF8, 0xFF, 0xF0, 0xFC, 0x7F, 0xC0, 0xFC, 0x0C, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xFE, 0x3F, 0x0F, 0xFF, 0xBF, 0x1F, 0xFF,
  0xBF, 0x3F, 0xFF, 0xFF, 0x3F, 0xF7, 0xFF, 0x7F, 0x80, 0xFF, 0x7F, 0x00,
  0x7F, 0x7E, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00,
  0x3F, 0x7F, 0x00, 0x7F, 0x7F, 0x80, 0xDF, 0x3F, 0xFF, 0xDF, 0x3F, 0xFF,
  0xDF, 0x1F, 0xFF, 0x9F, 0x0F, 0xFF, 0x3F, 0x03, 0xFE, 0x3F, 0x00, 0x30,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0xF8, 0xFF, 0xE0, 0xF9, 0xFF,
  0xF0, 0xFB, 0xFF, 0xF8, 0xFB, 0xFF, 0xFC, 0xFB, 0xC7, 0xFE, 0xFF, 0x00,
  0xFE, 0xFE, 0x00, 0x7E, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xFE, 0x07, 0xF9, 0xFC, 0x00, 0xFC, 0xFC,
  0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xBF, 0x80, 0x1F, 0xDF, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x01,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xF8,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0x7F, 0x01, 0xFC,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00,
  0x7F, 0xF0, 0x00, 0x04, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0xFF, 0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0xFC, 0xFC,
  0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F,
  0x83, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x3F, 0x07, 0xE0,
  0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0xC7, 0xE0, 0x01, 0xF8,
  0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x03, 0xF3, 0xE0, 0x00, 0x7E, 0xFC, 0x00,
  0x0F, 0xDF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0xF8, 0x0F, 0x80, 0x7F, 0xC0, 0x7C, 0x07, 0xFE, 0x03, 0xE0, 0x3F, 0xF0,
  0x3F, 0x81, 0xFF, 0x81, 0xDC, 0x0F, 0xFC, 0x0E, 0xE0, 0x7D, 0xE0, 0x77,
  0x03, 0xCF, 0x83, 0xB8, 0x3E, 0x7C, 0x1D, 0xC1, 0xF3, 0xE1, 0xEF, 0x0F,
  0x9F, 0x0F, 0x78, 0x7C, 0xF8, 0x71, 0xC3, 0xE3, 0xC3, 0x8E, 0x1E, 0x1E,
  0x1C, 0x70, 0xF0, 0xF8, 0xE3, 0x8F, 0x87, 0xC7, 0x1C, 0x7C, 0x3E, 0x78,
  0xF3, 0xE1, 0xF3, 0xC7, 0x9F, 0x0F, 0x9C, 0x1C, 0xF0, 0x3C, 0xE0, 0xE7,
  0x81, 0xE7, 0x07, 0x3C, 0x0F, 0xB8, 0x3B, 0xE0, 0x7F, 0xC1, 0xFF, 0x03,
  0xFE, 0x0F, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x01, 0xFC, 0x03, 0xF8,
  0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF0,
  0x1F, 0x80, 0x3F, 0x00, 0xFE, 0x03, 0xF8, 0x03, 0xF8, 0x1F, 0x80, 0x0F,
  0xC1, 0xF8, 0x00, 0x7F, 0x1F, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xFB,
  0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xFC, 0x7F, 0x00, 0x1F, 0xC1, 0xFC,
  0x00, 0xFC, 0x07, 0xE0, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x00, 0xFE, 0x07,
  0xE0, 0x03, 0xF0, 0x7F, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x7F, 0x7F, 0x00,
  0x03, 0xFC, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x3F,
  0x3F, 0x00, 0x07, 0xE7, 0xF0, 0x01, 0xFC, 0x7E, 0x00, 0x3F, 0x0F, 0xE0,
  0x07, 0xE0, 0xFC, 0x01, 0xFC, 0x1F, 0x80, 0x3F, 0x03, 0xF8, 0x07, 0xE0,
  0x3F, 0x01, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xC1,
  0xF8, 0x01, 0xFC, 0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF1, 0xF8, 0x00,
  0x3F, 0x3F, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0xFD, 0xF8, 0x00, 0x0F, 0xBF,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x03, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF,
  0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x3F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x07,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x03, 0xE7, 0xFF, 0x00, 0x7D,
  0xFF, 0xF0, 0x0F, 0xBF, 0xFF, 0x01, 0xFF, 0xE7, 0xF0, 0x3F, 0xF8, 0x7F,
  0x0F, 0xFE, 0x07, 0xF1, 0xFF, 0xC0, 0x7F, 0xFE, 0xF8, 0x07, 0xFF, 0xDF,
  0x00, 0x7F, 0xF3, 0xE0, 0x07, 0xFC, 0x00, 0x00, 0x1C, 0x00,
};

const GFXglyph JetBrainsMono_Medium55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 33, 0, -1 },
  { 1, 9, 40, 33, 12, -40 },
  { 46, 17, 16, 33, 8, -40 },
  { 80, 29, 40, 33, 2, -40 },
  { 225, 25, 56, 33, 4, -48 },
  { 400, 33, 40, 33, 0, -40 },
  { 565, 28, 42, 33, 3, -41 },
  { 712, 6, 16, 33, 13, -40 },
  { 724, 17, 53, 33, 10, -46 },
  { 837, 17, 53, 33, 6, -46 },
  { 950, 29, 29, 33, 2, -34 },
  { 1056, 27, 26, 33, 3, -31 },
  { 1144, 12, 17, 33, 9, -8 },
  { 1170, 17, 6, 33, 8, -21 },
  { 1183, 9, 10, 33, 12, -9 },
  { 1195, 25, 52, 33, 4, -46 },
  { 1358, 25, 42, 33, 4, -41 },
  { 1490, 25, 40, 33, 5, -40 },
  { 1615, 25, 41, 33, 4, -41 },
  { 1744, 25, 41, 33, 4, -40 },
  { 1873, 24, 40, 33, 4, -40 },
  { 1993, 25, 41, 33, 4, -40 },
  { 2122, 27, 41, 33, 3, -40 },
  { 2261, 26, 40, 33, 4, -40 },
  { 2391, 25, 42, 33, 4, -41 },
  { 2523, 27, 41, 33, 3, -41 },
  { 2662, 9, 32, 33, 12, -31 },
  { 2698, 12, 40, 33, 9, -31 },
  { 2758, 25, 30, 33, 4, -33 },
  { 2852, 23, 19, 33, 5, -28 },
  { 2907, 25, 30, 33, 4, -33 },
  { 3001, 20, 40, 33, 7, -40 },
  { 3101, 29, 51, 33, 2, -41 },
  { 3286, 29, 40, 33, 2, -40 },
  { 3431, 25, 40, 33, 5, -40 },
  { 3556, 25, 42, 33, 4, -41 },
  { 3688, 24, 40, 33, 5, -40 },
  { 3808, 24, 40, 33, 5, -40 },
  { 3928, 24, 40, 33, 5, -40 },
  { 4048, 25, 42, 33, 4, -41 },
  { 4180, 23, 40, 33, 5, -40 },
  { 4295, 23, 40, 33, 5, -40 },
  { 4410, 26, 41, 33, 2, -40 },
  { 4544, 26, 40, 33, 5, -40 },
  { 4674, 23, 40, 33, 6, -40 },
  { 4789, 25, 40, 33, 4, -40 },
  { 4914, 25, 40, 33, 4, -40 },
  { 5039, 25, 42, 33, 4, -41 },
  { 5171, 26, 40, 33, 5, -40 },
  { 5301, 25, 51, 33, 4, -41 },
  { 5461, 25, 40, 33, 5, -40 },
  { 5586, 25, 42, 33, 4, -41 },
  { 5718, 27, 40, 33, 3, -40 },
  { 5853, 25, 41, 33, 4, -40 },
  { 5982, 29, 40, 33, 2, -40 },
  { 6127, 31, 40, 33, 1, -40 },
  { 6282, 29, 40, 33, 2, -40 },
  { 6427, 29, 40, 33, 2, -40 },
  { 6572, 23, 40, 33, 5, -40 },
  { 6687, 14, 52, 33, 11, -46 },
  { 6778, 25, 52, 33, 4, -46 },
  { 6941, 14, 52, 33, 8, -46 },
  { 7032, 25, 21, 33, 4, -40 },
  { 7098, 27, 6, 33, 3, 1 },
  { 7119, 13, 8, 33, 9, -43 },
  { 7132, 25, 32, 33, 3, -31 },
  { 7232, 24, 41, 33, 5, -40 },
  { 7355, 25, 32, 33, 4, -31 },
  { 7455, 24, 41, 33, 4, -40 },
  { 7578, 25, 32, 33, 4, -31 },
  { 7678, 27, 40, 33, 3, -40 },
  { 7813, 24, 41, 33, 4, -31 },
  { 7936, 23, 40, 33, 5, -40 },
  { 8051, 27, 43, 33, 4, -43 },
  { 8197, 21, 53, 33, 5, -43 },
  { 8337, 26, 40, 33, 5, -40 },
  { 8467, 28, 40, 33, 2, -40 },
  { 8607, 27, 31, 33, 3, -31 },
  { 8712, 23, 31, 33, 5, -31 },
  { 8802, 25, 32, 33, 4, -31 },
  { 8902, 24, 41, 33, 5, -31 },
  { 9025, 24, 41, 33, 4, -31 },
  { 9148, 24, 31, 33, 6, -31 },
  { 9241, 25, 32, 33, 4, -31 },
  { 9341, 26, 39, 33, 3, -39 },
  { 9468, 23, 31, 33, 5, -30 },
  { 9558, 27, 30, 33, 3, -30 },
  { 9660, 29, 30, 33, 2, -30 },
  { 9769, 29, 30, 33, 2, -30 },
  { 9878, 27, 40, 33, 3, -30 },
  { 10013, 23, 30, 33, 5, -30 },
  { 10100, 23, 52, 33, 5, -46 },
  { 10250, 5, 52, 33, 14, -46 },
  { 10283, 23, 52, 33, 5, -46 },
  { 10433, 27, 12, 33, 3, -25 },
};

const GFXfont JetBrainsMono_Medium55pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Medium55pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Medium55pt7bGlyphs,
  0x20, 0x7E, 73
};

#endif // _JETBRAINSMONO_MEDIUM55PT7B_H_
