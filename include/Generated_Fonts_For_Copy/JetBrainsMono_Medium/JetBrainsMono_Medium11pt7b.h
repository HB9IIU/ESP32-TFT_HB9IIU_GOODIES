#ifndef _JETBRAINSMONO_MEDIUM11PT7B_H_
#define _JETBRAINSMONO_MEDIUM11PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Medium.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Medium11pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x53, 0xB6, 0x80, 0x24, 0x97, 0xCA, 0x4B, 0xF4, 0x94, 0x21,
  0x1D, 0x7A, 0x70, 0xC5, 0xAF, 0x88, 0x40, 0xE7, 0x4A, 0xA2, 0x82, 0xC6,
  0x95, 0x46, 0xF4, 0xA1, 0x8A, 0xDA, 0x5D, 0xE0, 0x2A, 0x49, 0x24, 0x44,
  0xC6, 0x23, 0x33, 0x32, 0x6C, 0x10, 0x4F, 0xC4, 0x29, 0x20, 0x21, 0x3E,
  0x42, 0x00, 0x7A, 0xE0, 0x70, 0x18, 0x84, 0x42, 0x11, 0x08, 0xC4, 0x00,
  0xF4, 0xE3, 0x5A, 0xC6, 0x6E, 0x65, 0x28, 0x42, 0x10, 0x9F, 0xF4, 0xC2,
  0x23, 0x33, 0x1F, 0xF0, 0x88, 0xE1, 0x86, 0x7E, 0x11, 0x18, 0xB9, 0xFC,
  0x63, 0xF4, 0x21, 0xE1, 0x86, 0x7E, 0x33, 0x11, 0xE9, 0xC6, 0x6E, 0xFC,
  0x44, 0x23, 0x11, 0x88, 0xF4, 0xE6, 0xED, 0x46, 0x7E, 0xF4, 0xE3, 0x37,
  0x08, 0x8C, 0xD0, 0x70, 0xD0, 0x7A, 0x09, 0xF9, 0x06, 0x0C, 0xFF, 0xC1,
  0xF0, 0x86, 0x0C, 0x17, 0x60, 0xF1, 0x11, 0x64, 0x06, 0x79, 0x18, 0x67,
  0x96, 0x59, 0xF0, 0x40, 0xC0, 0x30, 0xC2, 0x8A, 0x69, 0xE4, 0x71, 0xF4,
  0xE3, 0xE9, 0xC6, 0x7E, 0x74, 0xE1, 0x08, 0x42, 0x6E, 0xF4, 0xE3, 0x18,
  0xC6, 0x7E, 0xFC, 0x21, 0xE8, 0x42, 0x1F, 0xFC, 0x21, 0xFF, 0xC2, 0x10,
  0x74, 0xE1, 0x0B, 0xC6, 0x6E, 0x9C, 0xE7, 0xF9, 0xCE, 0x73, 0xF9, 0x08,
  0x42, 0x10, 0x9F, 0x3C, 0x30, 0xC3, 0x0C, 0x3C, 0x9E, 0x8C, 0xA5, 0xCB,
  0x4A, 0x51, 0x84, 0x21, 0x08, 0x42, 0x1F, 0x9E, 0xF7, 0xDA, 0xC6, 0x31,
  0xCE, 0x73, 0x5A, 0xD6, 0x73, 0x74, 0xE3, 0x18, 0xC6, 0x6E, 0xF4, 0x63,
  0x3F, 0x42, 0x10, 0x74, 0xE3, 0x18, 0xC6, 0x6E, 0x10, 0xC0, 0xF4, 0xE3,
  0x3F, 0x4A, 0x53, 0x74, 0xE1, 0xC3, 0x06, 0x3E, 0xF9, 0x08, 0x42, 0x10,
  0x84, 0x8C, 0x63, 0x18, 0xC6, 0x6E, 0xC5, 0x14, 0x9A, 0x28, 0xA3, 0x0C,
  0x96, 0x57, 0x5D, 0x6D, 0xB6, 0xDB, 0xC5, 0xA3, 0x8C, 0x30, 0xA4, 0xB1,
  0xC5, 0x32, 0x8E, 0x30, 0x41, 0x04, 0xF8, 0x8C, 0x46, 0x22, 0x1F, 0xF2,
  0x49, 0x24, 0x9C, 0x86, 0x10, 0x86, 0x10, 0x82, 0x10, 0xC0, 0xD5, 0x55,
  0x70, 0x22, 0x95, 0x30, 0xF8, 0x90, 0x74, 0xDF, 0x19, 0xF4, 0x84, 0x3D,
  0x38, 0xC6, 0x7E, 0xF4, 0xE1, 0x09, 0xB8, 0x18, 0xFB, 0x39, 0xCE, 0x7F,
  0xF4, 0xFF, 0x08, 0xB8, 0x3B, 0x19, 0xF6, 0x31, 0x8C, 0xFC, 0xE7, 0x3D,
  0xBC, 0x6E, 0x84, 0x3D, 0x38, 0xC6, 0x31, 0x21, 0x01, 0xC2, 0x10, 0x84,
  0xF8, 0x13, 0x0F, 0x11, 0x11, 0x13, 0xE0, 0x84, 0x27, 0x2E, 0x5A, 0x51,
  0xE0, 0x82, 0x08, 0x20, 0x83, 0x07, 0xFD, 0x6B, 0x5A, 0xD4, 0xF4, 0xE3,
  0x18, 0xC4, 0xF4, 0xE3, 0x19, 0xB8, 0xF4, 0xE3, 0x19, 0xFA, 0x10, 0xFC,
  0xE7, 0x39, 0xF4, 0x63, 0xB6, 0x61, 0x08, 0x40, 0xF4, 0x78, 0x38, 0xF8,
  0x42, 0x3E, 0x84, 0x21, 0x07, 0x8C, 0x63, 0x19, 0xB8, 0x8C, 0xF4, 0xA7,
  0x30, 0x95, 0x57, 0x5B, 0x6D, 0xA0, 0x4C, 0xA3, 0x0C, 0x6B, 0x30, 0xC5,
  0x32, 0x8A, 0x30, 0x43, 0x08, 0xF8, 0x88, 0x8C, 0x7C, 0x39, 0x08, 0x4E,
  0x70, 0x84, 0x21, 0xC0, 0xFF, 0xC0, 0xC3, 0x10, 0x87, 0x9D, 0x08, 0x66,
  0x00, 0xCD, 0xC0,
};

const GFXglyph JetBrainsMono_Medium11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 2, 8, 7, 2, -8 },
  { 3, 3, 3, 7, 2, -8 },
  { 5, 6, 8, 7, 0, -8 },
  { 11, 5, 12, 7, 1, -10 },
  { 19, 7, 8, 7, 0, -8 },
  { 26, 5, 8, 7, 1, -8 },
  { 31, 1, 3, 7, 3, -8 },
  { 32, 3, 10, 7, 2, -9 },
  { 36, 4, 10, 7, 1, -9 },
  { 41, 6, 6, 7, 0, -7 },
  { 46, 5, 5, 7, 1, -6 },
  { 50, 2, 4, 7, 2, -2 },
  { 51, 3, 1, 7, 2, -4 },
  { 52, 2, 2, 7, 2, -2 },
  { 53, 5, 10, 7, 1, -9 },
  { 60, 5, 8, 7, 1, -8 },
  { 65, 5, 8, 7, 1, -8 },
  { 70, 5, 8, 7, 1, -8 },
  { 75, 5, 8, 7, 1, -8 },
  { 80, 5, 8, 7, 1, -8 },
  { 85, 5, 8, 7, 1, -8 },
  { 90, 5, 8, 7, 1, -8 },
  { 95, 5, 8, 7, 1, -8 },
  { 100, 5, 8, 7, 1, -8 },
  { 105, 5, 8, 7, 1, -8 },
  { 110, 2, 6, 7, 2, -6 },
  { 112, 2, 8, 7, 2, -6 },
  { 114, 5, 6, 7, 1, -7 },
  { 118, 5, 4, 7, 1, -6 },
  { 121, 5, 6, 7, 1, -7 },
  { 125, 4, 8, 7, 1, -8 },
  { 129, 6, 10, 7, 0, -8 },
  { 137, 6, 8, 7, 0, -8 },
  { 143, 5, 8, 7, 1, -8 },
  { 148, 5, 8, 7, 1, -8 },
  { 153, 5, 8, 7, 1, -8 },
  { 158, 5, 8, 7, 1, -8 },
  { 163, 5, 8, 7, 1, -8 },
  { 168, 5, 8, 7, 1, -8 },
  { 173, 5, 8, 7, 1, -8 },
  { 178, 5, 8, 7, 1, -8 },
  { 183, 6, 8, 7, 0, -8 },
  { 189, 5, 8, 7, 1, -8 },
  { 194, 5, 8, 7, 1, -8 },
  { 199, 5, 8, 7, 1, -8 },
  { 204, 5, 8, 7, 1, -8 },
  { 209, 5, 8, 7, 1, -8 },
  { 214, 5, 8, 7, 1, -8 },
  { 219, 5, 10, 7, 1, -8 },
  { 226, 5, 8, 7, 1, -8 },
  { 231, 5, 8, 7, 1, -8 },
  { 236, 5, 8, 7, 1, -8 },
  { 241, 5, 8, 7, 1, -8 },
  { 246, 6, 8, 7, 0, -8 },
  { 252, 6, 8, 7, 0, -8 },
  { 258, 6, 8, 7, 0, -8 },
  { 264, 6, 8, 7, 0, -8 },
  { 270, 5, 8, 7, 1, -8 },
  { 275, 3, 10, 7, 2, -9 },
  { 279, 5, 10, 7, 1, -9 },
  { 286, 2, 10, 7, 2, -9 },
  { 289, 5, 4, 7, 1, -8 },
  { 292, 5, 1, 7, 1, 0 },
  { 293, 2, 2, 7, 2, -9 },
  { 294, 5, 6, 7, 1, -6 },
  { 298, 5, 8, 7, 1, -8 },
  { 303, 5, 6, 7, 1, -6 },
  { 307, 5, 8, 7, 1, -8 },
  { 312, 5, 6, 7, 1, -6 },
  { 316, 5, 8, 7, 1, -8 },
  { 321, 5, 8, 7, 1, -6 },
  { 326, 5, 8, 7, 1, -8 },
  { 331, 5, 9, 7, 1, -9 },
  { 337, 4, 11, 7, 1, -9 },
  { 343, 5, 8, 7, 1, -8 },
  { 348, 6, 8, 7, 0, -8 },
  { 354, 5, 6, 7, 1, -6 },
  { 358, 5, 6, 7, 1, -6 },
  { 362, 5, 6, 7, 1, -6 },
  { 366, 5, 8, 7, 1, -6 },
  { 371, 5, 8, 7, 1, -6 },
  { 376, 5, 6, 7, 1, -6 },
  { 380, 5, 6, 7, 1, -6 },
  { 384, 5, 8, 7, 1, -8 },
  { 389, 5, 6, 7, 1, -6 },
  { 393, 5, 6, 7, 1, -6 },
  { 397, 6, 6, 7, 0, -6 },
  { 402, 6, 6, 7, 0, -6 },
  { 407, 6, 8, 7, 0, -6 },
  { 413, 5, 6, 7, 1, -6 },
  { 417, 5, 10, 7, 1, -9 },
  { 424, 1, 10, 7, 3, -9 },
  { 426, 5, 10, 7, 1, -9 },
  { 433, 5, 2, 7, 1, -5 },
};

const GFXfont JetBrainsMono_Medium11pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Medium11pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Medium11pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _JETBRAINSMONO_MEDIUM11PT7B_H_
