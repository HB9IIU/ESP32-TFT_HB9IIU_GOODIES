#ifndef _JETBRAINSMONO_MEDIUM19PT7B_H_
#define _JETBRAINSMONO_MEDIUM19PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Medium.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Medium19pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB6, 0xDB, 0x68, 0x0F, 0xC0, 0xCF, 0x3C, 0xF3, 0xCF, 0x30,
  0x19, 0x84, 0x61, 0x10, 0xC4, 0xFF, 0xCC, 0xC2, 0x30, 0x8C, 0x62, 0x3F,
  0xE6, 0x21, 0x18, 0x46, 0x31, 0x00, 0x08, 0x04, 0x02, 0x07, 0xC7, 0xF3,
  0x4D, 0xA6, 0xD0, 0x78, 0x1F, 0x07, 0xC1, 0x70, 0x9E, 0x4F, 0xA6, 0xFF,
  0x3E, 0x04, 0x02, 0x01, 0x00, 0x78, 0x79, 0x0B, 0x33, 0x66, 0xCC, 0xD0,
  0xF6, 0x01, 0x80, 0x20, 0x0B, 0xC3, 0x4C, 0x48, 0x91, 0x16, 0x37, 0x83,
  0x80, 0x3E, 0x1F, 0xC6, 0x31, 0x80, 0x60, 0x0C, 0x07, 0x03, 0x63, 0xCD,
  0xB3, 0xCC, 0x73, 0x1C, 0xFF, 0x9F, 0x70, 0xFF, 0xF0, 0x04, 0x73, 0x9C,
  0x61, 0x8C, 0x30, 0xC3, 0x0C, 0x30, 0xE1, 0x87, 0x0E, 0x1C, 0x30, 0xC3,
  0x87, 0x06, 0x1C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x71, 0x8E, 0xF3,
  0x00, 0x0C, 0x03, 0x00, 0xC3, 0x22, 0xFB, 0xCF, 0xC1, 0xC0, 0xD8, 0x73,
  0x18, 0xC0, 0x0C, 0x06, 0x03, 0x01, 0x8F, 0xFF, 0xFC, 0x30, 0x18, 0x0C,
  0x00, 0x77, 0x66, 0xCC, 0xFF, 0xF0, 0xFF, 0x80, 0x01, 0x80, 0xC0, 0xC0,
  0x60, 0x70, 0x30, 0x18, 0x18, 0x0C, 0x06, 0x06, 0x03, 0x03, 0x81, 0x80,
  0xC0, 0xC0, 0x60, 0x70, 0x00, 0x3E, 0x3F, 0x98, 0x78, 0x3C, 0x1E, 0x0F,
  0x37, 0xBB, 0xC1, 0xE0, 0xF0, 0x6C, 0x37, 0xF1, 0xF0, 0x38, 0x78, 0xF8,
  0x98, 0x98, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xFF, 0xFF, 0x3E,
  0x3F, 0x98, 0xF8, 0x30, 0x18, 0x1C, 0x0C, 0x0C, 0x0E, 0x0E, 0x0E, 0x0E,
  0x07, 0xFB, 0xFC, 0x7F, 0x3F, 0x80, 0xC0, 0xC0, 0xC0, 0xE0, 0x7C, 0x07,
  0x01, 0x80, 0xF0, 0x7C, 0x77, 0xF1, 0xF0, 0x03, 0x03, 0x03, 0x03, 0x81,
  0x81, 0x81, 0xC6, 0xC3, 0xC1, 0xFF, 0xFF, 0xE0, 0x30, 0x18, 0x0C, 0x7F,
  0x3F, 0x98, 0x0C, 0x06, 0x03, 0xF9, 0xFC, 0xC3, 0x01, 0x80, 0xE0, 0x6C,
  0x37, 0xF1, 0xF0, 0x06, 0x06, 0x07, 0x03, 0x03, 0x03, 0xA1, 0xFD, 0xC7,
  0xC1, 0xE0, 0xF0, 0x7C, 0x37, 0xF1, 0xF0, 0xFF, 0xFF, 0xF0, 0x78, 0x30,
  0x30, 0x18, 0x18, 0x0C, 0x06, 0x06, 0x03, 0x03, 0x01, 0x81, 0xC0, 0x3E,
  0x3F, 0x98, 0xEC, 0x36, 0x1B, 0x98, 0xF8, 0x7E, 0x63, 0x70, 0xF0, 0x6C,
  0x37, 0xF1, 0xF0, 0x3E, 0x3F, 0x98, 0x78, 0x3C, 0x1E, 0x0D, 0x8E, 0xFF,
  0x1B, 0x03, 0x01, 0x81, 0x81, 0xC1, 0xC0, 0x5F, 0x80, 0x00, 0x7F, 0x80,
  0x37, 0x70, 0x00, 0x00, 0x37, 0x66, 0xEC, 0x03, 0x0F, 0x3C, 0xF0, 0xC0,
  0xE0, 0x78, 0x1E, 0x07, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0xE0, 0x78, 0x0F, 0x03, 0x07, 0x1C, 0xF0, 0xC0, 0x80, 0xF9, 0xF8,
  0x18, 0x30, 0x60, 0xCF, 0x9E, 0x30, 0x60, 0x00, 0x07, 0x0E, 0x00, 0x3F,
  0x1C, 0xEC, 0x1B, 0x03, 0xC0, 0xE3, 0xF8, 0xCE, 0x63, 0x98, 0xE6, 0x39,
  0x8E, 0x37, 0xCE, 0xF0, 0x0C, 0x01, 0xC0, 0x3E, 0x00, 0x1C, 0x07, 0x01,
  0xE0, 0xD8, 0x36, 0x0D, 0x83, 0x31, 0x8C, 0x63, 0x1F, 0xC6, 0x1B, 0x86,
  0xC1, 0xB0, 0x70, 0xFC, 0xFE, 0xC7, 0xC3, 0xC3, 0xC6, 0xFC, 0xFE, 0xC3,
  0xC3, 0xC3, 0xC3, 0xFE, 0xFC, 0x7C, 0xFE, 0xC3, 0xC3, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC3, 0xC3, 0xFE, 0x7C, 0xFC, 0xFE, 0xC7, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC7, 0xFE, 0xFC, 0xFF, 0xFF, 0xC0,
  0xC0, 0xC0, 0xC0, 0xFE, 0xFE, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0x7C, 0xFE, 0xC3, 0xC3, 0xC0, 0xC0, 0xC0, 0xDF, 0xDF, 0xC3, 0xC3,
  0xC3, 0xFE, 0x7C, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xFF, 0xFF, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xFF, 0xFF, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0xFF, 0xFF, 0x1F, 0x8F, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xF0, 0xF8, 0x6F, 0xF3, 0xF0, 0xC3,
  0xE1, 0xB1, 0x98, 0xCC, 0xC6, 0x63, 0xE1, 0xF8, 0xCC, 0x67, 0x31, 0x98,
  0xEC, 0x36, 0x1C, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xFF, 0xFF, 0xE1, 0xF1, 0xFC, 0xBE, 0x5D, 0x7E, 0xAF,
  0x77, 0x9B, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0C, 0xC3, 0xE3, 0xE3,
  0xA3, 0xB3, 0xB3, 0x93, 0x9B, 0x9B, 0x8B, 0x8F, 0x8F, 0x87, 0x87, 0x7C,
  0xFE, 0xC7, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xFE,
  0x7C, 0xFC, 0x7F, 0xB0, 0xD8, 0x7C, 0x3E, 0x1B, 0x1D, 0xFC, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x00, 0x3E, 0x3F, 0x98, 0xF8, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x6C, 0x37, 0xF1, 0xF0, 0x18, 0x06, 0x03,
  0x80, 0xFC, 0xFE, 0xC3, 0xC3, 0xC3, 0xC3, 0xFF, 0xFE, 0xCC, 0xCC, 0xC6,
  0xC6, 0xC7, 0xC3, 0x3E, 0x3F, 0x98, 0x6C, 0x36, 0x03, 0x80, 0xF8, 0x3E,
  0x03, 0x80, 0xF0, 0x7C, 0x37, 0xF9, 0xF0, 0xFF, 0xFF, 0xC3, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC7, 0xFE,
  0x7C, 0xC1, 0xF0, 0x6C, 0x19, 0x86, 0x63, 0x18, 0xC6, 0x30, 0xCC, 0x32,
  0x0D, 0x83, 0x60, 0x78, 0x1C, 0x07, 0x00, 0xC6, 0x68, 0xCD, 0x39, 0xB7,
  0x36, 0xA6, 0xD4, 0x9A, 0x93, 0x5A, 0x6B, 0xCD, 0x38, 0xA7, 0x1C, 0xE3,
  0x1C, 0x63, 0x00, 0xC1, 0xD8, 0x66, 0x30, 0xCC, 0x36, 0x07, 0x81, 0xC0,
  0x70, 0x1E, 0x0D, 0x83, 0x31, 0x8C, 0xE1, 0xB0, 0x70, 0xC0, 0xF0, 0x66,
  0x19, 0x8C, 0x33, 0x0D, 0x81, 0xE0, 0x70, 0x1C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xFF, 0xFF, 0x06, 0x06, 0x0C, 0x1C, 0x18, 0x30, 0x30,
  0x60, 0xE0, 0xC0, 0xFF, 0xFF, 0xFF, 0xF1, 0x8C, 0x63, 0x18, 0xC6, 0x31,
  0x8C, 0x63, 0x18, 0xFF, 0xC0, 0xE0, 0x30, 0x18, 0x0E, 0x03, 0x01, 0x80,
  0x60, 0x30, 0x1C, 0x06, 0x03, 0x01, 0xC0, 0x60, 0x30, 0x0C, 0x06, 0x03,
  0x80, 0xC0, 0xFF, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63,
  0xFF, 0xC0, 0x0C, 0x0E, 0x05, 0x86, 0xC3, 0x33, 0x19, 0x87, 0x83, 0xFF,
  0xFF, 0xC0, 0xE3, 0x8E, 0x1C, 0x1F, 0x98, 0xE0, 0x30, 0x1B, 0xFF, 0x87,
  0x83, 0xC1, 0xF3, 0xDF, 0x60, 0xC0, 0xC0, 0xC0, 0xDC, 0xFE, 0xC7, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xFE, 0xFE, 0x1C, 0x1F, 0x98, 0xEC, 0x3E,
  0x07, 0x03, 0x81, 0xC3, 0x61, 0xBF, 0x8F, 0x80, 0x01, 0x80, 0xC0, 0x63,
  0x37, 0xDB, 0x1D, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x6C, 0x77, 0xF9, 0xEC,
  0x1C, 0x1F, 0x98, 0xEC, 0x3C, 0x1F, 0xFF, 0x01, 0x80, 0x61, 0xBF, 0x8F,
  0x80, 0x0F, 0x8F, 0xC6, 0x03, 0x01, 0x87, 0xFF, 0xFE, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x30, 0xFB, 0xC7, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xEF, 0x7B, 0x03, 0x03, 0x07, 0x7E, 0xC0, 0xC0, 0xC0, 0xDC, 0xFE,
  0xC7, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x18, 0x0C, 0x06,
  0x00, 0x00, 0x07, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x87,
  0xFF, 0xFE, 0x0C, 0x1C, 0x30, 0x00, 0x1F, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0xE1, 0xC3, 0x06, 0x3D, 0xF0, 0xC0, 0x60, 0x30, 0x18, 0x1C, 0x36,
  0x33, 0x39, 0x98, 0xF8, 0x7E, 0x33, 0x98, 0xCC, 0x76, 0x1C, 0xF8, 0x3E,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x1F, 0xC3, 0xF0, 0x13, 0x7D, 0xF3, 0x79, 0x3C, 0x9E, 0x4F, 0x27,
  0x93, 0xC9, 0xE4, 0xF2, 0x60, 0x1C, 0xFE, 0xC7, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0x1C, 0x1F, 0x98, 0xEC, 0x3E, 0x1F, 0x0F, 0x87,
  0xC3, 0x61, 0xBF, 0x8F, 0x80, 0x1C, 0xFE, 0xC7, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xFE, 0xFE, 0xC0, 0xC0, 0xC0, 0x30, 0xFB, 0xC7, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC7, 0xFF, 0x7B, 0x03, 0x03, 0x03, 0x0C, 0xFE, 0xE7,
  0xC3, 0xC3, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x1C, 0x3F, 0x98, 0x6C,
  0x07, 0x01, 0xF8, 0x1E, 0x03, 0xE1, 0xBF, 0xCF, 0xC0, 0x18, 0x0C, 0x06,
  0x1F, 0xF1, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0xF0, 0xF8,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC7, 0xFE, 0x7C, 0xC1, 0xD8,
  0x66, 0x19, 0x8C, 0x33, 0x0C, 0xC3, 0x60, 0x78, 0x1E, 0x07, 0x00, 0x8C,
  0xF3, 0x3D, 0x4B, 0x52, 0xD5, 0xB5, 0x65, 0x39, 0x4E, 0x73, 0x18, 0xC0,
  0xE3, 0x9C, 0xC3, 0x60, 0x78, 0x1C, 0x07, 0x83, 0x60, 0xCC, 0x63, 0xB0,
  0x70, 0xC1, 0xD8, 0x66, 0x31, 0xCC, 0x33, 0x0D, 0x81, 0xE0, 0x78, 0x1C,
  0x03, 0x01, 0xC0, 0x60, 0x38, 0x00, 0xFF, 0x07, 0x0E, 0x1C, 0x18, 0x30,
  0x60, 0xC0, 0xFF, 0xFF, 0x07, 0x0F, 0x1C, 0x18, 0x18, 0x18, 0x1C, 0x18,
  0xF8, 0xF0, 0x18, 0x1C, 0x18, 0x18, 0x18, 0x18, 0x0F, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xC0, 0xF0, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x1F,
  0x1F, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0xF0, 0xE0, 0x71, 0xFC, 0xF3,
  0x78, 0xF0,
};

const GFXglyph JetBrainsMono_Medium19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 3, 14, 11, 4, -14 },
  { 7, 6, 6, 11, 3, -14 },
  { 12, 10, 14, 11, 1, -14 },
  { 30, 9, 20, 11, 1, -17 },
  { 53, 11, 14, 11, 0, -14 },
  { 73, 10, 14, 11, 1, -14 },
  { 91, 2, 6, 11, 5, -14 },
  { 93, 6, 18, 11, 3, -16 },
  { 107, 6, 18, 11, 2, -16 },
  { 121, 10, 10, 11, 1, -12 },
  { 134, 9, 9, 11, 1, -11 },
  { 145, 4, 6, 11, 3, -3 },
  { 148, 6, 2, 11, 3, -7 },
  { 150, 3, 3, 11, 4, -3 },
  { 152, 9, 18, 11, 1, -16 },
  { 173, 9, 14, 11, 1, -14 },
  { 189, 8, 14, 11, 2, -14 },
  { 203, 9, 14, 11, 1, -14 },
  { 219, 9, 14, 11, 1, -14 },
  { 235, 9, 14, 11, 1, -14 },
  { 251, 9, 14, 11, 1, -14 },
  { 267, 9, 14, 11, 1, -14 },
  { 283, 9, 14, 11, 1, -14 },
  { 299, 9, 14, 11, 1, -14 },
  { 315, 9, 14, 11, 1, -14 },
  { 331, 3, 11, 11, 4, -11 },
  { 336, 4, 14, 11, 3, -11 },
  { 343, 8, 10, 11, 2, -11 },
  { 353, 8, 7, 11, 2, -10 },
  { 360, 8, 10, 11, 2, -11 },
  { 370, 7, 14, 11, 2, -14 },
  { 383, 10, 17, 11, 1, -14 },
  { 405, 10, 14, 11, 1, -14 },
  { 423, 8, 14, 11, 2, -14 },
  { 437, 8, 14, 11, 2, -14 },
  { 451, 8, 14, 11, 2, -14 },
  { 465, 8, 14, 11, 2, -14 },
  { 479, 8, 14, 11, 2, -14 },
  { 493, 8, 14, 11, 2, -14 },
  { 507, 8, 14, 11, 2, -14 },
  { 521, 8, 14, 11, 2, -14 },
  { 535, 9, 14, 11, 1, -14 },
  { 551, 9, 14, 11, 2, -14 },
  { 567, 8, 14, 11, 2, -14 },
  { 581, 9, 14, 11, 1, -14 },
  { 597, 8, 14, 11, 2, -14 },
  { 611, 8, 14, 11, 2, -14 },
  { 625, 9, 14, 11, 2, -14 },
  { 641, 9, 17, 11, 1, -14 },
  { 661, 8, 14, 11, 2, -14 },
  { 675, 9, 14, 11, 1, -14 },
  { 691, 9, 14, 11, 1, -14 },
  { 707, 8, 14, 11, 2, -14 },
  { 721, 10, 14, 11, 1, -14 },
  { 739, 11, 14, 11, 0, -14 },
  { 759, 10, 14, 11, 1, -14 },
  { 777, 10, 14, 11, 1, -14 },
  { 795, 8, 14, 11, 2, -14 },
  { 809, 5, 18, 11, 4, -16 },
  { 821, 9, 18, 11, 1, -16 },
  { 842, 5, 18, 11, 3, -16 },
  { 854, 9, 8, 11, 1, -14 },
  { 863, 9, 2, 11, 1, 0 },
  { 866, 5, 3, 11, 3, -15 },
  { 868, 9, 11, 11, 1, -11 },
  { 881, 8, 14, 11, 2, -14 },
  { 895, 9, 11, 11, 1, -11 },
  { 908, 9, 14, 11, 1, -14 },
  { 924, 9, 11, 11, 1, -11 },
  { 937, 9, 14, 11, 1, -14 },
  { 953, 8, 14, 11, 2, -11 },
  { 967, 8, 14, 11, 2, -14 },
  { 981, 9, 15, 11, 2, -15 },
  { 998, 7, 18, 11, 2, -15 },
  { 1014, 9, 14, 11, 2, -14 },
  { 1030, 10, 14, 11, 1, -14 },
  { 1048, 9, 11, 11, 1, -11 },
  { 1061, 8, 11, 11, 2, -11 },
  { 1072, 9, 11, 11, 1, -11 },
  { 1085, 8, 14, 11, 2, -11 },
  { 1099, 8, 14, 11, 2, -11 },
  { 1113, 8, 11, 11, 2, -11 },
  { 1124, 9, 11, 11, 1, -11 },
  { 1137, 9, 13, 11, 1, -13 },
  { 1152, 8, 10, 11, 2, -10 },
  { 1162, 10, 10, 11, 1, -10 },
  { 1175, 10, 10, 11, 1, -10 },
  { 1188, 10, 10, 11, 1, -10 },
  { 1201, 10, 13, 11, 1, -10 },
  { 1218, 8, 10, 11, 2, -10 },
  { 1228, 8, 18, 11, 2, -16 },
  { 1246, 2, 18, 11, 5, -16 },
  { 1251, 8, 18, 11, 2, -16 },
  { 1269, 9, 4, 11, 1, -9 },
};

const GFXfont JetBrainsMono_Medium19pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Medium19pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Medium19pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _JETBRAINSMONO_MEDIUM19PT7B_H_
