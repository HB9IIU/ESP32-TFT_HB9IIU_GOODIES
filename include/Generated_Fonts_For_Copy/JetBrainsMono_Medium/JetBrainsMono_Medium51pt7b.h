#ifndef _JETBRAINSMONO_MEDIUM51PT7B_H_
#define _JETBRAINSMONO_MEDIUM51PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Medium.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Medium51pt7bBitmaps[] PROGMEM = {
  0x00, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3C,
  0x3C, 0x3C, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x7F, 0xFF, 0xFF,
  0x7F, 0x7E, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1,
  0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3E, 0xFC, 0x1F, 0x7E, 0x0F, 0xBE,
  0x07, 0xDF, 0x03, 0xE7, 0x81, 0xF3, 0xC0, 0xF9, 0xE0, 0x7C, 0x00, 0x78,
  0x0F, 0x80, 0x1F, 0x01, 0xE0, 0x03, 0xC0, 0x3C, 0x00, 0x78, 0x07, 0x80,
  0x0F, 0x00, 0xF0, 0x01, 0xE0, 0x3E, 0x00, 0x7C, 0x07, 0x80, 0x0F, 0x00,
  0xF0, 0x01, 0xE0, 0x1E, 0x00, 0x3C, 0x03, 0xC1, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0x07, 0x80, 0x78, 0x00, 0xF0, 0x0F,
  0x00, 0x1E, 0x01, 0xE0, 0x03, 0xC0, 0x7C, 0x00, 0x78, 0x0F, 0x00, 0x1E,
  0x01, 0xE0, 0x03, 0xC0, 0x3C, 0x00, 0x78, 0x07, 0x80, 0x0F, 0x00, 0xF0,
  0x01, 0xE0, 0x3E, 0x07, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x07, 0x80, 0xF8, 0x00, 0xF0, 0x1E, 0x00,
  0x3E, 0x03, 0xC0, 0x07, 0x80, 0x78, 0x00, 0xF0, 0x0F, 0x00, 0x1E, 0x01,
  0xE0, 0x03, 0xC0, 0x7C, 0x00, 0xF8, 0x0F, 0x00, 0x1E, 0x01, 0xE0, 0x03,
  0xC0, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3E, 0x00,
  0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC,
  0x3F, 0xDD, 0xFE, 0x3F, 0x1C, 0x7E, 0x3E, 0x1C, 0x3E, 0x7E, 0x1C, 0x3F,
  0x7E, 0x1C, 0x3F, 0x7E, 0x1C, 0x00, 0x7E, 0x1C, 0x00, 0x7E, 0x1C, 0x00,
  0x3F, 0x1C, 0x00, 0x3F, 0x9C, 0x00, 0x3F, 0xDC, 0x00, 0x1F, 0xFC, 0x00,
  0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x1C, 0xFE, 0x00, 0x1C, 0x7F,
  0x00, 0x1C, 0x3F, 0x00, 0x1C, 0x1F, 0x00, 0x1C, 0x1F, 0xFC, 0x1C, 0x1F,
  0xFC, 0x1C, 0x1F, 0x7C, 0x1C, 0x3F, 0x7E, 0x1C, 0x3F, 0x7F, 0x1C, 0x7E,
  0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0,
  0x01, 0xFF, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x0F, 0xF0, 0x00, 0x3C, 0x7F, 0xE0, 0x01, 0xE3, 0xFF, 0xC0, 0x0F, 0x1F,
  0x0F, 0x80, 0x7C, 0x78, 0x1E, 0x01, 0xE1, 0xE0, 0x78, 0x0F, 0x07, 0x81,
  0xE0, 0x7C, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x0F, 0x01, 0xE0, 0x78,
  0x7C, 0x07, 0x81, 0xE1, 0xE0, 0x1E, 0x07, 0x8F, 0x00, 0x7C, 0x3E, 0x7C,
  0x00, 0xFF, 0xF1, 0xE0, 0x03, 0xFF, 0x8F, 0x00, 0x03, 0xFC, 0x78, 0x00,
  0x03, 0x83, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x78, 0xFF, 0x80, 0x03,
  0xE7, 0xFF, 0x00, 0x0F, 0x3F, 0xFE, 0x00, 0x78, 0xF8, 0x78, 0x03, 0xC7,
  0xC1, 0xF0, 0x0F, 0x1F, 0x03, 0xC0, 0x78, 0x7C, 0x0F, 0x03, 0xC1, 0xF0,
  0x3C, 0x1F, 0x07, 0xC0, 0xF0, 0x78, 0x1F, 0x03, 0xC3, 0xC0, 0x7C, 0x0F,
  0x1F, 0x00, 0xF0, 0x7C, 0x78, 0x03, 0xF7, 0xE3, 0xC0, 0x07, 0xFF, 0x9F,
  0x00, 0x1F, 0xFC, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80,
  0x3F, 0x83, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00,
  0x7C, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F,
  0xFE, 0x00, 0x17, 0xE7, 0xE0, 0x7C, 0xF8, 0xFC, 0x1F, 0x9F, 0x0F, 0xC3,
  0xE7, 0xE0, 0xFC, 0xFC, 0xFC, 0x0F, 0x9F, 0x1F, 0x81, 0xFF, 0xE3, 0xF0,
  0x1F, 0xF8, 0x7E, 0x01, 0xFF, 0x0F, 0xC0, 0x1F, 0xC1, 0xF8, 0x03, 0xF0,
  0x1F, 0x00, 0x7F, 0x03, 0xE0, 0x0F, 0xE0, 0x7E, 0x03, 0xFE, 0x0F, 0xE1,
  0xFF, 0xE0, 0xFF, 0xFF, 0x7E, 0x1F, 0xFF, 0xC7, 0xC1, 0xFF, 0xF0, 0xFC,
  0x0F, 0xF8, 0x0F, 0xC0, 0x10, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF7, 0xDF, 0x7D, 0xF7, 0x80, 0x00, 0x01, 0x00, 0x0F, 0x00,
  0x3F, 0x00, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x07, 0xF8, 0x0F, 0xE0, 0x1F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF8, 0x07, 0xFE, 0x03,
  0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x1F, 0x00, 0x03, 0x80, 0x00, 0xF0,
  0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00,
  0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0xFF,
  0xC0, 0xFF, 0x80, 0xFF, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x03, 0x80,
  0xF0, 0x0C, 0x7C, 0x1E, 0x0F, 0xDF, 0xE1, 0xC7, 0xFB, 0xFF, 0x39, 0xFF,
  0xFF, 0xF6, 0xFF, 0xF3, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x1F, 0x7C, 0x00,
  0x07, 0xCF, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC1,
  0xF8, 0x03, 0xF0, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x07, 0x80, 0x3C, 0x00,
  0x60, 0x06, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x0F, 0xE1, 0xFC, 0x3F, 0x8F, 0xE1, 0xFC, 0x3F, 0x07,
  0xE1, 0xF8, 0x3F, 0x07, 0xE0, 0xF8, 0x3F, 0x07, 0xC0, 0xF8, 0x3F, 0x07,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x08,
  0x3F, 0x3F, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0x04, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0x8F, 0xF0, 0x7F, 0x1F, 0x80, 0x3F, 0x7E, 0x00, 0x7E, 0xFC, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x78, 0x3F,
  0xF0, 0xF8, 0x7F, 0xE3, 0xF0, 0xFF, 0xC7, 0xF1, 0xFF, 0x8F, 0xC3, 0xFF,
  0x0F, 0x87, 0xFE, 0x04, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x00,
  0x0F, 0xFF, 0x00, 0x1F, 0x7E, 0x00, 0x7E, 0x7E, 0x01, 0xFC, 0xFF, 0x8F,
  0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0x7F, 0xF0,
  0x00, 0x04, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF,
  0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xBF, 0x00, 0xFF, 0x3F,
  0x00, 0xFC, 0x3F, 0x00, 0xF8, 0x3F, 0x00, 0xF0, 0x3F, 0x00, 0xC0, 0x3F,
  0x00, 0x80, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x3F, 0xC3,
  0xFC, 0x7F, 0x00, 0xFE, 0x7E, 0x00, 0x7E, 0x7C, 0x00, 0x3E, 0xFC, 0x00,
  0x3E, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03,
  0xEF, 0x80, 0x0F, 0xDF, 0x80, 0x1F, 0xBF, 0x80, 0x7F, 0x3F, 0xC3, 0xFC,
  0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x3F, 0xF8, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0x80, 0xFC, 0xFC, 0x03, 0xF7, 0xF0, 0x0F, 0xDF, 0x80, 0x3F, 0xFC, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x7F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x8F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x8F,
  0xF8, 0x1F, 0x7F, 0xF8, 0x3E, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0xFF, 0x07,
  0xF9, 0xFC, 0x07, 0xF3, 0xF0, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x0F, 0xBF,
  0x00, 0x3F, 0x3F, 0x00, 0xFE, 0x7F, 0xCF, 0xF8, 0x7F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x9F, 0xC0, 0x1F, 0xBF, 0xF0, 0x3F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x7F, 0xE3, 0xFE, 0x7F, 0x00, 0xFE, 0x7E,
  0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0x7C, 0x00, 0x3F, 0x7E, 0x00, 0x7F, 0x3F, 0x00, 0xFE, 0x3F,
  0xC3, 0xFE, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x01,
  0xFF, 0xC0, 0x00, 0x08, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0xFD, 0xF0, 0x01, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF,
  0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x8F, 0xF0, 0x7F, 0x1F, 0x80, 0x7F,
  0x3E, 0x00, 0x7E, 0xFC, 0x00, 0x7D, 0xF8, 0x00, 0xFB, 0xF0, 0x01, 0xF7,
  0xE0, 0x03, 0xE7, 0xC0, 0x0F, 0xCF, 0xC0, 0x1F, 0x0F, 0xC0, 0x7E, 0x1F,
  0xC1, 0xF8, 0x1F, 0xEF, 0xE0, 0x0F, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xFE, 0x03, 0xF9, 0xFE, 0x0F, 0xC0, 0xFE, 0x3F, 0x00,
  0x7E, 0xFC, 0x00, 0xFD, 0xF8, 0x00, 0xFB, 0xE0, 0x01, 0xFF, 0xC0, 0x03,
  0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x7F,
  0xFE, 0x01, 0xFC, 0xFF, 0x8F, 0xF8, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x80,
  0xFF, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x04, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC,
  0x3F, 0xC1, 0xFE, 0x7F, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0x7C, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x3F,
  0x7E, 0x00, 0x7F, 0x7F, 0x80, 0xFE, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFC, 0x07, 0xFE, 0xFC, 0x01, 0xF1, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x18, 0x3F, 0xBF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x41, 0xFD, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xE0,
  0x40, 0x03, 0x80, 0xFE, 0x1F, 0xE1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xE0,
  0xFE, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x0F, 0xE0,
  0xFE, 0x0F, 0xC1, 0xFC, 0x1F, 0xC1, 0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x03,
  0xE0, 0x7E, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0xF8, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x30, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0x00, 0x03, 0xFC, 0x00,
  0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xF0,
  0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF,
  0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF,
  0xC0, 0x01, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03,
  0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x7F,
  0x00, 0x07, 0xFC, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x07,
  0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0xFE, 0x00,
  0x03, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x20, 0x00, 0x00, 0xFF, 0xE0, 0x3F,
  0xFE, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0xFF, 0xFF, 0x80, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0xFE, 0x01, 0xFF, 0x87,
  0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xF0, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x01, 0xFF,
  0x1F, 0xF0, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF3, 0xF0, 0x00, 0x3E,
  0x7C, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x07, 0xC7, 0xFE, 0x03, 0xFE, 0xFF,
  0xC0, 0xFF, 0xEF, 0xF8, 0x1F, 0xFD, 0xFF, 0x07, 0xE0, 0xFF, 0xE0, 0xF8,
  0x0F, 0xFC, 0x1F, 0x01, 0xFF, 0x83, 0xE0, 0x3F, 0xF0, 0x7C, 0x07, 0xFE,
  0x0F, 0x80, 0xFF, 0xC1, 0xF0, 0x1F, 0xF8, 0x3E, 0x03, 0xFF, 0x07, 0xC0,
  0x7F, 0xE0, 0xF8, 0x0F, 0xFC, 0x1F, 0x01, 0xFF, 0x83, 0xE0, 0x3F, 0xF0,
  0x7C, 0x07, 0xFE, 0x0F, 0xC1, 0xFF, 0xC0, 0xFE, 0xFF, 0xF8, 0x1F, 0xFD,
  0xFF, 0x01, 0xFF, 0x3F, 0xE0, 0x1F, 0xC7, 0xFC, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3E, 0xF0, 0x00, 0x0F, 0xBE, 0x00, 0x03,
  0xEF, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x1F, 0x00,
  0x07, 0xC7, 0xC0, 0x03, 0xF1, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x0F,
  0x80, 0x0F, 0x83, 0xE0, 0x07, 0xE0, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x7C,
  0x0F, 0xC0, 0x1F, 0x01, 0xF0, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xE0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x3F, 0x00, 0x1F, 0x0F, 0xC0,
  0x07, 0xE3, 0xE0, 0x01, 0xF8, 0xF8, 0x00, 0x3E, 0x7E, 0x00, 0x0F, 0x9F,
  0x80, 0x03, 0xF7, 0xC0, 0x00, 0xFD, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x07,
  0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0x9F, 0x80, 0x3F, 0xBF, 0x00, 0x3F, 0x7E, 0x00, 0x3E,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xEF,
  0xC0, 0x07, 0xDF, 0x80, 0x1F, 0xBF, 0x00, 0x7E, 0x7F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xCF, 0xC0,
  0x3F, 0xDF, 0x80, 0x1F, 0xBF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0xFE, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0x8F, 0xF0, 0x7F, 0x9F, 0x80, 0x3F, 0x3F, 0x00, 0x7E, 0xFC,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x07, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xBF, 0x00, 0x7E, 0x7F, 0x01, 0xFC, 0x7F,
  0xDF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x7F,
  0xF0, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x9F, 0x80, 0x7F, 0x3F, 0x00,
  0x7F, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0x7D, 0xF8, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x07, 0xDF, 0x80, 0x1F, 0xBF, 0x00, 0x7F, 0x7E, 0x01,
  0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x87, 0xFF, 0xFC,
  0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x8F,
  0xF0, 0x7F, 0x9F, 0x80, 0x3F, 0x3F, 0x00, 0x7E, 0xFC, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF,
  0x00, 0x1F, 0xBF, 0x00, 0x7E, 0x7F, 0x01, 0xFC, 0x7F, 0x8F, 0xF0, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x0C,
  0x00, 0x00, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC,
  0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x3E, 0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7F, 0x00, 0xFE, 0x3F, 0xE7,
  0xFC, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF,
  0x80, 0x00, 0x18, 0x00, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0xBF, 0x00,
  0x1F, 0x9F, 0x80, 0x0F, 0xCF, 0xC0, 0x0F, 0xC7, 0xE0, 0x07, 0xE3, 0xF0,
  0x07, 0xE1, 0xF8, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x3F,
  0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x7E, 0x03,
  0xF0, 0x7E, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80,
  0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xFC,
  0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x7E, 0x03,
  0xF0, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x1F, 0x87, 0xE0,
  0x0F, 0xC3, 0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0xFE, 0x7E,
  0x00, 0x3F, 0x3F, 0x00, 0x1F, 0xDF, 0x80, 0x07, 0xEF, 0xC0, 0x03, 0xF8,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0xFF, 0xF7, 0x80, 0xFF, 0xF7, 0x80, 0xFF, 0xFF, 0x81, 0xEF, 0xFB,
  0xC1, 0xEF, 0xFB, 0xC1, 0xEF, 0xFB, 0xC1, 0xCF, 0xFB, 0xE3, 0xCF, 0xF9,
  0xE3, 0xCF, 0xF9, 0xE3, 0xCF, 0xF9, 0xE7, 0x9F, 0xF8, 0xF7, 0x9F, 0xF8,
  0xF7, 0x9F, 0xF8, 0xF7, 0x1F, 0xF8, 0x7F, 0x1F, 0xF8, 0x7F, 0x1F, 0xF8,
  0x7E, 0x1F, 0xF8, 0x3E, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0,
  0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07,
  0xFF, 0xF0, 0x1F, 0xFB, 0xC0, 0x7F, 0xEF, 0x01, 0xFF, 0xBE, 0x07, 0xFE,
  0x78, 0x1F, 0xF9, 0xF0, 0x7F, 0xE7, 0xC1, 0xFF, 0x8F, 0x07, 0xFE, 0x3E,
  0x1F, 0xF8, 0xF8, 0x7F, 0xE1, 0xE1, 0xFF, 0x87, 0xC7, 0xFE, 0x1F, 0x1F,
  0xF8, 0x3C, 0x7F, 0xE0, 0xF9, 0xFF, 0x83, 0xE7, 0xFE, 0x07, 0x9F, 0xF8,
  0x1F, 0x7F, 0xE0, 0x3C, 0xFF, 0x80, 0xF3, 0xFE, 0x03, 0xEF, 0xF8, 0x07,
  0xBF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF,
  0xE0, 0x0F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFC, 0x00,
  0x7C, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0x8F, 0xF0, 0xFF, 0x1F, 0x80, 0x7F, 0x3E, 0x00, 0x7E, 0xFC, 0x00,
  0x7D, 0xF8, 0x00, 0xFB, 0xF0, 0x01, 0xF7, 0xE0, 0x03, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xDF, 0x80,
  0x0F, 0xBF, 0x00, 0x1F, 0x3F, 0x00, 0x7E, 0x7F, 0x01, 0xFC, 0xFF, 0xDF,
  0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0x7F, 0xF0,
  0x00, 0x04, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0xFC, 0x00, 0xFE, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x0F, 0xFF,
  0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x8F, 0xF0, 0x7F,
  0x1F, 0x80, 0x7F, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF,
  0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE,
  0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01,
  0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F,
  0x7E, 0x00, 0x7E, 0x7E, 0x01, 0xFC, 0xFF, 0x9F, 0xF0, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFC, 0xFC, 0x01, 0xFC, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC,
  0x00, 0x3E, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFE, 0xFC,
  0x03, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFC, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0xFC, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0xFC,
  0x03, 0xF0, 0xFC, 0x03, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC,
  0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC,
  0x00, 0x3F, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x3F, 0xC1, 0xFE, 0x3F, 0x00, 0x7E, 0x3E,
  0x00, 0x3E, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x03,
  0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0x7C, 0x00, 0x3F, 0x7E,
  0x00, 0x3F, 0x7F, 0x00, 0x7E, 0x3F, 0xF7, 0xFE, 0x3F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF,
  0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xF7, 0xE0, 0x0F, 0xDF, 0x80, 0x7F, 0x7F,
  0xCF, 0xF8, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x03, 0xFF,
  0x80, 0x00, 0x40, 0x00, 0xFC, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xF7, 0xE0,
  0x00, 0xFD, 0xF8, 0x00, 0x3E, 0x7E, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xE3,
  0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x7C, 0x3F, 0x00, 0x1F, 0x07, 0xC0, 0x07,
  0xC1, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0xF8, 0x1F, 0x80, 0x3E, 0x03, 0xE0,
  0x0F, 0x80, 0xF8, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0xC0, 0x7C, 0x01,
  0xF0, 0x1F, 0x00, 0x7C, 0x0F, 0xC0, 0x1F, 0x83, 0xE0, 0x07, 0xE0, 0xF8,
  0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x1F, 0x80, 0x0F, 0xC7, 0xC0, 0x03, 0xF1,
  0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x3F, 0x00, 0x07, 0xEF, 0x80, 0x01,
  0xFB, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x03, 0xEF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0xF8, 0x0F, 0x80, 0xFF, 0xC0, 0x7C, 0x07,
  0xBE, 0x03, 0xE0, 0x7D, 0xF0, 0x3F, 0x03, 0xE7, 0x81, 0xF8, 0x1F, 0x3E,
  0x0E, 0xE0, 0xF9, 0xF0, 0x77, 0x07, 0xCF, 0x83, 0xB8, 0x3E, 0x7C, 0x1D,
  0xC1, 0xF3, 0xE0, 0xEE, 0x0F, 0x1F, 0x07, 0x70, 0x78, 0xF8, 0x7B, 0x83,
  0xC7, 0xC3, 0x9C, 0x1E, 0x1E, 0x1C, 0xE1, 0xF0, 0xF0, 0xE7, 0x8F, 0x87,
  0x87, 0x1C, 0x7C, 0x3E, 0x38, 0xE3, 0xE1, 0xF1, 0xC7, 0x1F, 0x0F, 0x8E,
  0x38, 0xF0, 0x7C, 0xF1, 0xC7, 0x83, 0xE7, 0x8E, 0x3C, 0x1F, 0x38, 0x71,
  0xE0, 0x79, 0xC3, 0xCF, 0x03, 0xCE, 0x1E, 0xF8, 0x1E, 0x70, 0x77, 0xC0,
  0xF3, 0x83, 0xBE, 0x07, 0xDC, 0x1D, 0xF0, 0x3F, 0xE0, 0xEF, 0x01, 0xFF,
  0x07, 0x78, 0x0F, 0xF0, 0x3B, 0xC0, 0x7F, 0x81, 0xDE, 0x03, 0xFC, 0x0F,
  0xF0, 0x0F, 0xE0, 0x7F, 0x80, 0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xE0,
  0x1F, 0xC0, 0x7F, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xCF,
  0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x81, 0xF8, 0x03,
  0xF0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x07,
  0xE0, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0xFD, 0xF8,
  0x00, 0x1F, 0xBE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x0F, 0xDF, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x7E, 0x3F, 0x00,
  0x0F, 0x87, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x07,
  0xE0, 0x03, 0xF1, 0xF8, 0x00, 0x7F, 0x3F, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0xFE, 0xFE, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3E, 0x3E, 0x00, 0x07, 0xE3,
  0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0xF8, 0x0F, 0x80,
  0x1F, 0x80, 0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0x7E, 0x03, 0xF0,
  0x03, 0xE0, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x7C, 0x00, 0x1F,
  0x8F, 0xC0, 0x01, 0xF8, 0xF8, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0xFD, 0xF0,
  0x00, 0x07, 0xDF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1E,
  0xF0, 0x00, 0x7D, 0xF0, 0x00, 0xF3, 0xE0, 0x03, 0xE3, 0xC0, 0x07, 0xC7,
  0xC0, 0x1F, 0x07, 0x80, 0x3E, 0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x1F,
  0x03, 0xC0, 0x3E, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x7C, 0x00, 0xF8,
  0xF8, 0x00, 0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x01, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xF8, 0x1F, 0x81, 0xF8, 0x00,
  0x0C, 0x00, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xFF,
  0xFF, 0xC7, 0xF8, 0x3F, 0x8F, 0xC0, 0x1F, 0x9F, 0x00, 0x3F, 0x7E, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x7F, 0x80, 0x3E,
  0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF,
  0x80, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0x7F, 0x01, 0xFE, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFE, 0xF8, 0xFF, 0xF9, 0xF0, 0xFF, 0xC3, 0xE0, 0x18,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x06, 0x01, 0xF8, 0xFF, 0x83, 0xF3, 0xFF, 0x87, 0xEF, 0xFF,
  0x8F, 0xFF, 0xFF, 0x9F, 0xF8, 0xFF, 0xBF, 0xC0, 0x7F, 0x7F, 0x00, 0x7E,
  0xFC, 0x00, 0x7D, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0x80, 0x0F, 0xBF, 0x80, 0x3F, 0x7F, 0x80, 0xFE, 0xFF, 0xC7,
  0xF9, 0xFF, 0xFF, 0xF3, 0xF7, 0xFF, 0xC7, 0xE7, 0xFF, 0x0F, 0xC7, 0xFC,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF,
  0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x8F, 0xF8, 0xFF, 0x9F, 0x80, 0x7F,
  0x7E, 0x00, 0x7E, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xDF, 0x80, 0x3F, 0x3F, 0x80,
  0xFE, 0x7F, 0xC7, 0xFC, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x00, 0x3F, 0xF8, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x60, 0x7C, 0x1F, 0xF1, 0xF1, 0xFF,
  0xE7, 0xCF, 0xFF, 0xDF, 0x3F, 0xFF, 0x7D, 0xFF, 0x1F, 0xF7, 0xE0, 0x1F,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xDF, 0x80, 0x7F, 0x7F,
  0xCF, 0xFC, 0xFF, 0xFD, 0xF3, 0xFF, 0xF7, 0xC7, 0xFF, 0x9F, 0x07, 0xFC,
  0x7C, 0x03, 0x00, 0x00, 0x00, 0x10, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF,
  0x00, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x8F, 0xE0, 0x7F, 0x1F, 0x80, 0x3F,
  0x3E, 0x00, 0x7E, 0xFC, 0x00, 0x7D, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x5F, 0x00, 0x1F, 0x3F, 0x00,
  0x7E, 0x7F, 0x01, 0xFC, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x00, 0x3F, 0xF8, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x3F,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFC,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x60,
  0x00, 0x1F, 0xF1, 0xF1, 0xFF, 0xE7, 0xCF, 0xFF, 0xDF, 0x3F, 0xFF, 0x7D,
  0xFF, 0x1F, 0xF7, 0xE0, 0x1F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0x7E, 0x00, 0xFD, 0xFC, 0x07, 0xF7, 0xFF,
  0xFF, 0xCF, 0xFF, 0xDF, 0x1F, 0xFF, 0x7C, 0x3F, 0xF9, 0xF0, 0x7F, 0x87,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF,
  0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x04, 0x03, 0xF1, 0xFF, 0x0F, 0xCF,
  0xFE, 0x3F, 0x7F, 0xFC, 0xFF, 0xFF, 0xFB, 0xFE, 0x0F, 0xEF, 0xF0, 0x1F,
  0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF,
  0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC,
  0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00,
  0x7C, 0x00, 0x3C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x03, 0xC0, 0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE,
  0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x03, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF,
  0xC0, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xFF,
  0x00, 0x1F, 0xDF, 0x80, 0x0F, 0xCF, 0xC0, 0x0F, 0xC7, 0xE0, 0x0F, 0xE3,
  0xF0, 0x07, 0xE1, 0xF8, 0x07, 0xE0, 0xFC, 0x07, 0xF0, 0x7E, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x1F, 0x83, 0xF8, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF8,
  0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x7E, 0x0F,
  0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x81, 0xFC, 0x0F, 0xC0, 0x7E, 0x07, 0xE0,
  0x1F, 0x83, 0xF0, 0x0F, 0xE1, 0xF8, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x7E,
  0x00, 0x7F, 0x3F, 0x00, 0x1F, 0x9F, 0x80, 0x0F, 0xEF, 0xC0, 0x03, 0xF8,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x03,
  0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x40, 0x10, 0x7D, 0xF8, 0x7E, 0x3E,
  0xFE, 0x7F, 0x9F, 0xFF, 0xBF, 0xEF, 0xEF, 0xFF, 0xF7, 0xC1, 0xF0, 0xFB,
  0xE0, 0xF8, 0x3F, 0xF0, 0x78, 0x1F, 0xF8, 0x3C, 0x0F, 0xFC, 0x1E, 0x07,
  0xFE, 0x0F, 0x03, 0xFF, 0x07, 0x81, 0xFF, 0x83, 0xC0, 0xFF, 0xC1, 0xE0,
  0x7F, 0xE0, 0xF0, 0x3F, 0xF0, 0x78, 0x1F, 0xF8, 0x3C, 0x0F, 0xFC, 0x1E,
  0x07, 0xFE, 0x0F, 0x03, 0xFF, 0x07, 0x81, 0xFF, 0x83, 0xC0, 0xFF, 0xC1,
  0xE0, 0x7F, 0xE0, 0xF0, 0x3F, 0xF0, 0x78, 0x1F, 0xF8, 0x3C, 0x0F, 0xFC,
  0x1E, 0x07, 0xFE, 0x0F, 0x03, 0xFF, 0x07, 0x81, 0xFF, 0x83, 0xC0, 0xF8,
  0x00, 0x04, 0x03, 0xF1, 0xFF, 0x0F, 0xCF, 0xFE, 0x3F, 0x7F, 0xFC, 0xFF,
  0xFF, 0xFB, 0xFF, 0x1F, 0xEF, 0xF0, 0x1F, 0xFF, 0x80, 0x3F, 0xFC, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7C, 0x00, 0x10, 0x00, 0x07,
  0xFF, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x8F, 0xF9,
  0xFF, 0x1F, 0x80, 0x7F, 0x3E, 0x00, 0x7E, 0xFC, 0x00, 0x7D, 0xF8, 0x00,
  0xFB, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F,
  0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF,
  0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x07, 0xDF, 0x80, 0x0F, 0x9F,
  0x80, 0x3F, 0x3F, 0x80, 0xFE, 0x7F, 0xEF, 0xF8, 0x7F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x06, 0x01, 0xF8,
  0xFF, 0x83, 0xF3, 0xFF, 0x87, 0xEF, 0xFF, 0x8F, 0xFF, 0xFF, 0x9F, 0xF8,
  0xFF, 0xBF, 0xC0, 0x7F, 0x7F, 0x00, 0x7E, 0xFC, 0x00, 0x7D, 0xF8, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xBF,
  0x80, 0x3F, 0x7F, 0x80, 0xFE, 0xFF, 0xC7, 0xFD, 0xFF, 0xFF, 0xF3, 0xF7,
  0xFF, 0xC7, 0xE7, 0xFF, 0x0F, 0xC7, 0xFC, 0x1F, 0x81, 0x80, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x1F, 0xF1, 0xF1, 0xFF, 0xE7, 0xCF, 0xFF, 0xDF, 0x3F, 0xFF, 0x7D,
  0xFF, 0x1F, 0xF7, 0xE0, 0x1F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xE0,
  0x0F, 0xDF, 0x80, 0x7F, 0x7F, 0xCF, 0xFC, 0xFF, 0xFD, 0xF3, 0xFF, 0xF7,
  0xC7, 0xFF, 0x9F, 0x07, 0xFC, 0x7C, 0x03, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0C, 0x01, 0xF8, 0xFF,
  0x83, 0xF7, 0xFF, 0x87, 0xEF, 0xFF, 0x8F, 0xFF, 0xFF, 0x9F, 0xF0, 0x7F,
  0xBF, 0x80, 0x7F, 0x7F, 0x00, 0x7E, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x0F, 0xFF,
  0x80, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x8F, 0xE0, 0x3F,
  0x9F, 0x80, 0x3F, 0x3E, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x07,
  0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0x7F, 0x01, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xE0,
  0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC,
  0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFD, 0xF8, 0x03,
  0xF7, 0xF0, 0x1F, 0x8F, 0xF1, 0xFE, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0x80,
  0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x10, 0x00, 0xFC, 0x00, 0x0F, 0xDF,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x1F,
  0x8F, 0xC0, 0x07, 0xC1, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0xFC, 0x1F, 0x80,
  0x3E, 0x03, 0xE0, 0x0F, 0x80, 0xF8, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x07,
  0xC0, 0x7C, 0x01, 0xF0, 0x3F, 0x00, 0x7E, 0x0F, 0x80, 0x0F, 0x83, 0xE0,
  0x03, 0xE1, 0xF8, 0x00, 0xFC, 0x7C, 0x00, 0x1F, 0x1F, 0x00, 0x07, 0xC7,
  0xC0, 0x01, 0xFB, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0xF8, 0x0F, 0x80, 0xF7, 0x80, 0xF8, 0x1F, 0x78, 0x0F,
  0x81, 0xF7, 0xC1, 0xF8, 0x1F, 0x7C, 0x1F, 0x81, 0xE7, 0xC1, 0xF8, 0x1E,
  0x7C, 0x1D, 0xC1, 0xE3, 0xC1, 0xDC, 0x1E, 0x3C, 0x1D, 0xC3, 0xE3, 0xC3,
  0xDC, 0x3E, 0x3E, 0x39, 0xC3, 0xC3, 0xE3, 0x9C, 0x3C, 0x3E, 0x38, 0xE3,
  0xC1, 0xE3, 0x8E, 0x3C, 0x1E, 0x38, 0xE3, 0xC1, 0xE3, 0x8E, 0x7C, 0x1E,
  0x70, 0xE7, 0xC1, 0xF7, 0x0E, 0x78, 0x1F, 0x70, 0xF7, 0x81, 0xF7, 0x07,
  0x78, 0x0F, 0x70, 0x77, 0x80, 0xF7, 0x07, 0x78, 0x0F, 0xF0, 0x7F, 0x80,
  0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0xE0,
  0x3F, 0x00, 0x7E, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0xCF, 0xC0, 0x07, 0xE1,
  0xF8, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x3F,
  0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC7, 0xE0, 0x01, 0xFB, 0xF0, 0x00, 0x7E,
  0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x7E, 0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xC7, 0xE0, 0x07, 0xE1,
  0xF8, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x7E, 0x01, 0xF8, 0x1F,
  0x80, 0x3F, 0x0F, 0xC0, 0x0F, 0xE7, 0xE0, 0x01, 0xFB, 0xF8, 0x00, 0x3F,
  0xFE, 0x00, 0x0F, 0xDF, 0x80, 0x03, 0xF7, 0xE0, 0x01, 0xF8, 0xFC, 0x00,
  0x7E, 0x3F, 0x00, 0x1F, 0x87, 0xC0, 0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0x7E,
  0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0x7C, 0x07, 0xC0,
  0x1F, 0x83, 0xF0, 0x07, 0xE0, 0xFC, 0x00, 0xF8, 0x3E, 0x00, 0x3F, 0x1F,
  0x80, 0x0F, 0xC7, 0xE0, 0x01, 0xF9, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x0F,
  0xBE, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFE, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xF8, 0x00,
  0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFF,
  0xF0, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF0,
  0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x0F, 0xF0, 0x07, 0xCF, 0xFC, 0x03, 0xEF, 0xFF, 0x01,
  0xFF, 0xFF, 0xC0, 0xFF, 0xC3, 0xF0, 0x7F, 0xE0, 0xFC, 0x7D, 0xF0, 0x3F,
  0xFE, 0xF8, 0x1F, 0xFF, 0x7C, 0x07, 0xFF, 0x3E, 0x01, 0xFF, 0x00, 0x00,
  0x18, 0x00,
};

const GFXglyph JetBrainsMono_Medium51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 31, 0, -1 },
  { 1, 8, 37, 31, 11, -37 },
  { 38, 17, 15, 31, 7, -37 },
  { 70, 27, 37, 31, 2, -37 },
  { 195, 24, 51, 31, 3, -44 },
  { 348, 30, 37, 31, 0, -37 },
  { 487, 27, 39, 31, 2, -38 },
  { 619, 6, 15, 31, 12, -37 },
  { 631, 16, 49, 31, 9, -43 },
  { 729, 16, 49, 31, 6, -43 },
  { 827, 27, 26, 31, 2, -31 },
  { 915, 24, 24, 31, 3, -29 },
  { 987, 11, 16, 31, 8, -8 },
  { 1009, 16, 5, 31, 7, -19 },
  { 1019, 9, 10, 31, 11, -9 },
  { 1031, 24, 48, 31, 3, -42 },
  { 1175, 23, 39, 31, 4, -38 },
  { 1288, 24, 37, 31, 4, -37 },
  { 1399, 24, 38, 31, 3, -38 },
  { 1513, 23, 38, 31, 3, -37 },
  { 1623, 22, 37, 31, 4, -37 },
  { 1725, 23, 38, 31, 4, -37 },
  { 1835, 24, 38, 31, 3, -37 },
  { 1949, 23, 37, 31, 4, -37 },
  { 2056, 23, 39, 31, 4, -38 },
  { 2169, 24, 38, 31, 3, -38 },
  { 2283, 9, 30, 31, 11, -29 },
  { 2317, 12, 37, 31, 8, -29 },
  { 2373, 22, 28, 31, 4, -31 },
  { 2450, 22, 18, 31, 4, -26 },
  { 2500, 22, 28, 31, 4, -31 },
  { 2577, 18, 37, 31, 7, -37 },
  { 2661, 27, 47, 31, 2, -38 },
  { 2820, 26, 37, 31, 2, -37 },
  { 2941, 23, 37, 31, 4, -37 },
  { 3048, 23, 39, 31, 4, -38 },
  { 3161, 23, 37, 31, 4, -37 },
  { 3268, 22, 37, 31, 5, -37 },
  { 3370, 23, 37, 31, 4, -37 },
  { 3477, 23, 39, 31, 4, -38 },
  { 3590, 22, 37, 31, 4, -37 },
  { 3692, 21, 37, 31, 5, -37 },
  { 3790, 24, 38, 31, 2, -37 },
  { 3904, 25, 37, 31, 4, -37 },
  { 4020, 21, 37, 31, 6, -37 },
  { 4118, 24, 37, 31, 3, -37 },
  { 4229, 22, 37, 31, 4, -37 },
  { 4331, 23, 39, 31, 4, -38 },
  { 4444, 24, 37, 31, 4, -37 },
  { 4555, 23, 47, 31, 4, -38 },
  { 4691, 24, 37, 31, 4, -37 },
  { 4802, 24, 39, 31, 3, -38 },
  { 4919, 25, 37, 31, 3, -37 },
  { 5035, 22, 38, 31, 4, -37 },
  { 5140, 26, 37, 31, 2, -37 },
  { 5261, 29, 37, 31, 1, -37 },
  { 5396, 27, 37, 31, 2, -37 },
  { 5521, 28, 37, 31, 1, -37 },
  { 5651, 22, 37, 31, 4, -37 },
  { 5753, 13, 48, 31, 10, -42 },
  { 5831, 24, 48, 31, 3, -42 },
  { 5975, 14, 48, 31, 7, -42 },
  { 6059, 23, 20, 31, 4, -37 },
  { 6117, 25, 5, 31, 3, 1 },
  { 6133, 11, 7, 31, 9, -40 },
  { 6143, 23, 30, 31, 3, -29 },
  { 6230, 23, 38, 31, 4, -37 },
  { 6340, 23, 30, 31, 4, -29 },
  { 6427, 22, 38, 31, 4, -37 },
  { 6532, 23, 30, 31, 4, -29 },
  { 6619, 24, 37, 31, 3, -37 },
  { 6730, 22, 38, 31, 4, -29 },
  { 6835, 22, 37, 31, 4, -37 },
  { 6937, 24, 40, 31, 4, -40 },
  { 7057, 20, 49, 31, 4, -40 },
  { 7180, 25, 37, 31, 4, -37 },
  { 7296, 27, 37, 31, 1, -37 },
  { 7421, 25, 29, 31, 3, -29 },
  { 7512, 22, 29, 31, 4, -29 },
  { 7592, 23, 29, 31, 4, -29 },
  { 7676, 23, 38, 31, 4, -29 },
  { 7786, 22, 38, 31, 4, -29 },
  { 7891, 23, 29, 31, 5, -29 },
  { 7975, 23, 29, 31, 4, -29 },
  { 8059, 25, 36, 31, 2, -36 },
  { 8172, 22, 29, 31, 4, -28 },
  { 8252, 26, 28, 31, 2, -28 },
  { 8343, 28, 28, 31, 1, -28 },
  { 8441, 26, 28, 31, 2, -28 },
  { 8532, 26, 37, 31, 2, -28 },
  { 8653, 22, 28, 31, 4, -28 },
  { 8730, 22, 48, 31, 4, -42 },
  { 8862, 5, 48, 31, 13, -42 },
  { 8892, 22, 48, 31, 4, -42 },
  { 9024, 25, 12, 31, 3, -24 },
};

const GFXfont JetBrainsMono_Medium51pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Medium51pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Medium51pt7bGlyphs,
  0x20, 0x7E, 67
};

#endif // _JETBRAINSMONO_MEDIUM51PT7B_H_
