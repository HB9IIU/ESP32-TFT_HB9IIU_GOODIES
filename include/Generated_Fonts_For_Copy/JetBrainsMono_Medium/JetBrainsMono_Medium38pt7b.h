#ifndef _JETBRAINSMONO_MEDIUM38PT7B_H_
#define _JETBRAINSMONO_MEDIUM38PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Medium.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Medium38pt7bBitmaps[] PROGMEM = {
  0x00, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xE7, 0x9E, 0x38, 0xE3,
  0x8E, 0x38, 0xE3, 0x80, 0x00, 0x00, 0x0E, 0x7F, 0xFF, 0xDF, 0xF8, 0xFF,
  0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xF8, 0x7F, 0xC3, 0xDE, 0x1E, 0x70,
  0x73, 0x83, 0x9C, 0x1C, 0xE0, 0xE0, 0x01, 0xC0, 0xE0, 0x0E, 0x0F, 0x00,
  0x70, 0x70, 0x07, 0x03, 0x80, 0x38, 0x1C, 0x01, 0xC0, 0xE0, 0x0E, 0x07,
  0x00, 0x70, 0x70, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xC1, 0xC0, 0xE0, 0x0E,
  0x07, 0x00, 0x70, 0x78, 0x03, 0x83, 0x80, 0x3C, 0x1C, 0x01, 0xC0, 0xE0,
  0x0E, 0x07, 0x00, 0x70, 0x38, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFE, 0x0E, 0x07, 0x00, 0x70, 0x38, 0x03, 0x81, 0xC0, 0x1C, 0x1C, 0x01,
  0xE0, 0xE0, 0x0E, 0x07, 0x00, 0x70, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0xFE, 0x00, 0xFF, 0xE0,
  0x7F, 0xFC, 0x3F, 0xFF, 0x8F, 0x39, 0xE7, 0xCE, 0x7D, 0xE3, 0x8F, 0x78,
  0xE0, 0x1E, 0x38, 0x07, 0xCE, 0x00, 0xFB, 0x80, 0x3F, 0xE0, 0x07, 0xFC,
  0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0E, 0x7C,
  0x03, 0x8F, 0x00, 0xE3, 0xE0, 0x38, 0xF7, 0x8E, 0x3D, 0xE3, 0x8F, 0x7C,
  0xE7, 0xDF, 0xFF, 0xE3, 0xFF, 0xF8, 0x7F, 0xFC, 0x07, 0xFC, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00,
  0x1E, 0x7F, 0x80, 0x39, 0xFF, 0x80, 0xE3, 0x87, 0x03, 0x87, 0x0E, 0x0F,
  0x0E, 0x1C, 0x1C, 0x1C, 0x38, 0x70, 0x38, 0x71, 0xE0, 0x70, 0xE3, 0x80,
  0xE1, 0xCE, 0x01, 0xFF, 0xBC, 0x01, 0xFE, 0x70, 0x00, 0xF1, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x40, 0x00, 0xE7, 0xF0, 0x03,
  0xDF, 0xF0, 0x07, 0x3C, 0xF0, 0x1C, 0x70, 0xE0, 0x79, 0xE1, 0xC0, 0xE3,
  0xC3, 0x83, 0x87, 0x87, 0x0E, 0x0F, 0x0E, 0x1C, 0x0E, 0x1C, 0x70, 0x1F,
  0xF9, 0xC0, 0x1F, 0xE7, 0x80, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0xC0,
  0x1F, 0xFE, 0x03, 0xF7, 0xE0, 0x3C, 0x1F, 0x03, 0xC0, 0xF0, 0x38, 0x0F,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0,
  0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0xC1, 0xFF, 0x3E, 0x1E, 0xF1,
  0xE3, 0xCF, 0x0F, 0x3C, 0xF0, 0x7F, 0x8F, 0x07, 0xF8, 0xF0, 0x3F, 0x0F,
  0x01, 0xF0, 0xF0, 0x1F, 0x0F, 0x03, 0xF0, 0xF8, 0x7F, 0x87, 0xFF, 0xBC,
  0x3F, 0xF3, 0xE1, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x77, 0x00,
  0x20, 0x1C, 0x0F, 0x83, 0xF0, 0xFC, 0x3E, 0x0F, 0x83, 0xE0, 0x78, 0x0F,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xE0,
  0x3C, 0x07, 0xC0, 0x78, 0x0F, 0x80, 0xFC, 0x0F, 0xE0, 0xFC, 0x0F, 0x80,
  0x70, 0x02, 0xC0, 0x0F, 0x00, 0xFC, 0x0F, 0xE0, 0x3F, 0x00, 0xF8, 0x07,
  0xC0, 0x3C, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x7C, 0x0F,
  0xC1, 0xF8, 0xFF, 0x0F, 0xE0, 0xF8, 0x0E, 0x00, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x30,
  0x38, 0x11, 0xF1, 0xC7, 0xCF, 0xCE, 0xFE, 0xFF, 0xAF, 0xF8, 0xFF, 0xFE,
  0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x1D, 0xC0, 0x01, 0xEF, 0x00, 0x1E,
  0x3C, 0x01, 0xF1, 0xF0, 0x0F, 0x07, 0x80, 0xF0, 0x3E, 0x01, 0x80, 0xC0,
  0x04, 0x04, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x8F, 0x8F, 0xC7,
  0xC3, 0xE1, 0xE1, 0xF0, 0xF8, 0x78, 0x3C, 0x3C, 0x1E, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x7D, 0xFB, 0xFF, 0xFF, 0xEF, 0x80, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F,
  0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xEF, 0xEF, 0x80,
  0xF7, 0x80, 0x7F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x3C, 0x7F, 0x9F, 0x3F, 0xCF, 0x9F, 0xE7, 0x8F,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xF0, 0x1E, 0x7C, 0x3F, 0x1F, 0xFF, 0x07, 0xFF, 0x01,
  0xFF, 0x00, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0xC0, 0x7E,
  0xF0, 0x3E, 0x3C, 0x0F, 0x0F, 0x03, 0x83, 0xC0, 0x80, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xF0,
  0xFF, 0xFE, 0x7C, 0x0F, 0x9E, 0x01, 0xE7, 0x80, 0x7F, 0xE0, 0x0F, 0x00,
  0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7F,
  0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF, 0x3F, 0xFF, 0x8F, 0xFF,
  0xE3, 0xFF, 0xF8, 0xFF, 0xFE, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0xF0, 0x03,
  0xFE, 0x00, 0xFF, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0xF8, 0x03, 0xDE, 0x00, 0xF7, 0x80, 0x79,
  0xF0, 0x1E, 0x7E, 0x1F, 0x8F, 0xFF, 0xC1, 0xFF, 0xE0, 0x1F, 0xE0, 0x00,
  0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x03,
  0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x3E,
  0x0F, 0x3C, 0x0F, 0x78, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x7F, 0xFF, 0x3F, 0xFF, 0x9F,
  0xFF, 0xCF, 0xFF, 0xE7, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0xFE, 0x0F, 0xFF, 0xC7, 0xFF, 0xE3, 0xF1,
  0xF9, 0xE0, 0x3C, 0xF0, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3F, 0xC0, 0x3F, 0xF0, 0x1E, 0x7C, 0x3F,
  0x3F, 0xFF, 0x0F, 0xFF, 0x01, 0xFF, 0x00, 0x00, 0x7C, 0x00, 0x1E, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7B, 0xF0, 0x3D, 0xFF,
  0x0F, 0xFF, 0xE7, 0xE0, 0xF9, 0xF0, 0x1F, 0x78, 0x03, 0xFE, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xDE, 0x00, 0xF7, 0x80, 0x3D, 0xF0,
  0x1F, 0x3F, 0x1F, 0x8F, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x3F, 0xE0, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0,
  0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78,
  0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F,
  0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x07, 0xF0,
  0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xEF, 0xE7, 0x81, 0xF7, 0xC0, 0x7B, 0xC0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0x3C, 0x07, 0x9F, 0x07, 0xC7, 0xC7, 0xC1,
  0xFF, 0xC0, 0x3F, 0x80, 0x3F, 0xE0, 0x7E, 0xFC, 0x7C, 0x1F, 0x3C, 0x07,
  0xBC, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xF0,
  0x1F, 0x7C, 0x3F, 0x3F, 0xFF, 0x8F, 0xFF, 0x81, 0xFF, 0x00, 0x03, 0xF8,
  0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xFE, 0xFE, 0x7C, 0x07, 0x9E, 0x00, 0xF7,
  0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x3D, 0xE0,
  0x0F, 0x7C, 0x07, 0xDF, 0x83, 0xF3, 0xFF, 0xF8, 0x7F, 0xDE, 0x0F, 0xEF,
  0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00,
  0x0F, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F,
  0x00, 0x7D, 0xFF, 0xFF, 0xF7, 0xC7, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x18, 0x7D, 0xFF, 0xFF, 0xF7, 0xC0, 0x1F, 0x1F, 0xCF, 0xE7,
  0xF1, 0xF0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x1F, 0x0F, 0x8F, 0x87, 0xC3, 0xE1, 0xE1, 0xF0, 0xF0, 0x78,
  0x38, 0x3C, 0x00, 0x00, 0x00, 0x80, 0x01, 0xC0, 0x03, 0xE0, 0x07, 0xF0,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x00, 0x7C, 0x00,
  0x38, 0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xE0, 0x00, 0x70, 0x00, 0x08,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x00, 0x70, 0x00, 0x3E, 0x00, 0x1F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xC0, 0x00, 0xE0, 0x03, 0xF0, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0x00, 0x3E, 0x00, 0x1C, 0x00, 0x08, 0x00,
  0x00, 0xFE, 0x03, 0xFF, 0x0F, 0xFE, 0x3F, 0xFC, 0x01, 0xF8, 0x01, 0xE0,
  0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x01, 0xF8,
  0x7F, 0xC1, 0xFE, 0x07, 0xF0, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x3E, 0x00, 0xFC, 0x03, 0xE0,
  0x0F, 0x80, 0x01, 0xFE, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xF0, 0x3E, 0x07,
  0xC3, 0xC0, 0x1F, 0x3C, 0x00, 0x79, 0xE0, 0x01, 0xCE, 0x00, 0x0E, 0x70,
  0x00, 0x73, 0x80, 0x43, 0xFC, 0x0F, 0xDF, 0xE0, 0xFF, 0xFF, 0x0F, 0x8F,
  0xF8, 0x78, 0x3F, 0xC3, 0x81, 0xFE, 0x1C, 0x0F, 0xF0, 0xE0, 0x7F, 0x87,
  0x03, 0xFC, 0x38, 0x1F, 0xE1, 0xC0, 0xFF, 0x0E, 0x07, 0xF8, 0x78, 0x3F,
  0xC3, 0xC3, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0x7B, 0x80, 0xF3, 0xDC, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3B, 0x80, 0x0F, 0x70,
  0x01, 0xEF, 0x00, 0x3D, 0xE0, 0x07, 0x3C, 0x01, 0xE3, 0x80, 0x3C, 0x78,
  0x07, 0x8F, 0x00, 0xE1, 0xE0, 0x3C, 0x1C, 0x07, 0x83, 0xC0, 0xF0, 0x78,
  0x1E, 0x0F, 0x07, 0x80, 0xE0, 0xFF, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8,
  0xF0, 0x0F, 0x9E, 0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x03, 0xDE, 0x00, 0x7F,
  0xC0, 0x07, 0xF8, 0x00, 0xF0, 0xFF, 0xC0, 0x7F, 0xFE, 0x3F, 0xFF, 0x9F,
  0xFF, 0xEF, 0x01, 0xF7, 0x80, 0x7F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF8, 0x07, 0xFC, 0x03, 0xDE, 0x07, 0xCF, 0xFF, 0xC7, 0xFF, 0xC3, 0xFF,
  0xF9, 0xE0, 0x7E, 0xF0, 0x0F, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xBF, 0xFF, 0x1F, 0xFE, 0x00, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F,
  0xFF, 0xE7, 0xC0, 0xF7, 0xC0, 0x7F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x3E, 0xF0, 0x1E, 0x7E, 0x3F, 0x1F, 0xFF,
  0x07, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xFC, 0x3F, 0xFF, 0x1F,
  0xFF, 0xCF, 0x03, 0xF7, 0x80, 0x7B, 0xC0, 0x3F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x3D, 0xE0, 0x3E, 0xFF, 0xFE, 0x7F, 0xFF,
  0x3F, 0xFE, 0x1F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0xFE, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xE7, 0xC0, 0xF7,
  0xC0, 0x7F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC3, 0xFF, 0xE1, 0xFF, 0xF0,
  0xFF, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0xE0, 0x3E, 0xF0, 0x1E, 0x7E, 0x3F, 0x1F, 0xFF, 0x07, 0xFF, 0x01, 0xFF,
  0x00, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F,
  0xFC, 0x07, 0xFF, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0xF8, 0x03, 0xDE, 0x00, 0xF7, 0x80, 0x7D, 0xF0, 0x1E,
  0x3F, 0x1F, 0x8F, 0xFF, 0xC1, 0xFF, 0xE0, 0x1F, 0xF0, 0xF0, 0x03, 0xFC,
  0x01, 0xFF, 0x00, 0x7B, 0xC0, 0x3E, 0xF0, 0x0F, 0x3C, 0x07, 0xCF, 0x01,
  0xE3, 0xC0, 0xF8, 0xF0, 0x3C, 0x3C, 0x1F, 0x0F, 0x07, 0x83, 0xC3, 0xE0,
  0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0xF0, 0xF8, 0x3C,
  0x1E, 0x0F, 0x07, 0xC3, 0xC0, 0xF0, 0xF0, 0x3E, 0x3C, 0x07, 0x8F, 0x01,
  0xF3, 0xC0, 0x3C, 0xF0, 0x0F, 0xBC, 0x01, 0xEF, 0x00, 0x7F, 0xC0, 0x0F,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFC, 0x07,
  0xFE, 0x03, 0xFB, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xB8, 0xEF, 0xDC,
  0x77, 0xEE, 0x3B, 0xF7, 0x39, 0xF9, 0xDC, 0xFC, 0xEE, 0x7E, 0x76, 0x3F,
  0x1F, 0x1F, 0x8F, 0x8F, 0xC7, 0xCF, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xF0, 0xF8, 0x07, 0xFE, 0x03,
  0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFE,
  0x0F, 0xF7, 0x07, 0xFB, 0x83, 0xFD, 0xE1, 0xFE, 0x70, 0xFF, 0x3C, 0x7F,
  0x9E, 0x3F, 0xC7, 0x1F, 0xE3, 0xCF, 0xF0, 0xE7, 0xF8, 0x73, 0xFC, 0x3D,
  0xFE, 0x0E, 0xFF, 0x07, 0x7F, 0x83, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0,
  0x3F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xF0, 0x07, 0xF0, 0x0F, 0xFE,
  0x0F, 0xFF, 0x8F, 0xFF, 0xE7, 0x81, 0xF7, 0xC0, 0x7B, 0xC0, 0x3F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x3E, 0xF0, 0x1E, 0x7E,
  0x3F, 0x1F, 0xFF, 0x07, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0xF0, 0x3F, 0xFF,
  0x0F, 0xFF, 0xF3, 0xFF, 0xFE, 0xF0, 0x0F, 0xBC, 0x01, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xF0,
  0x0F, 0xBF, 0xFF, 0xEF, 0xFF, 0xF3, 0xFF, 0xF8, 0xFF, 0xF8, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xEF, 0x81, 0xF7, 0xC0, 0x7F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x3F,
  0xF0, 0x1E, 0x7E, 0x3F, 0x1F, 0xFF, 0x07, 0xFF, 0x01, 0xFF, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xE0, 0xFF, 0xE0, 0x3F, 0xFF, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0xF0,
  0x1F, 0xBC, 0x03, 0xEF, 0x00, 0x7B, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0x7B, 0xC0, 0x3E, 0xF0, 0x1F, 0xBF, 0xFF, 0xCF, 0xFF, 0xE3,
  0xFF, 0xF0, 0xFF, 0xF0, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xF0, 0xF0,
  0x3C, 0x3C, 0x0F, 0x8F, 0x01, 0xE3, 0xC0, 0x7C, 0xF0, 0x0F, 0x3C, 0x03,
  0xEF, 0x00, 0x7B, 0xC0, 0x1F, 0x03, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xF0,
  0xFF, 0xFE, 0x3C, 0x07, 0x9F, 0x01, 0xF7, 0x80, 0x3D, 0xE0, 0x00, 0x78,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xF0, 0x03, 0xFF,
  0x00, 0x7F, 0xF0, 0x03, 0xFE, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xFE, 0x00, 0xF7, 0x80, 0x3D, 0xF0, 0x1F, 0x7F,
  0x1F, 0x8F, 0xFF, 0xE1, 0xFF, 0xF0, 0x1F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x7F, 0xE0, 0x3C, 0xF0, 0x1E, 0x7E, 0x3F, 0x1F, 0xFF, 0x07, 0xFF,
  0x01, 0xFF, 0x00, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x01,
  0xE7, 0x80, 0x3C, 0xF0, 0x07, 0x9E, 0x00, 0xF3, 0xE0, 0x3C, 0x3C, 0x07,
  0x87, 0x80, 0xF0, 0xF0, 0x1E, 0x1F, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x1E,
  0x07, 0x83, 0xC0, 0xF8, 0xF0, 0x0F, 0x1E, 0x01, 0xE3, 0xC0, 0x3C, 0x78,
  0x03, 0x9E, 0x00, 0x7B, 0xC0, 0x0F, 0x78, 0x01, 0xEF, 0x00, 0x1D, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0xF0, 0x70,
  0x7F, 0x87, 0xC3, 0xFC, 0x3E, 0x1F, 0xE1, 0xB0, 0xFF, 0x0D, 0x87, 0xF8,
  0x6C, 0x3B, 0xC3, 0x61, 0xCE, 0x1B, 0x0E, 0x70, 0xD8, 0x73, 0x8E, 0xC3,
  0x9C, 0x77, 0x3C, 0xF3, 0xB9, 0xE7, 0x99, 0xCF, 0x3C, 0xC6, 0x79, 0xE6,
  0x33, 0x8F, 0x31, 0x9C, 0x39, 0x8C, 0xE1, 0xDC, 0x67, 0x0E, 0xE3, 0x38,
  0x77, 0x1D, 0xC3, 0xB0, 0xFE, 0x1D, 0x87, 0xF0, 0xFC, 0x1F, 0x87, 0xE0,
  0xF8, 0x3F, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x0F, 0x80,
  0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0x81, 0xF0,
  0x7C, 0x07, 0x83, 0xC0, 0x3E, 0x3E, 0x00, 0xF1, 0xE0, 0x07, 0xDF, 0x00,
  0x1E, 0xF0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0xF7, 0x80, 0x0F, 0x3E, 0x00, 0xF8, 0xF0, 0x07, 0x87, 0xC0, 0x7C, 0x1F,
  0x03, 0xC0, 0x78, 0x3E, 0x03, 0xE1, 0xE0, 0x0F, 0x1F, 0x00, 0x7D, 0xF0,
  0x01, 0xF0, 0xF0, 0x00, 0xFB, 0xC0, 0x07, 0x9E, 0x00, 0x7C, 0x78, 0x03,
  0xC3, 0xC0, 0x3E, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0xF0, 0x0F,
  0x07, 0x80, 0x7C, 0x78, 0x01, 0xE3, 0xC0, 0x0F, 0xBC, 0x00, 0x3D, 0xE0,
  0x01, 0xEE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF,
  0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00,
  0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00,
  0x0F, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0,
  0x01, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xEE, 0x00,
  0x77, 0x00, 0x7B, 0xC0, 0x38, 0xE0, 0x3C, 0x78, 0x1C, 0x3C, 0x1E, 0x0F,
  0x0F, 0x07, 0x8F, 0x01, 0xC7, 0x80, 0xF3, 0x80, 0x3B, 0xC0, 0x1E, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x78, 0x7C,
  0x3E, 0x1F, 0x07, 0xFC, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xFC, 0x7E, 0x3C,
  0x07, 0x9E, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC3, 0xFF,
  0xF3, 0xFF, 0xFD, 0xFF, 0xFF, 0x78, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x1F, 0xF8, 0x07, 0xDF, 0x03, 0xF7, 0xFF, 0xBC, 0xFF, 0xEF, 0x1F,
  0xE3, 0xC0, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE3, 0xF0, 0xF7, 0xFE, 0x7B, 0xFF, 0x3F,
  0x8F, 0xDF, 0x01, 0xEF, 0x80, 0xFF, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0xE0, 0x3F, 0xF0, 0x1E, 0xFE, 0x3F, 0x7B, 0xFF, 0xBD, 0xFF, 0x9E,
  0x7F, 0x00, 0x0F, 0xF8, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xC7, 0xE7, 0x80,
  0xFF, 0xC0, 0x7F, 0xC0, 0x1F, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF8, 0x0F, 0xBF, 0x1F, 0x8F, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0x80, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x1E, 0x1F, 0x8F, 0x3F, 0xE7, 0xBF, 0xFB, 0xDF, 0x9D, 0xFF, 0x03,
  0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F,
  0xF0, 0x3F, 0x7C, 0x37, 0xBF, 0xFB, 0xCF, 0xF9, 0xE3, 0xF8, 0xF0, 0x0F,
  0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0x83, 0xE7, 0x80, 0xF7, 0x80, 0x7F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x0F, 0xBE,
  0x0F, 0x8F, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x1F, 0xC0, 0x3F,
  0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x0F,
  0xCF, 0x9F, 0xF3, 0xDF, 0xFD, 0xEF, 0xCE, 0xFF, 0x81, 0xFF, 0xC0, 0x7F,
  0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x3E, 0xF8, 0x2F, 0x7F, 0xF7, 0x9F,
  0xFB, 0xC7, 0xF9, 0xE0, 0xE1, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C,
  0x00, 0x1E, 0x1F, 0xFF, 0x0F, 0xFF, 0x07, 0xFF, 0x03, 0xFE, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE3, 0xF0, 0xF7, 0xFE, 0x7B, 0xFF, 0x3F, 0x8F, 0xDF, 0x01,
  0xEF, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xF0, 0x00,
  0xC0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x38, 0x00, 0xF8, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xF9, 0xFF, 0xF3, 0xFF, 0xE7, 0xFF, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0xF9, 0xFF, 0xF3, 0xFF,
  0xC7, 0xFF, 0x0F, 0xF0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x1F, 0xF0,
  0x07, 0xBC, 0x03, 0xEF, 0x01, 0xF3, 0xC0, 0x78, 0xF0, 0x3E, 0x3C, 0x1F,
  0x0F, 0x07, 0x83, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03,
  0xC3, 0xE0, 0xF0, 0x7C, 0x3C, 0x0F, 0x0F, 0x03, 0xE3, 0xC0, 0x7C, 0xF0,
  0x1F, 0x3C, 0x03, 0xEF, 0x00, 0x7B, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFE,
  0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0xF0, 0x0F,
  0xFF, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xF7, 0xCF, 0x9F, 0xFB, 0xFB, 0xFF,
  0xFF, 0x78, 0xF1, 0xEF, 0x0E, 0x1F, 0xE1, 0xC3, 0xFC, 0x38, 0x7F, 0x87,
  0x0F, 0xF0, 0xE1, 0xFE, 0x1C, 0x3F, 0xC3, 0x87, 0xF8, 0x70, 0xFF, 0x0E,
  0x1F, 0xE1, 0xC3, 0xFC, 0x38, 0x7F, 0x87, 0x0F, 0xF0, 0xE1, 0xFE, 0x1C,
  0x3F, 0xC3, 0x87, 0xF8, 0x70, 0xFF, 0x0E, 0x1E, 0xF1, 0xF8, 0x7B, 0xFF,
  0x3D, 0xFF, 0x9F, 0xC7, 0xEF, 0x80, 0xF7, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x78, 0x0F, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F,
  0xEF, 0xE7, 0x80, 0xF7, 0x80, 0x7F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x1F, 0xE0, 0x1F, 0xF8, 0x0F, 0x3F, 0x1F, 0x8F, 0xFF, 0x83, 0xFF, 0x80,
  0xFF, 0x80, 0xF1, 0xF8, 0x7B, 0xFF, 0x3D, 0xFF, 0x9F, 0xC7, 0xEF, 0x80,
  0xF7, 0xC0, 0x7F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xF0, 0x1F,
  0xF8, 0x0F, 0x7F, 0x1F, 0xBD, 0xFF, 0xDE, 0xFF, 0xCF, 0x3F, 0x87, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0xC7, 0x9F, 0xF3, 0xDF, 0xFD, 0xEF, 0xCE, 0xFF, 0x81,
  0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x1F, 0xBF, 0x1B, 0xDF, 0xFD, 0xE7, 0xFC, 0xF1, 0xFC, 0x78, 0x00,
  0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0xF3, 0xF8, 0x7B, 0xFE, 0x3F, 0xFF, 0x9F, 0x87, 0xEF, 0x81,
  0xF7, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0xF8, 0x1F, 0xFF, 0x1F, 0xFF, 0xCF, 0x83, 0xE7, 0x80, 0xFF, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x7F, 0x80, 0x1F, 0xFC, 0x07, 0xFF, 0x80, 0xFF,
  0xE0, 0x01, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0xF0, 0x07, 0xFE,
  0x0F, 0xDF, 0xFF, 0xC7, 0xFF, 0xC0, 0xFF, 0xC0, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x07, 0xFC, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xF0, 0x1E, 0x78, 0x0F, 0x3F, 0x1F, 0x8F,
  0xFF, 0x83, 0xFF, 0x80, 0xFF, 0x80, 0xF0, 0x01, 0xFE, 0x00, 0x7D, 0xE0,
  0x0F, 0x3C, 0x01, 0xE7, 0x80, 0x7C, 0x78, 0x0F, 0x0F, 0x01, 0xE1, 0xE0,
  0x3C, 0x1E, 0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x3C, 0x07, 0x8F, 0x00, 0xF1,
  0xE0, 0x1E, 0x3C, 0x01, 0xEF, 0x00, 0x3D, 0xE0, 0x07, 0xBC, 0x00, 0x77,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x00, 0xF0, 0x70, 0x7F, 0x87,
  0x83, 0xFC, 0x3E, 0x1C, 0xE1, 0xF0, 0xE7, 0x0D, 0x87, 0x38, 0x6C, 0x39,
  0xC3, 0x63, 0xCF, 0x1B, 0x1E, 0x79, 0xD8, 0xE1, 0xCC, 0xE7, 0x0E, 0x67,
  0x38, 0x73, 0x19, 0xC3, 0x98, 0xCE, 0x1C, 0xC6, 0xF0, 0xFE, 0x37, 0x07,
  0xF1, 0xF8, 0x1F, 0x0F, 0xC0, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x0F,
  0x81, 0xF0, 0x78, 0x00, 0xF8, 0x03, 0xEF, 0x80, 0xF8, 0xF0, 0x3E, 0x1F,
  0x07, 0x81, 0xF1, 0xF0, 0x1E, 0x3C, 0x03, 0xEF, 0x00, 0x3F, 0xE0, 0x03,
  0xF8, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0x78, 0x03, 0xEF, 0x80, 0xF8, 0xF0, 0x1E, 0x0F, 0x07, 0xC1, 0xF1, 0xF0,
  0x1E, 0x3C, 0x03, 0xEF, 0x80, 0x3E, 0xF0, 0x01, 0xFF, 0x00, 0x7D, 0xE0,
  0x0F, 0x3E, 0x03, 0xE7, 0xC0, 0x78, 0x78, 0x0F, 0x0F, 0x83, 0xE0, 0xF0,
  0x78, 0x1E, 0x0F, 0x03, 0xE3, 0xE0, 0x3C, 0x78, 0x07, 0xCF, 0x00, 0x7B,
  0xE0, 0x0F, 0x78, 0x01, 0xEF, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x7F, 0xFF, 0x3F, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xE0, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x03,
  0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0x80, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0xFF, 0xE0, 0x7F, 0xE0,
  0x3F, 0xE0, 0x1F, 0xFC, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x1F,
  0xE0, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xFF, 0x80, 0xFF, 0xC0,
  0x3F, 0xE0, 0x7F, 0xF0, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0x80, 0x1F,
  0x80, 0x00, 0x04, 0x00, 0x07, 0xF0, 0x3D, 0xFF, 0x07, 0xBF, 0xF0, 0xFF,
  0x1F, 0x1F, 0xE1, 0xFF, 0xBC, 0x1F, 0xF7, 0x81, 0xFC, 0x00, 0x0E, 0x00,
};

const GFXglyph JetBrainsMono_Medium38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 23, 0, -1 },
  { 1, 6, 28, 23, 8, -28 },
  { 22, 13, 12, 23, 5, -28 },
  { 42, 21, 28, 23, 1, -28 },
  { 116, 18, 38, 23, 2, -33 },
  { 202, 23, 28, 23, 0, -28 },
  { 283, 20, 28, 23, 2, -28 },
  { 353, 4, 12, 23, 9, -28 },
  { 359, 11, 37, 23, 7, -32 },
  { 410, 12, 37, 23, 4, -32 },
  { 466, 21, 20, 23, 1, -23 },
  { 519, 18, 18, 23, 2, -22 },
  { 560, 9, 12, 23, 6, -6 },
  { 574, 12, 3, 23, 5, -14 },
  { 579, 7, 6, 23, 8, -6 },
  { 585, 17, 36, 23, 3, -32 },
  { 662, 17, 28, 23, 3, -28 },
  { 722, 18, 28, 23, 3, -28 },
  { 785, 18, 28, 23, 2, -28 },
  { 848, 18, 28, 23, 2, -28 },
  { 911, 16, 28, 23, 3, -28 },
  { 967, 17, 28, 23, 3, -28 },
  { 1027, 18, 28, 23, 2, -28 },
  { 1090, 17, 28, 23, 3, -28 },
  { 1150, 17, 28, 23, 3, -28 },
  { 1210, 18, 28, 23, 2, -28 },
  { 1273, 7, 21, 23, 8, -21 },
  { 1292, 9, 27, 23, 6, -21 },
  { 1323, 17, 21, 23, 3, -23 },
  { 1368, 17, 13, 23, 3, -19 },
  { 1396, 17, 21, 23, 3, -23 },
  { 1441, 14, 28, 23, 5, -28 },
  { 1490, 21, 35, 23, 1, -28 },
  { 1582, 19, 28, 23, 2, -28 },
  { 1649, 17, 28, 23, 3, -28 },
  { 1709, 17, 28, 23, 3, -28 },
  { 1769, 17, 28, 23, 3, -28 },
  { 1829, 16, 28, 23, 4, -28 },
  { 1885, 17, 28, 23, 3, -28 },
  { 1945, 17, 28, 23, 3, -28 },
  { 2005, 17, 28, 23, 3, -28 },
  { 2065, 15, 28, 23, 4, -28 },
  { 2118, 18, 28, 23, 1, -28 },
  { 2181, 18, 28, 23, 3, -28 },
  { 2244, 16, 28, 23, 4, -28 },
  { 2300, 17, 28, 23, 3, -28 },
  { 2360, 17, 28, 23, 3, -28 },
  { 2420, 17, 28, 23, 3, -28 },
  { 2480, 18, 28, 23, 3, -28 },
  { 2543, 17, 35, 23, 3, -28 },
  { 2618, 18, 28, 23, 3, -28 },
  { 2681, 18, 28, 23, 2, -28 },
  { 2744, 19, 28, 23, 2, -28 },
  { 2811, 17, 28, 23, 3, -28 },
  { 2871, 19, 28, 23, 2, -28 },
  { 2938, 21, 28, 23, 1, -28 },
  { 3012, 21, 28, 23, 1, -28 },
  { 3086, 21, 28, 23, 1, -28 },
  { 3160, 17, 28, 23, 3, -28 },
  { 3220, 10, 36, 23, 7, -32 },
  { 3265, 17, 36, 23, 3, -32 },
  { 3342, 10, 36, 23, 5, -32 },
  { 3387, 17, 15, 23, 3, -28 },
  { 3419, 19, 4, 23, 2, 1 },
  { 3429, 8, 5, 23, 7, -30 },
  { 3434, 18, 21, 23, 2, -21 },
  { 3482, 17, 28, 23, 3, -28 },
  { 3542, 17, 21, 23, 3, -21 },
  { 3587, 17, 28, 23, 3, -28 },
  { 3647, 17, 21, 23, 3, -21 },
  { 3692, 18, 28, 23, 2, -28 },
  { 3755, 17, 28, 23, 3, -21 },
  { 3815, 17, 28, 23, 3, -28 },
  { 3875, 18, 30, 23, 3, -30 },
  { 3943, 15, 37, 23, 3, -30 },
  { 4013, 18, 28, 23, 3, -28 },
  { 4076, 20, 28, 23, 1, -28 },
  { 4146, 19, 21, 23, 2, -21 },
  { 4196, 17, 21, 23, 3, -21 },
  { 4241, 17, 21, 23, 3, -21 },
  { 4286, 17, 28, 23, 3, -21 },
  { 4346, 17, 28, 23, 3, -21 },
  { 4406, 17, 21, 23, 4, -21 },
  { 4451, 17, 21, 23, 3, -21 },
  { 4496, 18, 27, 23, 2, -27 },
  { 4557, 17, 21, 23, 3, -21 },
  { 4602, 19, 21, 23, 2, -21 },
  { 4652, 21, 21, 23, 1, -21 },
  { 4708, 19, 21, 23, 2, -21 },
  { 4758, 19, 28, 23, 2, -21 },
  { 4825, 17, 21, 23, 3, -21 },
  { 4870, 17, 36, 23, 3, -32 },
  { 4947, 4, 36, 23, 9, -32 },
  { 4965, 17, 36, 23, 3, -32 },
  { 5042, 19, 9, 23, 2, -18 },
};

const GFXfont JetBrainsMono_Medium38pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Medium38pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Medium38pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _JETBRAINSMONO_MEDIUM38PT7B_H_
