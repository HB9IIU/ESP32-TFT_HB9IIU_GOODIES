#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated_Fonts_For_Copy/JetBrainsMono_Medium
// Headers: 67

#include "JetBrainsMono_Medium6pt7b.h"
#include "JetBrainsMono_Medium7pt7b.h"
#include "JetBrainsMono_Medium8pt7b.h"
#include "JetBrainsMono_Medium9pt7b.h"
#include "JetBrainsMono_Medium10pt7b.h"
#include "JetBrainsMono_Medium11pt7b.h"
#include "JetBrainsMono_Medium12pt7b.h"
#include "JetBrainsMono_Medium13pt7b.h"
#include "JetBrainsMono_Medium14pt7b.h"
#include "JetBrainsMono_Medium15pt7b.h"
#include "JetBrainsMono_Medium16pt7b.h"
#include "JetBrainsMono_Medium17pt7b.h"
#include "JetBrainsMono_Medium18pt7b.h"
#include "JetBrainsMono_Medium19pt7b.h"
#include "JetBrainsMono_Medium20pt7b.h"
#include "JetBrainsMono_Medium21pt7b.h"
#include "JetBrainsMono_Medium22pt7b.h"
#include "JetBrainsMono_Medium23pt7b.h"
#include "JetBrainsMono_Medium24pt7b.h"
#include "JetBrainsMono_Medium25pt7b.h"
#include "JetBrainsMono_Medium26pt7b.h"
#include "JetBrainsMono_Medium27pt7b.h"
#include "JetBrainsMono_Medium28pt7b.h"
#include "JetBrainsMono_Medium29pt7b.h"
#include "JetBrainsMono_Medium30pt7b.h"
#include "JetBrainsMono_Medium31pt7b.h"
#include "JetBrainsMono_Medium32pt7b.h"
#include "JetBrainsMono_Medium33pt7b.h"
#include "JetBrainsMono_Medium34pt7b.h"
#include "JetBrainsMono_Medium35pt7b.h"
#include "JetBrainsMono_Medium36pt7b.h"
#include "JetBrainsMono_Medium37pt7b.h"
#include "JetBrainsMono_Medium38pt7b.h"
#include "JetBrainsMono_Medium39pt7b.h"
#include "JetBrainsMono_Medium40pt7b.h"
#include "JetBrainsMono_Medium41pt7b.h"
#include "JetBrainsMono_Medium42pt7b.h"
#include "JetBrainsMono_Medium43pt7b.h"
#include "JetBrainsMono_Medium44pt7b.h"
#include "JetBrainsMono_Medium45pt7b.h"
#include "JetBrainsMono_Medium46pt7b.h"
#include "JetBrainsMono_Medium47pt7b.h"
#include "JetBrainsMono_Medium48pt7b.h"
#include "JetBrainsMono_Medium49pt7b.h"
#include "JetBrainsMono_Medium50pt7b.h"
#include "JetBrainsMono_Medium51pt7b.h"
#include "JetBrainsMono_Medium52pt7b.h"
#include "JetBrainsMono_Medium53pt7b.h"
#include "JetBrainsMono_Medium54pt7b.h"
#include "JetBrainsMono_Medium55pt7b.h"
#include "JetBrainsMono_Medium56pt7b.h"
#include "JetBrainsMono_Medium57pt7b.h"
#include "JetBrainsMono_Medium58pt7b.h"
#include "JetBrainsMono_Medium59pt7b.h"
#include "JetBrainsMono_Medium60pt7b.h"
#include "JetBrainsMono_Medium61pt7b.h"
#include "JetBrainsMono_Medium62pt7b.h"
#include "JetBrainsMono_Medium63pt7b.h"
#include "JetBrainsMono_Medium64pt7b.h"
#include "JetBrainsMono_Medium65pt7b.h"
#include "JetBrainsMono_Medium66pt7b.h"
#include "JetBrainsMono_Medium67pt7b.h"
#include "JetBrainsMono_Medium68pt7b.h"
#include "JetBrainsMono_Medium69pt7b.h"
#include "JetBrainsMono_Medium70pt7b.h"
#include "JetBrainsMono_Medium71pt7b.h"
#include "JetBrainsMono_Medium72pt7b.h"
