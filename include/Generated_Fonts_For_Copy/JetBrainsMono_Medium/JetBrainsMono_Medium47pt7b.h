#ifndef _JETBRAINSMONO_MEDIUM47PT7B_H_
#define _JETBRAINSMONO_MEDIUM47PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Medium.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Medium47pt7bBitmaps[] PROGMEM = {
  0x00, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x3E,
  0x3E, 0x3E, 0x3E, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x7E, 0xFF, 0xFF, 0x7F, 0x7E, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0x7C, 0x3F, 0x7C,
  0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7C, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78,
  0x1E, 0x78, 0x1E, 0x00, 0x78, 0x0E, 0x00, 0x1C, 0x07, 0x80, 0x0F, 0x01,
  0xE0, 0x03, 0xC0, 0x78, 0x00, 0xF0, 0x1E, 0x00, 0x3C, 0x07, 0x00, 0x0E,
  0x03, 0xC0, 0x07, 0x80, 0xF0, 0x01, 0xE0, 0x3C, 0x0F, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x01, 0xC0, 0x78, 0x00, 0xF0, 0x1E,
  0x00, 0x3C, 0x07, 0x80, 0x0F, 0x01, 0xE0, 0x03, 0xC0, 0x70, 0x00, 0xE0,
  0x3C, 0x00, 0x78, 0x0F, 0x00, 0x1E, 0x03, 0xC0, 0x07, 0x80, 0xF0, 0x3F,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0x03, 0xC0, 0x78, 0x00, 0xF0, 0x1E, 0x00, 0x3C, 0x07, 0x80, 0x0F, 0x01,
  0xC0, 0x03, 0x80, 0xF0, 0x01, 0xE0, 0x3C, 0x00, 0x78, 0x0F, 0x00, 0x1E,
  0x03, 0xC0, 0x07, 0x80, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF,
  0x0F, 0xCE, 0x7E, 0x7E, 0x38, 0xF9, 0xF0, 0xE3, 0xF7, 0xC3, 0x87, 0xDF,
  0x0E, 0x1F, 0x7C, 0x38, 0x01, 0xF0, 0xE0, 0x07, 0xE3, 0x80, 0x0F, 0xCE,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF0,
  0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x0E, 0x7E, 0x00,
  0x38, 0xFC, 0x00, 0xE3, 0xF0, 0x03, 0x87, 0xC0, 0x0E, 0x1F, 0xF8, 0x38,
  0x7F, 0xE0, 0xE1, 0xFF, 0xC3, 0x8F, 0xDF, 0x8E, 0x3F, 0x7F, 0x3B, 0xF8,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x1F, 0x3F, 0xF8, 0x01, 0xE7, 0xFF, 0x80, 0x3C, 0x78, 0x7C, 0x07, 0x87,
  0x83, 0xC0, 0x78, 0x78, 0x3C, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0x78, 0x3C,
  0x1E, 0x07, 0x83, 0xC3, 0xC0, 0x78, 0x3C, 0x78, 0x07, 0x83, 0xC7, 0x00,
  0x7C, 0x7C, 0xF0, 0x03, 0xFF, 0x9E, 0x00, 0x3F, 0xF3, 0xC0, 0x00, 0xFE,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0xC0, 0x00, 0x3C, 0x7F, 0x80, 0x03, 0xCF, 0xFC, 0x00,
  0x79, 0xFF, 0xE0, 0x0F, 0x3E, 0x1E, 0x00, 0xE3, 0xC1, 0xE0, 0x1E, 0x3C,
  0x0F, 0x03, 0xC3, 0xC0, 0xF0, 0x78, 0x3C, 0x0F, 0x07, 0x83, 0xC0, 0xF0,
  0xF0, 0x3C, 0x0F, 0x1E, 0x03, 0xC1, 0xE1, 0xE0, 0x1E, 0x3E, 0x3C, 0x01,
  0xFF, 0xE7, 0x80, 0x0F, 0xFC, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFE,
  0x00, 0xF8, 0x1F, 0x80, 0x7C, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x3E, 0x01,
  0xF0, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFE, 0x07, 0xEF, 0x9F, 0x83, 0xEF,
  0x87, 0xC3, 0xE7, 0xC1, 0xF1, 0xF3, 0xE0, 0x7D, 0xF1, 0xF0, 0x3F, 0xF8,
  0xF8, 0x0F, 0xF8, 0x7C, 0x03, 0xFC, 0x3E, 0x01, 0xFC, 0x1F, 0x00, 0x7C,
  0x0F, 0x80, 0x3F, 0x03, 0xE0, 0x3F, 0xC1, 0xF8, 0x3F, 0xF0, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0x3E, 0x0F, 0xFF, 0x1F, 0x83, 0xFE, 0x07, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF9, 0xE7, 0x9E, 0x79, 0xE0, 0x00, 0x0E,
  0x00, 0x7C, 0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0xFE, 0x03, 0xF0, 0x0F,
  0xC0, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80,
  0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xFC, 0x03,
  0xFF, 0x03, 0xFE, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0xF0, 0x00, 0x20, 0xE0,
  0x01, 0xF8, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x01, 0xF8,
  0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00,
  0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0xFE, 0x07, 0xF8,
  0x3F, 0xE0, 0xFF, 0x81, 0xFC, 0x03, 0xF0, 0x07, 0x80, 0x08, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0xE0, 0x78,
  0x0C, 0xFC, 0x3C, 0x3F, 0x7F, 0x8E, 0x7F, 0xBF, 0xE6, 0x7F, 0xEF, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0x80, 0x01, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xE7, 0x80, 0x01, 0xF3, 0xE0, 0x01, 0xF8, 0xF8, 0x00,
  0xF8, 0x7E, 0x00, 0xFC, 0x1F, 0x00, 0xFC, 0x0F, 0xC0, 0x3C, 0x03, 0xE0,
  0x0E, 0x00, 0xC0, 0x02, 0x00, 0x40, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0xE1, 0xF8, 0x7F, 0x0F, 0xC1, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0x3E, 0x07,
  0xC1, 0xF8, 0x3E, 0x07, 0xC0, 0xF0, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFC, 0x0F, 0xE7, 0xE0, 0x0F, 0x9F, 0x00,
  0x3E, 0x7C, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x1E, 0x1F, 0xF8,
  0xFC, 0x7F, 0xE3, 0xF1, 0xFF, 0x8F, 0xC7, 0xFE, 0x1F, 0x1F, 0xF8, 0x30,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xF7, 0x80, 0x07, 0xDF, 0x00, 0x1F, 0x7C, 0x00, 0xF9, 0xF8,
  0x07, 0xE3, 0xF0, 0x3F, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x7F, 0xFC, 0x03, 0xF9, 0xF0, 0x0F, 0xC7, 0xC0, 0x3E,
  0x1F, 0x00, 0xE0, 0x7C, 0x03, 0x01, 0xF0, 0x08, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF1, 0xFC, 0x0F, 0xC7, 0xE0, 0x1F, 0xBF, 0x00, 0x3E,
  0xF8, 0x00, 0xFB, 0xE0, 0x03, 0xEF, 0x80, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x07, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x7F,
  0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x3F, 0xF8, 0x01, 0xF7, 0xC0, 0x1F, 0xBF, 0x81, 0xF8, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x03,
  0xE3, 0xF0, 0x1F, 0x3F, 0x00, 0xF9, 0xF0, 0x07, 0xDF, 0x80, 0x3F, 0xF8,
  0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xC7, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x20, 0x0F, 0x9F,
  0xF0, 0x7D, 0xFF, 0xE3, 0xEF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFE, 0x07, 0xF7,
  0xE0, 0x1F, 0xBE, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xFE,
  0x00, 0x7D, 0xF0, 0x03, 0xEF, 0xC0, 0x3F, 0x3F, 0x03, 0xF1, 0xFF, 0xFF,
  0x87, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0xFE, 0x03,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF1, 0xFC, 0x0F, 0xEF, 0xE0,
  0x1F, 0xBF, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xDF,
  0x00, 0x3F, 0x7E, 0x01, 0xF9, 0xFC, 0x0F, 0xE3, 0xFF, 0xFF, 0x07, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0x3E, 0xF8, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0xFF,
  0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFC, 0x0F, 0xE7, 0xE0, 0x1F,
  0x9F, 0x00, 0x3E, 0x7C, 0x00, 0xF9, 0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0x9F,
  0x00, 0x3E, 0x3E, 0x01, 0xF0, 0xFC, 0x0F, 0xC1, 0xF8, 0x7E, 0x03, 0xFF,
  0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x07, 0xFB, 0xF8,
  0x3F, 0x83, 0xF0, 0xF8, 0x07, 0xC7, 0xC0, 0x0F, 0x9F, 0x00, 0x3E, 0x7C,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x1F, 0x7C, 0x00,
  0xFD, 0xF8, 0x07, 0xE7, 0xF0, 0x3F, 0x8F, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0,
  0x3F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x1F, 0xFE, 0x00,
  0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFC, 0x0F, 0xE7, 0xE0,
  0x0F, 0xBF, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0x07, 0xFF,
  0x00, 0x3F, 0x7E, 0x01, 0xFD, 0xFE, 0x0F, 0xE3, 0xFF, 0xFF, 0x87, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF0, 0x0F, 0xCF, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7F, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x1F, 0x8F, 0xF3,
  0xFC, 0xFF, 0x3F, 0xCF, 0xF1, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x1F, 0xC7,
  0xE3, 0xF8, 0xFC, 0x3F, 0x0F, 0x87, 0xE1, 0xF8, 0x7C, 0x1F, 0x0F, 0x83,
  0xE0, 0xF8, 0x3C, 0x00, 0x00, 0x00, 0x10, 0x00, 0x07, 0x00, 0x01, 0xF0,
  0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0x70, 0x00, 0x3F, 0x00, 0x0F,
  0xF0, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF,
  0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x0E, 0x00, 0x00, 0x80,
  0x00, 0x00, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xFF, 0x1F, 0xFF, 0xC0, 0x1F,
  0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x3F, 0xFE,
  0x1F, 0xFE, 0x0F, 0xFE, 0x07, 0xFC, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0x80,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x81, 0xFC, 0x0F, 0xC1, 0xF8, 0x01, 0xF1, 0xF8, 0x00,
  0x7C, 0xF8, 0x00, 0x3E, 0x78, 0x00, 0x0F, 0x7C, 0x00, 0x07, 0xBE, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x7C, 0xFF, 0x80, 0xFF, 0x3F, 0xC0,
  0xFF, 0xDF, 0xE0, 0x7E, 0x7F, 0xF0, 0x7C, 0x1F, 0xF8, 0x3E, 0x07, 0xFC,
  0x1E, 0x03, 0xFE, 0x0F, 0x01, 0xFF, 0x07, 0x80, 0xFF, 0x83, 0xC0, 0x7F,
  0xC1, 0xE0, 0x3F, 0xE0, 0xF0, 0x1F, 0xF0, 0x78, 0x0F, 0xF8, 0x3C, 0x07,
  0xFC, 0x1E, 0x03, 0xFE, 0x0F, 0x81, 0xFF, 0x07, 0xE1, 0xFF, 0x81, 0xFF,
  0xBF, 0xC0, 0x7F, 0xDF, 0xE0, 0x1F, 0xCF, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x01,
  0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x01, 0xF7, 0x80, 0x01, 0xE7, 0x80, 0x01, 0xE7, 0xC0, 0x03, 0xE7, 0xC0,
  0x03, 0xE7, 0xC0, 0x03, 0xC3, 0xC0, 0x07, 0xC3, 0xE0, 0x07, 0xC3, 0xE0,
  0x07, 0xC3, 0xE0, 0x07, 0xC1, 0xE0, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0,
  0x0F, 0x81, 0xF0, 0x0F, 0x80, 0xF0, 0x1F, 0x00, 0xF8, 0x1F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3E, 0x00, 0x7C,
  0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x7E, 0x00, 0x3E, 0x7C, 0x00, 0x3E,
  0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0x80,
  0x7F, 0x7C, 0x01, 0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x01, 0xFF,
  0xC0, 0x0F, 0xBE, 0x00, 0x7D, 0xF0, 0x03, 0xEF, 0x80, 0x3F, 0x7C, 0x03,
  0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x3E,
  0x03, 0xF9, 0xF0, 0x07, 0xEF, 0x80, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0,
  0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x0F, 0xFB, 0xFF, 0xFF, 0x9F, 0xFF, 0xF8,
  0xFF, 0xFF, 0x87, 0xFF, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0xF8, 0x07,
  0xFF, 0xE0, 0x7F, 0xFF, 0x87, 0xFF, 0xFE, 0x3F, 0x03, 0xFB, 0xF0, 0x07,
  0xDF, 0x00, 0x3E, 0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0x7E, 0x01,
  0xF9, 0xFC, 0x1F, 0xCF, 0xFF, 0xFC, 0x3F, 0xFF, 0xC0, 0xFF, 0xFC, 0x01,
  0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF,
  0x8F, 0x81, 0xFE, 0x7C, 0x03, 0xFB, 0xE0, 0x0F, 0xDF, 0x00, 0x3E, 0xF8,
  0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xBE, 0x00,
  0x7D, 0xF0, 0x07, 0xEF, 0x80, 0x7F, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x1F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFD, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x3F,
  0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x87, 0xFF, 0xFE, 0x3F, 0x03, 0xFB,
  0xF0, 0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x1F,
  0x7E, 0x01, 0xF9, 0xFC, 0x1F, 0xCF, 0xFF, 0xFC, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFC, 0x01, 0xFF, 0x80, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F,
  0xFF, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x80, 0x0F, 0xBF, 0x00, 0x3E, 0x7C, 0x01, 0xF9, 0xFC, 0x1F,
  0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xFC, 0x00,
  0xF8, 0x00, 0xFD, 0xF0, 0x01, 0xF3, 0xE0, 0x07, 0xE7, 0xC0, 0x0F, 0x8F,
  0x80, 0x3F, 0x1F, 0x00, 0x7C, 0x3E, 0x01, 0xF8, 0x7C, 0x03, 0xE0, 0xF8,
  0x0F, 0xC1, 0xF0, 0x1F, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0xF8, 0x0F, 0x83,
  0xF0, 0x1F, 0x07, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0xFF, 0xFC,
  0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xC1, 0xF8, 0x0F, 0x83, 0xF0,
  0x1F, 0x03, 0xF0, 0x3E, 0x07, 0xE0, 0x7C, 0x07, 0xE0, 0xF8, 0x0F, 0xC1,
  0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x3F, 0x1F,
  0x00, 0x3E, 0x3E, 0x00, 0x7E, 0x7C, 0x00, 0x7C, 0xF8, 0x00, 0xFD, 0xF0,
  0x00, 0xFC, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0xC0, 0x77, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0x70, 0x3B, 0xFD, 0xE0,
  0xEF, 0xF7, 0x87, 0xBF, 0xCE, 0x1E, 0xFF, 0x3C, 0x73, 0xFC, 0xF3, 0xCF,
  0xF1, 0xCF, 0x3F, 0xE7, 0xB8, 0xFF, 0x9F, 0xE3, 0xFE, 0x3F, 0x9F, 0xF8,
  0xFC, 0x7F, 0xE3, 0xF1, 0xFF, 0x87, 0xC7, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xF0, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xFF,
  0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0xFF, 0x78, 0x0F, 0xF7, 0x80, 0xFF,
  0x7C, 0x0F, 0xF3, 0xC0, 0xFF, 0x3C, 0x0F, 0xF3, 0xE0, 0xFF, 0x1E, 0x0F,
  0xF1, 0xE0, 0xFF, 0x0F, 0x0F, 0xF8, 0xF0, 0xFF, 0x8F, 0x0F, 0xF8, 0x78,
  0xFF, 0x87, 0x8F, 0xF8, 0x7C, 0xFF, 0x83, 0xCF, 0xF8, 0x3C, 0xFF, 0x83,
  0xEF, 0xF8, 0x1E, 0xFF, 0x81, 0xEF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xF8,
  0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x07, 0xFF,
  0x80, 0x3F, 0x01, 0xF8, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC,
  0x7F, 0xFF, 0xE7, 0xE0, 0x7E, 0xFC, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0xC0, 0x3F, 0x7F, 0x07, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF,
  0xC1, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0xF8, 0x07, 0xFB, 0xE0, 0x07, 0xEF, 0x80,
  0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x1F, 0xBE,
  0x01, 0xFE, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xC0, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC,
  0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFC, 0x0F, 0xE7, 0xE0, 0x1F, 0x9F,
  0x00, 0x3E, 0x7C, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC,
  0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00,
  0x7F, 0xF0, 0x01, 0xF7, 0xC0, 0x07, 0xDF, 0x00, 0x3F, 0x7C, 0x00, 0xF9,
  0xF8, 0x07, 0xE3, 0xF8, 0x3F, 0x8F, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F,
  0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xF8, 0xF8, 0x07, 0xF3, 0xE0, 0x07, 0xEF, 0x80, 0x1F, 0xBE, 0x00,
  0x3E, 0xF8, 0x00, 0xFB, 0xE0, 0x03, 0xEF, 0x80, 0x0F, 0xBE, 0x00, 0x3E,
  0xF8, 0x00, 0xFB, 0xE0, 0x07, 0xEF, 0x80, 0x3F, 0x3F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0xF8, 0x3E,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xE0, 0xF8, 0x0F, 0x83,
  0xE0, 0x3F, 0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xF8, 0xF8, 0x03, 0xE3, 0xE0,
  0x0F, 0xCF, 0x80, 0x1F, 0x3E, 0x00, 0x7E, 0xF8, 0x01, 0xFB, 0xE0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF0, 0xFC, 0x07, 0xE7, 0xE0, 0x0F, 0x9F, 0x00, 0x3F, 0x7C,
  0x00, 0x7D, 0xF0, 0x01, 0xF7, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFF, 0x00,
  0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0xFD, 0xF8, 0x03, 0xE7,
  0xF0, 0x3F, 0x8F, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xF7, 0xF0, 0x7E, 0x7F,
  0xFF, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0x7F, 0xE0, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E,
  0x7E, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C,
  0x3F, 0x00, 0x7C, 0x1F, 0x00, 0x78, 0x1F, 0x00, 0xF8, 0x1F, 0x00, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0,
  0x07, 0xC1, 0xF0, 0x07, 0xC1, 0xE0, 0x07, 0xC3, 0xE0, 0x07, 0xC3, 0xE0,
  0x03, 0xC3, 0xE0, 0x03, 0xE3, 0xC0, 0x03, 0xE7, 0xC0, 0x03, 0xE7, 0xC0,
  0x01, 0xE7, 0xC0, 0x01, 0xF7, 0x80, 0x01, 0xF7, 0x80, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x00, 0xF8, 0x1F, 0x03, 0xFE, 0x07, 0xC0, 0xFF, 0x83, 0xF0,
  0x3F, 0xE0, 0xFC, 0x1F, 0x78, 0x3F, 0x07, 0xDE, 0x0F, 0xC1, 0xF7, 0x83,
  0xF0, 0x79, 0xE0, 0xEC, 0x1E, 0x78, 0x3B, 0x87, 0x9E, 0x0E, 0xE1, 0xE7,
  0xC3, 0x38, 0x79, 0xF1, 0xCE, 0x1E, 0x7C, 0x73, 0x87, 0x9F, 0x1C, 0xE3,
  0xE3, 0xC7, 0x38, 0xF8, 0xF1, 0xCE, 0x3C, 0x3C, 0x71, 0x8F, 0x0F, 0x1C,
  0x73, 0xC3, 0xC6, 0x1C, 0xF0, 0xF3, 0x87, 0x3C, 0x3C, 0xE1, 0xCF, 0x0F,
  0xB8, 0x73, 0xC3, 0xEE, 0x1C, 0xF0, 0x7B, 0x87, 0x3C, 0x1E, 0xE1, 0xDE,
  0x07, 0xB8, 0x37, 0x81, 0xEE, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0,
  0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x0F,
  0xC0, 0xFE, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x1F,
  0x0F, 0x80, 0x1F, 0x87, 0xE0, 0x0F, 0x81, 0xF0, 0x0F, 0x80, 0xFC, 0x0F,
  0xC0, 0x3E, 0x07, 0xC0, 0x1F, 0x87, 0xE0, 0x07, 0xC3, 0xE0, 0x03, 0xF3,
  0xF0, 0x00, 0xF9, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x0F, 0x9F, 0x00, 0x0F, 0xCF, 0xC0, 0x07, 0xC3, 0xE0,
  0x07, 0xE1, 0xF8, 0x03, 0xE0, 0x7C, 0x03, 0xF0, 0x3F, 0x01, 0xF0, 0x0F,
  0xC1, 0xF8, 0x03, 0xE0, 0xF8, 0x01, 0xF8, 0xF8, 0x00, 0x7C, 0xFC, 0x00,
  0x3F, 0x7C, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x0F, 0xDF, 0x00, 0x03, 0xE3,
  0xE0, 0x01, 0xF8, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x3F, 0x07, 0xC0, 0x0F,
  0x80, 0xF8, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0xC0, 0x7C, 0x01, 0xF0,
  0x3E, 0x00, 0x7E, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x03, 0xF1, 0xF0, 0x00,
  0x7C, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x03, 0xEF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xEF, 0x00,
  0x0F, 0x3C, 0x00, 0x3C, 0xF8, 0x01, 0xF1, 0xE0, 0x07, 0x87, 0x80, 0x3E,
  0x0F, 0x00, 0xF0, 0x3C, 0x07, 0xC0, 0xF8, 0x1E, 0x01, 0xE0, 0x78, 0x07,
  0xC3, 0xE0, 0x0F, 0x0F, 0x00, 0x3E, 0x7C, 0x00, 0xFB, 0xE0, 0x01, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x0F, 0x81, 0xF8,
  0x01, 0xFF, 0x00, 0x3F, 0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE3, 0xF0,
  0x3F, 0xBF, 0x00, 0xFD, 0xF0, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x0F, 0xFF, 0xF1, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFD, 0xFC, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xFE, 0x01, 0xFD, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0x3F, 0xFE, 0xF8, 0x7F, 0xC7, 0xC0, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0xFF, 0x07, 0xCF, 0xFC, 0x3E,
  0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xF0, 0xFF, 0x7E, 0x01, 0xFB, 0xF0, 0x07,
  0xDF, 0x00, 0x3E, 0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F,
  0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7D, 0xF8, 0x03, 0xEF, 0xC0,
  0x3F, 0x7F, 0x83, 0xFB, 0xFF, 0xFF, 0x9F, 0x7F, 0xF8, 0xF9, 0xFF, 0xC7,
  0xC7, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xC7, 0xF0, 0x7F, 0x7E, 0x01, 0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xEF, 0xC0, 0x3F, 0x3F, 0x83,
  0xF9, 0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x3F, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x0F, 0xF1, 0xF1, 0xFF,
  0x9F, 0x3F, 0xFD, 0xF7, 0xFF, 0xFF, 0x7F, 0x0F, 0xFF, 0xC0, 0x3F, 0xF8,
  0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x03,
  0xF7, 0xE0, 0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0xDF, 0x1F, 0xFD, 0xF0, 0xFF,
  0x1F, 0x03, 0xFE, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC7,
  0xE0, 0x7E, 0x7E, 0x01, 0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x00,
  0xF7, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x03, 0xEF, 0xC0, 0x1F, 0x3F, 0x01, 0xF9, 0xFF,
  0xFF, 0x87, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x00, 0x1F,
  0xFC, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x01, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xF1, 0xF1, 0xFF,
  0x9F, 0x3F, 0xFD, 0xF7, 0xFF, 0xFF, 0x7F, 0x0F, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xF7, 0xE0, 0xFF, 0x7F, 0xFF,
  0xF3, 0xFF, 0xDF, 0x1F, 0xFD, 0xF0, 0xFF, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x1F,
  0xFF, 0xE1, 0xFF, 0xFE, 0x1F, 0xFF, 0xC1, 0xFF, 0xF0, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0xFF, 0x0F, 0x9F, 0xF8, 0xFB, 0xFF,
  0xCF, 0xFF, 0xFE, 0xFF, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0x00, 0x70,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0,
  0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x7F, 0xFF, 0x9F, 0xFF, 0xE7,
  0xFF, 0xF9, 0xFF, 0xFE, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFF,
  0x3F, 0xFF, 0x8F, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xF0, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0xE0,
  0x03, 0xEF, 0x80, 0x1F, 0xBE, 0x00, 0xFC, 0xF8, 0x03, 0xE3, 0xE0, 0x1F,
  0x8F, 0x80, 0xFC, 0x3E, 0x03, 0xE0, 0xF8, 0x1F, 0x83, 0xE0, 0xFC, 0x0F,
  0x83, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0x3E, 0x0F, 0xC0, 0xF8, 0x1F, 0x83, 0xE0, 0x7E, 0x0F, 0x80, 0xFC,
  0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xE3, 0xE0, 0x0F, 0xCF, 0x80, 0x3F, 0x3E,
  0x00, 0x7E, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xF0, 0xFF, 0xFC, 0x00, 0x7F,
  0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0xF3, 0xE1, 0xF3, 0xDF, 0xCF,
  0xEF, 0xFF, 0x7F, 0xFF, 0x7F, 0xBF, 0xF8, 0x78, 0x7F, 0xC1, 0xE0, 0xFF,
  0x07, 0x83, 0xFC, 0x1E, 0x0F, 0xF0, 0x78, 0x3F, 0xC1, 0xE0, 0xFF, 0x07,
  0x83, 0xFC, 0x1E, 0x0F, 0xF0, 0x78, 0x3F, 0xC1, 0xE0, 0xFF, 0x07, 0x83,
  0xFC, 0x1E, 0x0F, 0xF0, 0x78, 0x3F, 0xC1, 0xE0, 0xFF, 0x07, 0x83, 0xFC,
  0x1E, 0x0F, 0xF0, 0x78, 0x3F, 0xC1, 0xE0, 0xFF, 0x07, 0x83, 0xFC, 0x1E,
  0x0F, 0xF0, 0x78, 0x3F, 0xC1, 0xE0, 0xF0, 0xF8, 0xFF, 0x0F, 0x9F, 0xF8,
  0xFB, 0xFF, 0xCF, 0xFF, 0xFE, 0xFF, 0x0F, 0xFF, 0xC0, 0x3F, 0xFC, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0x03, 0xFE, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC7, 0xF0,
  0xFE, 0x7E, 0x01, 0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x01, 0xF7,
  0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xBE,
  0x00, 0x7D, 0xF0, 0x03, 0xEF, 0xC0, 0x3F, 0x3F, 0x83, 0xF1, 0xFF, 0xFF,
  0x87, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0xF8, 0xFF, 0x07,
  0xCF, 0xFC, 0x3E, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xF0, 0x7F, 0x7F, 0x01,
  0xFB, 0xF0, 0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0xFE,
  0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07,
  0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7D, 0xF8,
  0x03, 0xEF, 0xC0, 0x3F, 0x7F, 0x83, 0xFB, 0xFF, 0xFF, 0x9F, 0x7F, 0xFC,
  0xF9, 0xFF, 0xC7, 0xC7, 0xF8, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0xF1, 0xF1, 0xFF, 0x9F, 0x3F, 0xFD, 0xF7, 0xFF,
  0xFF, 0x7F, 0x0F, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x03, 0xF7, 0xE0, 0xFF, 0x7F, 0xFF,
  0xF3, 0xFF, 0xDF, 0x1F, 0xFD, 0xF0, 0xFF, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0xF8, 0xFF, 0x07, 0xDF, 0xFC, 0x3E, 0xFF, 0xF1,
  0xFF, 0xFF, 0xCF, 0xF0, 0x7F, 0x7E, 0x01, 0xFB, 0xF0, 0x07, 0xDF, 0x00,
  0x3E, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE7,
  0xE0, 0x3F, 0x7E, 0x00, 0xFB, 0xE0, 0x07, 0xFF, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xFC, 0x07,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xFE, 0x01, 0xF9, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF,
  0x80, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFC, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0x7C,
  0x03, 0xF7, 0xF0, 0x7E, 0x3F, 0xFF, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80,
  0x7F, 0xE0, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x3E, 0x7C,
  0x00, 0x3E, 0x3E, 0x00, 0x7E, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x1F,
  0x00, 0x7C, 0x1F, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x07, 0xC1, 0xF0, 0x07, 0xC3, 0xE0, 0x07,
  0xC3, 0xE0, 0x03, 0xE3, 0xE0, 0x03, 0xE7, 0xC0, 0x03, 0xE7, 0xC0, 0x01,
  0xF7, 0xC0, 0x01, 0xF7, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0xF8, 0x1E, 0x03, 0xDE,
  0x07, 0x80, 0xF7, 0x81, 0xF0, 0x7D, 0xE0, 0xFC, 0x1E, 0x78, 0x3F, 0x07,
  0x9E, 0x0F, 0xC1, 0xE7, 0x83, 0xF0, 0x79, 0xF0, 0xEC, 0x1E, 0x3C, 0x33,
  0x87, 0x8F, 0x0C, 0xE3, 0xC3, 0xC7, 0x38, 0xF0, 0xF1, 0xCE, 0x3C, 0x3C,
  0x73, 0x8F, 0x0F, 0x1C, 0x63, 0xC1, 0xE7, 0x18, 0xF0, 0x79, 0x87, 0x38,
  0x1E, 0xE1, 0xDE, 0x07, 0xB8, 0x77, 0x81, 0xEE, 0x1D, 0xE0, 0x7B, 0x87,
  0x78, 0x1E, 0xE0, 0xDE, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x3F,
  0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0x7E, 0x00, 0x3F,
  0x7E, 0x00, 0x7E, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0xF8, 0x0F, 0x81, 0xF8,
  0x0F, 0xC3, 0xF0, 0x07, 0xC3, 0xE0, 0x03, 0xE7, 0xE0, 0x03, 0xF7, 0xC0,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x03, 0xE7, 0xC0, 0x07, 0xE7, 0xE0, 0x0F, 0xC3, 0xF0, 0x0F, 0x81, 0xF0,
  0x1F, 0x81, 0xF8, 0x3F, 0x00, 0xFC, 0x3E, 0x00, 0x7C, 0x7E, 0x00, 0x7E,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0x7C, 0x00, 0x3F, 0x7E, 0x00, 0x3E,
  0x7E, 0x00, 0x7E, 0x3E, 0x00, 0x7C, 0x3F, 0x00, 0x7C, 0x1F, 0x00, 0xFC,
  0x1F, 0x00, 0xF8, 0x1F, 0x80, 0xF8, 0x0F, 0x81, 0xF8, 0x0F, 0xC1, 0xF0,
  0x07, 0xC1, 0xF0, 0x07, 0xC3, 0xF0, 0x07, 0xE3, 0xE0, 0x03, 0xE3, 0xE0,
  0x03, 0xE7, 0xC0, 0x01, 0xF7, 0xC0, 0x01, 0xF7, 0xC0, 0x01, 0xF7, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFF,
  0x00, 0x3F, 0xF0, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x1F, 0xC0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F,
  0xFF, 0x80, 0x03, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0,
  0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7E, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x7E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFF,
  0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x01, 0xFC, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x01, 0xFE, 0x00,
  0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0xFF, 0x00, 0xF7, 0xFE, 0x03, 0xFF, 0xFC, 0x0F, 0xF9, 0xF8, 0x3F,
  0xC3, 0xF0, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFB, 0xC0,
  0x3F, 0xC0, 0x00, 0x18, 0x00,
};

const GFXglyph JetBrainsMono_Medium47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 28, 0, -1 },
  { 1, 8, 34, 28, 10, -34 },
  { 35, 16, 14, 28, 6, -34 },
  { 63, 26, 34, 28, 1, -34 },
  { 174, 22, 48, 28, 3, -41 },
  { 306, 28, 35, 28, 0, -35 },
  { 429, 25, 35, 28, 2, -35 },
  { 539, 6, 14, 28, 11, -34 },
  { 550, 15, 45, 28, 8, -39 },
  { 635, 15, 45, 28, 5, -39 },
  { 720, 25, 25, 28, 2, -29 },
  { 799, 22, 23, 28, 3, -27 },
  { 863, 11, 15, 28, 7, -7 },
  { 884, 15, 5, 28, 7, -18 },
  { 894, 8, 8, 28, 10, -8 },
  { 902, 22, 44, 28, 3, -39 },
  { 1023, 22, 35, 28, 3, -35 },
  { 1120, 22, 34, 28, 4, -34 },
  { 1214, 22, 35, 28, 3, -35 },
  { 1311, 21, 34, 28, 3, -34 },
  { 1401, 21, 34, 28, 3, -34 },
  { 1491, 21, 34, 28, 4, -34 },
  { 1581, 22, 34, 28, 3, -34 },
  { 1675, 22, 34, 28, 3, -34 },
  { 1769, 22, 35, 28, 3, -35 },
  { 1866, 22, 35, 28, 3, -35 },
  { 1963, 8, 26, 28, 10, -26 },
  { 1989, 10, 34, 28, 8, -26 },
  { 2032, 20, 25, 28, 4, -28 },
  { 2095, 20, 16, 28, 4, -24 },
  { 2135, 20, 25, 28, 4, -28 },
  { 2198, 17, 34, 28, 6, -34 },
  { 2271, 25, 43, 28, 2, -35 },
  { 2406, 24, 34, 28, 2, -34 },
  { 2508, 21, 34, 28, 4, -34 },
  { 2598, 21, 35, 28, 4, -35 },
  { 2690, 21, 34, 28, 4, -34 },
  { 2780, 21, 34, 28, 4, -34 },
  { 2870, 21, 34, 28, 4, -34 },
  { 2960, 21, 35, 28, 4, -35 },
  { 3052, 20, 34, 28, 4, -34 },
  { 3137, 19, 34, 28, 5, -34 },
  { 3218, 22, 34, 28, 2, -34 },
  { 3312, 23, 34, 28, 4, -34 },
  { 3410, 20, 34, 28, 5, -34 },
  { 3495, 22, 34, 28, 3, -34 },
  { 3589, 20, 34, 28, 4, -34 },
  { 3674, 20, 35, 28, 4, -35 },
  { 3762, 22, 34, 28, 4, -34 },
  { 3856, 22, 43, 28, 3, -35 },
  { 3975, 22, 34, 28, 4, -34 },
  { 4069, 22, 35, 28, 3, -35 },
  { 4166, 24, 34, 28, 2, -34 },
  { 4268, 20, 34, 28, 4, -34 },
  { 4353, 24, 34, 28, 2, -34 },
  { 4455, 26, 34, 28, 1, -34 },
  { 4566, 25, 34, 28, 2, -34 },
  { 4673, 26, 34, 28, 1, -34 },
  { 4784, 20, 34, 28, 4, -34 },
  { 4869, 12, 44, 28, 9, -39 },
  { 4935, 22, 44, 28, 3, -39 },
  { 5056, 12, 44, 28, 7, -39 },
  { 5122, 22, 18, 28, 3, -34 },
  { 5172, 22, 5, 28, 3, 1 },
  { 5186, 11, 7, 28, 8, -37 },
  { 5196, 21, 26, 28, 3, -26 },
  { 5265, 21, 34, 28, 4, -34 },
  { 5355, 21, 26, 28, 4, -26 },
  { 5424, 20, 34, 28, 4, -34 },
  { 5509, 21, 26, 28, 4, -26 },
  { 5578, 22, 34, 28, 3, -34 },
  { 5672, 20, 34, 28, 4, -26 },
  { 5757, 20, 34, 28, 4, -34 },
  { 5842, 22, 37, 28, 4, -37 },
  { 5944, 18, 45, 28, 4, -37 },
  { 6046, 22, 34, 28, 4, -34 },
  { 6140, 25, 34, 28, 1, -34 },
  { 6247, 22, 26, 28, 3, -26 },
  { 6319, 20, 26, 28, 4, -26 },
  { 6384, 21, 26, 28, 4, -26 },
  { 6453, 21, 34, 28, 4, -26 },
  { 6543, 20, 34, 28, 4, -26 },
  { 6628, 21, 26, 28, 5, -26 },
  { 6697, 21, 26, 28, 4, -26 },
  { 6766, 23, 33, 28, 2, -33 },
  { 6861, 20, 26, 28, 4, -26 },
  { 6926, 24, 26, 28, 2, -26 },
  { 7004, 26, 26, 28, 1, -26 },
  { 7089, 24, 26, 28, 2, -26 },
  { 7167, 24, 34, 28, 2, -26 },
  { 7269, 20, 26, 28, 4, -26 },
  { 7334, 20, 44, 28, 4, -39 },
  { 7444, 5, 44, 28, 12, -39 },
  { 7472, 20, 44, 28, 4, -39 },
  { 7582, 22, 11, 28, 3, -22 },
};

const GFXfont JetBrainsMono_Medium47pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Medium47pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Medium47pt7bGlyphs,
  0x20, 0x7E, 62
};

#endif // _JETBRAINSMONO_MEDIUM47PT7B_H_
