#ifndef _JETBRAINSMONO_MEDIUM59PT7B_H_
#define _JETBRAINSMONO_MEDIUM59PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Medium.ttf
// Size: 59pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Medium59pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F,
  0x9F, 0xCF, 0xE7, 0xF3, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3,
  0xF1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xDF, 0xC0, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF,
  0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF,
  0xC0, 0xFF, 0xF8, 0x1F, 0xFE, 0x03, 0xF7, 0xC0, 0x7E, 0xF8, 0x0F, 0xDF,
  0x01, 0xFB, 0xE0, 0x3F, 0x7C, 0x07, 0xEF, 0x80, 0xFC, 0x00, 0x3E, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x3E, 0x01,
  0xF0, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x7C, 0x01,
  0xF0, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x78, 0x03,
  0xE0, 0x00, 0x78, 0x03, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFF, 0x01, 0xF0, 0x07, 0xC0, 0x01, 0xF0, 0x07, 0xC0, 0x01, 0xF0, 0x07,
  0x80, 0x01, 0xF0, 0x0F, 0x80, 0x01, 0xE0, 0x0F, 0x80, 0x01, 0xE0, 0x0F,
  0x80, 0x03, 0xE0, 0x0F, 0x80, 0x03, 0xE0, 0x0F, 0x80, 0x03, 0xE0, 0x0F,
  0x00, 0x03, 0xE0, 0x1F, 0x00, 0x03, 0xC0, 0x1F, 0x00, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x80, 0x3E, 0x00, 0x0F, 0x80, 0x3E,
  0x00, 0x0F, 0x80, 0x3E, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x0F, 0x80, 0x7C,
  0x00, 0x0F, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x78, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x83, 0xFE,
  0xF7, 0xFC, 0x3F, 0x8F, 0x1F, 0xC7, 0xF0, 0xF0, 0xFE, 0x7F, 0x0F, 0x0F,
  0xE7, 0xE0, 0xF0, 0xFE, 0x7E, 0x0F, 0x07, 0xE7, 0xE0, 0xF0, 0x00, 0x7E,
  0x0F, 0x00, 0x07, 0xF0, 0xF0, 0x00, 0x7F, 0x0F, 0x00, 0x03, 0xF8, 0xF0,
  0x00, 0x3F, 0xCF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xF7, 0xFC,
  0x00, 0x0F, 0x1F, 0xE0, 0x00, 0xF0, 0xFE, 0x00, 0x0F, 0x0F, 0xE0, 0x00,
  0xF0, 0x7E, 0x00, 0x0F, 0x07, 0xF0, 0x00, 0xF0, 0x7F, 0xFC, 0x0F, 0x07,
  0xFF, 0xC0, 0xF0, 0x7E, 0xFE, 0x0F, 0x07, 0xEF, 0xE0, 0xF0, 0xFE, 0x7F,
  0x8F, 0x1F, 0xE7, 0xFE, 0xF7, 0xFC, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xE3, 0xFF, 0xC0, 0x00,
  0xF8, 0xFF, 0xFC, 0x00, 0x3E, 0x1F, 0xFF, 0xC0, 0x07, 0xC7, 0xE1, 0xF8,
  0x01, 0xF0, 0xF8, 0x1F, 0x00, 0x7C, 0x1F, 0x01, 0xF0, 0x0F, 0x83, 0xE0,
  0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x1E, 0x01,
  0xF0, 0x1F, 0x07, 0xC0, 0x3E, 0x03, 0xE1, 0xF0, 0x07, 0xC0, 0x7C, 0x7C,
  0x00, 0xF8, 0x1F, 0x0F, 0x80, 0x1F, 0x83, 0xE3, 0xE0, 0x01, 0xFF, 0xFC,
  0xF8, 0x00, 0x3F, 0xFF, 0x1F, 0x00, 0x03, 0xFF, 0xC7, 0xC0, 0x00, 0x1F,
  0xF1, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x07, 0xC3, 0xFE, 0x00, 0x01, 0xF1, 0xFF, 0xE0, 0x00, 0x3E,
  0x7F, 0xFE, 0x00, 0x0F, 0x8F, 0xFF, 0xE0, 0x03, 0xE3, 0xF0, 0x7C, 0x00,
  0x7C, 0x7C, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0xF8, 0x07, 0xC1, 0xF0, 0x1F,
  0x00, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xF8,
  0x0F, 0x83, 0xE0, 0x1F, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0x3E, 0x1F, 0x00,
  0x7C, 0x0F, 0x87, 0xC0, 0x0F, 0xC3, 0xF0, 0xF8, 0x00, 0xFF, 0xFE, 0x3E,
  0x00, 0x1F, 0xFF, 0x8F, 0x80, 0x01, 0xFF, 0xE3, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0,
  0x07, 0xF8, 0x1F, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x80,
  0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xBF, 0x80, 0x7E, 0xFE, 0x3F,
  0x81, 0xF9, 0xF8, 0x3F, 0x03, 0xF3, 0xF0, 0x7F, 0x0F, 0xC7, 0xE0, 0x7F,
  0x3F, 0x8F, 0xC0, 0x7F, 0x7E, 0x1F, 0x80, 0x7F, 0xFC, 0x3F, 0x00, 0xFF,
  0xF0, 0x7E, 0x00, 0xFF, 0xE0, 0xFC, 0x00, 0xFF, 0x81, 0xF8, 0x01, 0xFF,
  0x03, 0xF0, 0x01, 0xFC, 0x07, 0xE0, 0x03, 0xFC, 0x0F, 0xE0, 0x0F, 0xF8,
  0x1F, 0xC0, 0x3F, 0xF8, 0x1F, 0xC0, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF7, 0xF0, 0x7F, 0xFF, 0xC7, 0xF0, 0x7F, 0xFE, 0x07, 0xF0,
  0x3F, 0xF8, 0x07, 0xF0, 0x06, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0x9F, 0x3E, 0x7C, 0xF8,
  0x00, 0x00, 0x20, 0x00, 0x3C, 0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x03, 0xFE,
  0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0xF8, 0x07, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07,
  0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x03, 0xF8, 0x00,
  0x1F, 0x00, 0x00, 0x60, 0x80, 0x00, 0x38, 0x00, 0x0F, 0x80, 0x03, 0xF8,
  0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0,
  0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xFE, 0x07, 0xFF, 0x03, 0xFF,
  0x80, 0xFF, 0xC0, 0x3F, 0xC0, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x30, 0x07, 0xC0, 0x0C,
  0xF8, 0x0F, 0x80, 0xF9, 0xFE, 0x0F, 0x07, 0xF3, 0xFE, 0x1E, 0x3F, 0xFF,
  0xFF, 0x38, 0xFF, 0xFF, 0xFF, 0x77, 0xFF, 0xC7, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3B, 0xC0, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x1F,
  0x8F, 0xC0, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xF8,
  0x3F, 0x80, 0x0F, 0xE0, 0x3F, 0x80, 0x1F, 0xC0, 0x7F, 0x80, 0x7F, 0x00,
  0x7F, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x38, 0x00, 0x60, 0x00, 0x20, 0x00,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xFC, 0x1F, 0xE0, 0xFF, 0x83, 0xFC, 0x0F, 0xF0, 0x3F, 0x81,
  0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x00,
  0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1E, 0x1F, 0xCF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xC1, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0x0F, 0xF0, 0x1F, 0xE3, 0xFC, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xCF,
  0xC0, 0x01, 0xFD, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x0F, 0x83,
  0xFF, 0xC3, 0xF8, 0x7F, 0xF8, 0x7F, 0x0F, 0xFF, 0x0F, 0xE1, 0xFF, 0xE1,
  0xFC, 0x3F, 0xFC, 0x1F, 0x87, 0xFF, 0x81, 0xE0, 0xFF, 0xF0, 0x00, 0x1F,
  0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFD,
  0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xF7, 0xF0, 0x01, 0xFC, 0xFF, 0x00,
  0x3F, 0x8F, 0xF0, 0x1F, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xF3, 0xF0,
  0x07, 0xFC, 0x7E, 0x00, 0xFF, 0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x03, 0xE0,
  0x3F, 0x00, 0x70, 0x07, 0xE0, 0x0C, 0x00, 0xFC, 0x01, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x0F,
  0xF8, 0x3F, 0xE3, 0xFC, 0x01, 0xFE, 0x7F, 0x00, 0x1F, 0xDF, 0xC0, 0x01,
  0xFB, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF,
  0x80, 0x01, 0xFB, 0xF8, 0x00, 0x3F, 0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x03,
  0xFC, 0xFF, 0x80, 0xFF, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0xFC, 0x3F, 0x80, 0x3F, 0x1F, 0xC0, 0x0F, 0xCF, 0xF0, 0x03,
  0xF3, 0xF8, 0x00, 0xFD, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x7F, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xC7, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0xFF,
  0x80, 0x7E, 0x7F, 0xF8, 0x1F, 0xBF, 0xFF, 0x07, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFC, 0x7F, 0xC0, 0xFF, 0xBF, 0xC0, 0x1F, 0xEF, 0xE0, 0x03, 0xFB,
  0xF8, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF,
  0xC0, 0x01, 0xFB, 0xF8, 0x00, 0xFE, 0xFF, 0x00, 0x7F, 0x9F, 0xF0, 0x3F,
  0xC7, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE1, 0x80, 0x01, 0xFC, 0xFF, 0x80, 0x3F,
  0xBF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0x1F,
  0xFC, 0x7F, 0x80, 0x3F, 0xCF, 0xF0, 0x01, 0xFE, 0xFE, 0x00, 0x0F, 0xEF,
  0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F,
  0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7E, 0xFE, 0x00, 0x0F, 0xE7, 0xF0,
  0x00, 0xFE, 0x7F, 0x80, 0x1F, 0xC3, 0xFC, 0x07, 0xFC, 0x3F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x60, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7E, 0xFC, 0x00,
  0x0F, 0xEF, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0xCF, 0xC0, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x0F, 0xF0, 0x1F,
  0xE1, 0xFC, 0x01, 0xFE, 0x7F, 0x00, 0x1F, 0xCF, 0xE0, 0x01, 0xF9, 0xF8,
  0x00, 0x3F, 0x3F, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0xFC, 0xFE, 0x00, 0x1F,
  0x9F, 0xC0, 0x07, 0xF1, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x83, 0xF8,
  0x0F, 0xE0, 0x3F, 0xC7, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80,
  0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFB,
  0xFE, 0x03, 0xFC, 0x1F, 0xE0, 0xFF, 0x00, 0xFE, 0x1F, 0x80, 0x0F, 0xE7,
  0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00,
  0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0x00, 0x07, 0xF7, 0xF0, 0x00, 0xFE, 0xFF, 0x00, 0x3F, 0x9F, 0xF0, 0x1F,
  0xF1, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0x60, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x3F, 0xC0, 0x7F, 0xC7, 0xF8, 0x01,
  0xFC, 0x7F, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0xFE, 0x7F, 0x00, 0x1F, 0xE7, 0xFC,
  0x03, 0xFE, 0x3F, 0xF9, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xDF,
  0x80, 0xFF, 0xFB, 0xF8, 0x03, 0xFF, 0x7F, 0x00, 0x01, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3E, 0x1F, 0xEF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x1F, 0xCF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F,
  0x06, 0x00, 0x07, 0xE0, 0x7F, 0x87, 0xFC, 0x3F, 0xF3, 0xFF, 0x8F, 0xFC,
  0x7F, 0xE3, 0xFE, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x7F, 0x83, 0xFC, 0x3F, 0xC1,
  0xFE, 0x0F, 0xF0, 0x7F, 0x07, 0xF8, 0x3F, 0x81, 0xFC, 0x0F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xF0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x01, 0xFF,
  0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFE, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xFC, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF,
  0xE0, 0x3F, 0xFE, 0x01, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0xFE, 0x0F,
  0xC0, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0xFD, 0xF8,
  0x00, 0x01, 0xFB, 0xF0, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x03, 0xEF, 0x80,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x3E, 0x1F, 0xFC, 0x01,
  0xFF, 0x3F, 0xF8, 0x07, 0xFF, 0x7F, 0xF0, 0x1F, 0xFF, 0x7F, 0xE0, 0x3F,
  0xCF, 0xFF, 0xC0, 0xFC, 0x07, 0xFF, 0x81, 0xF8, 0x0F, 0xFF, 0x03, 0xE0,
  0x0F, 0xFE, 0x07, 0xC0, 0x1F, 0xFC, 0x0F, 0x80, 0x3F, 0xF8, 0x1F, 0x00,
  0x7F, 0xF0, 0x3E, 0x00, 0xFF, 0xE0, 0x7C, 0x01, 0xFF, 0xC0, 0xF8, 0x03,
  0xFF, 0x81, 0xF0, 0x07, 0xFF, 0x03, 0xE0, 0x0F, 0xFE, 0x07, 0xC0, 0x1F,
  0xFC, 0x0F, 0x80, 0x3F, 0xF8, 0x1F, 0x00, 0x7F, 0xF0, 0x3F, 0x01, 0xFF,
  0xE0, 0x7E, 0x03, 0xFF, 0xC0, 0x7F, 0xBF, 0xFF, 0x80, 0xFF, 0xFB, 0xFF,
  0x00, 0xFF, 0xE7, 0xFE, 0x00, 0xFF, 0x8F, 0xFC, 0x00, 0x78, 0x20, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x1F, 0x7E, 0x00,
  0x00, 0xFD, 0xF8, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x0F, 0xCF, 0xC0, 0x00,
  0x3E, 0x3F, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x1F,
  0x87, 0xE0, 0x00, 0x7C, 0x1F, 0x80, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0x3F,
  0x00, 0x1F, 0x80, 0xFC, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF8, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x07,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0x80, 0x07, 0xE0, 0xFC, 0x00,
  0x1F, 0x83, 0xF0, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0xFC, 0x7F, 0x00, 0x03,
  0xF1, 0xF8, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x7E,
  0xFE, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x1F, 0xC0,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xF1, 0xF8, 0x0F, 0xFE, 0x3F, 0x00, 0x1F, 0xE7,
  0xE0, 0x01, 0xFC, 0xFC, 0x00, 0x1F, 0xDF, 0x80, 0x03, 0xFB, 0xF0, 0x00,
  0x7F, 0x7E, 0x00, 0x0F, 0xEF, 0xC0, 0x01, 0xFD, 0xF8, 0x00, 0x3F, 0xBF,
  0x00, 0x07, 0xE7, 0xE0, 0x01, 0xFC, 0xFC, 0x00, 0x7F, 0x1F, 0x80, 0x1F,
  0xE3, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x87, 0xE0, 0x0F, 0xF8, 0xFC, 0x00, 0x7F,
  0x9F, 0x80, 0x03, 0xFB, 0xF0, 0x00, 0x7F, 0x7E, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F,
  0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0x7E, 0x00,
  0x0F, 0xEF, 0xC0, 0x07, 0xFD, 0xF8, 0x0F, 0xFF, 0x3F, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0x80,
  0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC7, 0xFC, 0x0F,
  0xF9, 0xFC, 0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xBF, 0x80, 0x07, 0xFF, 0xC0,
  0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x3F, 0x9F, 0xC0, 0x0F, 0xE7, 0xFC, 0x0F, 0xF8, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xCF, 0xC0, 0x0F, 0xF3, 0xF0, 0x01, 0xFE, 0xFC, 0x00, 0x3F, 0xBF, 0x00,
  0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00,
  0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xEF, 0xC0, 0x03, 0xFB, 0xF0,
  0x01, 0xFE, 0xFC, 0x00, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xF9, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xBF, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC7, 0xFC, 0x0F, 0xF9, 0xFC,
  0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xBF, 0x80, 0x07, 0xFF, 0xC0, 0x01, 0xFF,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x3F,
  0x9F, 0xC0, 0x0F, 0xE7, 0xFC, 0x0F, 0xF8, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00,
  0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00,
  0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0,
  0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F,
  0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00,
  0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0,
  0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x7E, 0x7E, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0xFE, 0x7F, 0x80, 0x1F,
  0xC3, 0xFE, 0x07, 0xFC, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x60,
  0x00, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFE, 0xFC, 0x00, 0x0F, 0xEF,
  0xC0, 0x01, 0xFC, 0xFC, 0x00, 0x1F, 0xCF, 0xC0, 0x03, 0xF8, 0xFC, 0x00,
  0x3F, 0x8F, 0xC0, 0x07, 0xF0, 0xFC, 0x00, 0x7F, 0x0F, 0xC0, 0x0F, 0xE0,
  0xFC, 0x00, 0xFE, 0x0F, 0xC0, 0x1F, 0xC0, 0xFC, 0x01, 0xFC, 0x0F, 0xC0,
  0x3F, 0x80, 0xFC, 0x03, 0xF8, 0x0F, 0xC0, 0x7F, 0x00, 0xFC, 0x07, 0xF0,
  0x0F, 0xC0, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE,
  0x00, 0xFC, 0x0F, 0xF0, 0x0F, 0xC0, 0x7F, 0x00, 0xFC, 0x07, 0xF0, 0x0F,
  0xC0, 0x3F, 0x80, 0xFC, 0x03, 0xF8, 0x0F, 0xC0, 0x1F, 0xC0, 0xFC, 0x01,
  0xFC, 0x0F, 0xC0, 0x0F, 0xE0, 0xFC, 0x00, 0xFE, 0x0F, 0xC0, 0x07, 0xF0,
  0xFC, 0x00, 0x7F, 0x0F, 0xC0, 0x03, 0xF8, 0xFC, 0x00, 0x3F, 0x8F, 0xC0,
  0x01, 0xFC, 0xFC, 0x00, 0x1F, 0xCF, 0xC0, 0x01, 0xFE, 0xFC, 0x00, 0x0F,
  0xEF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xF7, 0x80, 0x3F, 0xFF, 0x78, 0x03,
  0xFF, 0xFF, 0xC0, 0x3D, 0xFF, 0xFC, 0x07, 0xDF, 0xFB, 0xC0, 0x7D, 0xFF,
  0xBE, 0x07, 0x9F, 0xFB, 0xE0, 0xFB, 0xFF, 0x9E, 0x0F, 0xBF, 0xF9, 0xF0,
  0xF3, 0xFF, 0x9F, 0x0F, 0x3F, 0xF8, 0xF1, 0xF3, 0xFF, 0x8F, 0x9F, 0x3F,
  0xF8, 0xF9, 0xE3, 0xFF, 0x87, 0xBE, 0x3F, 0xFC, 0x7B, 0xE3, 0xFF, 0xC7,
  0xFC, 0x3F, 0xFC, 0x3F, 0xC3, 0xFF, 0xC3, 0xFC, 0x3F, 0xFC, 0x3F, 0x83,
  0xFF, 0xC3, 0xF8, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F,
  0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xF0, 0xFF,
  0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00,
  0x3F, 0xFB, 0xE0, 0x0F, 0xFE, 0xF8, 0x03, 0xFF, 0xBF, 0x00, 0xFF, 0xE7,
  0xC0, 0x3F, 0xF9, 0xF0, 0x0F, 0xFE, 0x7E, 0x03, 0xFF, 0xCF, 0x80, 0xFF,
  0xF3, 0xE0, 0x3F, 0xFC, 0xFC, 0x0F, 0xFF, 0x1F, 0x03, 0xFF, 0xC7, 0xC0,
  0xFF, 0xF1, 0xF8, 0x3F, 0xFC, 0x3E, 0x0F, 0xFF, 0x0F, 0x83, 0xFF, 0xC3,
  0xF0, 0xFF, 0xF0, 0x7C, 0x3F, 0xFC, 0x1F, 0x0F, 0xFF, 0x07, 0xE3, 0xFF,
  0xC0, 0xF8, 0xFF, 0xF0, 0x3E, 0x3F, 0xFC, 0x07, 0xCF, 0xFF, 0x01, 0xF3,
  0xFF, 0xC0, 0x7E, 0xFF, 0xF0, 0x0F, 0xBF, 0xFC, 0x03, 0xEF, 0xFF, 0x00,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x1C, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xC7, 0xFC, 0x0F, 0xF1, 0xFC, 0x01, 0xFE, 0xFE, 0x00, 0x3F,
  0xBF, 0x80, 0x07, 0xEF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00,
  0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC,
  0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F,
  0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00,
  0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0,
  0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF,
  0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01,
  0xFF, 0xF8, 0x00, 0x7E, 0xFE, 0x00, 0x3F, 0x9F, 0xC0, 0x1F, 0xE7, 0xFC,
  0x1F, 0xF0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0xFC, 0x00, 0x3F, 0xCF, 0xC0,
  0x01, 0xFE, 0xFC, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0xFE, 0xFC, 0x00, 0x1F, 0xEF, 0xC0, 0x07, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xF8, 0x3F, 0xE0, 0x7F, 0x87, 0xF8, 0x03, 0xFC, 0x7F, 0x00, 0x1F,
  0xC7, 0xE0, 0x00, 0xFE, 0x7E, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x7E, 0xFE,
  0x00, 0x07, 0xEF, 0xE0, 0x00, 0x7E, 0xFE, 0x00, 0x07, 0xEF, 0xE0, 0x00,
  0x7E, 0xFE, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x7E, 0xFE, 0x00, 0x07, 0xEF,
  0xE0, 0x00, 0x7E, 0xFE, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x7E, 0xFE, 0x00,
  0x07, 0xEF, 0xE0, 0x00, 0x7E, 0xFE, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x7E,
  0xFE, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x7E, 0xFE, 0x00, 0x07, 0xEF, 0xE0,
  0x00, 0x7E, 0xFE, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x7E, 0xFE, 0x00, 0x07,
  0xEF, 0xE0, 0x00, 0xFE, 0x7E, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0xFE, 0x7F,
  0x00, 0x1F, 0xC7, 0xF8, 0x03, 0xFC, 0x3F, 0xE0, 0x7F, 0x81, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xF8, 0xFC, 0x00, 0x7F, 0xCF, 0xC0, 0x01, 0xFC, 0xFC, 0x00,
  0x1F, 0xCF, 0xC0, 0x00, 0xFE, 0xFC, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0xFE,
  0xFC, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0xFE, 0xFC, 0x00, 0x0F, 0xEF, 0xC0,
  0x00, 0xFE, 0xFC, 0x00, 0x1F, 0xCF, 0xC0, 0x01, 0xFC, 0xFC, 0x00, 0x3F,
  0xCF, 0xC0, 0x1F, 0xF8, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x0F, 0xC0, 0xFE,
  0x00, 0xFC, 0x07, 0xF0, 0x0F, 0xC0, 0x7F, 0x00, 0xFC, 0x03, 0xF8, 0x0F,
  0xC0, 0x3F, 0x80, 0xFC, 0x01, 0xFC, 0x0F, 0xC0, 0x1F, 0xC0, 0xFC, 0x00,
  0xFE, 0x0F, 0xC0, 0x0F, 0xE0, 0xFC, 0x00, 0xFE, 0x0F, 0xC0, 0x07, 0xF0,
  0xFC, 0x00, 0x7F, 0x0F, 0xC0, 0x03, 0xF8, 0xFC, 0x00, 0x3F, 0x8F, 0xC0,
  0x01, 0xFC, 0xFC, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0xFE, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x3F, 0xE0,
  0x7F, 0xC3, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0xFE,
  0x7E, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F,
  0xFC, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x7E, 0xFE, 0x00, 0x0F, 0xE7, 0xF8,
  0x01, 0xFE, 0x7F, 0xE0, 0x7F, 0xC3, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x16, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01,
  0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0,
  0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF,
  0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07,
  0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00,
  0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF,
  0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F,
  0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00,
  0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC,
  0x00, 0x1F, 0xFF, 0x00, 0x07, 0xEF, 0xE0, 0x01, 0xFB, 0xF8, 0x00, 0xFE,
  0x7F, 0x00, 0x7F, 0x9F, 0xF0, 0x3F, 0xC3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x70, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xEF, 0xE0, 0x00,
  0x1F, 0xBF, 0x80, 0x00, 0x7E, 0x7E, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x0F,
  0xC7, 0xF0, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xF0,
  0xFC, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x7E, 0x0F, 0xE0, 0x01, 0xF8, 0x1F,
  0x80, 0x0F, 0xE0, 0x7E, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0xFC, 0x07, 0xF0,
  0x03, 0xF0, 0x0F, 0xC0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xFE, 0x01,
  0xF8, 0x03, 0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x1F, 0x80, 0x1F, 0x80, 0xFC,
  0x00, 0x7F, 0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7E, 0x1F, 0x80, 0x01,
  0xF8, 0x7E, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x3F,
  0x3F, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x0F, 0xDF,
  0x80, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xFE, 0x01, 0xF8, 0x0F, 0xDF, 0x00, 0xFC, 0x07, 0xEF, 0x80, 0xFE, 0x03,
  0xF7, 0xC0, 0x7F, 0x01, 0xFB, 0xE0, 0x3F, 0x80, 0xFD, 0xF8, 0x1F, 0xE0,
  0x7C, 0xFC, 0x0E, 0xF0, 0x3E, 0x7E, 0x07, 0x78, 0x1F, 0x3F, 0x03, 0xBC,
  0x0F, 0x9F, 0x81, 0xDE, 0x07, 0xCF, 0xC1, 0xEF, 0x07, 0xE3, 0xE0, 0xF3,
  0x83, 0xF1, 0xF0, 0x79, 0xC1, 0xF8, 0xF8, 0x3C, 0xE0, 0xFC, 0x7C, 0x1E,
  0x78, 0x7C, 0x3F, 0x0E, 0x3C, 0x3E, 0x1F, 0x87, 0x1E, 0x1F, 0x0F, 0xC3,
  0x8F, 0x0F, 0x87, 0xE1, 0xC7, 0x87, 0xC3, 0xF1, 0xE3, 0xC3, 0xE0, 0xF8,
  0xF0, 0xE1, 0xF0, 0x7C, 0x78, 0x71, 0xF8, 0x3E, 0x3C, 0x38, 0xFC, 0x1F,
  0x1E, 0x1E, 0x7C, 0x0F, 0x8E, 0x0F, 0x3E, 0x07, 0xC7, 0x07, 0x9F, 0x03,
  0xF3, 0x83, 0xCF, 0x81, 0xFB, 0xC1, 0xE7, 0xC0, 0xFD, 0xE0, 0xF3, 0xE0,
  0x3E, 0xF0, 0x39, 0xF0, 0x1F, 0x78, 0x1C, 0xF8, 0x0F, 0xBC, 0x0E, 0xFC,
  0x07, 0xDC, 0x07, 0xFC, 0x03, 0xEE, 0x03, 0xFE, 0x01, 0xF7, 0x01, 0xFF,
  0x00, 0xFB, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F,
  0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x03,
  0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x7F, 0x00,
  0x03, 0xF8, 0xFE, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xC1, 0xFC, 0x00,
  0x7F, 0x01, 0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x07,
  0xF0, 0x07, 0xF0, 0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0x00, 0x0F, 0xE0, 0xFE,
  0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x1F, 0xCF, 0xC0,
  0x00, 0x1F, 0xBF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01,
  0xFB, 0xF0, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x3F,
  0x8F, 0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF8,
  0x1F, 0xC0, 0x0F, 0xE0, 0x3F, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0x7F, 0x00,
  0x7F, 0x00, 0xFC, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x00,
  0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x7F, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0xFE, 0x7F, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x01,
  0xFC, 0x3F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF8, 0x1F, 0xC0, 0x03,
  0xF0, 0x0F, 0xC0, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F,
  0xE0, 0x07, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0xC0, 0x03, 0xF8, 0x1F,
  0x80, 0x01, 0xF8, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x7F,
  0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0x7E, 0xFC,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x3E, 0xFC, 0x00, 0x0F, 0xCF, 0x80, 0x01, 0xF1, 0xF8, 0x00, 0x7E, 0x1F,
  0x00, 0x0F, 0xC3, 0xE0, 0x01, 0xF0, 0x7E, 0x00, 0x7E, 0x07, 0xC0, 0x0F,
  0x80, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x7C, 0x01, 0xF8, 0x1F, 0x80, 0x3F,
  0x03, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x07, 0xE7, 0xE0,
  0x00, 0xFC, 0xFC, 0x00, 0x0F, 0xBF, 0x00, 0x01, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFE, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x7F, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xF8, 0x7F, 0xE3, 0xFF, 0x0F, 0xE0, 0x0F, 0xF1, 0xF8, 0x00, 0xFE, 0x7F,
  0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x7F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFD, 0xFF, 0x00, 0x3F,
  0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xF7, 0xFE, 0x3F, 0xFE, 0xFF, 0xFF,
  0xDF, 0xCF, 0xFF, 0xFB, 0xF8, 0xFF, 0xFE, 0x7F, 0x07, 0xFF, 0x0F, 0xE0,
  0x1E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC1, 0xFE, 0x03, 0xF1, 0xFF, 0xE0, 0xFC, 0xFF, 0xFC, 0x3F, 0x3F, 0xFF,
  0x8F, 0xDF, 0xFF, 0xF3, 0xF7, 0xFF, 0xFC, 0xFF, 0x80, 0x7F, 0xBF, 0xC0,
  0x0F, 0xEF, 0xE0, 0x01, 0xFB, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF,
  0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F,
  0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00,
  0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC,
  0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0xFE,
  0xFF, 0x00, 0x7F, 0xBF, 0xF0, 0x3F, 0xEF, 0xDF, 0xFF, 0xF3, 0xF7, 0xFF,
  0xFC, 0xFC, 0xFF, 0xFE, 0x3F, 0x1F, 0xFF, 0x0F, 0xC3, 0xFF, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xC7, 0xF8, 0x07,
  0xFB, 0xFC, 0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x07, 0xF7, 0xF0, 0x03, 0xF9, 0xFF, 0x03, 0xFE, 0x3F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x01, 0xFF,
  0xE0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x7F, 0x07, 0xE0, 0xFF, 0xE3, 0xF1, 0xFF, 0xF9, 0xF9, 0xFF, 0xFE,
  0xFC, 0xFF, 0xFF, 0x7E, 0xFF, 0xFF, 0xFF, 0x7F, 0x80, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0,
  0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F,
  0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x07,
  0xFB, 0xFE, 0x0F, 0xFD, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xBF, 0x1F, 0xFF,
  0xDF, 0x87, 0xFF, 0xCF, 0xC1, 0xFF, 0x87, 0xE0, 0x0E, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFE, 0x1F, 0xF0, 0x3F, 0xC7, 0xF0, 0x07, 0xFB, 0xF8, 0x00,
  0xFE, 0xFE, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xE7,
  0xF0, 0x03, 0xF9, 0xFE, 0x01, 0xFE, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFF, 0x8F, 0xC7, 0xFF, 0xE7, 0xE7,
  0xFF, 0xFB, 0xF3, 0xFF, 0xFD, 0xFB, 0xFF, 0xFF, 0xFD, 0xFE, 0x03, 0xFF,
  0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x07,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00,
  0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00,
  0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0x7F, 0x80, 0xFF, 0xBF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xF7, 0xE7, 0xFF, 0xFB, 0xF1, 0xFF, 0xF9, 0xF8, 0x3F, 0xF8, 0xFC,
  0x07, 0xF0, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFE, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC1, 0xFE, 0x03, 0xF1, 0xFF, 0xE0, 0xFC,
  0xFF, 0xFC, 0x3F, 0x7F, 0xFF, 0x8F, 0xDF, 0xFF, 0xF3, 0xF7, 0xDF, 0xFC,
  0xFF, 0x80, 0x7F, 0xBF, 0xC0, 0x0F, 0xEF, 0xE0, 0x03, 0xFB, 0xF8, 0x00,
  0x7E, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0,
  0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF,
  0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01,
  0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0,
  0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF,
  0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07,
  0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x3F, 0xC0, 0x03, 0xFF, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x01, 0xFC, 0xFE,
  0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x0F,
  0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x0F,
  0xE0, 0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x00, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xE0, 0x0F, 0xE0, 0xFF, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xFC, 0x0F, 0xE0, 0x1F, 0xC0, 0xFE, 0x00, 0xFE,
  0x0F, 0xE0, 0x0F, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF8, 0xFE,
  0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x1F, 0xEF, 0xE0, 0x00,
  0xFE, 0xFE, 0x00, 0x07, 0xF0, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x7C, 0x0F, 0x87, 0xE7, 0xF0, 0xFF, 0x3F,
  0x7F, 0xCF, 0xF9, 0xFF, 0xFE, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x7F, 0x0F,
  0xE1, 0xFF, 0xF0, 0x3E, 0x07, 0xFF, 0x81, 0xF0, 0x3F, 0xFC, 0x0F, 0x81,
  0xFF, 0xE0, 0x7C, 0x0F, 0xFF, 0x03, 0xE0, 0x7F, 0xF8, 0x1F, 0x03, 0xFF,
  0xC0, 0xF8, 0x1F, 0xFE, 0x07, 0xC0, 0xFF, 0xF0, 0x3E, 0x07, 0xFF, 0x81,
  0xF0, 0x3F, 0xFC, 0x0F, 0x81, 0xFF, 0xE0, 0x7C, 0x0F, 0xFF, 0x03, 0xE0,
  0x7F, 0xF8, 0x1F, 0x03, 0xFF, 0xC0, 0xF8, 0x1F, 0xFE, 0x07, 0xC0, 0xFF,
  0xF0, 0x3E, 0x07, 0xFF, 0x81, 0xF0, 0x3F, 0xFC, 0x0F, 0x81, 0xFF, 0xE0,
  0x7C, 0x0F, 0xFF, 0x03, 0xE0, 0x7F, 0xF8, 0x1F, 0x03, 0xFF, 0xC0, 0xF8,
  0x1F, 0xFE, 0x07, 0xC0, 0xFF, 0xF0, 0x3E, 0x07, 0xFF, 0x81, 0xF0, 0x3F,
  0xFC, 0x0F, 0x81, 0xF8, 0x00, 0x1F, 0xE0, 0x3F, 0x1F, 0xFE, 0x0F, 0xCF,
  0xFF, 0xC3, 0xF7, 0xFF, 0xF8, 0xFD, 0xFF, 0xFF, 0x3F, 0x7F, 0xFF, 0xCF,
  0xF8, 0x07, 0xFB, 0xFC, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x07,
  0xEF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00,
  0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF,
  0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F,
  0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00,
  0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC,
  0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F,
  0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC7,
  0xF8, 0x0F, 0xFB, 0xFC, 0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xBF, 0x00, 0x07,
  0xEF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00,
  0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF,
  0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F,
  0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00,
  0x1F, 0xBF, 0x80, 0x0F, 0xE7, 0xF0, 0x07, 0xF9, 0xFF, 0x07, 0xFC, 0x3F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0,
  0x01, 0xFF, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x3F, 0x1F,
  0xFE, 0x0F, 0xCF, 0xFF, 0xC3, 0xF3, 0xFF, 0xF8, 0xFD, 0xFF, 0xFF, 0x3F,
  0x7F, 0xFF, 0xCF, 0xF8, 0x07, 0xFB, 0xFC, 0x00, 0xFE, 0xFE, 0x00, 0x1F,
  0xBF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00,
  0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC,
  0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F,
  0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00,
  0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xEF, 0xF0, 0x07, 0xFB, 0xFF,
  0x03, 0xFE, 0xFD, 0xFF, 0xFF, 0x3F, 0x7F, 0xFF, 0x8F, 0xCF, 0xFF, 0xE3,
  0xF1, 0xFF, 0xF0, 0xFC, 0x3F, 0xF0, 0x3F, 0x00, 0xC0, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFF, 0x8F,
  0xC7, 0xFF, 0xE7, 0xE7, 0xFF, 0xFB, 0xF3, 0xFF, 0xFD, 0xFB, 0xFF, 0xFF,
  0xFD, 0xFE, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00,
  0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0,
  0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0xEF, 0xF8, 0x3F, 0xF7, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFE, 0xFC, 0x7F, 0xFF, 0x7E, 0x1F, 0xFF, 0x3F, 0x07, 0xFE,
  0x1F, 0x80, 0x38, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0xE0, 0x3F, 0x1F, 0xFE, 0x0F, 0xCF, 0xFF, 0xC3, 0xF7, 0xFF,
  0xF8, 0xFD, 0xFF, 0xFF, 0x3F, 0xFC, 0xFF, 0xEF, 0xF8, 0x07, 0xFB, 0xFC,
  0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0x1F, 0xF8, 0x7F, 0xE7, 0xF0, 0x03, 0xF9, 0xF8,
  0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x03,
  0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07,
  0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00,
  0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF,
  0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F,
  0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00,
  0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC,
  0x00, 0x1F, 0xFF, 0x00, 0x07, 0xEF, 0xC0, 0x01, 0xFB, 0xF8, 0x00, 0x7E,
  0xFE, 0x00, 0x3F, 0x9F, 0xC0, 0x1F, 0xE7, 0xFC, 0x0F, 0xF0, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x07, 0xE7, 0xE0, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0xFC, 0x7F, 0x00, 0x03,
  0xF0, 0xFC, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7E, 0x0F, 0xE0, 0x01, 0xF8,
  0x1F, 0x80, 0x0F, 0xE0, 0x7E, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0xFC, 0x03,
  0xF0, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x7E, 0x00, 0x7E,
  0x03, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xF0, 0x3F, 0x00, 0x0F, 0xC0,
  0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0xFE, 0x1F, 0x80, 0x01, 0xF8, 0x7E,
  0x00, 0x07, 0xE3, 0xF0, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x3F, 0x3F, 0x00,
  0x00, 0xFD, 0xF8, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0xF8, 0x07, 0xE0, 0x3F, 0xF8, 0x07,
  0xE0, 0x3E, 0xF8, 0x07, 0xE0, 0x3E, 0xFC, 0x0F, 0xE0, 0x3E, 0xFC, 0x0F,
  0xE0, 0x3E, 0x7C, 0x0F, 0xE0, 0x3E, 0x7C, 0x0E, 0xE0, 0x3E, 0x7C, 0x0E,
  0xF0, 0x7C, 0x7C, 0x0E, 0xF0, 0x7C, 0x7C, 0x1E, 0xF0, 0x7C, 0x7E, 0x1E,
  0x70, 0x7C, 0x3E, 0x1E, 0x70, 0x7C, 0x3E, 0x1E, 0x70, 0x7C, 0x3E, 0x1C,
  0x78, 0x7C, 0x3E, 0x1C, 0x78, 0xF8, 0x3E, 0x1C, 0x78, 0xF8, 0x3E, 0x3C,
  0x78, 0xF8, 0x3F, 0x3C, 0x38, 0xF8, 0x1F, 0x3C, 0x38, 0xF8, 0x1F, 0x38,
  0x38, 0xF8, 0x1F, 0x38, 0x3C, 0xF0, 0x1F, 0x38, 0x3D, 0xF0, 0x1F, 0x78,
  0x3D, 0xF0, 0x1F, 0x78, 0x1D, 0xF0, 0x0F, 0x78, 0x1D, 0xF0, 0x0F, 0xF0,
  0x1D, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x0F, 0xF0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xE0, 0x07, 0xF0,
  0x0F, 0xE0, 0xFF, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00,
  0xFE, 0x07, 0xF0, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0xFE,
  0x00, 0x7F, 0x07, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xF8, 0xFE, 0x00,
  0x07, 0xF3, 0xF0, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x07, 0xF3, 0xF8,
  0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0x80,
  0x3F, 0x80, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x07, 0xF0, 0x03, 0xF8, 0x3F,
  0x80, 0x0F, 0xF1, 0xFC, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x3F, 0xBF, 0x80,
  0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xE7, 0xF0, 0x00,
  0x3F, 0x9F, 0xC0, 0x00, 0xFC, 0x3F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x1F,
  0xC3, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x0F, 0xC0,
  0x3F, 0x00, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x07,
  0xF0, 0x3F, 0x80, 0x1F, 0xC0, 0xFE, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0xFE,
  0x1F, 0xC0, 0x03, 0xF8, 0x7E, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x1F, 0xCF,
  0xE0, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x1F,
  0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x0F,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x01, 0xF8, 0xFF, 0xE0, 0x0F, 0xCF,
  0xFF, 0x80, 0x7E, 0xFF, 0xFE, 0x03, 0xF7, 0xFF, 0xF8, 0x1F, 0xBF, 0x1F,
  0xC0, 0xFF, 0xF0, 0x3F, 0x07, 0xFF, 0x81, 0xFE, 0xFF, 0xFC, 0x07, 0xFF,
  0xF7, 0xE0, 0x1F, 0xFF, 0xBF, 0x00, 0x7F, 0xF9, 0xF8, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xE0, 0x00,
};

const GFXglyph JetBrainsMono_Medium59pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 35, 0, -1 },
  { 1, 9, 43, 35, 13, -43 },
  { 50, 19, 18, 35, 8, -43 },
  { 93, 32, 43, 35, 2, -43 },
  { 265, 28, 59, 35, 4, -51 },
  { 472, 35, 43, 35, 0, -43 },
  { 661, 31, 45, 35, 3, -44 },
  { 836, 7, 18, 35, 14, -43 },
  { 852, 19, 57, 35, 10, -50 },
  { 988, 18, 57, 35, 7, -50 },
  { 1117, 31, 31, 35, 2, -36 },
  { 1238, 28, 27, 35, 4, -33 },
  { 1333, 14, 18, 35, 9, -9 },
  { 1365, 19, 5, 35, 8, -22 },
  { 1377, 10, 11, 35, 13, -10 },
  { 1391, 27, 55, 35, 4, -49 },
  { 1577, 27, 45, 35, 4, -44 },
  { 1729, 27, 43, 35, 5, -43 },
  { 1875, 27, 44, 35, 4, -44 },
  { 2024, 27, 44, 35, 4, -43 },
  { 2173, 26, 43, 35, 4, -43 },
  { 2313, 26, 44, 35, 5, -43 },
  { 2456, 28, 44, 35, 4, -43 },
  { 2610, 28, 43, 35, 4, -43 },
  { 2761, 27, 45, 35, 4, -44 },
  { 2913, 28, 44, 35, 4, -44 },
  { 3067, 10, 34, 35, 13, -33 },
  { 3110, 13, 42, 35, 10, -33 },
  { 3179, 26, 31, 35, 5, -35 },
  { 3280, 25, 21, 35, 5, -30 },
  { 3346, 26, 31, 35, 5, -35 },
  { 3447, 21, 43, 35, 8, -43 },
  { 3560, 31, 55, 35, 2, -44 },
  { 3774, 30, 43, 35, 3, -43 },
  { 3936, 27, 43, 35, 5, -43 },
  { 4082, 26, 45, 35, 5, -44 },
  { 4229, 26, 43, 35, 5, -43 },
  { 4369, 25, 43, 35, 6, -43 },
  { 4504, 26, 43, 35, 5, -43 },
  { 4644, 26, 45, 35, 5, -44 },
  { 4791, 25, 43, 35, 5, -43 },
  { 4926, 24, 43, 35, 6, -43 },
  { 5055, 28, 44, 35, 2, -43 },
  { 5209, 28, 43, 35, 5, -43 },
  { 5360, 26, 43, 35, 6, -43 },
  { 5500, 28, 43, 35, 4, -43 },
  { 5651, 26, 43, 35, 5, -43 },
  { 5791, 26, 45, 35, 5, -44 },
  { 5938, 28, 43, 35, 5, -43 },
  { 6089, 28, 55, 35, 4, -44 },
  { 6282, 28, 43, 35, 5, -43 },
  { 6433, 28, 45, 35, 4, -44 },
  { 6591, 29, 43, 35, 3, -43 },
  { 6747, 26, 44, 35, 5, -43 },
  { 6890, 30, 43, 35, 3, -43 },
  { 7052, 33, 43, 35, 1, -43 },
  { 7230, 31, 43, 35, 2, -43 },
  { 7397, 32, 43, 35, 2, -43 },
  { 7569, 26, 43, 35, 5, -43 },
  { 7709, 16, 55, 35, 11, -49 },
  { 7819, 27, 55, 35, 4, -49 },
  { 8005, 16, 55, 35, 8, -49 },
  { 8115, 27, 23, 35, 4, -43 },
  { 8193, 28, 6, 35, 4, 1 },
  { 8214, 14, 8, 35, 10, -46 },
  { 8228, 27, 34, 35, 4, -33 },
  { 8343, 26, 44, 35, 5, -43 },
  { 8486, 26, 34, 35, 5, -33 },
  { 8597, 25, 44, 35, 5, -43 },
  { 8735, 26, 34, 35, 5, -33 },
  { 8846, 29, 43, 35, 3, -43 },
  { 9002, 25, 44, 35, 5, -33 },
  { 9140, 26, 43, 35, 5, -43 },
  { 9280, 28, 46, 35, 5, -46 },
  { 9441, 22, 57, 35, 5, -46 },
  { 9598, 28, 43, 35, 5, -43 },
  { 9749, 31, 43, 35, 2, -43 },
  { 9916, 29, 33, 35, 3, -33 },
  { 10036, 26, 33, 35, 5, -33 },
  { 10144, 26, 34, 35, 5, -33 },
  { 10255, 26, 44, 35, 5, -33 },
  { 10398, 25, 44, 35, 5, -33 },
  { 10536, 26, 33, 35, 6, -33 },
  { 10644, 26, 34, 35, 5, -33 },
  { 10755, 28, 42, 35, 3, -42 },
  { 10902, 26, 33, 35, 5, -32 },
  { 11010, 30, 32, 35, 3, -32 },
  { 11130, 32, 32, 35, 2, -32 },
  { 11258, 30, 32, 35, 3, -32 },
  { 11378, 30, 43, 35, 3, -32 },
  { 11540, 25, 32, 35, 5, -32 },
  { 11640, 26, 55, 35, 5, -49 },
  { 11819, 6, 55, 35, 15, -49 },
  { 11861, 26, 55, 35, 5, -49 },
  { 12040, 29, 13, 35, 3, -27 },
};

const GFXfont JetBrainsMono_Medium59pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Medium59pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Medium59pt7bGlyphs,
  0x20, 0x7E, 78
};

#endif // _JETBRAINSMONO_MEDIUM59PT7B_H_
