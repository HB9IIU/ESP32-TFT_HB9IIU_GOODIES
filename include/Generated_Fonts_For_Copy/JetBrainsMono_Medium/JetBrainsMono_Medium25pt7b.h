#ifndef _JETBRAINSMONO_MEDIUM25PT7B_H_
#define _JETBRAINSMONO_MEDIUM25PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Medium.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Medium25pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFC, 0xE3, 0xF1, 0xF8, 0xEC,
  0x66, 0x33, 0x19, 0x8C, 0x0C, 0x30, 0x61, 0x83, 0x1C, 0x18, 0xC1, 0x86,
  0x3F, 0xFC, 0x61, 0x83, 0x0C, 0x18, 0xC1, 0xC6, 0x0C, 0x31, 0xFF, 0xEF,
  0xFF, 0x18, 0x60, 0xC6, 0x0C, 0x30, 0x61, 0x83, 0x0C, 0x00, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x03, 0xF8, 0xFF, 0xB9, 0x3F, 0x27, 0xE4, 0x1C, 0x83,
  0xD0, 0x3E, 0x03, 0xF8, 0x3F, 0x81, 0xF8, 0x27, 0x04, 0x78, 0x8F, 0x93,
  0xFA, 0xF7, 0xFC, 0x7F, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x7C, 0x0E,
  0xFC, 0x1B, 0x18, 0x66, 0x31, 0x8C, 0x67, 0x1C, 0xCC, 0x1F, 0xB0, 0x1E,
  0xE0, 0x01, 0x80, 0x06, 0x00, 0x19, 0xE0, 0x37, 0xE0, 0xCC, 0x63, 0x18,
  0xC6, 0x31, 0x98, 0x67, 0x60, 0xFD, 0xC0, 0xF0, 0x02, 0x00, 0xFC, 0x0F,
  0xF0, 0xE1, 0xC7, 0x0E, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x03, 0xE0,
  0x3F, 0x8F, 0xCE, 0x6E, 0x3F, 0x71, 0xF3, 0x87, 0x9C, 0x3C, 0xF3, 0xE3,
  0xFF, 0x8F, 0x8E, 0xFF, 0xFF, 0xF8, 0x01, 0x07, 0x1F, 0x3C, 0x38, 0x70,
  0x70, 0x60, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x60, 0x70,
  0x70, 0x38, 0x3C, 0x1F, 0x07, 0x03, 0x80, 0xE0, 0xF8, 0x3C, 0x1C, 0x0E,
  0x0E, 0x06, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x06, 0x0E,
  0x0E, 0x1C, 0x3C, 0xF8, 0xE0, 0xC0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x8E,
  0x2F, 0x27, 0xFF, 0xFC, 0x7F, 0x00, 0xE0, 0x0D, 0x80, 0xEE, 0x0E, 0x38,
  0x71, 0xC1, 0x04, 0x00, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE1, 0xFF,
  0xFF, 0xF8, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x3C, 0xE7, 0x9C,
  0x71, 0x8E, 0x38, 0xFF, 0xFF, 0xC0, 0x77, 0xFE, 0xE0, 0x00, 0xE0, 0x1C,
  0x03, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x18,
  0x07, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x00, 0xC0, 0x38,
  0x07, 0x00, 0xC0, 0x38, 0x07, 0x00, 0x04, 0x07, 0xF1, 0xFF, 0x70, 0xFE,
  0x0F, 0x80, 0xF0, 0x1E, 0x03, 0xC4, 0x79, 0xCF, 0x39, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1F, 0x07, 0xF1, 0xEF, 0xF8, 0xFE, 0x00, 0x1F, 0x03, 0xF0,
  0x77, 0x0E, 0x70, 0xC7, 0x08, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0xFF, 0xFF, 0xFF,
  0x04, 0x07, 0xF1, 0xFF, 0x70, 0xFE, 0x0F, 0x81, 0xC0, 0x38, 0x07, 0x01,
  0xC0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x1F,
  0xFF, 0xFF, 0x80, 0xFF, 0xDF, 0xF8, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x00, 0xFC, 0x1F, 0xC0, 0x1C, 0x03, 0x80, 0x70, 0x0F, 0x81, 0xF8, 0x3F,
  0x8E, 0x7F, 0xC7, 0xE0, 0x03, 0xC0, 0x70, 0x1C, 0x07, 0x00, 0xE0, 0x38,
  0x0E, 0x01, 0xC7, 0x70, 0xFC, 0x1F, 0x83, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0xFF, 0xDF, 0xFB, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x3B, 0xE7, 0xFE, 0xF9, 0xFC, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xF8, 0x3F, 0x8F, 0x7F, 0xC7, 0xF0, 0x07, 0x81, 0xC0, 0x38, 0x0E, 0x01,
  0xC0, 0x70, 0x1C, 0x03, 0xFC, 0xFF, 0xDC, 0x1F, 0x83, 0xE0, 0x3C, 0x07,
  0x80, 0xF8, 0x3F, 0x8F, 0x7F, 0xC7, 0xF0, 0xFF, 0xFF, 0xFF, 0x01, 0xE0,
  0x7C, 0x0E, 0x03, 0x80, 0x70, 0x0C, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x80,
  0x60, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x00, 0x04, 0x07, 0xF1, 0xFF,
  0x78, 0xFE, 0x0F, 0xC1, 0xF8, 0x3B, 0x8E, 0x3B, 0x83, 0xE0, 0xFE, 0x38,
  0xEE, 0x0F, 0xC1, 0xF0, 0x1F, 0x07, 0xF1, 0xEF, 0xF8, 0xFE, 0x00, 0x04,
  0x07, 0xF1, 0xFF, 0x70, 0x7E, 0x0F, 0x80, 0xF0, 0x1E, 0x03, 0xE0, 0xFE,
  0x3D, 0xFF, 0x9E, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x0E, 0x03, 0x80,
  0xF0, 0x00, 0x77, 0xFE, 0xE0, 0x00, 0x00, 0x00, 0x1D, 0xFF, 0xB8, 0x39,
  0xF7, 0xCE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xCE, 0x79, 0xC7, 0x18, 0xE3,
  0x80, 0x00, 0x20, 0x1C, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0x38, 0x07, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x06, 0x00, 0x40, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x80, 0x1C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x38, 0x0F, 0x07, 0xC3, 0xE1,
  0xF0, 0x78, 0x0C, 0x01, 0x00, 0x00, 0xFE, 0x7F, 0x81, 0xE0, 0x70, 0x18,
  0x0C, 0x0E, 0x0F, 0x3F, 0x1F, 0x0E, 0x07, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x78, 0x1C, 0x00, 0x02, 0x00, 0xFF, 0x0F, 0xFC, 0xE0, 0x66, 0x03, 0xF0,
  0x0F, 0x00, 0x78, 0x7B, 0xC7, 0xFE, 0x38, 0xF1, 0x87, 0x8C, 0x3C, 0x61,
  0xE3, 0x0F, 0x18, 0x78, 0xE7, 0xC3, 0xFE, 0x0C, 0x38, 0x00, 0xC0, 0x07,
  0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x70, 0x07, 0x00, 0x7C, 0x03, 0x60, 0x1B,
  0x01, 0xD8, 0x0E, 0xE0, 0x77, 0x03, 0x18, 0x38, 0xE1, 0xC7, 0x0E, 0x38,
  0x7F, 0xC7, 0xFF, 0x38, 0x39, 0xC1, 0xCC, 0x06, 0xE0, 0x3F, 0x01, 0xC0,
  0xFF, 0x9F, 0xFB, 0x87, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0xFE, 0xFF,
  0x1F, 0xFB, 0x83, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x3F, 0x0F, 0xFF, 0xDF,
  0xE0, 0x04, 0x07, 0xF1, 0xFF, 0x78, 0x7E, 0x0F, 0xC1, 0xF8, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x3F, 0x07, 0x71,
  0xEF, 0xF8, 0xFE, 0x00, 0xFF, 0x1F, 0xFB, 0x87, 0x70, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x3E, 0xFF, 0x9F, 0xE0, 0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0xFE, 0xFF, 0xDF, 0xFB, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x00, 0x04, 0x07, 0xF1, 0xFF, 0x78,
  0x7E, 0x0F, 0xC1, 0xF8, 0x07, 0x00, 0xE0, 0x1C, 0xFF, 0x9F, 0xF3, 0xFE,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0x71, 0xEF, 0xF8, 0xFE, 0x00, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1C, 0xFF,
  0xFF, 0xFC, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0xFF, 0xFF, 0xFC,
  0x07, 0xF0, 0x7F, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x7E, 0x07, 0xE0, 0xE7, 0x1E,
  0x7F, 0xC1, 0xF8, 0xE0, 0x7E, 0x0E, 0xE0, 0xEE, 0x1C, 0xE1, 0xCE, 0x38,
  0xE3, 0x8F, 0xF0, 0xFF, 0x0F, 0xF0, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x1C,
  0xE1, 0xCE, 0x0E, 0xE0, 0xEE, 0x07, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xFF, 0xFF, 0xF0, 0xE0, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F,
  0xB6, 0xF6, 0xDE, 0xDB, 0xCE, 0x79, 0xCF, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0C, 0xF0, 0xFE, 0x1F, 0xC3, 0xEC, 0x7D,
  0x8F, 0xB1, 0xF3, 0x3F, 0x67, 0xEE, 0xFC, 0xDF, 0x9B, 0xF3, 0xBE, 0x37,
  0xC6, 0xF8, 0xFF, 0x0F, 0xE1, 0xFC, 0x3C, 0x04, 0x07, 0xF1, 0xFF, 0x78,
  0xFE, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0x71, 0xCF, 0xF8, 0xFE, 0x00, 0xFF, 0x8F,
  0xFE, 0xE0, 0xEE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0E, 0xFF, 0xEF,
  0xFC, 0xFF, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0x04, 0x07, 0xF1, 0xFF, 0x78, 0xFE, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xF1,
  0xEF, 0xF8, 0xFE, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x07, 0xFF, 0x8F,
  0xFC, 0xE1, 0xEE, 0x0E, 0xE0, 0x7E, 0x07, 0xE0, 0x6E, 0x0E, 0xFF, 0xCF,
  0xF8, 0xFF, 0x0E, 0x38, 0xE3, 0x8E, 0x1C, 0xE1, 0xCE, 0x0E, 0xE0, 0xEE,
  0x0F, 0x04, 0x07, 0xF1, 0xFF, 0x78, 0x7E, 0x0F, 0xC0, 0x38, 0x07, 0x80,
  0x7C, 0x07, 0xF0, 0x7F, 0x00, 0xF0, 0x0E, 0x00, 0xF0, 0x1F, 0x07, 0xF1,
  0xEF, 0xF8, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC1, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3B, 0x8E, 0x7F, 0xC7, 0xF0, 0xE0,
  0x3B, 0x01, 0x9C, 0x0C, 0xE0, 0xE7, 0x07, 0x18, 0x30, 0xC1, 0x87, 0x1C,
  0x38, 0xE0, 0xC6, 0x06, 0x30, 0x3B, 0x81, 0xDC, 0x06, 0xC0, 0x36, 0x01,
  0xF0, 0x0F, 0x80, 0x38, 0x00, 0xC7, 0x1E, 0x38, 0xF1, 0x47, 0x8A, 0x3C,
  0x51, 0xE2, 0x8F, 0xB6, 0xFD, 0xB7, 0xED, 0xBB, 0x6D, 0x9B, 0x6C, 0xD1,
  0x66, 0x8B, 0x34, 0x59, 0xA2, 0xCF, 0x1E, 0x78, 0xF3, 0xC7, 0x00, 0xF0,
  0x3B, 0x83, 0x8E, 0x38, 0x71, 0xC1, 0xDC, 0x0E, 0xE0, 0x3E, 0x01, 0xF0,
  0x07, 0x00, 0x3C, 0x03, 0xE0, 0x3B, 0x81, 0xDC, 0x1C, 0x70, 0xE3, 0x8E,
  0x0E, 0x70, 0x77, 0x01, 0xC0, 0xE0, 0x3B, 0x01, 0x9C, 0x1C, 0xE0, 0xE3,
  0x8E, 0x1C, 0x70, 0x77, 0x03, 0xB8, 0x0D, 0x80, 0x7C, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0xFF,
  0xFF, 0xFC, 0x03, 0x80, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x0E, 0x01,
  0xC0, 0x70, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x00, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF8, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38,
  0xE3, 0x8E, 0x38, 0xE3, 0xFF, 0xFF, 0xE0, 0x1C, 0x01, 0x80, 0x38, 0x07,
  0x00, 0x60, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x30, 0x07, 0x00, 0xE0,
  0x0C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x70, 0x0E, 0x00, 0xE0, 0x1C, 0x01,
  0x80, 0x38, 0x07, 0xFF, 0xFF, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7,
  0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1F, 0xFF, 0xFF, 0x0E, 0x03, 0xE0,
  0x6C, 0x0D, 0x83, 0x18, 0x63, 0x1C, 0x73, 0x06, 0xE0, 0xF8, 0x0C, 0xFF,
  0xFF, 0xFF, 0xC0, 0xE1, 0xC3, 0x87, 0x0F, 0x83, 0xFE, 0x3C, 0xE7, 0x07,
  0x00, 0x70, 0x07, 0x1F, 0xF7, 0xFF, 0x70, 0x76, 0x07, 0xE0, 0x77, 0x0F,
  0x7F, 0xF3, 0xF7, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0xF9, 0xFF, 0xBE,
  0xFF, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x8F, 0xFF, 0xDD, 0xF0, 0x1F, 0x0F, 0xF9, 0xEF, 0xF0, 0x7E, 0x0F, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x1F, 0x83, 0xF8, 0xF7, 0xFC, 0x7F, 0x00,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x73, 0xEE, 0xFF, 0xFC, 0xFF, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x8F, 0x7F, 0xE7,
  0xDC, 0x1F, 0x0F, 0xF9, 0xC7, 0x70, 0x7E, 0x0F, 0xC1, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1C, 0x03, 0x83, 0xF8, 0x77, 0xFC, 0x7F, 0x00, 0x03, 0xF0, 0x7F,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x3E, 0xEF, 0xFF, 0xCF, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0xC7, 0xBF, 0xF3, 0xEE, 0x01, 0xC0, 0x38, 0x07, 0x3F, 0xC7,
  0xF0, 0xF0, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0xF9, 0xFF, 0xBC,
  0x77, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1C, 0x04, 0x00, 0xF0, 0x0F, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x7E, 0x07, 0xE0, 0x7E, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0x01, 0x00,
  0xE0, 0x3C, 0x06, 0x00, 0x00, 0x07, 0xF9, 0xFE, 0x7F, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x81, 0xEF, 0xF3, 0xF8, 0xF0, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x7E, 0x0E, 0xE1, 0xEE, 0x1C, 0xE3, 0x8E, 0x78, 0xFF, 0x0F, 0xF0,
  0xE3, 0x8E, 0x38, 0xE1, 0xCE, 0x1E, 0xE0, 0xEE, 0x07, 0xFE, 0x07, 0xF0,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xE0, 0x07,
  0xF8, 0x1F, 0xC0, 0xEE, 0xE7, 0xF7, 0xB9, 0xCD, 0xCE, 0x7E, 0x73, 0xF3,
  0x9F, 0x9C, 0xFC, 0xE7, 0xE7, 0x3F, 0x39, 0xF9, 0xCF, 0xCE, 0x7E, 0x73,
  0xF3, 0x9C, 0xEF, 0x9F, 0xFB, 0xEF, 0x70, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xC0, 0x1F, 0x0F,
  0xF9, 0xEF, 0x70, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF8, 0xE7, 0xFC, 0x7F, 0x00, 0xEF, 0x9F, 0xFB, 0xEF, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF8, 0xFF, 0xFD,
  0xDF, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x00, 0x3E, 0xEF, 0xFF,
  0xCF, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF8, 0xF7, 0xFE, 0x7D, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0xCF, 0x1B, 0xF3, 0xCF, 0x70, 0xEC, 0x0F, 0x81, 0xF0, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x00, 0x1F, 0x8F, 0xF9, 0xC7,
  0xF0, 0x7E, 0x00, 0xE0, 0x1F, 0xE0, 0xFE, 0x01, 0xE0, 0x1F, 0x83, 0xF0,
  0x77, 0xFE, 0x7F, 0x00, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xF0, 0x07, 0xF0, 0x3F, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xB8, 0xE7,
  0xFC, 0x7F, 0x00, 0xE0, 0x3B, 0x01, 0x9C, 0x1C, 0xE0, 0xE3, 0x06, 0x1C,
  0x70, 0xE3, 0x83, 0x18, 0x1D, 0xC0, 0xEE, 0x03, 0x60, 0x1B, 0x00, 0xF8,
  0x03, 0x80, 0xC7, 0x1E, 0x38, 0xF1, 0x47, 0x8A, 0x3E, 0x53, 0xB2, 0x99,
  0xB6, 0xCD, 0xB6, 0x6D, 0xB3, 0x45, 0x9A, 0x2C, 0xF1, 0xE3, 0x8E, 0x1C,
  0x70, 0xF0, 0x7B, 0x83, 0x8E, 0x38, 0x3B, 0x81, 0xDC, 0x07, 0xC0, 0x1C,
  0x01, 0xF0, 0x0F, 0x80, 0xEE, 0x0E, 0x38, 0x71, 0xC7, 0x07, 0x70, 0x3C,
  0xE0, 0x3B, 0x81, 0x9C, 0x1C, 0xE0, 0xE3, 0x8E, 0x1C, 0x70, 0x63, 0x83,
  0xB8, 0x1D, 0xC0, 0x6C, 0x03, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xF0, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x0F,
  0xFF, 0xFF, 0xC0, 0x00, 0xE0, 0x7C, 0x1F, 0x83, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x3C, 0x7F, 0x0F, 0xE0, 0x1E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0F, 0xC0, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0x03,
  0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x78,
  0x07, 0xF0, 0xFE, 0x3C, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC1, 0xF8, 0x3E, 0x07, 0x00, 0x18, 0x03, 0xF1, 0xDF, 0x8F, 0xCE,
  0x6E, 0x3F, 0x70, 0xF0,
};

const GFXglyph JetBrainsMono_Medium25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 3, 18, 15, 6, -18 },
  { 8, 9, 7, 15, 3, -18 },
  { 16, 13, 18, 15, 1, -18 },
  { 46, 11, 26, 15, 2, -22 },
  { 82, 15, 18, 15, 0, -18 },
  { 116, 13, 19, 15, 1, -19 },
  { 147, 3, 7, 15, 6, -18 },
  { 150, 8, 24, 15, 4, -21 },
  { 174, 8, 24, 15, 3, -21 },
  { 198, 13, 13, 15, 1, -15 },
  { 220, 11, 12, 15, 2, -14 },
  { 237, 6, 8, 15, 4, -4 },
  { 243, 9, 2, 15, 3, -9 },
  { 246, 5, 4, 15, 5, -4 },
  { 249, 11, 24, 15, 2, -21 },
  { 282, 11, 19, 15, 2, -19 },
  { 309, 12, 18, 15, 2, -18 },
  { 336, 11, 19, 15, 2, -19 },
  { 363, 11, 18, 15, 2, -18 },
  { 388, 11, 18, 15, 2, -18 },
  { 413, 11, 18, 15, 2, -18 },
  { 438, 11, 18, 15, 2, -18 },
  { 463, 11, 18, 15, 2, -18 },
  { 488, 11, 19, 15, 2, -19 },
  { 515, 11, 19, 15, 2, -19 },
  { 542, 5, 14, 15, 5, -14 },
  { 551, 6, 18, 15, 4, -14 },
  { 565, 11, 14, 15, 2, -15 },
  { 585, 11, 9, 15, 2, -13 },
  { 598, 11, 14, 15, 2, -15 },
  { 618, 9, 18, 15, 3, -18 },
  { 639, 13, 24, 15, 1, -19 },
  { 678, 13, 18, 15, 1, -18 },
  { 708, 11, 18, 15, 2, -18 },
  { 733, 11, 19, 15, 2, -19 },
  { 760, 11, 18, 15, 2, -18 },
  { 785, 11, 18, 15, 2, -18 },
  { 810, 11, 18, 15, 2, -18 },
  { 835, 11, 19, 15, 2, -19 },
  { 862, 11, 18, 15, 2, -18 },
  { 887, 11, 18, 15, 2, -18 },
  { 912, 12, 18, 15, 1, -18 },
  { 939, 12, 18, 15, 2, -18 },
  { 966, 10, 18, 15, 3, -18 },
  { 989, 11, 18, 15, 2, -18 },
  { 1014, 11, 18, 15, 2, -18 },
  { 1039, 11, 19, 15, 2, -19 },
  { 1066, 12, 18, 15, 2, -18 },
  { 1093, 11, 24, 15, 2, -19 },
  { 1126, 12, 18, 15, 2, -18 },
  { 1153, 11, 19, 15, 2, -19 },
  { 1180, 13, 18, 15, 1, -18 },
  { 1210, 11, 18, 15, 2, -18 },
  { 1235, 13, 18, 15, 1, -18 },
  { 1265, 13, 18, 15, 1, -18 },
  { 1295, 13, 18, 15, 1, -18 },
  { 1325, 13, 18, 15, 1, -18 },
  { 1355, 11, 18, 15, 2, -18 },
  { 1380, 6, 24, 15, 5, -21 },
  { 1398, 11, 24, 15, 2, -21 },
  { 1431, 6, 24, 15, 4, -21 },
  { 1449, 11, 10, 15, 2, -18 },
  { 1463, 13, 2, 15, 1, 1 },
  { 1467, 6, 4, 15, 4, -20 },
  { 1470, 12, 14, 15, 1, -14 },
  { 1491, 11, 18, 15, 2, -18 },
  { 1516, 11, 14, 15, 2, -14 },
  { 1536, 11, 18, 15, 2, -18 },
  { 1561, 11, 14, 15, 2, -14 },
  { 1581, 12, 18, 15, 1, -18 },
  { 1608, 11, 19, 15, 2, -14 },
  { 1635, 11, 18, 15, 2, -18 },
  { 1660, 12, 20, 15, 2, -20 },
  { 1690, 10, 25, 15, 2, -20 },
  { 1722, 12, 18, 15, 2, -18 },
  { 1749, 13, 18, 15, 1, -18 },
  { 1779, 13, 14, 15, 1, -14 },
  { 1802, 11, 14, 15, 2, -14 },
  { 1822, 11, 14, 15, 2, -14 },
  { 1842, 11, 19, 15, 2, -14 },
  { 1869, 11, 19, 15, 2, -14 },
  { 1896, 11, 14, 15, 3, -14 },
  { 1916, 11, 14, 15, 2, -14 },
  { 1936, 12, 18, 15, 1, -18 },
  { 1963, 11, 14, 15, 2, -14 },
  { 1983, 13, 14, 15, 1, -14 },
  { 2006, 13, 14, 15, 1, -14 },
  { 2029, 13, 14, 15, 1, -14 },
  { 2052, 13, 19, 15, 1, -14 },
  { 2083, 11, 14, 15, 2, -14 },
  { 2103, 11, 24, 15, 2, -21 },
  { 2136, 3, 24, 15, 6, -21 },
  { 2145, 11, 24, 15, 2, -21 },
  { 2178, 13, 6, 15, 1, -12 },
};

const GFXfont JetBrainsMono_Medium25pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Medium25pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Medium25pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _JETBRAINSMONO_MEDIUM25PT7B_H_
