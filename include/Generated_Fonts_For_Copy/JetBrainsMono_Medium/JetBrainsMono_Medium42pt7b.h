#ifndef _JETBRAINSMONO_MEDIUM42PT7B_H_
#define _JETBRAINSMONO_MEDIUM42PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Medium.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Medium42pt7bBitmaps[] PROGMEM = {
  0x00, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x8F, 0x1E, 0x3C, 0x70, 0xE1, 0xC3, 0x87, 0x00, 0x00, 0x00, 0x01,
  0xF7, 0xFF, 0xFF, 0xDF, 0x00, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF,
  0x87, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0,
  0xFF, 0x07, 0x80, 0x00, 0xE0, 0x78, 0x01, 0xC0, 0xF0, 0x07, 0x81, 0xC0,
  0x0F, 0x03, 0x80, 0x1C, 0x07, 0x00, 0x38, 0x0E, 0x00, 0x70, 0x3C, 0x00,
  0xE0, 0x78, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xF0, 0x38, 0x1E, 0x00, 0xF0, 0x3C, 0x01, 0xE0, 0x70, 0x03, 0xC0,
  0xE0, 0x07, 0x01, 0xC0, 0x0E, 0x07, 0x80, 0x1C, 0x0F, 0x00, 0x78, 0x1C,
  0x0F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x07, 0x03, 0xC0,
  0x1E, 0x07, 0x80, 0x3C, 0x0E, 0x00, 0x78, 0x1C, 0x00, 0xE0, 0x38, 0x01,
  0xC0, 0xF0, 0x03, 0x81, 0xE0, 0x0F, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0xFF, 0x00, 0x7F, 0xF8, 0x1F, 0xFF, 0x87, 0xFF, 0xF9, 0xFB, 0xBF, 0x3E,
  0x71, 0xF7, 0x8E, 0x3F, 0xF1, 0xC3, 0xFE, 0x38, 0x07, 0xC7, 0x00, 0x7C,
  0xE0, 0x0F, 0x9C, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0xEF, 0xC0, 0x1C, 0xFC, 0x03,
  0x8F, 0x80, 0x70, 0xF0, 0x0E, 0x1F, 0xE1, 0xC3, 0xFC, 0x38, 0x7F, 0xC7,
  0x1F, 0xFC, 0xE7, 0xEF, 0xFF, 0xF8, 0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0x7F,
  0xE0, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x0F, 0x80, 0x07, 0x9F, 0xF0, 0x03, 0x9F, 0xFC,
  0x03, 0xCF, 0x1E, 0x03, 0xC7, 0x07, 0x01, 0xC3, 0x83, 0xC1, 0xC1, 0xC1,
  0xE1, 0xE0, 0xE0, 0xF0, 0xE0, 0x70, 0x78, 0xE0, 0x38, 0x38, 0xF0, 0x1E,
  0x3C, 0xF0, 0x0F, 0xFE, 0x70, 0x03, 0xFE, 0x78, 0x00, 0xFE, 0x78, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x7C,
  0x00, 0x1C, 0xFF, 0x80, 0x1E, 0x7F, 0xE0, 0x1E, 0x78, 0xF0, 0x0E, 0x38,
  0x38, 0x0F, 0x1C, 0x1E, 0x0F, 0x0E, 0x0F, 0x07, 0x07, 0x07, 0x87, 0x83,
  0x83, 0xC7, 0x81, 0xC1, 0xE3, 0x80, 0xF0, 0xE3, 0x80, 0x7F, 0xF3, 0xC0,
  0x1F, 0xF3, 0xC0, 0x03, 0xF0, 0x03, 0xF8, 0x00, 0x1F, 0xF8, 0x01, 0xFF,
  0xF0, 0x07, 0xFF, 0xE0, 0x3E, 0x0F, 0x80, 0xF8, 0x1F, 0x03, 0xC0, 0x7C,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x7D, 0xF0, 0x7F, 0xE7, 0xC3, 0xEF, 0x8F, 0x8F, 0x3C, 0x1F, 0x7C,
  0xF0, 0x3D, 0xE3, 0xC0, 0xFF, 0x8F, 0x01, 0xFC, 0x3C, 0x03, 0xF0, 0xF0,
  0x07, 0x83, 0xE0, 0x3F, 0x0F, 0x81, 0xFE, 0x1F, 0xFF, 0xF8, 0x7F, 0xFD,
  0xF0, 0xFF, 0xE3, 0xE1, 0xFF, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xE7, 0x00, 0x00, 0x18, 0x03, 0xC0, 0x7E, 0x07, 0xF0, 0x7F,
  0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x3E, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03,
  0xF8, 0x0F, 0xF0, 0x3F, 0x80, 0xFC, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x3F, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0,
  0x0F, 0x80, 0x7C, 0x01, 0xE0, 0x0F, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x7C, 0x07, 0xE0, 0x7E, 0x0F, 0xE1, 0xFE, 0x0F, 0xE0, 0x7E, 0x03, 0xC0,
  0x18, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x08, 0x0E, 0x03, 0x3E, 0x1C,
  0x3E, 0x7F, 0x39, 0xFD, 0xFF, 0x37, 0xFC, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0x00, 0x03, 0x80, 0x00, 0x0D, 0x80, 0x00, 0x3B, 0xC0, 0x00, 0xF7, 0xC0,
  0x03, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x3E, 0x0F, 0x80, 0xFC, 0x1F, 0x80,
  0xF0, 0x1E, 0x00, 0x40, 0x10, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x1F, 0x8F, 0x8F, 0xC7,
  0xC3, 0xE3, 0xF1, 0xF0, 0xF8, 0x78, 0x7C, 0x3E, 0x1E, 0x0F, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0,
  0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFE, 0x1F, 0xFF, 0xC7, 0xE0, 0xFC,
  0xF8, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE1, 0xC3, 0xFC, 0x7C, 0x7F,
  0x8F, 0x8F, 0xF1, 0xF1, 0xFE, 0x1E, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x03, 0xEF,
  0x00, 0x7D, 0xF0, 0x1F, 0x3F, 0xFF, 0xE3, 0xFF, 0xF8, 0x3F, 0xFE, 0x01,
  0xFF, 0x00, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x1F, 0xF8, 0x07,
  0xFF, 0x01, 0xF9, 0xE0, 0x3E, 0x3C, 0x07, 0x07, 0x80, 0xC0, 0xF0, 0x10,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0xFE, 0x1F,
  0xFF, 0xC7, 0xE0, 0xFD, 0xF8, 0x0F, 0xBE, 0x00, 0xFF, 0x80, 0x1F, 0xF0,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3F, 0xFF, 0xF7, 0xFF,
  0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xF8, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFF,
  0xFF, 0x3F, 0xFF, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x3F,
  0xC0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x07, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0xFB, 0xF0, 0x1F, 0x3F, 0xFF,
  0xC3, 0xFF, 0xF8, 0x3F, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0xF3, 0xE0, 0x3C, 0xF8, 0x0F, 0x7C, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFF,
  0xFF, 0x3F, 0xFF, 0xE7, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x7F, 0x07, 0xBF,
  0xF0, 0xF7, 0xFF, 0x1F, 0xFF, 0xF3, 0xF0, 0x3E, 0x7C, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0xF8, 0x03, 0xEF, 0x00, 0x7D, 0xF0, 0x1F, 0x3F, 0xFF,
  0xE3, 0xFF, 0xF8, 0x3F, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x3E, 0x7C, 0x03, 0xDF, 0xF0, 0x7F, 0xFF, 0x87, 0xFF, 0xFC,
  0xFC, 0x07, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x00, 0x1E, 0xF0, 0x01,
  0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1E, 0xF8, 0x01, 0xEF, 0x80,
  0x3E, 0x7C, 0x07, 0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0x81, 0xFF, 0xF0, 0x07,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0xF0, 0x03, 0xEF, 0x00, 0x3E, 0xF0, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xFC, 0x01, 0xFF,
  0xC0, 0x7F, 0xFE, 0x1F, 0xFF, 0xC7, 0xE0, 0xFC, 0xF8, 0x0F, 0x9E, 0x00,
  0xFB, 0xC0, 0x1F, 0x78, 0x03, 0xEF, 0x00, 0x79, 0xF0, 0x1F, 0x1F, 0x03,
  0xE3, 0xF1, 0xF8, 0x3F, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xFF,
  0x07, 0xE3, 0xF1, 0xF8, 0x3F, 0x3E, 0x03, 0xEF, 0x80, 0x3F, 0xF0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x7D, 0xF0, 0x1F,
  0xBF, 0xFF, 0xE3, 0xFF, 0xF8, 0x3F, 0xFE, 0x01, 0xFF, 0x80, 0x03, 0xF8,
  0x00, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFC, 0x7E, 0x0F, 0xCF, 0xC0,
  0x3E, 0xF8, 0x03, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xEF, 0x80, 0x3E, 0xFC, 0x07, 0xE7,
  0xF1, 0xFE, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F, 0xEF, 0x80, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0xC0, 0x00, 0x10, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF7, 0xFF, 0xFF, 0xFF,
  0xBE, 0x04, 0x0F, 0x8F, 0xE7, 0xF3, 0xF9, 0xFC, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE3, 0xE3,
  0xF1, 0xF8, 0xF8, 0x7C, 0x7C, 0x3E, 0x1F, 0x0F, 0x0F, 0x87, 0x83, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x07, 0xFC,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xC0, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xF0,
  0x00, 0x1E, 0x00, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xC0, 0x00, 0x1E, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03,
  0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0xFE, 0x00, 0x7F, 0xC0, 0x3F,
  0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0x00,
  0x0F, 0x80, 0x01, 0x80, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0xE0, 0xFF, 0xF8,
  0xFF, 0xFC, 0xFF, 0xFE, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7E, 0x1F, 0xFC,
  0x1F, 0xFC, 0x1F, 0xF8, 0x1F, 0xC0, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0x00, 0x01, 0xFE, 0x00, 0x1F,
  0xFE, 0x01, 0xFF, 0xFE, 0x0F, 0xE1, 0xFC, 0x3E, 0x01, 0xF1, 0xF0, 0x03,
  0xE7, 0x80, 0x07, 0xBC, 0x00, 0x0E, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x43, 0xFC, 0x0F, 0xEF, 0xF0, 0x7F, 0xBF, 0xC3, 0xF7, 0xFF, 0x0F,
  0x07, 0xFC, 0x3C, 0x0F, 0xF0, 0xF0, 0x3F, 0xC3, 0xC0, 0xFF, 0x0F, 0x03,
  0xFC, 0x3C, 0x0F, 0xF0, 0xF0, 0x3F, 0xC3, 0xC0, 0xFF, 0x0F, 0x03, 0xFC,
  0x3C, 0x0F, 0xF0, 0xF0, 0x7F, 0xC3, 0xE3, 0xFF, 0x07, 0xFF, 0xFC, 0x0F,
  0xEF, 0xF0, 0x0E, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x01, 0xEF, 0x00,
  0x0F, 0x78, 0x00, 0x7B, 0xC0, 0x03, 0xDF, 0x00, 0x3C, 0x78, 0x01, 0xE3,
  0xC0, 0x0F, 0x1E, 0x00, 0x78, 0xF8, 0x07, 0xC3, 0xC0, 0x3C, 0x1E, 0x01,
  0xE0, 0xF0, 0x1F, 0x07, 0xC0, 0xF8, 0x1E, 0x07, 0x80, 0xF0, 0x3F, 0xFF,
  0x83, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0x80, 0x3C, 0x7C,
  0x01, 0xF3, 0xE0, 0x07, 0x9F, 0x00, 0x3C, 0xF0, 0x01, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0x01, 0xE0, 0xFF, 0xE0, 0x1F, 0xFF, 0x83, 0xFF,
  0xF8, 0x7F, 0xFF, 0x8F, 0x03, 0xF9, 0xE0, 0x1F, 0xBC, 0x01, 0xF7, 0x80,
  0x3E, 0xF0, 0x07, 0xDE, 0x00, 0xFB, 0xC0, 0x1F, 0x78, 0x03, 0xCF, 0x01,
  0xF9, 0xFF, 0xFE, 0x3F, 0xFF, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x1E, 0x03,
  0xF3, 0xC0, 0x1F, 0x78, 0x03, 0xEF, 0x00, 0x3D, 0xE0, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xDE, 0x00, 0xFB, 0xC0, 0x3F, 0x7F, 0xFF,
  0xCF, 0xFF, 0xF1, 0xFF, 0xFC, 0x3F, 0xFE, 0x00, 0x03, 0xFC, 0x01, 0xFF,
  0xE0, 0x7F, 0xFE, 0x1F, 0xFF, 0xE7, 0xE0, 0xFC, 0xF8, 0x07, 0xDE, 0x00,
  0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x7F, 0xC0, 0x1F, 0x78, 0x03, 0xEF, 0x80, 0x7D, 0xF8, 0x1F,
  0x1F, 0xFF, 0xE3, 0xFF, 0xF8, 0x3F, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xE0,
  0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0x87, 0xFD, 0xF0, 0x0F,
  0xBE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0xFB,
  0xE0, 0x7F, 0x7F, 0xFF, 0xCF, 0xFF, 0xF1, 0xFF, 0xFC, 0x3F, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3F, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE,
  0xFF, 0xFF, 0xBC, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF,
  0xBF, 0xFF, 0xEF, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xFC, 0x01, 0xFF,
  0xE0, 0x7F, 0xFE, 0x1F, 0xFF, 0xE7, 0xE0, 0xFC, 0xF8, 0x07, 0xDE, 0x00,
  0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC3, 0xFF, 0xF8, 0x7F,
  0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03,
  0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0x78, 0x03, 0xEF, 0x80, 0x7D, 0xF8, 0x1F,
  0x1F, 0xFF, 0xE3, 0xFF, 0xF8, 0x3F, 0xFE, 0x01, 0xFF, 0x00, 0xF0, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0,
  0x1F, 0xFE, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF8,
  0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0x3F, 0xFF, 0xE3, 0xFF, 0xF8, 0x3F,
  0xFE, 0x03, 0xFF, 0x00, 0xF0, 0x03, 0xEF, 0x00, 0x3E, 0xF0, 0x07, 0xCF,
  0x00, 0x7C, 0xF0, 0x0F, 0x8F, 0x00, 0xF8, 0xF0, 0x1F, 0x0F, 0x01, 0xF0,
  0xF0, 0x3E, 0x0F, 0x03, 0xE0, 0xF0, 0x7C, 0x0F, 0x07, 0xC0, 0xF0, 0xF8,
  0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x0F, 0x0F,
  0x80, 0xF0, 0x7C, 0x0F, 0x07, 0xC0, 0xF0, 0x3E, 0x0F, 0x03, 0xE0, 0xF0,
  0x1F, 0x0F, 0x01, 0xF0, 0xF0, 0x0F, 0x8F, 0x00, 0xF8, 0xF0, 0x0F, 0xCF,
  0x00, 0x7C, 0xF0, 0x07, 0xEF, 0x00, 0x3E, 0xF0, 0x03, 0xF0, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0x03, 0xFF, 0x80,
  0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0xDC, 0x1F, 0xFB, 0x83,
  0xBF, 0x78, 0x77, 0xE7, 0x1E, 0xFC, 0xE3, 0x9F, 0xDE, 0x73, 0xF9, 0xDE,
  0x7F, 0x3B, 0x9F, 0xE7, 0x73, 0xFC, 0xFE, 0x7F, 0x8F, 0xCF, 0xF1, 0xF1,
  0xFE, 0x3E, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x78, 0xFC, 0x01,
  0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x03,
  0xFD, 0xC0, 0x7F, 0xBC, 0x0F, 0xF7, 0x81, 0xFE, 0x70, 0x3F, 0xCF, 0x07,
  0xFD, 0xE0, 0xFF, 0x9C, 0x1F, 0xF3, 0xC3, 0xFE, 0x78, 0x7F, 0xC7, 0x0F,
  0xF8, 0xF1, 0xFF, 0x1E, 0x3F, 0xE1, 0xC7, 0xFC, 0x3C, 0xFF, 0x87, 0x9F,
  0xF0, 0x7B, 0xFE, 0x0F, 0x7F, 0xC1, 0xEF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF,
  0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFE, 0x01, 0xF8,
  0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFE, 0x1F, 0xFF, 0xC7, 0xE0, 0xFC,
  0xF8, 0x0F, 0x9E, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0x78, 0x03, 0xEF,
  0x80, 0x79, 0xF8, 0x1F, 0x1F, 0xFF, 0xE3, 0xFF, 0xF8, 0x3F, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF,
  0x03, 0xFD, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xFC,
  0x07, 0xF7, 0xFF, 0xFC, 0xFF, 0xFF, 0x1F, 0xFF, 0xC3, 0xFF, 0xE0, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFE, 0x1F,
  0xFF, 0xC7, 0xE0, 0xFC, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8,
  0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0,
  0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0,
  0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0,
  0x1F, 0xF8, 0x03, 0xEF, 0x80, 0x7D, 0xF8, 0x1F, 0x3F, 0xFF, 0xE3, 0xFF,
  0xF8, 0x3F, 0xFE, 0x01, 0xFF, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0xFF, 0xE0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0x03,
  0xF9, 0xE0, 0x1F, 0xBC, 0x01, 0xF7, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00,
  0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xEF, 0x00, 0x7D, 0xE0, 0x1F, 0xBF, 0xFF,
  0xE7, 0xFF, 0xF8, 0xFF, 0xFE, 0x1F, 0xFF, 0x83, 0xC3, 0xE0, 0x78, 0x3E,
  0x0F, 0x07, 0xC1, 0xE0, 0x7C, 0x3C, 0x0F, 0x87, 0x80, 0xF8, 0xF0, 0x1F,
  0x1E, 0x01, 0xF3, 0xC0, 0x3E, 0x78, 0x07, 0xCF, 0x00, 0x7D, 0xE0, 0x0F,
  0xBC, 0x00, 0xF8, 0x03, 0xFC, 0x01, 0xFF, 0xE0, 0x7F, 0xFE, 0x1F, 0xFF,
  0xE7, 0xE0, 0xFC, 0xF8, 0x07, 0xDE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xC0,
  0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x3F,
  0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x01, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xBF, 0xFF, 0xE3, 0xFF, 0xF8,
  0x3F, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F,
  0x78, 0x03, 0xEF, 0x80, 0xF9, 0xF8, 0x1F, 0x1F, 0xFF, 0xE3, 0xFF, 0xF8,
  0x3F, 0xFE, 0x01, 0xFF, 0x00, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00,
  0x3E, 0xF0, 0x01, 0xF7, 0x80, 0x0F, 0x3E, 0x00, 0x79, 0xF0, 0x07, 0xC7,
  0x80, 0x3E, 0x3C, 0x01, 0xE1, 0xF0, 0x0F, 0x0F, 0x80, 0xF8, 0x3C, 0x07,
  0xC1, 0xE0, 0x3C, 0x0F, 0x81, 0xE0, 0x7C, 0x1F, 0x01, 0xE0, 0xF8, 0x0F,
  0x07, 0x80, 0x7C, 0x3C, 0x03, 0xE3, 0xE0, 0x0F, 0x1F, 0x00, 0x78, 0xF0,
  0x03, 0xE7, 0x80, 0x1F, 0x3C, 0x00, 0x7B, 0xC0, 0x03, 0xDE, 0x00, 0x1E,
  0xF0, 0x00, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0xF0, 0x3C, 0x1F, 0xE0, 0xF8, 0x3F, 0xC1, 0xF0, 0x7F,
  0x83, 0xE0, 0xFF, 0x07, 0xC1, 0xFE, 0x0D, 0x83, 0xDE, 0x1B, 0x07, 0xBC,
  0x37, 0x0F, 0x78, 0x6E, 0x1C, 0xF1, 0xDC, 0x79, 0xE3, 0xB8, 0xF3, 0xC7,
  0x71, 0xE7, 0x8E, 0x63, 0xCF, 0x1C, 0xC7, 0x9E, 0x31, 0x8F, 0x1C, 0x63,
  0x1E, 0x38, 0xC7, 0x3C, 0x7B, 0x8E, 0x70, 0xF7, 0x1C, 0xE1, 0xEE, 0x39,
  0xC3, 0xDC, 0x77, 0x87, 0xB8, 0x6F, 0x0F, 0x70, 0xDE, 0x1E, 0xC1, 0xBC,
  0x1D, 0x83, 0x78, 0x3B, 0x07, 0xF0, 0x7E, 0x0F, 0xC0, 0xFC, 0x1F, 0x81,
  0xF8, 0x3F, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x7C, 0x00, 0xF8, 0xF8, 0x03, 0xE0, 0xF8, 0x07, 0xC1, 0xF0, 0x1F, 0x01,
  0xF0, 0x3C, 0x03, 0xE0, 0xF8, 0x03, 0xE1, 0xE0, 0x07, 0xC7, 0xC0, 0x07,
  0xCF, 0x00, 0x0F, 0xBE, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0x78, 0x00, 0x3E, 0xF8, 0x00, 0x78, 0xF8,
  0x01, 0xF1, 0xF0, 0x03, 0xC1, 0xF0, 0x0F, 0x83, 0xE0, 0x3E, 0x03, 0xE0,
  0x7C, 0x07, 0xC1, 0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x8F, 0x80, 0x0F, 0xBF,
  0x00, 0x1F, 0x80, 0xF8, 0x00, 0x3E, 0xF0, 0x00, 0x79, 0xF0, 0x01, 0xF1,
  0xE0, 0x03, 0xE3, 0xE0, 0x0F, 0x83, 0xC0, 0x1F, 0x07, 0xC0, 0x7C, 0x07,
  0x80, 0xF8, 0x0F, 0x81, 0xE0, 0x0F, 0x07, 0xC0, 0x1F, 0x0F, 0x00, 0x3E,
  0x3E, 0x00, 0x3E, 0x78, 0x00, 0x7D, 0xF0, 0x00, 0x7B, 0xC0, 0x00, 0xFF,
  0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0xFF, 0xCF,
  0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xF0,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xE0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF0,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3B, 0xC0,
  0x0F, 0x78, 0x01, 0xE7, 0x80, 0x78, 0xF0, 0x0F, 0x1E, 0x03, 0xC1, 0xE0,
  0x78, 0x3C, 0x1F, 0x03, 0xC3, 0xC0, 0x78, 0x78, 0x07, 0x9E, 0x00, 0xF3,
  0xC0, 0x1F, 0xF0, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x00,
  0x60, 0x00, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC3, 0xF1, 0xFC, 0xF8,
  0x0F, 0x9E, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x07,
  0xFF, 0x8F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0x80,
  0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x03, 0xFF, 0xC1,
  0xFE, 0xFF, 0xFF, 0xCF, 0xFE, 0xF8, 0xFF, 0x9F, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x80, 0xF3, 0xFC, 0x3D, 0xFF, 0x8F, 0x7F, 0xF3, 0xFD, 0xFE, 0xFC,
  0x0F, 0xBE, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F,
  0xC0, 0x1F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0xFB, 0xFF, 0xFE, 0xF7,
  0xFF, 0x3D, 0xFF, 0x8F, 0x1F, 0xC0, 0x00, 0x60, 0x00, 0xFF, 0xC0, 0x7F,
  0xFC, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0xF8, 0x0F, 0x9F, 0x00, 0xFF, 0xC0,
  0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x01, 0xFF, 0x00,
  0x7D, 0xF0, 0x0F, 0xBF, 0x03, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0x07, 0xFF,
  0xC0, 0x3F, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x0C, 0x1F, 0x0F, 0xF3,
  0xE3, 0xFF, 0x7C, 0xFF, 0xFF, 0xBF, 0xDF, 0xF7, 0xC0, 0x7E, 0xF0, 0x0F,
  0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x03, 0xEF, 0x00, 0xFD, 0xF0, 0x1F, 0xBF, 0xFF, 0xF3, 0xFF, 0xFE,
  0x3F, 0xF7, 0xC3, 0xFC, 0xF8, 0x00, 0x40, 0x00, 0xFF, 0x80, 0x7F, 0xFC,
  0x1F, 0xFF, 0xC3, 0xE0, 0xFC, 0xF8, 0x0F, 0x9E, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01,
  0xE0, 0x0F, 0xBE, 0x01, 0xE3, 0xF0, 0xFC, 0x7F, 0xFF, 0x07, 0xFF, 0xC0,
  0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF,
  0xF0, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x80, 0x01, 0xFE, 0x7C, 0x7F, 0xEF, 0x9F, 0xFF, 0xF7, 0xFB, 0xFE,
  0xF8, 0x0F, 0xDF, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x1F, 0x7C, 0x07, 0xEF, 0x80, 0xFD, 0xFC, 0xFF, 0x9F, 0xFF, 0xF1,
  0xFF, 0xBE, 0x1F, 0xE7, 0xC0, 0x60, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x00, 0x07, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x03,
  0xFF, 0x80, 0x7F, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x80, 0xF3, 0xFC,
  0x3D, 0xFF, 0xCF, 0x7F, 0xF3, 0xFC, 0xFE, 0xF8, 0x0F, 0xBE, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF,
  0x00, 0x7C, 0x00, 0x70, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0,
  0x01, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x07, 0xFF,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x1C, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7E, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x7F,
  0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xFC, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xC0, 0xFC, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x03, 0xEF, 0x00, 0x7C,
  0xF0, 0x07, 0xCF, 0x00, 0xF8, 0xF0, 0x1F, 0x0F, 0x01, 0xF0, 0xF0, 0x3E,
  0x0F, 0x07, 0xE0, 0xF0, 0x7C, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF,
  0x80, 0xFF, 0xF8, 0x0F, 0x07, 0xC0, 0xF0, 0x7C, 0x0F, 0x03, 0xE0, 0xF0,
  0x3F, 0x0F, 0x01, 0xF0, 0xF0, 0x0F, 0x8F, 0x00, 0xF8, 0xF0, 0x07, 0xCF,
  0x00, 0x7E, 0xF0, 0x03, 0xF0, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x7F,
  0xFC, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x80, 0x87, 0x9F, 0x3F,
  0x3D, 0xFD, 0xFD, 0xEF, 0xFF, 0xEF, 0x8F, 0x8F, 0xFC, 0x38, 0x3F, 0xE1,
  0xC1, 0xFF, 0x0E, 0x0F, 0xF8, 0x70, 0x7F, 0xC3, 0x83, 0xFE, 0x1C, 0x1F,
  0xF0, 0xE0, 0xFF, 0x87, 0x07, 0xFC, 0x38, 0x3F, 0xE1, 0xC1, 0xFF, 0x0E,
  0x0F, 0xF8, 0x70, 0x7F, 0xC3, 0x83, 0xFE, 0x1C, 0x1F, 0xF0, 0xE0, 0xFF,
  0x87, 0x07, 0xFC, 0x38, 0x3F, 0xE1, 0xC1, 0xFF, 0x0E, 0x0F, 0x00, 0x20,
  0x3C, 0xFF, 0x0F, 0x7F, 0xF3, 0xDF, 0xFC, 0xFF, 0x7F, 0xBF, 0x03, 0xEF,
  0x80, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x1F, 0x07, 0xFC, 0x03, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F,
  0xFF, 0xE7, 0xC0, 0x7C, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xEF, 0x80, 0x79, 0xF8,
  0x1F, 0x1F, 0xFF, 0xE3, 0xFF, 0xF8, 0x3F, 0xFE, 0x01, 0xFF, 0x00, 0x00,
  0x20, 0x3C, 0xFF, 0x0F, 0x7F, 0xF3, 0xDF, 0xFC, 0xFF, 0x7F, 0xBF, 0x03,
  0xEF, 0x80, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F,
  0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0,
  0x07, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x3E, 0xFF, 0xFF, 0xBD, 0xFF,
  0xCF, 0x7F, 0xE3, 0xC7, 0xF0, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0x80, 0x01, 0xFE, 0x7C, 0x7F, 0xEF, 0x9F, 0xFF, 0xF7, 0xFB, 0xFE, 0xF8,
  0x0F, 0xDF, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0,
  0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7D, 0xF0, 0x1F, 0xBE, 0x03, 0xF7, 0xFF,
  0xFE, 0x7F, 0xFF, 0xC7, 0xFE, 0xF8, 0x7F, 0x9F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x30, 0x1F, 0x3F, 0xC3, 0xEF, 0xFC, 0x7F, 0xFF,
  0xCF, 0xF1, 0xFD, 0xF8, 0x0F, 0xBE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0xFE, 0x03, 0xFF, 0xF0, 0xFF, 0xFF, 0x3F, 0x87, 0xE7, 0xC0, 0x3E,
  0xF0, 0x07, 0xDE, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xFE, 0x00,
  0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xF8,
  0x00, 0x0F, 0x00, 0x01, 0xFF, 0x00, 0x3D, 0xF0, 0x0F, 0xBF, 0x8F, 0xF3,
  0xFF, 0xFC, 0x3F, 0xFF, 0x03, 0xFF, 0x80, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F,
  0x78, 0x03, 0xEF, 0x80, 0xF9, 0xF8, 0x1F, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8,
  0x3F, 0xFE, 0x01, 0xFF, 0x00, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xDE, 0x00,
  0x3C, 0xF8, 0x03, 0xE7, 0xC0, 0x1F, 0x1E, 0x00, 0xF0, 0xF8, 0x07, 0x87,
  0xC0, 0x7C, 0x1E, 0x03, 0xC0, 0xF8, 0x1E, 0x07, 0xC1, 0xF0, 0x1E, 0x0F,
  0x00, 0xF8, 0x78, 0x07, 0xC7, 0xC0, 0x1E, 0x3C, 0x00, 0xF9, 0xE0, 0x07,
  0xDF, 0x00, 0x1E, 0xF0, 0x00, 0xF7, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0xF0, 0x3C, 0x1F, 0xE0, 0xF8, 0x3D,
  0xC1, 0xF0, 0x7B, 0x83, 0xE0, 0xE7, 0x86, 0xC1, 0xCF, 0x0D, 0x83, 0x9E,
  0x1B, 0x8F, 0x3C, 0x77, 0x1E, 0x38, 0xEE, 0x3C, 0x71, 0xCC, 0x78, 0xE3,
  0x98, 0xE1, 0xE6, 0x31, 0xC3, 0xCC, 0x63, 0x87, 0x98, 0xEF, 0x0F, 0x71,
  0xDE, 0x0E, 0xE3, 0xBC, 0x1D, 0xC3, 0x70, 0x3B, 0x06, 0xE0, 0x7E, 0x0D,
  0xC0, 0xFC, 0x1B, 0x81, 0xF8, 0x3F, 0x01, 0xF0, 0x7E, 0x03, 0xE0, 0xF8,
  0x00, 0xFC, 0x01, 0xFB, 0xF0, 0x0F, 0x8F, 0x80, 0xF8, 0x3E, 0x0F, 0xC1,
  0xF0, 0x7C, 0x07, 0xC7, 0xC0, 0x1F, 0x3C, 0x00, 0xFB, 0xE0, 0x03, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x01,
  0xFF, 0x00, 0x0F, 0x7C, 0x00, 0xFB, 0xE0, 0x0F, 0x8F, 0x80, 0x7C, 0x3E,
  0x07, 0xC1, 0xF0, 0x7C, 0x07, 0xC7, 0xE0, 0x1F, 0x3E, 0x00, 0xFB, 0xE0,
  0x03, 0xE0, 0xF8, 0x00, 0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x3C, 0xF8, 0x03,
  0xE3, 0xE0, 0x1F, 0x1F, 0x01, 0xF0, 0x78, 0x0F, 0x83, 0xE0, 0x78, 0x1F,
  0x07, 0xC0, 0x7C, 0x3E, 0x03, 0xE1, 0xE0, 0x0F, 0x1F, 0x00, 0x7C, 0xF8,
  0x03, 0xE7, 0x80, 0x0F, 0x7C, 0x00, 0x7B, 0xE0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80,
  0x3F, 0xF0, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x3F, 0x03, 0xFF,
  0xC0, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xF0, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x03,
  0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x7F,
  0xE0, 0x00, 0xFC, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0xF8, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0x80,
  0x07, 0x80, 0x00, 0x1F, 0xC0, 0x79, 0xFF, 0x03, 0xDF, 0xFC, 0x1E, 0xF3,
  0xE0, 0xFF, 0x8F, 0x8F, 0xF8, 0x3F, 0xFB, 0xC0, 0xFF, 0xDE, 0x03, 0xFC,
  0x00, 0x07, 0x80,
};

const GFXglyph JetBrainsMono_Medium42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 7, 31, 25, 9, -31 },
  { 29, 13, 13, 25, 6, -31 },
  { 51, 23, 31, 25, 1, -31 },
  { 141, 19, 43, 25, 3, -37 },
  { 244, 25, 31, 25, 0, -31 },
  { 341, 22, 31, 25, 2, -31 },
  { 427, 5, 13, 25, 10, -31 },
  { 436, 13, 40, 25, 7, -35 },
  { 501, 13, 40, 25, 5, -35 },
  { 566, 23, 22, 25, 1, -26 },
  { 630, 20, 20, 25, 3, -24 },
  { 680, 9, 13, 25, 7, -6 },
  { 695, 13, 4, 25, 6, -16 },
  { 702, 7, 7, 25, 9, -7 },
  { 709, 19, 40, 25, 3, -35 },
  { 804, 19, 31, 25, 3, -31 },
  { 878, 19, 31, 25, 4, -31 },
  { 952, 19, 31, 25, 3, -31 },
  { 1026, 19, 31, 25, 3, -31 },
  { 1100, 18, 31, 25, 3, -31 },
  { 1170, 19, 31, 25, 3, -31 },
  { 1244, 20, 31, 25, 3, -31 },
  { 1322, 20, 31, 25, 3, -31 },
  { 1400, 19, 31, 25, 3, -31 },
  { 1474, 20, 31, 25, 3, -31 },
  { 1552, 7, 24, 25, 9, -24 },
  { 1573, 9, 31, 25, 7, -24 },
  { 1608, 19, 22, 25, 3, -25 },
  { 1661, 18, 14, 25, 4, -21 },
  { 1693, 19, 22, 25, 3, -25 },
  { 1746, 16, 31, 25, 5, -31 },
  { 1808, 22, 39, 25, 2, -31 },
  { 1916, 21, 31, 25, 2, -31 },
  { 1998, 19, 31, 25, 4, -31 },
  { 2072, 19, 31, 25, 3, -31 },
  { 2146, 19, 31, 25, 3, -31 },
  { 2220, 18, 31, 25, 4, -31 },
  { 2290, 18, 31, 25, 4, -31 },
  { 2360, 19, 31, 25, 3, -31 },
  { 2434, 18, 31, 25, 4, -31 },
  { 2504, 17, 31, 25, 4, -31 },
  { 2570, 19, 31, 25, 2, -31 },
  { 2644, 20, 31, 25, 4, -31 },
  { 2722, 18, 31, 25, 5, -31 },
  { 2792, 19, 31, 25, 3, -31 },
  { 2866, 19, 31, 25, 3, -31 },
  { 2940, 19, 31, 25, 3, -31 },
  { 3014, 19, 31, 25, 4, -31 },
  { 3088, 19, 39, 25, 3, -31 },
  { 3181, 19, 31, 25, 4, -31 },
  { 3255, 19, 31, 25, 3, -31 },
  { 3329, 21, 31, 25, 2, -31 },
  { 3411, 19, 31, 25, 3, -31 },
  { 3485, 21, 31, 25, 2, -31 },
  { 3567, 23, 31, 25, 1, -31 },
  { 3657, 23, 31, 25, 1, -31 },
  { 3747, 23, 31, 25, 1, -31 },
  { 3837, 19, 31, 25, 3, -31 },
  { 3911, 11, 40, 25, 8, -35 },
  { 3966, 19, 40, 25, 3, -35 },
  { 4061, 11, 40, 25, 6, -35 },
  { 4116, 19, 17, 25, 3, -31 },
  { 4157, 20, 4, 25, 3, 1 },
  { 4167, 10, 6, 25, 7, -33 },
  { 4175, 19, 24, 25, 3, -24 },
  { 4232, 18, 31, 25, 4, -31 },
  { 4302, 19, 24, 25, 3, -24 },
  { 4359, 19, 31, 25, 3, -31 },
  { 4433, 19, 24, 25, 3, -24 },
  { 4490, 21, 31, 25, 2, -31 },
  { 4572, 19, 32, 25, 3, -24 },
  { 4648, 18, 31, 25, 4, -31 },
  { 4718, 20, 33, 25, 3, -33 },
  { 4801, 16, 41, 25, 4, -33 },
  { 4883, 20, 31, 25, 4, -31 },
  { 4961, 22, 31, 25, 1, -31 },
  { 5047, 21, 24, 25, 2, -24 },
  { 5110, 18, 24, 25, 4, -24 },
  { 5164, 19, 23, 25, 3, -23 },
  { 5219, 18, 32, 25, 4, -24 },
  { 5291, 19, 32, 25, 3, -24 },
  { 5367, 19, 24, 25, 4, -24 },
  { 5424, 19, 23, 25, 3, -23 },
  { 5479, 20, 30, 25, 2, -30 },
  { 5554, 19, 23, 25, 3, -23 },
  { 5609, 21, 23, 25, 2, -23 },
  { 5670, 23, 23, 25, 1, -23 },
  { 5737, 21, 23, 25, 2, -23 },
  { 5798, 21, 31, 25, 2, -23 },
  { 5880, 18, 23, 25, 4, -23 },
  { 5932, 19, 40, 25, 3, -35 },
  { 6027, 5, 40, 25, 10, -35 },
  { 6052, 19, 40, 25, 3, -35 },
  { 6147, 21, 9, 25, 2, -19 },
};

const GFXfont JetBrainsMono_Medium42pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Medium42pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Medium42pt7bGlyphs,
  0x20, 0x7E, 55
};

#endif // _JETBRAINSMONO_MEDIUM42PT7B_H_
