#ifndef _JETBRAINSMONO_MEDIUM41PT7B_H_
#define _JETBRAINSMONO_MEDIUM41PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Medium.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Medium41pt7bBitmaps[] PROGMEM = {
  0x00, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xC7,
  0x8F, 0x1E, 0x3C, 0x78, 0x70, 0xE1, 0xC3, 0x80, 0x00, 0x00, 0x00, 0xFB,
  0xF7, 0xFF, 0xCF, 0x80, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F,
  0xF8, 0x7F, 0xC3, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xF0,
  0x00, 0xE0, 0x70, 0x07, 0x81, 0xC0, 0x1E, 0x07, 0x00, 0x70, 0x3C, 0x01,
  0xC0, 0xF0, 0x07, 0x03, 0x80, 0x3C, 0x0E, 0x00, 0xF0, 0x38, 0x3F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xC0, 0xE0, 0x70, 0x07, 0x81, 0xC0,
  0x1E, 0x07, 0x00, 0x70, 0x3C, 0x01, 0xC0, 0xF0, 0x07, 0x03, 0x80, 0x3C,
  0x0E, 0x00, 0xF0, 0x38, 0x3F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xE0, 0xE0, 0x70, 0x07, 0x81, 0xC0, 0x1E, 0x07, 0x00, 0x70, 0x3C, 0x01,
  0xC0, 0xF0, 0x07, 0x03, 0x80, 0x3C, 0x0E, 0x00, 0xF0, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x01, 0xFF, 0x00, 0xFF, 0xF8, 0x3F, 0xFF, 0x8F, 0xFF, 0xF1, 0xF3,
  0x9F, 0x3C, 0x71, 0xEF, 0x8E, 0x3D, 0xF1, 0xC7, 0xFE, 0x38, 0x07, 0xC7,
  0x00, 0x7C, 0xE0, 0x0F, 0xDC, 0x00, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF,
  0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0xE7, 0xC0, 0x1C,
  0x7C, 0x03, 0x8F, 0x80, 0x71, 0xFF, 0x0E, 0x1F, 0xE1, 0xC7, 0xFE, 0x38,
  0xFF, 0xE7, 0x3E, 0x7F, 0xFF, 0xC7, 0xFF, 0xF0, 0x7F, 0xFC, 0x07, 0xFE,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x1F, 0x80, 0x07, 0x3F, 0xE0, 0x0E, 0x7F, 0xF0, 0x1E,
  0x78, 0xF0, 0x1C, 0x70, 0x70, 0x38, 0x70, 0x70, 0x78, 0x70, 0x70, 0xF0,
  0x70, 0x70, 0xE0, 0x70, 0x71, 0xE0, 0x70, 0x73, 0xC0, 0x79, 0xF3, 0x80,
  0x3F, 0xE7, 0x00, 0x1F, 0xCF, 0x00, 0x02, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x38, 0x20, 0x00, 0x71, 0xFC, 0x00, 0xF7, 0xFE,
  0x01, 0xE7, 0xDF, 0x01, 0xCF, 0x0F, 0x03, 0xCF, 0x07, 0x07, 0x8F, 0x07,
  0x07, 0x0F, 0x07, 0x0E, 0x0F, 0x07, 0x1E, 0x0F, 0x07, 0x1C, 0x07, 0x0F,
  0x38, 0x07, 0xFE, 0x78, 0x03, 0xFE, 0xF0, 0x01, 0xF8, 0x07, 0xFC, 0x00,
  0x7F, 0xF0, 0x07, 0xFF, 0xC0, 0x7F, 0x7F, 0x03, 0xE0, 0xF8, 0x1E, 0x03,
  0xC0, 0xF0, 0x1E, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00,
  0x0F, 0xFC, 0x0F, 0xF9, 0xF0, 0xFF, 0x87, 0x87, 0xBC, 0x3E, 0x79, 0xE0,
  0xFF, 0xCF, 0x03, 0xFC, 0x78, 0x0F, 0xE3, 0xC0, 0x7E, 0x1E, 0x01, 0xF0,
  0xF0, 0x0F, 0x87, 0xC0, 0xFE, 0x1F, 0x9F, 0xF8, 0xFF, 0xFB, 0xE3, 0xFF,
  0x8F, 0x0F, 0xF0, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x38,
  0x07, 0xC0, 0x7E, 0x0F, 0xF0, 0xFE, 0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x3C,
  0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xFE, 0x07, 0xF0, 0x1F, 0x80, 0x3C,
  0x00, 0x60, 0xE0, 0x0F, 0x80, 0xFC, 0x0F, 0xE0, 0x3F, 0x01, 0xF8, 0x07,
  0xC0, 0x7C, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x1F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xF0, 0x3E, 0x03,
  0xE0, 0x7C, 0x0F, 0xC3, 0xF8, 0xFF, 0x0F, 0xE0, 0xF8, 0x0F, 0x00, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x01, 0x01, 0xE0, 0x27, 0x83, 0x83, 0x9F, 0x8E, 0x3F, 0x7F,
  0x33, 0xFF, 0xFF, 0xDF, 0xF1, 0xFF, 0xFE, 0x00, 0x1E, 0x00, 0x00, 0x7C,
  0x00, 0x03, 0xB8, 0x00, 0x1E, 0xF0, 0x00, 0xF3, 0xE0, 0x07, 0xC7, 0xC0,
  0x3E, 0x1F, 0x01, 0xF8, 0x3E, 0x03, 0xC0, 0x78, 0x06, 0x01, 0x80, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x0F, 0xC7, 0xE1,
  0xF8, 0x7C, 0x1F, 0x0F, 0x83, 0xE0, 0xF0, 0x3C, 0x1F, 0x07, 0x81, 0xE0,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x39, 0xFB, 0xFF,
  0xFF, 0xFF, 0xDF, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00,
  0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7, 0xC0,
  0x7D, 0xF0, 0x0F, 0xBE, 0x00, 0xF7, 0x80, 0x1E, 0xF0, 0x03, 0xFE, 0x00,
  0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x0C, 0x3F, 0xE3, 0xE7, 0xFC, 0x7C,
  0xFF, 0x8F, 0x9F, 0xF1, 0xE3, 0xFE, 0x18, 0x7F, 0xC0, 0x0F, 0xF8, 0x01,
  0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x1E, 0xF8, 0x03,
  0xCF, 0x80, 0xF9, 0xFE, 0xFE, 0x1F, 0xFF, 0xC1, 0xFF, 0xE0, 0x0F, 0xF8,
  0x00, 0x03, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0xFE, 0xF0,
  0x3E, 0x3C, 0x0F, 0x0F, 0x03, 0x83, 0xC0, 0x80, 0xF0, 0x20, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFC, 0x03,
  0xFF, 0xC0, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7, 0xC0, 0xFD, 0xF0, 0x0F, 0xBC,
  0x00, 0xF7, 0x80, 0x1E, 0xF0, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0x9F,
  0xFF, 0xE7, 0xFF, 0xF9, 0xFF, 0xFE, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0xE0,
  0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF8, 0x07, 0xFF, 0x03, 0xF7, 0xF3, 0xF8, 0xFF, 0xFC,
  0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x81,
  0xF3, 0xE0, 0x7D, 0xF0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x7F,
  0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x7F, 0xFF, 0x9F, 0xFF, 0xE7, 0xFF, 0xF9, 0xFF, 0xFE, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x87, 0x81, 0xE7, 0xF8, 0x7B, 0xFF, 0x1F, 0xFF, 0xE7, 0xE0, 0xFD, 0xF0,
  0x1F, 0x78, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x07, 0xDF, 0x01, 0xF7,
  0xFF, 0xF8, 0xFF, 0xFE, 0x1F, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0x3E, 0x00,
  0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x1F, 0xFF, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xC7, 0xF0,
  0x7E, 0x7C, 0x03, 0xE7, 0xC0, 0x1F, 0x78, 0x01, 0xF7, 0x80, 0x0F, 0xF8,
  0x00, 0xF7, 0x80, 0x0F, 0x78, 0x00, 0xF7, 0x80, 0x1F, 0x7C, 0x01, 0xE3,
  0xE0, 0x3E, 0x3F, 0xDF, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x3F, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xE0, 0x07, 0xFC, 0x00, 0xF7, 0x80, 0x3E, 0xF0, 0x07, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7, 0xC0, 0xFC,
  0xF0, 0x0F, 0xBE, 0x00, 0xF7, 0xC0, 0x1E, 0x78, 0x03, 0xCF, 0x00, 0xF9,
  0xF0, 0x1E, 0x1F, 0x07, 0xC1, 0xFB, 0xF0, 0x1F, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0xF0, 0x1F, 0xBF, 0x07, 0xC1, 0xF1, 0xF0, 0x1F, 0x7C, 0x01, 0xEF,
  0x80, 0x3D, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xDF,
  0x80, 0xF9, 0xFE, 0xFF, 0x1F, 0xFF, 0xC1, 0xFF, 0xF0, 0x1F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3E, 0x03,
  0xE7, 0xC0, 0x1E, 0x78, 0x01, 0xF7, 0x80, 0x0F, 0x78, 0x00, 0xFF, 0x80,
  0x0F, 0x78, 0x00, 0xF7, 0x80, 0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x3F, 0x3F,
  0x07, 0xE3, 0xFF, 0xFE, 0x1F, 0xFB, 0xC0, 0xFF, 0x7C, 0x00, 0xCF, 0x80,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x79, 0xFB, 0xFF, 0xFF, 0xEF, 0x84, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0x00,
  0x1E, 0x1F, 0x8F, 0xE7, 0xF3, 0xF9, 0xF8, 0x10, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC7, 0xC7, 0xE3, 0xE1,
  0xF1, 0xF8, 0xF8, 0x7C, 0x3C, 0x3E, 0x1E, 0x0F, 0x07, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x30, 0x00, 0x3C, 0x00, 0x3F, 0x00, 0x3F, 0xC0, 0x3F, 0xC0,
  0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x0F, 0xC0, 0x03, 0xC0,
  0x00, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFE,
  0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0x00, 0x03, 0xC0, 0x00, 0x30,
  0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00,
  0x38, 0x00, 0x0F, 0x80, 0x03, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFC, 0x00,
  0x07, 0x00, 0x07, 0xC0, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF8, 0x03, 0xF8, 0x00, 0xF8, 0x00, 0x38, 0x00, 0x08,
  0x00, 0x00, 0xFF, 0x81, 0xFF, 0xC3, 0xFF, 0xE7, 0xFF, 0xE0, 0x0F, 0xC0,
  0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01,
  0xF0, 0x07, 0xE0, 0x7F, 0x87, 0xFF, 0x0F, 0xFC, 0x1F, 0xE0, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0xFC, 0x01, 0xFC, 0x03, 0xF0, 0x03, 0xE0, 0x00, 0x03,
  0xFF, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF8, 0x7E, 0x07, 0xC7, 0xC0, 0x1F,
  0x3C, 0x00, 0x7B, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xF8, 0x07, 0x8F, 0xC0, 0xFF, 0x7E, 0x0F, 0xFB, 0xF0, 0x78, 0x7F,
  0x83, 0xC1, 0xFC, 0x1C, 0x0F, 0xE0, 0xE0, 0x7F, 0x07, 0x03, 0xF8, 0x38,
  0x1F, 0xC1, 0xC0, 0xFE, 0x0E, 0x07, 0xF0, 0x70, 0x3F, 0x83, 0x81, 0xFC,
  0x1E, 0x0F, 0xE0, 0xF8, 0xFF, 0x03, 0xFD, 0xF8, 0x1F, 0xEF, 0xE0, 0x1C,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xEF, 0x00, 0x0F, 0x78, 0x00, 0xFB, 0xC0, 0x07, 0x9E,
  0x00, 0x3C, 0x78, 0x01, 0xE3, 0xC0, 0x1F, 0x1E, 0x00, 0xF0, 0xF0, 0x07,
  0x87, 0xC0, 0x3C, 0x1E, 0x03, 0xE0, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x3E,
  0x07, 0x80, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0xF0,
  0x07, 0x8F, 0x80, 0x3C, 0x7C, 0x01, 0xE3, 0xC0, 0x0F, 0x9E, 0x00, 0x3D,
  0xF0, 0x01, 0xEF, 0x80, 0x0F, 0x78, 0x00, 0x7C, 0xFF, 0xF8, 0x1F, 0xFF,
  0xC3, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0x80, 0xFD, 0xF0, 0x0F, 0xBE, 0x00,
  0xF7, 0xC0, 0x1E, 0xF8, 0x03, 0xDF, 0x00, 0x7B, 0xE0, 0x1F, 0x7C, 0x03,
  0xCF, 0x83, 0xF9, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xF8, 0xF8, 0x1F,
  0x9F, 0x00, 0xFB, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x03,
  0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x01, 0xFB, 0xFF, 0xFF,
  0x7F, 0xFF, 0xCF, 0xFF, 0xF1, 0xFF, 0xF8, 0x00, 0x07, 0xFC, 0x03, 0xFF,
  0xE0, 0xFF, 0xFE, 0x1F, 0xFF, 0xC7, 0xC0, 0x7C, 0xF0, 0x0F, 0xBE, 0x00,
  0xF7, 0xC0, 0x1F, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0xFF, 0xC0, 0x1E, 0x78, 0x07, 0xCF, 0x80, 0xF8, 0xFF, 0xFE,
  0x1F, 0xFF, 0xC1, 0xFF, 0xF0, 0x0F, 0xF8, 0x00, 0xFF, 0xF0, 0x3F, 0xFF,
  0x0F, 0xFF, 0xF3, 0xFF, 0xFE, 0xF8, 0x1F, 0xBE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x07, 0xEF, 0xFF, 0xFB, 0xFF, 0xFC, 0xFF,
  0xFE, 0x3F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFD,
  0xFF, 0xFE, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3F, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xBC, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0xFC, 0x03, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F,
  0xFF, 0xC7, 0xC0, 0x7C, 0xF0, 0x0F, 0xBE, 0x00, 0xF7, 0xC0, 0x1F, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0,
  0x1E, 0x78, 0x07, 0xCF, 0x80, 0xF8, 0xFE, 0xFE, 0x1F, 0xFF, 0xC1, 0xFF,
  0xF0, 0x0F, 0xF8, 0x00, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0,
  0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03,
  0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0,
  0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03,
  0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80,
  0xFF, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80,
  0x1E, 0xF8, 0x07, 0xDF, 0x81, 0xF9, 0xFF, 0xFE, 0x1F, 0xFF, 0x81, 0xFF,
  0xE0, 0x1F, 0xF8, 0x00, 0xF8, 0x01, 0xFF, 0x80, 0x3E, 0xF8, 0x03, 0xEF,
  0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0xF8, 0xF8, 0x0F, 0x8F, 0x81, 0xF0,
  0xF8, 0x1F, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x87, 0xC0, 0xF8, 0x7C,
  0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0x87,
  0xC0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF8,
  0x0F, 0x8F, 0x80, 0xF8, 0xF8, 0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x07, 0xCF,
  0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x1F, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xF8, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x07,
  0xFF, 0xE0, 0xEF, 0xDC, 0x1D, 0xFB, 0x83, 0xFF, 0x70, 0xEF, 0xE7, 0x1D,
  0xFC, 0xE3, 0xBF, 0x9C, 0xE7, 0xF9, 0xDC, 0xFF, 0x3B, 0x9F, 0xE7, 0x73,
  0xFC, 0xFC, 0x7F, 0x8F, 0x8F, 0xF1, 0xF1, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xC0, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F,
  0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0x70, 0x3F, 0xDE, 0x0F, 0xF7, 0x83, 0xFC,
  0xE0, 0xFF, 0x3C, 0x3F, 0xCF, 0x0F, 0xF1, 0xC3, 0xFC, 0x78, 0xFF, 0x1E,
  0x3F, 0xC3, 0x8F, 0xF0, 0xF3, 0xFC, 0x3C, 0xFF, 0x07, 0x3F, 0xC1, 0xEF,
  0xF0, 0x7B, 0xFC, 0x0E, 0xFF, 0x03, 0xFF, 0xC0, 0xF7, 0xF0, 0x1D, 0xFC,
  0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x01, 0xF0, 0x07,
  0xFC, 0x07, 0xFF, 0x83, 0xFF, 0xF1, 0xFF, 0xFE, 0x7C, 0x0F, 0xDE, 0x01,
  0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0x78, 0x07, 0xDF, 0x03, 0xF7, 0xFF, 0xF8,
  0xFF, 0xFC, 0x1F, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xF8, 0x07, 0xEF, 0x80, 0x3E, 0xF8, 0x01,
  0xEF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x03, 0xEF, 0x80, 0x7E, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF,
  0xFF, 0x0F, 0xFF, 0xC0, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xFC,
  0x03, 0xFF, 0xC0, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7, 0xC0, 0xFD, 0xF0, 0x0F,
  0xBE, 0x00, 0xF7, 0xC0, 0x1E, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F,
  0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F,
  0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F,
  0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1E, 0xF8, 0x07, 0xCF, 0x81, 0xF9,
  0xFF, 0xFE, 0x1F, 0xFF, 0xC1, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x7E, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC,
  0xF8, 0x0F, 0xCF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x01,
  0xEF, 0x80, 0x1E, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x07, 0xCF, 0x80,
  0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0xF8,
  0x7C, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F,
  0x80, 0xF8, 0xF8, 0x0F, 0x8F, 0x80, 0x78, 0xF8, 0x07, 0xCF, 0x80, 0x7C,
  0xF8, 0x03, 0xEF, 0x80, 0x3F, 0x07, 0xFC, 0x03, 0xFF, 0xE0, 0xFF, 0xFE,
  0x3F, 0xFF, 0xC7, 0xC0, 0x7C, 0xF0, 0x07, 0xBE, 0x00, 0xF7, 0xC0, 0x1F,
  0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00,
  0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x03, 0xF8,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0xF9, 0xFF, 0xFF, 0x1F, 0xFF, 0xC1,
  0xFF, 0xF0, 0x1F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE,
  0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F,
  0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE,
  0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0x78, 0x07, 0xDF, 0x03, 0xF7, 0xFF,
  0xF8, 0xFF, 0xFC, 0x1F, 0xFE, 0x01, 0xFF, 0x00, 0xF0, 0x00, 0xFF, 0xC0,
  0x07, 0xBE, 0x00, 0x3C, 0xF0, 0x01, 0xE7, 0x80, 0x1F, 0x3E, 0x00, 0xF1,
  0xF0, 0x07, 0x87, 0x80, 0x3C, 0x3C, 0x03, 0xE1, 0xF0, 0x1E, 0x0F, 0x80,
  0xF0, 0x3C, 0x07, 0x81, 0xE0, 0x7C, 0x0F, 0x83, 0xC0, 0x7C, 0x1E, 0x01,
  0xE0, 0xF0, 0x0F, 0x0F, 0x80, 0x7C, 0x78, 0x03, 0xE3, 0xC0, 0x0F, 0x1E,
  0x00, 0x79, 0xF0, 0x03, 0xCF, 0x00, 0x1F, 0x78, 0x00, 0x7B, 0xC0, 0x03,
  0xDE, 0x00, 0x1E, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFC, 0x00, 0xF0, 0x78, 0x1F, 0xE0, 0xF8, 0x3F, 0xC1, 0xF0, 0x77,
  0x83, 0xE0, 0xEF, 0x07, 0xC3, 0xDE, 0x0D, 0x87, 0x9C, 0x1B, 0x0F, 0x3C,
  0x76, 0x1E, 0x78, 0xEC, 0x3C, 0xF1, 0xD8, 0x79, 0xE3, 0xB8, 0xF3, 0xC6,
  0x71, 0xC7, 0x8C, 0xE3, 0x8F, 0x19, 0xC7, 0x1E, 0x31, 0x9E, 0x1C, 0xE3,
  0x3C, 0x39, 0xC6, 0x78, 0x73, 0x8C, 0xF0, 0xF7, 0x1D, 0xE1, 0xEE, 0x3B,
  0xC3, 0xD8, 0x77, 0x07, 0xB0, 0xEE, 0x0F, 0x61, 0xDC, 0x1F, 0xC1, 0xB8,
  0x3F, 0x83, 0x70, 0x3F, 0x06, 0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x1F, 0x81,
  0xF0, 0x3F, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0xF8, 0x03, 0xE3,
  0xE0, 0x0F, 0x07, 0xC0, 0x7C, 0x1F, 0x01, 0xE0, 0x3E, 0x0F, 0x80, 0xF8,
  0x3C, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0x80, 0x0F, 0xBE, 0x00, 0x1E, 0xF0,
  0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0xFB,
  0xC0, 0x03, 0xCF, 0x80, 0x1F, 0x1F, 0x00, 0x78, 0x7C, 0x03, 0xE0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0x3E, 0x7C,
  0x00, 0xFB, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0x3D, 0xE0, 0x01, 0xF7, 0xC0,
  0x07, 0x8F, 0x00, 0x3E, 0x3E, 0x00, 0xF0, 0x78, 0x07, 0xC1, 0xF0, 0x1E,
  0x03, 0xC0, 0xF8, 0x0F, 0x83, 0xC0, 0x1E, 0x0F, 0x00, 0x7C, 0x7C, 0x00,
  0xF1, 0xE0, 0x03, 0xEF, 0x80, 0x07, 0xBC, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF,
  0xFF, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1E,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xE0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07,
  0x80, 0x00, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7B, 0x80, 0x0F, 0x78, 0x03,
  0xC7, 0x00, 0x78, 0xF0, 0x1E, 0x1E, 0x03, 0xC1, 0xE0, 0x70, 0x3C, 0x1E,
  0x03, 0xC3, 0xC0, 0x78, 0xF0, 0x0F, 0x1E, 0x00, 0xF7, 0x80, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3E, 0x0F,
  0x83, 0xE0, 0xF8, 0x3C, 0x01, 0xFC, 0x00, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F,
  0xFF, 0xE3, 0xE0, 0x7E, 0x78, 0x07, 0xCF, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFE, 0xF8,
  0x03, 0xDE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x7D, 0xF0,
  0x0F, 0xBF, 0x07, 0xF3, 0xFF, 0xDE, 0x7F, 0xFB, 0xC3, 0xFC, 0x78, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE3, 0xF0, 0xF9, 0xFE, 0x3E, 0xFF, 0xCF, 0xFF, 0xFB,
  0xF8, 0x3F, 0xFC, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xFB, 0xFB,
  0xFF, 0xFE, 0xFB, 0xFF, 0x3E, 0x7F, 0x80, 0x03, 0xF8, 0x01, 0xFF, 0xC0,
  0x7F, 0xFC, 0x1F, 0xFF, 0xC7, 0xE0, 0xFC, 0xF8, 0x0F, 0xBE, 0x00, 0xF7,
  0xC0, 0x1F, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x1F, 0xF8, 0x03, 0xCF,
  0x00, 0x79, 0xF0, 0x1F, 0x3F, 0xDF, 0xC3, 0xFF, 0xF8, 0x3F, 0xFE, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x1F, 0x0F, 0x1F, 0xF3, 0xCF, 0xFE,
  0xF7, 0xFF, 0xBD, 0xF8, 0x3F, 0x7C, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x3F,
  0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xF8, 0x07, 0xDF, 0x03,
  0xF7, 0xFB, 0xFC, 0xFF, 0xEF, 0x1F, 0xFB, 0xC3, 0xF8, 0xF0, 0x03, 0xF8,
  0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0xFE, 0x7C, 0x0F, 0x9E, 0x01, 0xFF,
  0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00,
  0x1E, 0x00, 0xF7, 0xC0, 0x7D, 0xF8, 0x3E, 0x3F, 0xFF, 0x87, 0xFF, 0xC0,
  0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFF,
  0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x07, 0xC3, 0xC7, 0xFC, 0xF3, 0xFF, 0xBD,
  0xFF, 0xEF, 0x7E, 0x0F, 0xDF, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0x7C, 0x07, 0xDF, 0x87, 0xF3, 0xFF, 0xBC,
  0xFF, 0xEF, 0x0F, 0xF3, 0xC0, 0xE0, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x01, 0xF0, 0x01, 0xFC, 0x7F, 0xFE, 0x1F, 0xFF, 0x07, 0xFF,
  0x80, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE3, 0xF0, 0xFB, 0xFE, 0x3E, 0xFF, 0xCF,
  0xFF, 0xFB, 0xF8, 0x3F, 0xFC, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0,
  0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03,
  0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x7F, 0xF8,
  0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3E, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFE, 0x3F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFE, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x3E, 0x00, 0x7E, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x1F, 0xF0, 0x07, 0xDE, 0x00, 0xFB, 0xC0,
  0x3E, 0x78, 0x0F, 0x8F, 0x01, 0xF1, 0xE0, 0x7C, 0x3C, 0x1F, 0x07, 0x83,
  0xE0, 0xF0, 0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0x0F,
  0x81, 0xE0, 0xF8, 0x3C, 0x1F, 0x07, 0x81, 0xF0, 0xF0, 0x1F, 0x1E, 0x03,
  0xE3, 0xC0, 0x3E, 0x78, 0x07, 0xEF, 0x00, 0x7D, 0xE0, 0x07, 0xC0, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF0, 0xF3, 0xC3,
  0xCF, 0x7E, 0x7E, 0xF7, 0xEF, 0xFF, 0x9F, 0x9F, 0xF8, 0xF0, 0xFF, 0x07,
  0x0F, 0xF0, 0x70, 0xFF, 0x07, 0x0F, 0xF0, 0x70, 0xFF, 0x07, 0x0F, 0xF0,
  0x70, 0xFF, 0x07, 0x0F, 0xF0, 0x70, 0xFF, 0x07, 0x0F, 0xF0, 0x70, 0xFF,
  0x07, 0x0F, 0xF0, 0x70, 0xFF, 0x07, 0x0F, 0xF0, 0x70, 0xFF, 0x07, 0x0F,
  0xF0, 0x70, 0xFF, 0x07, 0x0F, 0xF0, 0x70, 0xF0, 0xF8, 0xFC, 0x3E, 0xFF,
  0x8F, 0xBF, 0xF3, 0xFF, 0xFE, 0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3C,
  0x03, 0xF0, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0xFE, 0x7E, 0x0F, 0x9F,
  0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F,
  0xF8, 0x03, 0xDE, 0x01, 0xF7, 0xC0, 0xFD, 0xFF, 0xFE, 0x3F, 0xFF, 0x07,
  0xFF, 0x80, 0x7F, 0xC0, 0xF8, 0xFC, 0x3E, 0x7F, 0x8F, 0xBF, 0xFB, 0xFF,
  0xFE, 0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03,
  0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xFE,
  0xFE, 0xFF, 0xFF, 0xBE, 0xFF, 0xCF, 0x9F, 0xE3, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC3, 0xC7, 0xFC, 0xF3, 0xFF, 0xBD, 0xFF, 0xEF, 0x7E, 0x0F, 0xDF,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F,
  0xF8, 0x07, 0xDE, 0x01, 0xF7, 0xC0, 0xFD, 0xFE, 0xFF, 0x3F, 0xFB, 0xC7,
  0xFE, 0xF0, 0xFE, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0xF0, 0xF8, 0x3C, 0xFF,
  0x8F, 0x7F, 0xF3, 0xDF, 0xFE, 0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xFC, 0x03, 0xFF, 0xE0, 0xFF, 0xFE, 0x3F, 0xFF, 0xE7, 0xC0, 0x7C,
  0xF0, 0x07, 0x9E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x7F, 0x80, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0x3F, 0x0F, 0xE7,
  0xFF, 0xFC, 0x7F, 0xFF, 0x03, 0xFF, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0x80,
  0x7F, 0xF0, 0x03, 0xFE, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0,
  0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03,
  0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xDE, 0x01, 0xF7, 0xC0, 0xFC, 0xFE,
  0xFE, 0x3F, 0xFF, 0x07, 0xFF, 0x80, 0x7F, 0xC0, 0xF0, 0x00, 0xFF, 0xC0,
  0x07, 0x9E, 0x00, 0x3C, 0xF0, 0x03, 0xE7, 0xC0, 0x1E, 0x1E, 0x00, 0xF0,
  0xF0, 0x0F, 0x87, 0xC0, 0x78, 0x1E, 0x03, 0xC0, 0xF0, 0x3E, 0x07, 0xC1,
  0xE0, 0x1E, 0x0F, 0x00, 0xF0, 0xF8, 0x07, 0xC7, 0x80, 0x1E, 0x3C, 0x00,
  0xF3, 0xE0, 0x07, 0xDE, 0x00, 0x1E, 0xF0, 0x00, 0xF7, 0x80, 0x07, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0xF0, 0x78, 0x1F,
  0xC1, 0xE0, 0x7F, 0x07, 0x81, 0xDC, 0x1F, 0x0F, 0x70, 0x7C, 0x3D, 0xE1,
  0xB0, 0xF7, 0x8E, 0xC3, 0xDE, 0x3B, 0x0E, 0x78, 0xEC, 0x38, 0xE3, 0x38,
  0xE3, 0x8C, 0xE7, 0x8E, 0x33, 0x9E, 0x3C, 0xC6, 0x78, 0xF7, 0x19, 0xC3,
  0xDC, 0x67, 0x0F, 0x71, 0xDC, 0x1D, 0x87, 0x70, 0x76, 0x1F, 0xC1, 0xD8,
  0x7F, 0x07, 0xE0, 0xF8, 0x1F, 0x83, 0xE0, 0x7E, 0x0F, 0x80, 0xF0, 0x3E,
  0x00, 0xF8, 0x01, 0xF3, 0xE0, 0x0F, 0x8F, 0x80, 0xF8, 0x7C, 0x0F, 0x81,
  0xF0, 0x7C, 0x07, 0xC7, 0xC0, 0x3E, 0x7C, 0x00, 0xFB, 0xE0, 0x03, 0xFE,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0xFB, 0xE0, 0x0F, 0x8F, 0x00, 0xF8, 0x7C,
  0x07, 0xC1, 0xF0, 0x7C, 0x0F, 0x87, 0xC0, 0x3E, 0x3E, 0x00, 0xFB, 0xE0,
  0x07, 0xE0, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0x9F, 0x00, 0x7C, 0xF8, 0x03,
  0xE7, 0xC0, 0x1E, 0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x83, 0xC0, 0x78, 0x1F,
  0x07, 0xC0, 0xF8, 0x3C, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0x78, 0xF0,
  0x03, 0xEF, 0x80, 0x1F, 0x7C, 0x00, 0x7B, 0xC0, 0x03, 0xDE, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0xFF, 0xDF,
  0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x07, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0xF8, 0x3F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xF0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x3F,
  0xC0, 0x07, 0xF0, 0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFC, 0x00, 0x3F, 0xC0, 0x0F, 0xF8,
  0x03, 0xFF, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0xF0, 0x0F,
  0xFC, 0x01, 0xFF, 0x01, 0xFF, 0xC0, 0xFC, 0x00, 0x3C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x0F, 0xFC,
  0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x03, 0xFC, 0x0F, 0x7F, 0xE0, 0xF7, 0xFF, 0x0F, 0xF0, 0xF8, 0xFF, 0x07,
  0xFF, 0xF0, 0x7F, 0xFF, 0x03, 0xFE, 0xF0, 0x0F, 0x80,
};

const GFXglyph JetBrainsMono_Medium41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 7, 30, 25, 9, -30 },
  { 28, 13, 12, 25, 6, -30 },
  { 48, 22, 30, 25, 1, -30 },
  { 131, 19, 42, 25, 3, -36 },
  { 231, 24, 30, 25, 0, -30 },
  { 321, 21, 30, 25, 2, -30 },
  { 400, 4, 12, 25, 10, -30 },
  { 406, 13, 39, 25, 7, -34 },
  { 470, 12, 39, 25, 5, -34 },
  { 529, 22, 21, 25, 1, -25 },
  { 587, 19, 19, 25, 3, -23 },
  { 633, 10, 13, 25, 6, -6 },
  { 650, 13, 4, 25, 6, -16 },
  { 657, 7, 7, 25, 9, -7 },
  { 664, 19, 39, 25, 3, -34 },
  { 757, 19, 30, 25, 3, -30 },
  { 829, 18, 30, 25, 4, -30 },
  { 897, 19, 30, 25, 3, -30 },
  { 969, 18, 30, 25, 3, -30 },
  { 1037, 18, 30, 25, 3, -30 },
  { 1105, 18, 30, 25, 3, -30 },
  { 1173, 20, 30, 25, 2, -30 },
  { 1248, 19, 30, 25, 3, -30 },
  { 1320, 19, 30, 25, 3, -30 },
  { 1392, 20, 30, 25, 2, -30 },
  { 1467, 7, 23, 25, 9, -23 },
  { 1488, 9, 30, 25, 7, -23 },
  { 1522, 18, 23, 25, 3, -25 },
  { 1574, 18, 14, 25, 3, -21 },
  { 1606, 18, 23, 25, 3, -25 },
  { 1658, 15, 30, 25, 5, -30 },
  { 1715, 21, 37, 25, 2, -30 },
  { 1813, 21, 30, 25, 2, -30 },
  { 1892, 19, 30, 25, 3, -30 },
  { 1964, 19, 30, 25, 3, -30 },
  { 2036, 18, 30, 25, 3, -30 },
  { 2104, 17, 30, 25, 4, -30 },
  { 2168, 18, 30, 25, 4, -30 },
  { 2236, 19, 30, 25, 3, -30 },
  { 2308, 18, 30, 25, 3, -30 },
  { 2376, 17, 30, 25, 4, -30 },
  { 2440, 19, 30, 25, 2, -30 },
  { 2512, 20, 30, 25, 3, -30 },
  { 2587, 18, 30, 25, 4, -30 },
  { 2655, 19, 30, 25, 3, -30 },
  { 2727, 18, 30, 25, 3, -30 },
  { 2795, 18, 30, 25, 3, -30 },
  { 2863, 20, 30, 25, 3, -30 },
  { 2938, 19, 37, 25, 3, -30 },
  { 3026, 20, 30, 25, 3, -30 },
  { 3101, 19, 30, 25, 3, -30 },
  { 3173, 21, 30, 25, 2, -30 },
  { 3252, 18, 30, 25, 3, -30 },
  { 3320, 21, 30, 25, 2, -30 },
  { 3399, 23, 30, 25, 1, -30 },
  { 3486, 22, 30, 25, 1, -30 },
  { 3569, 22, 30, 25, 1, -30 },
  { 3652, 18, 30, 25, 3, -30 },
  { 3720, 11, 39, 25, 8, -34 },
  { 3774, 19, 39, 25, 3, -34 },
  { 3867, 11, 39, 25, 6, -34 },
  { 3921, 19, 16, 25, 3, -30 },
  { 3959, 20, 4, 25, 2, 1 },
  { 3969, 9, 6, 25, 7, -32 },
  { 3976, 19, 23, 25, 2, -23 },
  { 4031, 18, 30, 25, 3, -30 },
  { 4099, 19, 23, 25, 3, -23 },
  { 4154, 18, 30, 25, 3, -30 },
  { 4222, 18, 23, 25, 3, -23 },
  { 4274, 20, 30, 25, 2, -30 },
  { 4349, 18, 30, 25, 3, -23 },
  { 4417, 18, 30, 25, 3, -30 },
  { 4485, 20, 32, 25, 3, -32 },
  { 4565, 16, 39, 25, 3, -32 },
  { 4643, 19, 30, 25, 4, -30 },
  { 4715, 22, 30, 25, 1, -30 },
  { 4798, 20, 23, 25, 2, -23 },
  { 4856, 18, 23, 25, 3, -23 },
  { 4908, 18, 23, 25, 3, -23 },
  { 4960, 18, 30, 25, 3, -23 },
  { 5028, 18, 30, 25, 3, -23 },
  { 5096, 18, 23, 25, 4, -23 },
  { 5148, 19, 23, 25, 3, -23 },
  { 5203, 19, 29, 25, 2, -29 },
  { 5272, 18, 23, 25, 3, -23 },
  { 5324, 21, 23, 25, 2, -23 },
  { 5385, 22, 23, 25, 1, -23 },
  { 5449, 21, 23, 25, 2, -23 },
  { 5510, 21, 30, 25, 2, -23 },
  { 5589, 18, 23, 25, 3, -23 },
  { 5641, 18, 39, 25, 3, -34 },
  { 5729, 5, 39, 25, 10, -34 },
  { 5754, 18, 39, 25, 3, -34 },
  { 5842, 20, 9, 25, 2, -19 },
};

const GFXfont JetBrainsMono_Medium41pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Medium41pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Medium41pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _JETBRAINSMONO_MEDIUM41PT7B_H_
