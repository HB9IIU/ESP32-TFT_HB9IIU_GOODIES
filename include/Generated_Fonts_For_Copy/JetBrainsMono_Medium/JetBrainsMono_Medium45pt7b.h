#ifndef _JETBRAINSMONO_MEDIUM45PT7B_H_
#define _JETBRAINSMONO_MEDIUM45PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Medium.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Medium45pt7bBitmaps[] PROGMEM = {
  0x00, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF1, 0xC3, 0x87, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xDF, 0xFF, 0xFF, 0x7C, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF,
  0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3E, 0xF0,
  0x7D, 0xE0, 0xF3, 0xC1, 0xE7, 0x83, 0xCF, 0x07, 0x80, 0x00, 0xF0, 0x1C,
  0x00, 0x78, 0x0E, 0x00, 0x3C, 0x0F, 0x00, 0x1C, 0x07, 0x80, 0x0E, 0x03,
  0xC0, 0x0F, 0x01, 0xC0, 0x07, 0x80, 0xE0, 0x03, 0xC0, 0xF0, 0x01, 0xE0,
  0x78, 0x1F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF0, 0x3C,
  0x07, 0x00, 0x1E, 0x07, 0x80, 0x0F, 0x03, 0xC0, 0x07, 0x01, 0xE0, 0x03,
  0x80, 0xF0, 0x03, 0xC0, 0x70, 0x01, 0xE0, 0x78, 0x00, 0xF0, 0x3C, 0x00,
  0x70, 0x1E, 0x07, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFC,
  0x0F, 0x03, 0xC0, 0x07, 0x81, 0xE0, 0x03, 0x80, 0xF0, 0x01, 0xC0, 0x78,
  0x01, 0xE0, 0x38, 0x00, 0xF0, 0x1C, 0x00, 0x78, 0x1E, 0x00, 0x38, 0x0F,
  0x00, 0x1C, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x0F, 0xF8, 0x01,
  0xFF, 0xF0, 0x1F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xDD, 0xFC, 0xF8, 0xE3,
  0xE7, 0xC7, 0x1F, 0x3E, 0x38, 0x7D, 0xF1, 0xC3, 0xEF, 0x8E, 0x00, 0x7C,
  0x70, 0x03, 0xF3, 0x80, 0x1F, 0xDC, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80,
  0x0F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x80, 0x1C, 0xFC, 0x00, 0xE3, 0xF0, 0x07, 0x0F, 0x80, 0x38, 0x7F,
  0xE1, 0xC3, 0xFF, 0x0E, 0x1F, 0xF8, 0x70, 0xFF, 0xE3, 0x8F, 0xDF, 0x9C,
  0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x1F, 0xFC, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x0F, 0xC0, 0x01, 0xE7, 0xFE, 0x00, 0x78, 0xFF,
  0xC0, 0x1E, 0x3E, 0x7C, 0x03, 0x87, 0x87, 0x80, 0xF0, 0xE0, 0x70, 0x3C,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC1, 0xE0, 0x70, 0x38, 0x78, 0x0E, 0x07,
  0x0E, 0x01, 0xE1, 0xE3, 0xC0, 0x3E, 0x7C, 0xF0, 0x03, 0xFF, 0x3C, 0x00,
  0x3F, 0xE7, 0x80, 0x03, 0xF1, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x1C, 0x7F, 0x80,
  0x07, 0x9F, 0xF8, 0x01, 0xE7, 0xCF, 0x80, 0x78, 0xF0, 0xF0, 0x0F, 0x1C,
  0x0E, 0x03, 0xC3, 0x81, 0xC0, 0xF0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x07,
  0x81, 0xC0, 0xE1, 0xE0, 0x38, 0x3C, 0x38, 0x07, 0x87, 0x8F, 0x00, 0xFF,
  0xF3, 0xC0, 0x0F, 0xFC, 0xF0, 0x00, 0x7E, 0x00, 0x01, 0xFE, 0x00, 0x07,
  0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x1F, 0x07, 0xE0, 0x3E,
  0x03, 0xE0, 0x3E, 0x01, 0xE0, 0x3E, 0x01, 0xE0, 0x3E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x7F,
  0xF8, 0x3E, 0xF8, 0xF8, 0x3E, 0xF8, 0x7C, 0x7C, 0xF8, 0x3E, 0x78, 0xF8,
  0x3E, 0xF8, 0xF8, 0x1F, 0xF0, 0xF8, 0x0F, 0xF0, 0xF8, 0x0F, 0xE0, 0xF8,
  0x07, 0xE0, 0xF8, 0x07, 0xE0, 0xF8, 0x07, 0xF0, 0x7C, 0x1F, 0xF0, 0x7F,
  0xFF, 0xF8, 0x3F, 0xFE, 0x7C, 0x1F, 0xFC, 0x3E, 0x0F, 0xF8, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x78, 0x00, 0x04, 0x00, 0xF0,
  0x0F, 0xC0, 0x7F, 0x03, 0xFC, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x00,
  0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x80, 0x7F, 0xC0, 0xFF, 0x01, 0xFC, 0x01, 0xF0, 0x01, 0xC0,
  0x80, 0x03, 0xC0, 0x0F, 0xC0, 0x3F, 0x80, 0xFF, 0x00, 0xFE, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xF8, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xE0,
  0x1F, 0x00, 0xFC, 0x07, 0xE0, 0x7F, 0x0F, 0xF8, 0x3F, 0xC0, 0xFE, 0x03,
  0xE0, 0x0E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0xE0,
  0x70, 0x38, 0xFC, 0x38, 0x7E, 0x7F, 0x9C, 0xFF, 0x7F, 0xEE, 0xFF, 0xCF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xDE, 0x00, 0x03, 0xEF, 0x80, 0x03, 0xE3, 0xE0, 0x01, 0xF1, 0xF0,
  0x01, 0xF0, 0x7C, 0x01, 0xF8, 0x3F, 0x00, 0xF8, 0x0F, 0x80, 0x38, 0x03,
  0x80, 0x04, 0x01, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0xC7, 0xF1, 0xF8, 0x7E, 0x1F, 0x0F, 0xC3, 0xF0, 0xF8, 0x3E, 0x1F,
  0x07, 0xC1, 0xE0, 0x78, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x10, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xBE, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC7, 0xF0,
  0x7F, 0x3E, 0x00, 0xF9, 0xF0, 0x07, 0xDF, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x7F, 0xE3, 0xE3, 0xFF, 0x1F, 0x1F, 0xF8, 0xF8, 0xFF, 0xC7, 0xC7, 0xFE,
  0x3E, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xDF, 0x00, 0x7C, 0xF8,
  0x03, 0xE7, 0xE0, 0x7F, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x01, 0xFF, 0xF0,
  0x03, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0x00, 0x3F,
  0xF8, 0x07, 0xF7, 0xC0, 0x7F, 0x3E, 0x03, 0xF1, 0xF0, 0x1E, 0x0F, 0x80,
  0xE0, 0x7C, 0x06, 0x03, 0xE0, 0x20, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xFC, 0x07,
  0xFF, 0xF0, 0x7F, 0xFF, 0xC7, 0xF0, 0x7E, 0x3E, 0x01, 0xFB, 0xF0, 0x07,
  0xDF, 0x00, 0x3E, 0xF8, 0x01, 0xF7, 0xC0, 0x07, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xFF,
  0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE7,
  0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x3F, 0x7E, 0x07, 0xE7, 0xFF, 0xFE,
  0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x81, 0xF1, 0xF0, 0x1F,
  0x3E, 0x01, 0xF7, 0xE0, 0x1F, 0x7C, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB,
  0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x1C, 0x0F,
  0x9F, 0xF1, 0xF7, 0xFF, 0x3F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFC, 0x07, 0xFF,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0xC0, 0xFE, 0xFF, 0xFF, 0x8F, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0xBF, 0x80, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x7F, 0xDF, 0xF3, 0xF0,
  0x1F, 0xBF, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x3E, 0xF8, 0x03, 0xE7, 0xE0, 0x3F, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x01,
  0xFF, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x00, 0x3E, 0xF8, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x7F,
  0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xF0, 0x7E, 0x3F, 0x01, 0xF9,
  0xF0, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0x9F, 0x00,
  0x7C, 0x7C, 0x07, 0xC3, 0xF0, 0x7E, 0x0F, 0xC7, 0xE0, 0x3F, 0xFE, 0x00,
  0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x7F, 0xFC, 0x07, 0xE3, 0xF0, 0x7E, 0x0F,
  0xC7, 0xC0, 0x3F, 0x3E, 0x00, 0xFB, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3E, 0xF8, 0x03, 0xE7, 0xE0, 0x3F,
  0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x81, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC7, 0xF0, 0x7F,
  0x3E, 0x00, 0xFB, 0xF0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F,
  0xF0, 0x07, 0xEF, 0xC0, 0x7E, 0x7F, 0xDF, 0xF1, 0xFF, 0xFF, 0x87, 0xFF,
  0xF8, 0x1F, 0xEF, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xE0, 0x00, 0x7D, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0x7C,
  0x0F, 0x83, 0xF8, 0x7F, 0x1F, 0xF1, 0xFC, 0x3F, 0x83, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x07, 0xE1, 0xF8, 0x3F, 0x07, 0xE0, 0xF8, 0x3F, 0x07, 0xC0,
  0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x1E, 0x07, 0xC0, 0x00, 0x00, 0x20, 0x00,
  0x1C, 0x00, 0x0F, 0x80, 0x07, 0xF0, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x03, 0xF8, 0x00, 0x7C, 0x00,
  0x0F, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFE, 0x00, 0x07,
  0xC0, 0x00, 0x38, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0x03,
  0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0x80, 0x01, 0xF0,
  0x00, 0x1E, 0x00, 0x0F, 0xC0, 0x07, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x01,
  0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x0F, 0xE0, 0x01, 0xF0, 0x00, 0x38,
  0x00, 0x04, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0xF0, 0xFF, 0xF8, 0xFF, 0xFC,
  0xFF, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0xFE, 0x1F, 0xFE,
  0x1F, 0xFC, 0x1F, 0xF8, 0x1F, 0xE0, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0x00, 0x01, 0xFF,
  0x80, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFE, 0x1F, 0xC3, 0xF0, 0x07,
  0xCF, 0x80, 0x07, 0x9F, 0x00, 0x0F, 0xBC, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x7C, 0xFF, 0x03, 0xFC, 0xFE,
  0x07, 0xFD, 0xFC, 0x1F, 0x0F, 0xF8, 0x3C, 0x0F, 0xF0, 0x78, 0x1F, 0xE0,
  0xF0, 0x3F, 0xC1, 0xE0, 0x7F, 0x83, 0xC0, 0xFF, 0x07, 0x81, 0xFE, 0x0F,
  0x03, 0xFC, 0x1E, 0x07, 0xF8, 0x3C, 0x0F, 0xF0, 0x78, 0x1F, 0xE0, 0xF0,
  0x3F, 0xC1, 0xF0, 0xFF, 0x83, 0xFF, 0xFF, 0x03, 0xFE, 0xFE, 0x03, 0xF9,
  0xFC, 0x00, 0x80, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1E, 0xF0, 0x00, 0x3D,
  0xE0, 0x00, 0x7B, 0xC0, 0x01, 0xF7, 0xC0, 0x03, 0xEF, 0x80, 0x07, 0x8F,
  0x00, 0x0F, 0x1E, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF0, 0x78,
  0x01, 0xE0, 0xF0, 0x07, 0xC1, 0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0x07, 0xC0,
  0x3C, 0x07, 0x80, 0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0x03, 0xFF, 0xFE, 0x07,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x7C, 0x01, 0xF0, 0xF0,
  0x01, 0xE3, 0xE0, 0x03, 0xE7, 0xC0, 0x07, 0xCF, 0x80, 0x0F, 0x9E, 0x00,
  0x0F, 0x7C, 0x00, 0x1F, 0xF8, 0x00, 0x3E, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xF8, 0x1F, 0xEF, 0x80, 0x7E, 0xF8, 0x03,
  0xEF, 0x80, 0x3E, 0xF8, 0x01, 0xEF, 0x80, 0x1E, 0xF8, 0x03, 0xEF, 0x80,
  0x3E, 0xF8, 0x07, 0xEF, 0x80, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFC, 0xF8, 0x0F, 0xEF, 0x80, 0x3E, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xCF, 0xFF, 0xF0, 0xFF, 0xFC, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0xF0, 0x3F,
  0xFF, 0x87, 0xFF, 0xFC, 0x7E, 0x0F, 0xEF, 0xC0, 0x3E, 0xF8, 0x03, 0xEF,
  0x80, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x03, 0xEF, 0xC0, 0x3E, 0x7E, 0x0F, 0xE7, 0xFF, 0xFC, 0x3F, 0xFF, 0x81,
  0xFF, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xCF, 0x80, 0xFE, 0xF8, 0x03, 0xEF, 0x80,
  0x3E, 0xF8, 0x01, 0xEF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xEF, 0x80, 0x3E, 0xF8, 0x03,
  0xEF, 0x80, 0x7E, 0xF8, 0x3F, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF,
  0xE0, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFC, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xEF, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x87, 0xFF, 0xFC,
  0x7E, 0x0F, 0xEF, 0xC0, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0,
  0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xEF, 0xC0, 0x3E,
  0x7E, 0x07, 0xE7, 0xFF, 0xFC, 0x3F, 0xFF, 0x81, 0xFF, 0xF0, 0x07, 0xFE,
  0x00, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01,
  0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xBE,
  0x00, 0x7D, 0xF8, 0x07, 0xE7, 0xE0, 0x7F, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x03, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xBE,
  0x00, 0x7D, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x03, 0xE3, 0xE0, 0x1F,
  0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x87, 0xC0, 0xF8, 0x3E, 0x07, 0xC1, 0xF0,
  0x7C, 0x0F, 0x83, 0xE0, 0x7C, 0x3E, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x00,
  0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3E, 0x1F, 0x81, 0xF0, 0x7C, 0x0F, 0x83,
  0xE0, 0x7C, 0x1F, 0x83, 0xE0, 0x7C, 0x1F, 0x03, 0xF0, 0xF8, 0x0F, 0x87,
  0xC0, 0x7E, 0x3E, 0x01, 0xF1, 0xF0, 0x0F, 0xCF, 0x80, 0x3E, 0x7C, 0x01,
  0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x3F, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0xFF,
  0xFC, 0x07, 0xFE, 0xE0, 0x3B, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFE, 0xE0,
  0xEF, 0xF7, 0x87, 0x7F, 0xBC, 0x7B, 0xFC, 0xE3, 0x9F, 0xE7, 0x1C, 0xFF,
  0x3D, 0xE7, 0xF8, 0xEF, 0x3F, 0xC7, 0x71, 0xFE, 0x3F, 0x8F, 0xF0, 0xFC,
  0x7F, 0x87, 0xC3, 0xFC, 0x3E, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xF8, 0xFC, 0x01, 0xFF, 0x80, 0x3F,
  0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F,
  0xF8, 0x0F, 0xF7, 0x81, 0xFE, 0xF0, 0x3F, 0xDE, 0x07, 0xF9, 0xE0, 0xFF,
  0x3C, 0x1F, 0xE7, 0x83, 0xFC, 0x78, 0x7F, 0x8F, 0x0F, 0xF1, 0xF1, 0xFE,
  0x1E, 0x3F, 0xC3, 0xC7, 0xF8, 0x3C, 0xFF, 0x07, 0x9F, 0xE0, 0xF3, 0xFC,
  0x0F, 0x7F, 0x81, 0xEF, 0xF0, 0x3D, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8,
  0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF0,
  0x07, 0xE0, 0x07, 0xFC, 0x03, 0xFF, 0xE0, 0xFF, 0xFE, 0x3F, 0xFF, 0xE7,
  0xE0, 0xFD, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x03, 0xF7, 0xE0, 0xFC, 0xFF,
  0xFF, 0x8F, 0xFF, 0xE0, 0xFF, 0xF8, 0x07, 0xFC, 0x00, 0xFF, 0xFC, 0x07,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x7C, 0x01,
  0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFB, 0xE0, 0x0F,
  0xDF, 0x03, 0xFE, 0xFF, 0xFF, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF, 0xE1, 0xFF,
  0xF8, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC7, 0xF0,
  0x7F, 0x3F, 0x01, 0xF9, 0xF0, 0x07, 0xDF, 0x00, 0x1E, 0xF8, 0x00, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xDF, 0x00, 0x7C, 0xF8,
  0x03, 0xE7, 0xF0, 0x7F, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x01, 0xFF, 0xF0,
  0x03, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8,
  0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0x83,
  0xFE, 0x7C, 0x03, 0xF3, 0xE0, 0x0F, 0xDF, 0x00, 0x3E, 0xF8, 0x01, 0xF7,
  0xC0, 0x0F, 0xBE, 0x00, 0x7D, 0xF0, 0x03, 0xEF, 0x80, 0x1F, 0x7C, 0x01,
  0xFB, 0xE0, 0x1F, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC, 0x3F,
  0xFF, 0x81, 0xFF, 0xF8, 0x0F, 0x83, 0xE0, 0x7C, 0x1F, 0x03, 0xE0, 0x7C,
  0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x87, 0xC0, 0x7C, 0x3E, 0x03, 0xF1, 0xF0,
  0x0F, 0x8F, 0x80, 0x7E, 0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0xDF, 0x00, 0x3E,
  0xF8, 0x01, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x7F,
  0xFF, 0xC3, 0xF0, 0x7F, 0x3E, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x1F,
  0x7C, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x80,
  0x1F, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x3F, 0xF8, 0x03, 0xF7, 0xE0, 0x3F, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x83, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x03, 0xF7,
  0xE0, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFC, 0x00,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7D, 0xF0, 0x00, 0xF3, 0xE0, 0x03, 0xE7,
  0xC0, 0x07, 0xCF, 0x80, 0x0F, 0x8F, 0x00, 0x1E, 0x1F, 0x00, 0x7C, 0x3E,
  0x00, 0xF8, 0x7C, 0x01, 0xF0, 0x78, 0x03, 0xC0, 0xF8, 0x0F, 0x81, 0xF0,
  0x1F, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x78, 0x07, 0xC0, 0xF0, 0x0F, 0x83,
  0xE0, 0x1F, 0x07, 0xC0, 0x1E, 0x0F, 0x00, 0x3E, 0x1E, 0x00, 0x7C, 0x7C,
  0x00, 0xF8, 0xF8, 0x00, 0xF1, 0xE0, 0x01, 0xF3, 0xC0, 0x03, 0xEF, 0x80,
  0x07, 0xDF, 0x00, 0x07, 0xBC, 0x00, 0x0F, 0x78, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0xF0,
  0x3E, 0x07, 0xF8, 0x1F, 0x03, 0xFE, 0x0F, 0x81, 0xFF, 0x07, 0xC1, 0xFF,
  0x83, 0x60, 0xFB, 0xC1, 0xB0, 0x79, 0xE0, 0xDC, 0x3C, 0xF0, 0xEE, 0x1E,
  0x78, 0x77, 0x0F, 0x3C, 0x3B, 0x87, 0x9E, 0x1D, 0xC3, 0xCF, 0x0E, 0xE1,
  0xE7, 0x87, 0x70, 0xF3, 0xE3, 0x18, 0x78, 0xF1, 0x8C, 0x78, 0x79, 0xC7,
  0x3C, 0x3C, 0xE3, 0x9E, 0x1E, 0x71, 0xCF, 0x0F, 0x38, 0xE7, 0x87, 0x9C,
  0x73, 0xC3, 0xCE, 0x39, 0xE1, 0xE7, 0x1C, 0xF0, 0xF3, 0x06, 0x78, 0x79,
  0x83, 0x38, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x7F, 0x03,
  0xF8, 0x3F, 0x81, 0xFC, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7E, 0x07, 0xF0,
  0x3F, 0x01, 0xF8, 0x1F, 0x80, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0xF8, 0x00,
  0xF9, 0xF8, 0x03, 0xF1, 0xF0, 0x07, 0xC3, 0xF0, 0x1F, 0x83, 0xE0, 0x3E,
  0x07, 0xE0, 0xF8, 0x07, 0xC1, 0xF0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x80,
  0x0F, 0xBE, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xF0, 0x01, 0xF3,
  0xF0, 0x03, 0xE3, 0xE0, 0x0F, 0x83, 0xE0, 0x1F, 0x07, 0xC0, 0x7C, 0x07,
  0xC0, 0xF8, 0x0F, 0x83, 0xE0, 0x0F, 0x8F, 0xC0, 0x1F, 0x9F, 0x00, 0x1F,
  0x7E, 0x00, 0x3F, 0xF8, 0x00, 0x3E, 0xFC, 0x00, 0x1F, 0xBE, 0x00, 0x0F,
  0x9F, 0x00, 0x07, 0xC7, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE0, 0xF8, 0x03,
  0xE0, 0x7C, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x03, 0xE0,
  0xF8, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x0F,
  0x9E, 0x00, 0x07, 0xDF, 0x00, 0x01, 0xEF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80,
  0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3D, 0xE0, 0x01, 0xEF, 0x00, 0x1F, 0x3C,
  0x00, 0xF1, 0xE0, 0x0F, 0x8F, 0x80, 0x78, 0x3C, 0x03, 0xC1, 0xE0, 0x3C,
  0x07, 0x81, 0xE0, 0x3C, 0x1F, 0x01, 0xF0, 0xF0, 0x07, 0x8F, 0x80, 0x3E,
  0x78, 0x00, 0xF7, 0xC0, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x1F, 0x83, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F,
  0x07, 0xF7, 0xC0, 0x1F, 0x7C, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0xFF, 0xF0, 0xFF, 0xFF, 0x3F, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xFC, 0x03, 0xFF, 0xF1, 0xEF, 0x7F, 0xFE, 0xF3, 0xFF,
  0xCF, 0x1F, 0xF8, 0xF0, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0xFE, 0x1F, 0x7F, 0xE3, 0xEF, 0xFE, 0x7F, 0xFF, 0xEF, 0xE0, 0xFF, 0xF8,
  0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0,
  0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0,
  0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xDF, 0xFC, 0xF9, 0xFE, 0x00, 0x07,
  0xFC, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x87, 0xFF, 0xFC, 0x7E, 0x0F, 0xEF,
  0xC0, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x1F, 0xF8, 0x03, 0xEF, 0xC0,
  0x3E, 0xFE, 0x07, 0xE7, 0xFF, 0xFC, 0x3F, 0xFF, 0x81, 0xFF, 0xF0, 0x07,
  0xFE, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x0F, 0xE3, 0xE3,
  0xFF, 0x7C, 0xFF, 0xEF, 0xBF, 0xFF, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFE,
  0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8,
  0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0,
  0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0xE0, 0xFE, 0xFF,
  0xFF, 0xDF, 0xFF, 0xF9, 0xFF, 0xDF, 0x0F, 0xF3, 0xE0, 0x07, 0xFC, 0x03,
  0xFF, 0xE0, 0xFF, 0xFE, 0x3F, 0xFF, 0xE7, 0xC0, 0x7D, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC3, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x01, 0xFF, 0xC0, 0x7E, 0xFF,
  0xFF, 0x8F, 0xFF, 0xE0, 0xFF, 0xF8, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xC0, 0x00, 0xF8,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0xE3, 0xE3, 0xFF, 0x7C, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F,
  0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF,
  0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xF0, 0x3F, 0xBF, 0xFF, 0xF7,
  0xFF, 0xFE, 0x7F, 0xF7, 0xC3, 0xFC, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x3F, 0xFF, 0x87,
  0xFF, 0xE0, 0xFF, 0xF8, 0x1F, 0xFE, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0xFE, 0x1F, 0x7F, 0xE3, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF,
  0xE0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0x80, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80,
  0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F,
  0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xCF, 0xFF, 0xE7,
  0xFF, 0xF3, 0xFF, 0xF9, 0xFF, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x07, 0xF9, 0xFF, 0xF8, 0xFF,
  0xF8, 0x7F, 0xF8, 0x3F, 0xF0, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xBE, 0x00, 0xFD, 0xF0,
  0x07, 0xCF, 0x80, 0x7C, 0x7C, 0x07, 0xE3, 0xE0, 0x3E, 0x1F, 0x03, 0xE0,
  0xF8, 0x3F, 0x07, 0xC1, 0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0x7F, 0xFE, 0x03, 0xE1, 0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x3F, 0x07,
  0xC0, 0xFC, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x8F, 0x80, 0x7E, 0x7C, 0x01,
  0xF3, 0xE0, 0x0F, 0xDF, 0x00, 0x3E, 0xF8, 0x01, 0xF8, 0xFF, 0xF8, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF,
  0xF3, 0xC3, 0xE7, 0xBF, 0x3F, 0xBF, 0xFF, 0xFF, 0xFB, 0xFB, 0xFF, 0x0F,
  0x87, 0xF8, 0x38, 0x3F, 0xC1, 0xC1, 0xFE, 0x0E, 0x0F, 0xF0, 0x70, 0x7F,
  0x83, 0x83, 0xFC, 0x1C, 0x1F, 0xE0, 0xE0, 0xFF, 0x07, 0x07, 0xF8, 0x38,
  0x3F, 0xC1, 0xC1, 0xFE, 0x0E, 0x0F, 0xF0, 0x70, 0x7F, 0x83, 0x83, 0xFC,
  0x1C, 0x1F, 0xE0, 0xE0, 0xFF, 0x07, 0x07, 0xF8, 0x38, 0x3F, 0xC1, 0xC1,
  0xFE, 0x0E, 0x0F, 0xF0, 0x70, 0x78, 0xF8, 0xFE, 0x1F, 0x7F, 0xE3, 0xFF,
  0xFE, 0x7F, 0xFF, 0xEF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0xC0,
  0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xE0, 0x07, 0xFC, 0x03, 0xFF, 0xE0, 0xFF,
  0xFE, 0x3F, 0xFF, 0xE7, 0xE0, 0xFD, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0xC0,
  0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0xE0, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF,
  0xE0, 0xFF, 0xF8, 0x07, 0xFC, 0x00, 0xF8, 0xFE, 0x1F, 0x7F, 0xE3, 0xEF,
  0xFE, 0x7F, 0xFF, 0xEF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0xC0,
  0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80,
  0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xF7, 0xDF, 0xFC, 0xF9, 0xFE, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0xE3, 0xE3, 0xFF, 0x7C, 0xFF, 0xEF, 0xBF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xFE, 0x00,
  0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x03,
  0xFF, 0xE0, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xF9, 0xFF, 0xDF, 0x0F, 0xF3,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0xF1, 0xFE, 0x0F, 0x3F,
  0xF0, 0xF7, 0xFF, 0x8F, 0x7F, 0xFC, 0xFE, 0x0F, 0xEF, 0xC0, 0x7E, 0xF8,
  0x03, 0xEF, 0x80, 0x3E, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0xFE, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0xC7, 0xFF, 0xFE, 0xFC, 0x07, 0xEF,
  0x80, 0x3E, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x3F,
  0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0x80,
  0x1F, 0xFC, 0x03, 0xEF, 0xFF, 0xFE, 0x7F, 0xFF, 0xC3, 0xFF, 0xF8, 0x0F,
  0xFF, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xF8, 0x03, 0xFF,
  0xE0, 0x07, 0xFF, 0x80, 0x07, 0xFE, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0,
  0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xFE, 0x03, 0xF7, 0xE0, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF,
  0xE0, 0xFF, 0xF8, 0x07, 0xFC, 0x00, 0xF8, 0x00, 0x3E, 0xF0, 0x00, 0x79,
  0xF0, 0x01, 0xF3, 0xE0, 0x03, 0xE3, 0xC0, 0x07, 0xC7, 0xC0, 0x1F, 0x0F,
  0x80, 0x3E, 0x0F, 0x00, 0x7C, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x3C,
  0x07, 0xC0, 0x7C, 0x1F, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x7C, 0x01, 0xF1,
  0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xC7, 0xC0, 0x07, 0xCF, 0x00, 0x0F, 0xBE,
  0x00, 0x1F, 0x7C, 0x00, 0x1E, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0xF0, 0x3E, 0x07, 0xFC, 0x1F, 0x03,
  0xDE, 0x0F, 0x83, 0xCF, 0x07, 0xC1, 0xE7, 0x83, 0x60, 0xF3, 0xC1, 0xB0,
  0x79, 0xE1, 0xDC, 0x3C, 0xF0, 0xEE, 0x1E, 0x3C, 0x77, 0x0E, 0x1E, 0x3B,
  0x8F, 0x0F, 0x1D, 0xC7, 0x87, 0x8C, 0x63, 0xC3, 0xC6, 0x31, 0xE1, 0xE7,
  0x1C, 0xF0, 0xF3, 0x8E, 0x70, 0x3D, 0xC7, 0x38, 0x1E, 0xE3, 0xBC, 0x0F,
  0x60, 0xDE, 0x07, 0xB0, 0x6F, 0x03, 0xF8, 0x3F, 0x81, 0xFC, 0x1F, 0xC0,
  0x7E, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0x80, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0xFC, 0x01, 0xF8, 0xFC, 0x03, 0xE0, 0xF8, 0x0F,
  0x81, 0xF8, 0x3F, 0x01, 0xF0, 0x7C, 0x01, 0xF1, 0xF0, 0x03, 0xF7, 0xE0,
  0x03, 0xEF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xC0, 0x01, 0xF7, 0xC0, 0x03,
  0xEF, 0x80, 0x0F, 0x8F, 0x80, 0x3F, 0x1F, 0x80, 0x7C, 0x1F, 0x01, 0xF0,
  0x1F, 0x07, 0xE0, 0x3F, 0x0F, 0x80, 0x3E, 0x3E, 0x00, 0x3E, 0xFC, 0x00,
  0x7E, 0xFC, 0x00, 0x3E, 0xF8, 0x00, 0xF9, 0xF0, 0x01, 0xF3, 0xF0, 0x03,
  0xE3, 0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0xF8,
  0x1F, 0x01, 0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x0F, 0x80, 0x3E, 0x1F, 0x00,
  0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x00, 0xF9, 0xF0, 0x01, 0xF7, 0xC0, 0x03,
  0xEF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xE0, 0x7F, 0xF8, 0x0F,
  0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x00,
  0x1F, 0xE0, 0x00, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFE, 0x00, 0x1F, 0xE0, 0x03,
  0xFE, 0x00, 0x7F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0xC0,
  0x7F, 0xF8, 0x1F, 0x80, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x7F,
  0x80, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x00, 0x01, 0xFE, 0x03, 0xDF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0x9F, 0x87,
  0xF8, 0x7C, 0x3F, 0xC1, 0xFF, 0xFE, 0x07, 0xFE, 0xF0, 0x1F, 0xF7, 0x80,
  0x7E, 0x00,
};

const GFXglyph JetBrainsMono_Medium45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 27, 0, -1 },
  { 1, 7, 33, 27, 10, -33 },
  { 30, 15, 14, 27, 6, -33 },
  { 57, 25, 33, 27, 1, -33 },
  { 161, 21, 45, 27, 3, -39 },
  { 280, 27, 33, 27, 0, -33 },
  { 392, 24, 33, 27, 2, -33 },
  { 491, 5, 14, 27, 11, -33 },
  { 500, 14, 43, 27, 8, -38 },
  { 576, 14, 43, 27, 5, -38 },
  { 652, 25, 23, 27, 1, -27 },
  { 724, 21, 21, 27, 3, -25 },
  { 780, 10, 14, 27, 7, -7 },
  { 798, 15, 4, 27, 6, -17 },
  { 806, 7, 8, 27, 10, -8 },
  { 813, 21, 42, 27, 3, -37 },
  { 924, 21, 33, 27, 3, -33 },
  { 1011, 21, 33, 27, 4, -33 },
  { 1098, 21, 33, 27, 3, -33 },
  { 1185, 20, 33, 27, 3, -33 },
  { 1268, 20, 33, 27, 3, -33 },
  { 1351, 19, 33, 27, 4, -33 },
  { 1430, 21, 33, 27, 3, -33 },
  { 1517, 21, 33, 27, 3, -33 },
  { 1604, 21, 33, 27, 3, -33 },
  { 1691, 21, 33, 27, 3, -33 },
  { 1778, 7, 25, 27, 10, -25 },
  { 1800, 11, 32, 27, 7, -25 },
  { 1844, 19, 24, 27, 4, -27 },
  { 1901, 19, 16, 27, 4, -23 },
  { 1939, 19, 24, 27, 4, -27 },
  { 1996, 16, 33, 27, 6, -33 },
  { 2062, 23, 41, 27, 2, -33 },
  { 2180, 23, 33, 27, 2, -33 },
  { 2275, 20, 33, 27, 4, -33 },
  { 2358, 20, 33, 27, 4, -33 },
  { 2441, 20, 33, 27, 4, -33 },
  { 2524, 20, 33, 27, 4, -33 },
  { 2607, 20, 33, 27, 4, -33 },
  { 2690, 20, 33, 27, 4, -33 },
  { 2773, 19, 33, 27, 4, -33 },
  { 2852, 19, 33, 27, 4, -33 },
  { 2931, 21, 33, 27, 2, -33 },
  { 3018, 21, 33, 27, 4, -33 },
  { 3105, 19, 33, 27, 5, -33 },
  { 3184, 21, 33, 27, 3, -33 },
  { 3271, 19, 33, 27, 4, -33 },
  { 3350, 19, 33, 27, 4, -33 },
  { 3429, 21, 33, 27, 4, -33 },
  { 3516, 21, 41, 27, 3, -33 },
  { 3624, 21, 33, 27, 4, -33 },
  { 3711, 21, 33, 27, 3, -33 },
  { 3798, 23, 33, 27, 2, -33 },
  { 3893, 19, 33, 27, 4, -33 },
  { 3972, 23, 33, 27, 2, -33 },
  { 4067, 25, 33, 27, 1, -33 },
  { 4171, 23, 33, 27, 2, -33 },
  { 4266, 25, 33, 27, 1, -33 },
  { 4370, 19, 33, 27, 4, -33 },
  { 4449, 12, 42, 27, 9, -37 },
  { 4512, 21, 42, 27, 3, -37 },
  { 4623, 12, 42, 27, 6, -37 },
  { 4686, 21, 18, 27, 3, -33 },
  { 4734, 21, 4, 27, 3, 1 },
  { 4745, 10, 6, 27, 8, -35 },
  { 4753, 20, 25, 27, 3, -25 },
  { 4816, 19, 33, 27, 4, -33 },
  { 4895, 20, 25, 27, 4, -25 },
  { 4958, 19, 33, 27, 4, -33 },
  { 5037, 19, 25, 27, 4, -25 },
  { 5097, 21, 33, 27, 3, -33 },
  { 5184, 19, 33, 27, 4, -25 },
  { 5263, 19, 33, 27, 4, -33 },
  { 5342, 21, 35, 27, 4, -35 },
  { 5434, 17, 43, 27, 4, -35 },
  { 5526, 21, 33, 27, 4, -33 },
  { 5613, 24, 33, 27, 1, -33 },
  { 5712, 21, 25, 27, 3, -25 },
  { 5778, 19, 25, 27, 4, -25 },
  { 5838, 19, 25, 27, 4, -25 },
  { 5898, 19, 33, 27, 4, -25 },
  { 5977, 19, 33, 27, 4, -25 },
  { 6056, 20, 25, 27, 5, -25 },
  { 6119, 20, 25, 27, 4, -25 },
  { 6182, 22, 32, 27, 2, -32 },
  { 6270, 19, 25, 27, 4, -25 },
  { 6330, 23, 25, 27, 2, -25 },
  { 6402, 25, 25, 27, 1, -25 },
  { 6481, 23, 25, 27, 2, -25 },
  { 6553, 23, 33, 27, 2, -25 },
  { 6648, 19, 25, 27, 4, -25 },
  { 6708, 19, 42, 27, 4, -37 },
  { 6808, 5, 42, 27, 11, -37 },
  { 6835, 19, 42, 27, 4, -37 },
  { 6935, 21, 10, 27, 3, -21 },
};

const GFXfont JetBrainsMono_Medium45pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Medium45pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Medium45pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _JETBRAINSMONO_MEDIUM45PT7B_H_
