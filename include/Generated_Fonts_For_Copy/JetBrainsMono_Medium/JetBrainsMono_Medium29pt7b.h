#ifndef _JETBRAINSMONO_MEDIUM29PT7B_H_
#define _JETBRAINSMONO_MEDIUM29PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Medium.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Medium29pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x18, 0xC0, 0x01,
  0x1F, 0xF7, 0x80, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7,
  0xE3, 0x80, 0x06, 0x0C, 0x06, 0x1C, 0x06, 0x1C, 0x0E, 0x18, 0x0E, 0x18,
  0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x0C, 0x38, 0x1C, 0x30, 0x1C, 0x30,
  0x18, 0x30, 0x18, 0x70, 0xFF, 0xFE, 0xFF, 0xFE, 0x38, 0x60, 0x30, 0x60,
  0x30, 0x60, 0x30, 0xE0, 0x30, 0xE0, 0x70, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x1F, 0xE0, 0xFF, 0xC7, 0xBF, 0x9C, 0xCE, 0xF3, 0x3B,
  0x8C, 0x0F, 0x30, 0x1C, 0xC0, 0x7F, 0x00, 0xFF, 0x01, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x0C, 0xE0, 0x33, 0xB8, 0xCF, 0xE3, 0x3B, 0xCC, 0xE7, 0xFF,
  0x8F, 0xFC, 0x1F, 0xC0, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x3E,
  0x03, 0xBF, 0x81, 0x98, 0xE1, 0x9C, 0x71, 0xCE, 0x38, 0xC7, 0x1C, 0xC1,
  0x8E, 0xE0, 0xFE, 0xE0, 0x3E, 0x60, 0x00, 0x70, 0x00, 0x70, 0x00, 0x31,
  0x00, 0x33, 0xF0, 0x3B, 0xFC, 0x19, 0x8E, 0x18, 0xC3, 0x1C, 0x61, 0x8C,
  0x30, 0xCC, 0x18, 0xEE, 0x0F, 0xEE, 0x03, 0xE0, 0x0F, 0xE0, 0x1F, 0xF0,
  0x3C, 0x70, 0x38, 0x38, 0x38, 0x38, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0x7F, 0x00, 0x77, 0x8E, 0xF3, 0x9C, 0xE1, 0xDC,
  0xE0, 0xF8, 0xE0, 0xF8, 0xE0, 0x70, 0x70, 0xF8, 0x79, 0xFC, 0x7F, 0xDC,
  0x3F, 0x8F, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0x83, 0xC3, 0xE3, 0xC3, 0xC3,
  0xC1, 0xC0, 0xE0, 0xF0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1E, 0x07, 0x03, 0xC0, 0xF0, 0x7C, 0x1F, 0x83, 0xC0,
  0xE0, 0xE0, 0x7C, 0x3F, 0x07, 0xC0, 0xE0, 0x38, 0x1C, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x78, 0x38, 0x3C, 0x7C, 0xFC, 0x7C, 0x38, 0x00, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x04, 0x38, 0x3E, 0x33, 0xFF, 0x5F, 0xBF, 0xFE, 0x01,
  0x80, 0x07, 0x80, 0x3B, 0x80, 0x73, 0x81, 0xC7, 0x87, 0x87, 0x06, 0x0C,
  0x00, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x3D, 0xE7, 0x9C, 0x73, 0xCE, 0x38, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x77,
  0xFF, 0xF7, 0x80, 0x00, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0F, 0x00,
  0x70, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x78,
  0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03,
  0xC0, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x38, 0x00, 0x1F,
  0xC1, 0xFF, 0x9E, 0x3D, 0xE0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE2, 0x3F, 0x39, 0xF9, 0xEF, 0xCE, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3B, 0x83, 0xDF, 0x7C, 0x7F, 0xE1, 0xFC, 0x00, 0x0F, 0x80,
  0x7E, 0x03, 0xF8, 0x3E, 0xE0, 0xF3, 0x83, 0x0E, 0x08, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x07, 0xFF, 0xDF, 0xFF, 0x7F, 0xFC, 0x1F,
  0xC1, 0xFF, 0x9F, 0x3D, 0xE0, 0xFE, 0x03, 0xF0, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x70, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xF3,
  0xFF, 0x9F, 0xFC, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x0F,
  0xC0, 0x7F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0xFC, 0x07,
  0xE0, 0x3F, 0x83, 0xDF, 0x7C, 0x7F, 0xC1, 0xFC, 0x00, 0x00, 0xF0, 0x0F,
  0x00, 0x70, 0x07, 0x00, 0x78, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x3C, 0x01,
  0xC1, 0xDE, 0x0F, 0xE0, 0x7E, 0x03, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x7F, 0xF3, 0xFF, 0x9F,
  0xFC, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0xF8, 0x7F, 0xF3, 0xFF,
  0x9E, 0x1E, 0xE0, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0xE0, 0x3B,
  0x83, 0xDF, 0x7C, 0x7F, 0xE1, 0xFC, 0x00, 0x03, 0xC0, 0x0E, 0x00, 0x78,
  0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0E, 0x00, 0x7B, 0xE1, 0xFF,
  0xCF, 0xDF, 0xBC, 0x1E, 0xE0, 0x3B, 0x80, 0xFE, 0x01, 0xF8, 0x0F, 0xE0,
  0x3B, 0xC1, 0xE7, 0xDF, 0x0F, 0xFC, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x0E, 0xE0, 0x3B, 0x81, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0,
  0x03, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xE0,
  0x07, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x1F, 0xE1, 0xFF,
  0x9E, 0x3C, 0xE0, 0xFF, 0x03, 0xF8, 0x1D, 0xC1, 0xEF, 0x0E, 0x3D, 0xE0,
  0xFE, 0x07, 0xF0, 0x7B, 0xC7, 0x87, 0x78, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x83, 0xDF, 0x7E, 0x7F, 0xE1, 0xFC, 0x00, 0x1F, 0xC0, 0xFF, 0xC7,
  0x8F, 0xBC, 0x0E, 0xE0, 0x3B, 0x80, 0xFE, 0x01, 0xF8, 0x0F, 0xE0, 0x3B,
  0xC1, 0xE7, 0xFF, 0x8F, 0xFC, 0x1F, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x70,
  0x03, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x1E, 0x00, 0x7F, 0xFE, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xEF, 0x3D, 0xF7, 0xCF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0xE7, 0x9E, 0x71, 0xCE, 0x38, 0xE0, 0x00,
  0x18, 0x03, 0xC0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x03, 0xE0, 0x1C, 0x00,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0x80, 0x3C, 0x00, 0x60,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0x07, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x03, 0x00, 0xF8, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC0, 0x78, 0x03, 0x00, 0x00, 0xFE, 0x3F, 0xEF, 0xF8, 0x0F, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x03, 0xCF, 0xE3, 0xF8, 0xF8, 0x38, 0x0E, 0x03,
  0x80, 0x00, 0x00, 0x04, 0x07, 0x81, 0xF0, 0x78, 0x00, 0x0F, 0xF0, 0x3F,
  0xF8, 0xE0, 0x73, 0x80, 0x76, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF0, 0xFB,
  0xE3, 0xFF, 0xC7, 0x1F, 0x8E, 0x1F, 0x18, 0x3E, 0x30, 0x7C, 0x60, 0xF8,
  0xC1, 0xF1, 0x83, 0xE3, 0x8F, 0xC7, 0xFF, 0x87, 0xDF, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0xC0, 0x0F, 0x80, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x37, 0x00, 0xEE, 0x01, 0xDC, 0x03, 0x98, 0x07,
  0x38, 0x1C, 0x70, 0x38, 0xE0, 0x70, 0xC0, 0xE1, 0xC3, 0x83, 0x87, 0xFF,
  0x0F, 0xFF, 0x1F, 0xFE, 0x78, 0x1C, 0xE0, 0x39, 0xC0, 0x7B, 0x80, 0x7F,
  0x00, 0xE0, 0xFF, 0xC3, 0xFF, 0xCF, 0xFF, 0x3C, 0x1E, 0xF0, 0x3B, 0xC0,
  0xEF, 0x03, 0xBC, 0x1E, 0xF0, 0xF3, 0xFF, 0x8F, 0xFE, 0x3C, 0x3C, 0xF0,
  0x3B, 0xC0, 0xEF, 0x03, 0xFC, 0x0F, 0xF0, 0x3B, 0xC1, 0xEF, 0xFF, 0xBF,
  0xFC, 0xFF, 0xC0, 0x1F, 0xE1, 0xFF, 0x9F, 0x3E, 0xE0, 0x7F, 0x03, 0xF0,
  0x1F, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x07, 0xF0, 0x3B, 0x83, 0xDF, 0xFC, 0x7F, 0xE1,
  0xFC, 0x00, 0xFF, 0xC7, 0xFF, 0x3F, 0xFD, 0xE0, 0xFF, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x83, 0xFF, 0xFD, 0xFF, 0xCF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0F, 0xFE, 0xFF, 0xEE, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x1F, 0xE1, 0xFF, 0x9F, 0x3E, 0xE0, 0x7F,
  0x03, 0xF0, 0x1F, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0xFF, 0xC7,
  0xFE, 0x3F, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xF0, 0x3B, 0x83, 0xDF, 0xFC,
  0x7F, 0xE1, 0xFC, 0x00, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F,
  0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0xFC, 0x1F, 0xF0, 0x7F, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xF8, 0x0F, 0xE0, 0x39, 0xC0, 0xE7, 0xFF, 0x8F, 0xFC, 0x1F, 0xE0,
  0xF0, 0x3F, 0xC0, 0xEF, 0x07, 0xBC, 0x1C, 0xF0, 0xF3, 0xC3, 0x8F, 0x1E,
  0x3C, 0x70, 0xF3, 0xC3, 0xFE, 0x0F, 0xF8, 0x3C, 0xF0, 0xF1, 0xC3, 0xC7,
  0x8F, 0x0E, 0x3C, 0x3C, 0xF0, 0x73, 0xC1, 0xEF, 0x03, 0xBC, 0x0F, 0xF0,
  0x1C, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xF0, 0x7F, 0x83, 0xFE, 0x1F, 0xB0, 0xFD, 0x8D, 0xEE, 0x6F, 0xB3, 0x7D,
  0xBB, 0xED, 0x9F, 0x3C, 0xF9, 0xE7, 0xCE, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0x80, 0xF8,
  0x3F, 0xC1, 0xFE, 0x0F, 0xF8, 0x7F, 0xC3, 0xF6, 0x1F, 0xB8, 0xFD, 0xC7,
  0xE6, 0x3F, 0x39, 0xF9, 0xCF, 0xC6, 0x7E, 0x3B, 0xF1, 0xDF, 0x86, 0xFC,
  0x3F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC0, 0xFE, 0x07, 0x80, 0x1F, 0xC1,
  0xFF, 0x9F, 0x3C, 0xE0, 0xFF, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xF0, 0x3B, 0x83, 0xDF, 0xFC, 0x7F, 0xE1, 0xFC, 0x00, 0xFF, 0xE3, 0xFF,
  0xCF, 0xFF, 0xBC, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x3F, 0xC1, 0xEF, 0xFF, 0xBF, 0xF8, 0xFF, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x1F, 0xC0,
  0xFF, 0xC7, 0x8F, 0x3C, 0x1E, 0xE0, 0x3B, 0x80, 0xEE, 0x03, 0xB8, 0x0E,
  0xE0, 0x3B, 0x80, 0xEE, 0x03, 0xB8, 0x0E, 0xE0, 0x3B, 0x80, 0xEE, 0x03,
  0xB8, 0x0E, 0xF0, 0x39, 0xC1, 0xE7, 0xFF, 0x0F, 0xFC, 0x1F, 0xC0, 0x07,
  0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xF0, 0xFF, 0xC3, 0xFF, 0xCF,
  0xFF, 0xBC, 0x1E, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3B,
  0xC7, 0xEF, 0xFF, 0x3F, 0xF8, 0xF1, 0xC3, 0xC7, 0x0F, 0x0E, 0x3C, 0x38,
  0xF0, 0xF3, 0xC1, 0xCF, 0x07, 0xBC, 0x0E, 0xF0, 0x3C, 0x1F, 0xE0, 0xFF,
  0xC7, 0x8F, 0x9C, 0x0E, 0xF0, 0x3B, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x7C,
  0x00, 0xFF, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xB8,
  0x0F, 0xE0, 0x3B, 0xC0, 0xE7, 0xFF, 0x9F, 0xFC, 0x1F, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xF0, 0x3B, 0x83, 0xDF, 0xFC, 0x7F, 0xE1, 0xFC,
  0x00, 0xF0, 0x0E, 0xE0, 0x1D, 0xC0, 0x73, 0x80, 0xE7, 0x81, 0xC7, 0x03,
  0x8E, 0x0E, 0x1C, 0x1C, 0x3C, 0x38, 0x38, 0x70, 0x71, 0xC0, 0xE3, 0x81,
  0xE7, 0x01, 0xCE, 0x03, 0xB8, 0x07, 0x70, 0x0E, 0xE0, 0x0F, 0xC0, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xC3, 0x87, 0xE3, 0x87, 0xE3, 0xC7, 0xE3,
  0xC6, 0xE3, 0xC6, 0xE2, 0xC6, 0xE6, 0xCE, 0xE6, 0xCE, 0x66, 0xCE, 0x66,
  0x4E, 0x66, 0x4E, 0x76, 0x6C, 0x76, 0x6C, 0x74, 0x6C, 0x74, 0x6C, 0x7C,
  0x6C, 0x7C, 0x7C, 0x3C, 0x7C, 0x3C, 0x7C, 0x3C, 0x3C, 0x3C, 0x38, 0xF0,
  0x1E, 0xF0, 0x38, 0xE0, 0xF1, 0xE1, 0xC1, 0xC7, 0x83, 0xCE, 0x03, 0xB8,
  0x07, 0xF0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x7E, 0x01,
  0xDC, 0x03, 0xBC, 0x0E, 0x38, 0x3C, 0x38, 0x70, 0x79, 0xE0, 0x73, 0x80,
  0xFF, 0x00, 0xE0, 0xE0, 0x0F, 0x70, 0x0E, 0x70, 0x1C, 0x38, 0x1C, 0x38,
  0x38, 0x1C, 0x38, 0x1C, 0x70, 0x1E, 0x70, 0x0E, 0xE0, 0x0E, 0xE0, 0x07,
  0xE0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x7F, 0xFB, 0xFF,
  0xDF, 0xFE, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x38, 0x03, 0x80,
  0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x78,
  0x03, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x0E,
  0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3,
  0x87, 0x0E, 0x1C, 0x38, 0x70, 0xFF, 0xFF, 0xF8, 0xE0, 0x03, 0x80, 0x1C,
  0x00, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0x70,
  0x03, 0x80, 0x1E, 0x00, 0x70, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x03, 0x80,
  0x0E, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00,
  0x70, 0x01, 0xC0, 0x0E, 0xFF, 0xFF, 0xFF, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0xFF, 0xFF, 0xFF, 0x07, 0x80, 0x7C, 0x03, 0xE0,
  0x1B, 0x81, 0xCC, 0x0C, 0x70, 0xE3, 0x87, 0x0E, 0x70, 0x73, 0x81, 0xF8,
  0x0E, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0xE0, 0xE0, 0xF0, 0x1F, 0xC1, 0xFF,
  0x9F, 0x7C, 0xE0, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0xE7, 0xFF, 0x7F, 0xFF,
  0x81, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xF8, 0x7D, 0xFE, 0xE7, 0xE7, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x7B, 0xF3, 0xFF, 0xDF, 0xFE,
  0xF0, 0x7F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x83, 0xFF, 0x7D, 0xFF, 0xEF, 0x7E, 0x00, 0x1F, 0xC1,
  0xFF, 0x9F, 0xFC, 0xE0, 0xFF, 0x03, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xE0, 0x77, 0x07, 0xBF, 0xF8, 0xFF, 0xC3, 0xF8,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x8F, 0x9C, 0xFE, 0xEF,
  0xFF, 0x70, 0x7F, 0x81, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xF0, 0x3B, 0x83, 0xDF, 0x7E, 0x7F, 0x71, 0xF3, 0x80, 0x1F,
  0xC1, 0xFF, 0x1E, 0x3C, 0xE0, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x03, 0xBC, 0x78, 0xFF, 0xC3,
  0xF8, 0x03, 0xFC, 0x1F, 0xF0, 0xFF, 0xC3, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x1F, 0x39, 0xFD, 0xDF, 0xFE, 0xE0, 0xFF, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xFC, 0x0E, 0xE0, 0xF7, 0xFF, 0x9F,
  0xDC, 0x7C, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x3C, 0x3F, 0xE1, 0xFE,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x7B, 0xF3, 0xFF,
  0xDF, 0xBE, 0xF0, 0x7F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0x80,
  0x03, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x7F, 0xEF, 0xFC, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x01, 0xFF, 0xFB, 0xFE, 0x7F, 0x80, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x3F, 0x81, 0xDC, 0x1E, 0xE1, 0xE7, 0x0E,
  0x38, 0xF1, 0xFF, 0x0F, 0xF0, 0x7F, 0xC3, 0x8E, 0x1C, 0x78, 0xE1, 0xE7,
  0x07, 0x38, 0x3D, 0xC0, 0xEE, 0x07, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x0F, 0xE0, 0xDE,
  0x73, 0x7F, 0xEE, 0x73, 0xF8, 0xC7, 0xE3, 0x1F, 0x8C, 0x7E, 0x31, 0xF8,
  0xC7, 0xE3, 0x1F, 0x8C, 0x7E, 0x31, 0xF8, 0xC7, 0xE3, 0x1F, 0x8C, 0x7E,
  0x31, 0xF8, 0xC7, 0xF7, 0xE7, 0xFF, 0xBF, 0xFD, 0xE0, 0xFF, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0x1F, 0xC1, 0xFF, 0x1F, 0xFC, 0xE0, 0xFF,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xE0,
  0x77, 0x07, 0xBF, 0xF8, 0xFF, 0x83, 0xF8, 0xF7, 0xE7, 0xFF, 0xBF, 0xFD,
  0xE0, 0xFF, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xE0, 0x7F, 0x07, 0xFE, 0xFB, 0xFF, 0xDE, 0xFC, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x1F, 0x39, 0xFD, 0xDF, 0xFE, 0xE0,
  0xFF, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xE0, 0x77, 0x07, 0xBE, 0xFC, 0xFE, 0xE3, 0xE7, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0xE7, 0xC7, 0x7F, 0x3F, 0x7D, 0xE0, 0xFE,
  0x07, 0xF0, 0x1F, 0x80, 0xFC, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x1F, 0xE1, 0xFF, 0x9F, 0x3E,
  0xE0, 0x77, 0x00, 0x38, 0x01, 0xF8, 0x07, 0xFC, 0x0F, 0xF0, 0x07, 0xC0,
  0x0E, 0x00, 0x7F, 0x03, 0xBE, 0x7D, 0xFF, 0xC3, 0xFC, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x7F, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81,
  0xFC, 0x0F, 0xE0, 0x77, 0x07, 0xBE, 0xF8, 0xFF, 0x83, 0xF8, 0xF0, 0x0E,
  0xE0, 0x3D, 0xC0, 0x73, 0xC0, 0xE3, 0x83, 0xC7, 0x07, 0x0F, 0x0E, 0x0E,
  0x1C, 0x1C, 0x70, 0x3C, 0xE0, 0x39, 0xC0, 0x77, 0x00, 0xFE, 0x00, 0xFC,
  0x01, 0xF0, 0x03, 0xE0, 0xE3, 0x87, 0xE3, 0x86, 0xE3, 0x86, 0xE3, 0xC6,
  0xE2, 0xCE, 0x62, 0xCE, 0x66, 0xCE, 0x76, 0xCC, 0x76, 0x4C, 0x76, 0x4C,
  0x74, 0x6C, 0x34, 0x7C, 0x3C, 0x7C, 0x3C, 0x78, 0x3C, 0x38, 0x3C, 0x38,
  0x70, 0x1E, 0x70, 0x78, 0xF0, 0xE0, 0xE3, 0x80, 0xEF, 0x01, 0xFC, 0x01,
  0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x3B, 0x80, 0xF3, 0x81, 0xC7,
  0x87, 0x07, 0x1E, 0x07, 0x78, 0x0F, 0xF0, 0x0E, 0xE0, 0x3D, 0xE0, 0x71,
  0xC0, 0xE3, 0x83, 0x87, 0x87, 0x07, 0x1E, 0x0F, 0x38, 0x0E, 0x70, 0x1D,
  0xE0, 0x3F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0,
  0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x7F, 0xFB,
  0xFF, 0xDF, 0xFE, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x78, 0x0F, 0xC0, 0xFE, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x0F, 0xF8, 0x7E, 0x03, 0xFC,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x78, 0x03, 0xF8, 0x0F, 0xC0, 0x3E, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x07, 0xE0, 0x3F, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1E, 0x00, 0x7F, 0x80, 0xFC, 0x1F, 0xE1, 0xE0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0xFE, 0x07,
  0xE0, 0x3E, 0x00, 0x7C, 0x1F, 0xF8, 0x7E, 0x71, 0xF0, 0xFF, 0xC3, 0xFB,
  0x03, 0xC0,
};

const GFXglyph JetBrainsMono_Medium29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 5, 21, 17, 6, -21 },
  { 15, 9, 9, 17, 4, -21 },
  { 26, 16, 21, 17, 1, -21 },
  { 68, 14, 29, 17, 2, -25 },
  { 119, 17, 21, 17, 0, -21 },
  { 164, 16, 21, 17, 1, -21 },
  { 206, 3, 9, 17, 7, -21 },
  { 210, 9, 27, 17, 5, -24 },
  { 241, 9, 27, 17, 3, -24 },
  { 272, 15, 15, 17, 1, -18 },
  { 301, 14, 13, 17, 2, -16 },
  { 324, 6, 9, 17, 5, -4 },
  { 331, 9, 3, 17, 4, -11 },
  { 335, 5, 5, 17, 6, -5 },
  { 339, 13, 27, 17, 2, -24 },
  { 383, 13, 21, 17, 2, -21 },
  { 418, 14, 21, 17, 2, -21 },
  { 455, 13, 21, 17, 2, -21 },
  { 490, 13, 21, 17, 2, -21 },
  { 525, 13, 21, 17, 2, -21 },
  { 560, 13, 21, 17, 2, -21 },
  { 595, 14, 21, 17, 2, -21 },
  { 632, 14, 21, 17, 2, -21 },
  { 669, 13, 21, 17, 2, -21 },
  { 704, 14, 21, 17, 2, -21 },
  { 741, 5, 16, 17, 6, -16 },
  { 751, 6, 21, 17, 5, -16 },
  { 767, 13, 15, 17, 2, -17 },
  { 792, 13, 10, 17, 2, -15 },
  { 809, 13, 15, 17, 2, -17 },
  { 834, 10, 21, 17, 4, -21 },
  { 861, 15, 26, 17, 1, -21 },
  { 910, 15, 21, 17, 1, -21 },
  { 950, 14, 21, 17, 2, -21 },
  { 987, 13, 21, 17, 2, -21 },
  { 1022, 13, 21, 17, 2, -21 },
  { 1057, 12, 21, 17, 3, -21 },
  { 1089, 12, 21, 17, 3, -21 },
  { 1121, 13, 21, 17, 2, -21 },
  { 1156, 13, 21, 17, 2, -21 },
  { 1191, 12, 21, 17, 3, -21 },
  { 1223, 14, 21, 17, 1, -21 },
  { 1260, 14, 21, 17, 2, -21 },
  { 1297, 13, 21, 17, 3, -21 },
  { 1332, 13, 21, 17, 2, -21 },
  { 1367, 13, 21, 17, 2, -21 },
  { 1402, 13, 21, 17, 2, -21 },
  { 1437, 14, 21, 17, 2, -21 },
  { 1474, 14, 26, 17, 2, -21 },
  { 1520, 14, 21, 17, 2, -21 },
  { 1557, 14, 21, 17, 2, -21 },
  { 1594, 15, 21, 17, 1, -21 },
  { 1634, 13, 21, 17, 2, -21 },
  { 1669, 15, 21, 17, 1, -21 },
  { 1709, 16, 21, 17, 1, -21 },
  { 1751, 15, 21, 17, 1, -21 },
  { 1791, 16, 21, 17, 1, -21 },
  { 1833, 13, 21, 17, 2, -21 },
  { 1868, 7, 27, 17, 6, -24 },
  { 1892, 13, 27, 17, 2, -24 },
  { 1936, 8, 27, 17, 4, -24 },
  { 1963, 13, 11, 17, 2, -21 },
  { 1981, 14, 2, 17, 2, 1 },
  { 1985, 7, 4, 17, 5, -23 },
  { 1989, 13, 16, 17, 2, -16 },
  { 2015, 13, 21, 17, 2, -21 },
  { 2050, 13, 16, 17, 2, -16 },
  { 2076, 13, 21, 17, 2, -21 },
  { 2111, 13, 16, 17, 2, -16 },
  { 2137, 14, 21, 17, 2, -21 },
  { 2174, 13, 21, 17, 2, -16 },
  { 2209, 13, 21, 17, 2, -21 },
  { 2244, 14, 23, 17, 2, -23 },
  { 2285, 11, 28, 17, 2, -23 },
  { 2324, 13, 21, 17, 3, -21 },
  { 2359, 15, 21, 17, 1, -21 },
  { 2399, 14, 16, 17, 2, -16 },
  { 2427, 13, 16, 17, 2, -16 },
  { 2453, 13, 16, 17, 2, -16 },
  { 2479, 13, 21, 17, 2, -16 },
  { 2514, 13, 21, 17, 2, -16 },
  { 2549, 13, 16, 17, 3, -16 },
  { 2575, 13, 16, 17, 2, -16 },
  { 2601, 14, 20, 17, 1, -20 },
  { 2636, 13, 16, 17, 2, -16 },
  { 2662, 15, 16, 17, 1, -16 },
  { 2692, 16, 16, 17, 1, -16 },
  { 2724, 15, 16, 17, 1, -16 },
  { 2754, 15, 21, 17, 1, -16 },
  { 2794, 13, 16, 17, 2, -16 },
  { 2820, 13, 27, 17, 2, -24 },
  { 2864, 3, 27, 17, 7, -24 },
  { 2875, 13, 27, 17, 2, -24 },
  { 2919, 14, 6, 17, 2, -13 },
};

const GFXfont JetBrainsMono_Medium29pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Medium29pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Medium29pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _JETBRAINSMONO_MEDIUM29PT7B_H_
