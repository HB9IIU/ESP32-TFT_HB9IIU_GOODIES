#ifndef _JETBRAINSMONO_MEDIUM35PT7B_H_
#define _JETBRAINSMONO_MEDIUM35PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Medium.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Medium35pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x80, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF,
  0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF0, 0xFC, 0x1F, 0x83, 0x80, 0x03, 0x83,
  0x80, 0x70, 0x70, 0x0E, 0x0E, 0x01, 0xC1, 0xC0, 0x30, 0x38, 0x0E, 0x0E,
  0x01, 0xC1, 0xC3, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0x18, 0x18,
  0x07, 0x07, 0x00, 0xE0, 0xE0, 0x1C, 0x1C, 0x03, 0x83, 0x80, 0x70, 0x70,
  0x1C, 0x0C, 0x1F, 0xFF, 0xFB, 0xFF, 0xFF, 0x0E, 0x0E, 0x01, 0xC1, 0xC0,
  0x30, 0x30, 0x0E, 0x0E, 0x01, 0xC1, 0xC0, 0x38, 0x38, 0x07, 0x07, 0x00,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x3F, 0x00, 0x7F,
  0xE0, 0xFF, 0xF8, 0x7F, 0xFE, 0x78, 0xCF, 0x3C, 0x67, 0x9E, 0x31, 0xCF,
  0x18, 0x07, 0x8C, 0x03, 0xE6, 0x00, 0xFB, 0x00, 0x7F, 0x80, 0x1F, 0xF8,
  0x07, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0C, 0xF0, 0x06, 0x3C, 0x03,
  0x1F, 0xE1, 0x8F, 0xF0, 0xC7, 0xBC, 0x67, 0x9F, 0x37, 0xC7, 0xFF, 0xC1,
  0xFF, 0xC0, 0x7F, 0xC0, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x0E, 0x00, 0x39, 0xFC, 0x03, 0x9F, 0xF0, 0x38, 0xE3,
  0x81, 0xCE, 0x0C, 0x1C, 0x70, 0x61, 0xC3, 0x83, 0x0E, 0x1C, 0x18, 0xE0,
  0x71, 0xCE, 0x03, 0xFE, 0x70, 0x0F, 0xE7, 0x00, 0x3E, 0x70, 0x00, 0x03,
  0x00, 0x00, 0x38, 0x00, 0x03, 0x84, 0x00, 0x39, 0xFC, 0x01, 0xDF, 0xF0,
  0x1C, 0xE3, 0x81, 0xC6, 0x0C, 0x0E, 0x30, 0x70, 0xE1, 0x83, 0x8E, 0x0C,
  0x1C, 0x70, 0x71, 0xC7, 0x03, 0xDE, 0x70, 0x0F, 0xF7, 0x00, 0x3E, 0x00,
  0x07, 0xE0, 0x07, 0xFC, 0x03, 0xFF, 0x80, 0xF9, 0xF0, 0x78, 0x3C, 0x1E,
  0x07, 0x87, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xE0, 0xFF, 0x3C, 0x7B, 0x8F, 0x1E,
  0xE1, 0xEF, 0x38, 0x3F, 0xCE, 0x07, 0xE3, 0x81, 0xF0, 0xE0, 0x3C, 0x3C,
  0x1F, 0x8F, 0x0F, 0xE3, 0xFF, 0xFC, 0x7F, 0xE7, 0x8F, 0xF0, 0xF0, 0xFF,
  0xFF, 0xFF, 0xF7, 0x77, 0x70, 0x00, 0xE0, 0x7C, 0x1F, 0x87, 0xE1, 0xF0,
  0x7C, 0x0F, 0x03, 0xC0, 0x78, 0x0E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x03, 0xC0, 0x78, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xF8, 0x1F, 0xC1, 0xF8,
  0x0F, 0x00, 0x60, 0xE0, 0x1F, 0x03, 0xF0, 0x3F, 0x01, 0xF0, 0x1F, 0x01,
  0xE0, 0x1E, 0x03, 0xC0, 0x38, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x1E,
  0x03, 0xC0, 0xF8, 0x1E, 0x07, 0xC3, 0xF1, 0xFC, 0x3F, 0x07, 0x80, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x04, 0x0E,
  0x04, 0xF1, 0xC7, 0x9F, 0x39, 0xF7, 0xFA, 0xFF, 0x3F, 0xFF, 0x80, 0x1C,
  0x00, 0x07, 0xC0, 0x01, 0xDC, 0x00, 0x7B, 0xC0, 0x1E, 0x3C, 0x03, 0xC7,
  0x80, 0xF0, 0x78, 0x0C, 0x06, 0x00, 0x80, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x3E, 0x7C, 0xF3,
  0xE7, 0x8F, 0x1E, 0x78, 0xF1, 0xC3, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x38, 0xFB, 0xF7, 0xF7, 0xCF, 0x80, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03,
  0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x3F, 0xE1, 0xFF, 0xF3, 0xF7,
  0xEF, 0x01, 0xFE, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x1C, 0x7E, 0x7C, 0xFC, 0xF9, 0xF8, 0xE3, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFE, 0x03, 0xFE, 0x0F,
  0xBF, 0xFE, 0x3F, 0xF8, 0x3F, 0xE0, 0x03, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0,
  0x3F, 0xE0, 0xFD, 0xE0, 0xF1, 0xE0, 0xE1, 0xE0, 0xC1, 0xE0, 0x81, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xE0,
  0x0F, 0xFC, 0x0F, 0xFF, 0x0F, 0xEF, 0xC7, 0x81, 0xF3, 0xC0, 0x7B, 0xC0,
  0x3D, 0xE0, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xFF,
  0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xC0, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE,
  0x7F, 0xFE, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0,
  0x07, 0x80, 0x07, 0xF0, 0x07, 0xFC, 0x07, 0xFE, 0x00, 0x3E, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0x78, 0x0F, 0x7C, 0x1E, 0x3F, 0xFE, 0x1F, 0xFC, 0x0F, 0xF0, 0x00, 0x7C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xE0, 0xF7, 0xC1, 0xEF, 0x03,
  0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0xFF,
  0xFD, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xEF, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE3, 0x83, 0xDF, 0xE7, 0xFF, 0xEF, 0xEF, 0xDF,
  0x03, 0xFC, 0x07, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0xFF, 0x01, 0xFE, 0x03, 0xFE, 0x0F, 0xBF, 0xFE, 0x3F, 0xF8, 0x3F, 0xE0,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x3C, 0x07,
  0xFF, 0x87, 0xFF, 0xE3, 0xF1, 0xF9, 0xE0, 0x3D, 0xE0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7B, 0xC0, 0x79, 0xF0,
  0x7C, 0x7F, 0xFC, 0x1F, 0xFC, 0x07, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0x80, 0x7B, 0xC0, 0x3D, 0xE0,
  0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x07, 0x80, 0x00, 0x07, 0xE0, 0x7F, 0xF1, 0xFF, 0xF3, 0xF7, 0xEF,
  0x83, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1E, 0xF0, 0x79, 0xF1,
  0xF1, 0xFF, 0xC0, 0xFE, 0x03, 0xFE, 0x0F, 0xBE, 0x3C, 0x1E, 0xF0, 0x1F,
  0xE0, 0x3F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFE, 0x03, 0xFE, 0x0F, 0xBF,
  0xFE, 0x3F, 0xF8, 0x3F, 0xE0, 0x03, 0xE0, 0x07, 0xFC, 0x0F, 0xFF, 0x8F,
  0xEF, 0xC7, 0x80, 0xF3, 0xC0, 0x7B, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xFC, 0x01, 0xEF, 0x01, 0xE7, 0xC1, 0xF1, 0xFF, 0xF8, 0xFF,
  0xF8, 0x1F, 0xBC, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0xC0,
  0x00, 0x10, 0xFB, 0xFF, 0xF7, 0xC7, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x7D, 0xFD, 0xF3, 0xE0, 0x08, 0x3E, 0x7F, 0x7F, 0x3E,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x3E, 0x3E,
  0x3C, 0x3C, 0x7C, 0x78, 0x78, 0xF0, 0xF0, 0xE0, 0xE0, 0x00, 0x02, 0x00,
  0x1C, 0x00, 0xF8, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x00,
  0xF8, 0x01, 0xC0, 0x03, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x00, 0x3E, 0x00, 0x1C, 0x00, 0x08, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x01, 0xC0, 0x03,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3E, 0x00, 0x1C, 0x00, 0xF8, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7F, 0x00, 0xF8, 0x01, 0xC0, 0x02, 0x00, 0x00, 0xFC, 0x07, 0xFE, 0x3F,
  0xF9, 0xFF, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xE0, 0x07, 0x00, 0x38, 0x03,
  0xC0, 0x1E, 0x01, 0xF1, 0xFF, 0x0F, 0xF0, 0x7F, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x07, 0xE0, 0x3F,
  0x00, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xFE, 0x1F, 0x03,
  0xC3, 0xC0, 0x3C, 0xF0, 0x03, 0x9C, 0x00, 0x7B, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x0F, 0x9F, 0xC3, 0xFB, 0xF8, 0x79, 0xFF, 0x1E, 0x1F, 0xE3, 0x81,
  0xFC, 0x70, 0x3F, 0x8E, 0x07, 0xF1, 0xC0, 0xFE, 0x38, 0x1F, 0xC7, 0x03,
  0xF8, 0xE0, 0xFF, 0x1E, 0x1F, 0xE1, 0xE7, 0xFC, 0x3F, 0xBF, 0x83, 0xE7,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xE0, 0x00,
  0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3B, 0x80, 0x07, 0x70, 0x01, 0xEF, 0x00,
  0x3D, 0xE0, 0x07, 0x1C, 0x00, 0xE3, 0x80, 0x3C, 0x78, 0x07, 0x8F, 0x00,
  0xF1, 0xE0, 0x1C, 0x1C, 0x07, 0x83, 0xC0, 0xF0, 0x78, 0x1F, 0xFF, 0x03,
  0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0xFF, 0xC3, 0xC0, 0x78, 0x70, 0x07, 0x1E,
  0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x03, 0xDE, 0x00, 0x3C, 0xFF, 0x00, 0xFF,
  0xF0, 0xFF, 0xFC, 0xFF, 0xFC, 0xF0, 0x3E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0,
  0x0E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3C, 0xFF, 0xF8, 0xFF, 0xE0, 0xFF,
  0xF8, 0xF0, 0x7C, 0xF0, 0x1E, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x1E, 0xF0, 0x7E, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF,
  0xE0, 0x07, 0xE0, 0x3F, 0xF0, 0xFF, 0xF3, 0xF7, 0xEF, 0x81, 0xFE, 0x03,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x7F, 0x01, 0xFE, 0x03, 0xDE, 0x0F, 0xBF, 0xFE, 0x3F, 0xF8,
  0x1F, 0xE0, 0xFF, 0x01, 0xFF, 0xE3, 0xFF, 0xE7, 0xFF, 0xEF, 0x03, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0xFF, 0x01, 0xFE, 0x07, 0xFC, 0x7F, 0x7F, 0xFC, 0xFF,
  0xF1, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0xBC, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x07, 0xE0, 0x3F, 0xF0,
  0xFF, 0xF3, 0xF7, 0xEF, 0x81, 0xFE, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x3F, 0xFC, 0x7F,
  0xF8, 0xFF, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x01, 0xFE,
  0x03, 0xDE, 0x0F, 0xBF, 0xFE, 0x3F, 0xF8, 0x1F, 0xE0, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3C, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0xF3, 0xC0, 0x79, 0xF0, 0x7C,
  0x7F, 0xFC, 0x1F, 0xFC, 0x07, 0xFC, 0x00, 0xF0, 0x0F, 0x78, 0x07, 0xBC,
  0x07, 0x9E, 0x03, 0xCF, 0x03, 0xC7, 0x81, 0xE3, 0xC1, 0xF1, 0xE0, 0xF0,
  0xF0, 0xF8, 0x78, 0x78, 0x3C, 0x7C, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF,
  0x03, 0xC7, 0x81, 0xE1, 0xE0, 0xF0, 0xF0, 0x78, 0x7C, 0x3C, 0x1E, 0x1E,
  0x0F, 0x8F, 0x03, 0xC7, 0x81, 0xF3, 0xC0, 0x79, 0xE0, 0x3E, 0xF0, 0x0F,
  0x78, 0x07, 0x80, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0x0F, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0x83,
  0xFF, 0xC1, 0xFF, 0x70, 0xDF, 0xB8, 0xEF, 0xDC, 0x77, 0xE6, 0x33, 0xFB,
  0xBB, 0xFD, 0xDD, 0xFE, 0x6C, 0xFF, 0x3E, 0x7F, 0x9F, 0x3F, 0xC7, 0x9F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xC0,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFB,
  0x83, 0xF7, 0x07, 0xEE, 0x0F, 0xCE, 0x1F, 0x9C, 0x3F, 0x38, 0x7E, 0x38,
  0xFC, 0x71, 0xF8, 0xF3, 0xF0, 0xE7, 0xE1, 0xCF, 0xC3, 0xDF, 0x83, 0xBF,
  0x07, 0x7E, 0x0F, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7C, 0x07, 0xC0, 0x3F, 0xE1, 0xFF, 0xF3, 0xF7, 0xEF, 0x83, 0xFE, 0x03,
  0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xDE, 0x0F, 0x3F, 0xFE, 0x3F, 0xF8,
  0x3F, 0xE0, 0xFF, 0x80, 0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0xF0, 0x1F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x1F, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xF8, 0xFF, 0xE0, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x1F, 0xF0, 0x7F, 0xFC,
  0x7E, 0xFC, 0xF8, 0x3E, 0xF0, 0x1E, 0xE0, 0x1E, 0xE0, 0x0E, 0xE0, 0x0E,
  0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E,
  0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xF0, 0x1E,
  0xF0, 0x1E, 0xF8, 0x3E, 0x7F, 0xFC, 0x3F, 0xF8, 0x1F, 0xF0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0xFF, 0x00,
  0xFF, 0xF0, 0xFF, 0xFC, 0xFF, 0xFE, 0xF0, 0x3E, 0xF0, 0x1F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x3E, 0xFF, 0xFE,
  0xFF, 0xFC, 0xFF, 0xF0, 0xFF, 0xE0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0x78,
  0xF0, 0x78, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x3E, 0xF0, 0x1E, 0xF0, 0x1F,
  0xF0, 0x0F, 0x03, 0xF0, 0x07, 0xFE, 0x0F, 0xFF, 0x87, 0xEF, 0xE7, 0x80,
  0xF3, 0xC0, 0x79, 0xE0, 0x1C, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x07, 0xF8, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x07, 0xF8, 0x00, 0x7E,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7B, 0xC0,
  0x79, 0xF0, 0x7C, 0x7F, 0xFC, 0x1F, 0xFC, 0x07, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xDE,
  0x0F, 0x3F, 0xFE, 0x3F, 0xF8, 0x3F, 0xE0, 0xF0, 0x01, 0xEF, 0x00, 0x79,
  0xE0, 0x0F, 0x3C, 0x01, 0xE3, 0x80, 0x38, 0x78, 0x0F, 0x0F, 0x01, 0xE1,
  0xE0, 0x3C, 0x1C, 0x07, 0x03, 0xC0, 0xE0, 0x78, 0x3C, 0x0F, 0x07, 0x80,
  0xE0, 0xE0, 0x1E, 0x1C, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x07, 0x1C, 0x00,
  0xE3, 0x80, 0x1E, 0xF0, 0x03, 0xDE, 0x00, 0x3B, 0x80, 0x07, 0x70, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0xE0, 0xE0, 0xFC,
  0x1C, 0x1F, 0x83, 0xC3, 0xF0, 0xF8, 0x7E, 0x1B, 0x0F, 0xE3, 0x63, 0xFC,
  0x6C, 0x7B, 0x8D, 0x8E, 0x71, 0xB1, 0xCE, 0x36, 0x39, 0xC6, 0xC7, 0x39,
  0xDC, 0xE7, 0x39, 0x9C, 0xE6, 0x33, 0x9C, 0xC6, 0x73, 0xD8, 0xCE, 0x7B,
  0x1B, 0x87, 0x63, 0x70, 0xEC, 0x6E, 0x1D, 0x8D, 0xC3, 0xF1, 0xF8, 0x7C,
  0x1F, 0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x3E, 0x0F, 0x87, 0xC1, 0xE0, 0x78,
  0x03, 0xCF, 0x00, 0x78, 0xF0, 0x1E, 0x1E, 0x03, 0xC1, 0xE0, 0xF0, 0x3C,
  0x1E, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x07, 0xBC, 0x00, 0x77, 0x00, 0x0F,
  0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x1F,
  0xC0, 0x07, 0xBC, 0x00, 0xF7, 0x80, 0x3C, 0x78, 0x07, 0x8F, 0x01, 0xE0,
  0xF0, 0x3C, 0x1E, 0x0F, 0x01, 0xE1, 0xE0, 0x3C, 0x78, 0x03, 0xDF, 0x00,
  0x7C, 0xF0, 0x01, 0xEE, 0x00, 0x3D, 0xE0, 0x0F, 0x3C, 0x01, 0xE3, 0xC0,
  0x78, 0x78, 0x0F, 0x07, 0x83, 0xC0, 0xF0, 0x78, 0x0F, 0x1E, 0x01, 0xE3,
  0xC0, 0x1E, 0xF0, 0x03, 0xDE, 0x00, 0x3B, 0x80, 0x07, 0xF0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x3C,
  0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0x80, 0x0F, 0x80, 0x1F,
  0x00, 0x77, 0x00, 0xEE, 0x03, 0xDE, 0x07, 0x1C, 0x0E, 0x38, 0x38, 0x38,
  0x70, 0x71, 0xE0, 0xF3, 0x80, 0xEF, 0x01, 0xFC, 0x01, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF8, 0x3C, 0x3E, 0x1F, 0x01, 0x80, 0x0F,
  0xF8, 0x1F, 0xFE, 0x3F, 0xFE, 0x7C, 0x1F, 0x78, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x1F, 0xFF, 0x3F, 0xFF, 0x7C, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0x7F, 0xFF, 0x3F, 0xFF, 0x1F,
  0xCF, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x20, 0x7B, 0xFC, 0xFF, 0xFD, 0xFF, 0xFB, 0xE0, 0xFF, 0x80, 0xFF,
  0x01, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFE, 0x0F, 0xFF, 0xFE, 0xF7, 0xF9,
  0xE7, 0xE0, 0x01, 0x00, 0x3F, 0xE0, 0xFF, 0xE3, 0xFF, 0xEF, 0x83, 0xFE,
  0x03, 0xFC, 0x03, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x07, 0xF8, 0x0F, 0xF8, 0x3E, 0xFF, 0xF8,
  0xFF, 0xE0, 0x7F, 0x80, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC1, 0x87, 0x9F, 0xEF, 0x7F, 0xFE, 0xFF, 0xFF, 0xE0,
  0xFF, 0x80, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFF, 0x01, 0xFE, 0x03, 0xFE, 0x0F, 0xBF,
  0xFF, 0x3F, 0xDE, 0x3F, 0x3C, 0x01, 0x00, 0x3F, 0xE0, 0xFF, 0xE3, 0xF7,
  0xEF, 0x81, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x78, 0x0F, 0xF8,
  0x3E, 0xFF, 0xF8, 0xFF, 0xE0, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0xFF, 0xC0,
  0xFF, 0xE0, 0x7F, 0xF0, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x00, 0x06, 0x00, 0x7F, 0xBD, 0xFF, 0xFB, 0xFF, 0xFF, 0x83,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFE, 0x0F, 0xBF, 0x7F, 0x7F, 0xFE, 0x7F,
  0xBC, 0x3C, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x9F, 0xFE,
  0x3F, 0xF8, 0x7F, 0xE0, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x20, 0x7B, 0xFC, 0xFF, 0xFD, 0xFF, 0xFB, 0xE0,
  0xFF, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3C, 0x03, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x7F,
  0xC0, 0x7F, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFB, 0xFF, 0xDF, 0xFE, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0xFB,
  0xFF, 0x9F, 0xF8, 0xFF, 0x80, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x1E, 0xF0, 0x1E,
  0x78, 0x0F, 0x3C, 0x0F, 0x1E, 0x0F, 0x0F, 0x07, 0x87, 0x87, 0x83, 0xFF,
  0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3C, 0x3C, 0x1E, 0x1F, 0x0F,
  0x07, 0x87, 0x81, 0xE3, 0xC0, 0xF9, 0xE0, 0x3C, 0xF0, 0x1F, 0x78, 0x07,
  0xC0, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x1F, 0x00, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xF0,
  0x02, 0x04, 0x77, 0xCF, 0xBB, 0xEF, 0xDE, 0x7C, 0xFF, 0x1C, 0x7F, 0x0E,
  0x1F, 0x87, 0x0F, 0xC3, 0x87, 0xE1, 0xC3, 0xF0, 0xE1, 0xF8, 0x70, 0xFC,
  0x38, 0x7E, 0x1C, 0x3F, 0x0E, 0x1F, 0x87, 0x0F, 0xC3, 0x87, 0xE1, 0xC3,
  0xF0, 0xE1, 0xF8, 0x70, 0xFC, 0x38, 0x70, 0x00, 0x81, 0xEF, 0xF3, 0xFF,
  0xF7, 0xFF, 0xEF, 0x83, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xF0, 0x03, 0x00, 0x3F,
  0xE0, 0xFF, 0xE3, 0xFF, 0xEF, 0x83, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF8, 0x3C, 0xFF, 0xF8, 0xFF, 0xE0, 0x7F, 0x00, 0x00,
  0x81, 0xEF, 0xF3, 0xFF, 0xF7, 0xFF, 0xEF, 0x83, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF8, 0x3F, 0xFF, 0xFB, 0xDF, 0xE7, 0x9F,
  0x8F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x00,
  0x02, 0x00, 0x7F, 0xBD, 0xFF, 0xFB, 0xFF, 0xFF, 0x83, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF8, 0x3E, 0xFF, 0xFC, 0xFF, 0x78,
  0xFC, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x81, 0xCF, 0xE3, 0xBF, 0xE7, 0xFF, 0xEF, 0x83, 0xFE, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x3F, 0xF8, 0x7F, 0xFC, 0x7F, 0xFE, 0xF0,
  0x1E, 0xF0, 0x1E, 0xF0, 0x00, 0xF0, 0x00, 0x7F, 0x00, 0x7F, 0xF0, 0x1F,
  0xFC, 0x03, 0xFE, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0xF0, 0x0E, 0xF0,
  0x1E, 0x7F, 0xFE, 0x7F, 0xFC, 0x1F, 0xF8, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0xC0, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xBC, 0x1E, 0x7F, 0xFC, 0x7F, 0xF0, 0x3F, 0x80, 0xF0, 0x07, 0xF8,
  0x03, 0xDC, 0x01, 0xCF, 0x01, 0xE7, 0x80, 0xF1, 0xC0, 0x70, 0xF0, 0x78,
  0x78, 0x3C, 0x1C, 0x1C, 0x0F, 0x1E, 0x07, 0x8F, 0x01, 0xC7, 0x00, 0xF3,
  0x80, 0x7B, 0xC0, 0x1D, 0xC0, 0x0E, 0xE0, 0x07, 0xF0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0xE0, 0xE0, 0xFC, 0x1C, 0x1F, 0xC7, 0xC3, 0xB8, 0xD8, 0xE7,
  0x1B, 0x1C, 0xE3, 0x63, 0x9C, 0x6C, 0x73, 0x8D, 0x8E, 0x71, 0xB1, 0xCF,
  0x63, 0x30, 0xEC, 0x6E, 0x1D, 0x8D, 0xC3, 0xB1, 0xB8, 0x76, 0x37, 0x0E,
  0xC6, 0xE1, 0xF8, 0xFC, 0x1E, 0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x3C, 0x00,
  0x7C, 0x07, 0xC7, 0x80, 0xF0, 0x78, 0x3C, 0x0F, 0x8F, 0x80, 0xF1, 0xE0,
  0x0F, 0x78, 0x00, 0xEF, 0x00, 0x1F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7B, 0xC0, 0x1E, 0x3C, 0x03, 0xC7, 0x80,
  0xF0, 0x78, 0x3C, 0x07, 0x87, 0x80, 0xF3, 0xE0, 0x0F, 0x80, 0xF0, 0x07,
  0xF8, 0x03, 0xDE, 0x03, 0xCF, 0x01, 0xE7, 0xC0, 0xF1, 0xE0, 0xF0, 0xF0,
  0x78, 0x3C, 0x3C, 0x1E, 0x3C, 0x0F, 0x1E, 0x03, 0xCE, 0x01, 0xEF, 0x00,
  0x77, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3E, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0x80,
  0x1E, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x01, 0xF0, 0x7F, 0xC0, 0xFE, 0x01,
  0xFF, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3F,
  0xC0, 0x3F, 0x80, 0x3F, 0x00, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF8, 0x01, 0xFC, 0x03, 0xF8,
  0x01, 0xF8, 0x00, 0xF0, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xF0, 0x01,
  0xFF, 0x00, 0xFE, 0x0F, 0xFC, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x78, 0x00,
  0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0x7E, 0x00, 0xF0, 0x00, 0x3F, 0x03, 0xBF,
  0xC1, 0xFF, 0xF0, 0xFE, 0x78, 0x7E, 0x1F, 0xFF, 0x07, 0xFB, 0x81, 0xF8,
  0x00, 0x10,
};

const GFXglyph JetBrainsMono_Medium35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 21, 0, -1 },
  { 1, 5, 26, 21, 8, -26 },
  { 18, 11, 11, 21, 5, -26 },
  { 34, 19, 26, 21, 1, -26 },
  { 96, 17, 35, 21, 2, -30 },
  { 171, 21, 26, 21, 0, -26 },
  { 240, 18, 26, 21, 2, -26 },
  { 299, 4, 11, 21, 8, -26 },
  { 305, 11, 33, 21, 6, -29 },
  { 351, 11, 33, 21, 4, -29 },
  { 397, 19, 18, 21, 1, -21 },
  { 440, 17, 17, 21, 2, -20 },
  { 477, 7, 11, 21, 6, -5 },
  { 487, 11, 3, 21, 5, -13 },
  { 492, 7, 6, 21, 7, -6 },
  { 498, 17, 33, 21, 2, -29 },
  { 569, 15, 26, 21, 3, -26 },
  { 618, 16, 26, 21, 3, -26 },
  { 670, 17, 26, 21, 2, -26 },
  { 726, 16, 26, 21, 2, -26 },
  { 778, 15, 26, 21, 3, -26 },
  { 827, 15, 26, 21, 3, -26 },
  { 876, 17, 26, 21, 2, -26 },
  { 932, 17, 26, 21, 2, -26 },
  { 988, 15, 26, 21, 3, -26 },
  { 1037, 17, 26, 21, 2, -26 },
  { 1093, 7, 20, 21, 7, -20 },
  { 1111, 8, 26, 21, 6, -20 },
  { 1137, 15, 19, 21, 3, -21 },
  { 1173, 15, 12, 21, 3, -18 },
  { 1196, 15, 19, 21, 3, -21 },
  { 1232, 13, 26, 21, 4, -26 },
  { 1275, 19, 32, 21, 1, -26 },
  { 1351, 19, 26, 21, 1, -26 },
  { 1413, 16, 26, 21, 3, -26 },
  { 1465, 15, 26, 21, 3, -26 },
  { 1514, 15, 26, 21, 3, -26 },
  { 1563, 15, 26, 21, 3, -26 },
  { 1612, 16, 26, 21, 3, -26 },
  { 1664, 15, 26, 21, 3, -26 },
  { 1713, 15, 26, 21, 3, -26 },
  { 1762, 15, 26, 21, 3, -26 },
  { 1811, 17, 26, 21, 1, -26 },
  { 1867, 17, 26, 21, 3, -26 },
  { 1923, 15, 26, 21, 4, -26 },
  { 1972, 17, 26, 21, 2, -26 },
  { 2028, 15, 26, 21, 3, -26 },
  { 2077, 15, 26, 21, 3, -26 },
  { 2126, 16, 26, 21, 3, -26 },
  { 2178, 16, 32, 21, 3, -26 },
  { 2242, 16, 26, 21, 3, -26 },
  { 2294, 17, 26, 21, 2, -26 },
  { 2350, 17, 26, 21, 2, -26 },
  { 2406, 15, 26, 21, 3, -26 },
  { 2455, 19, 26, 21, 1, -26 },
  { 2517, 19, 26, 21, 1, -26 },
  { 2579, 19, 26, 21, 1, -26 },
  { 2641, 19, 26, 21, 1, -26 },
  { 2703, 15, 26, 21, 3, -26 },
  { 2752, 9, 33, 21, 7, -29 },
  { 2790, 17, 33, 21, 2, -29 },
  { 2861, 9, 33, 21, 5, -29 },
  { 2899, 15, 14, 21, 3, -26 },
  { 2926, 17, 3, 21, 2, 1 },
  { 2933, 8, 4, 21, 6, -27 },
  { 2937, 16, 20, 21, 2, -20 },
  { 2977, 15, 26, 21, 3, -26 },
  { 3026, 15, 20, 21, 3, -20 },
  { 3064, 15, 26, 21, 3, -26 },
  { 3113, 15, 20, 21, 3, -20 },
  { 3151, 17, 26, 21, 2, -26 },
  { 3207, 15, 26, 21, 3, -20 },
  { 3256, 15, 26, 21, 3, -26 },
  { 3305, 16, 27, 21, 3, -27 },
  { 3359, 13, 33, 21, 3, -27 },
  { 3413, 17, 26, 21, 3, -26 },
  { 3469, 18, 26, 21, 1, -26 },
  { 3528, 17, 20, 21, 2, -20 },
  { 3571, 15, 20, 21, 3, -20 },
  { 3609, 15, 20, 21, 3, -20 },
  { 3647, 15, 26, 21, 3, -20 },
  { 3696, 15, 26, 21, 3, -20 },
  { 3745, 15, 20, 21, 4, -20 },
  { 3783, 16, 20, 21, 3, -20 },
  { 3823, 16, 25, 21, 2, -25 },
  { 3873, 15, 19, 21, 3, -19 },
  { 3909, 17, 19, 21, 2, -19 },
  { 3950, 19, 19, 21, 1, -19 },
  { 3996, 19, 19, 21, 1, -19 },
  { 4042, 17, 25, 21, 2, -19 },
  { 4096, 15, 19, 21, 3, -19 },
  { 4132, 15, 33, 21, 3, -29 },
  { 4194, 3, 33, 21, 9, -29 },
  { 4207, 15, 33, 21, 3, -29 },
  { 4269, 17, 8, 21, 2, -16 },
};

const GFXfont JetBrainsMono_Medium35pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Medium35pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Medium35pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _JETBRAINSMONO_MEDIUM35PT7B_H_
