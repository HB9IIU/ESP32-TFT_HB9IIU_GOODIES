#ifndef _JETBRAINSMONO_MEDIUM33PT7B_H_
#define _JETBRAINSMONO_MEDIUM33PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Medium.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Medium33pt7bBitmaps[] PROGMEM = {
  0x00, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x71, 0xC7,
  0x0C, 0x30, 0x00, 0x00, 0x7B, 0xEF, 0xDE, 0xE1, 0xF8, 0x7E, 0x1F, 0x87,
  0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x70, 0x03, 0x87, 0x00, 0xC1,
  0xC0, 0x70, 0x70, 0x1C, 0x1C, 0x07, 0x06, 0x01, 0xC1, 0x87, 0xFF, 0xFD,
  0xFF, 0xFF, 0x7F, 0xFF, 0xC3, 0x83, 0x00, 0xE0, 0xC0, 0x38, 0x70, 0x0C,
  0x1C, 0x07, 0x07, 0x01, 0xC1, 0xC3, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF,
  0xE1, 0x83, 0x80, 0xE0, 0xE0, 0x38, 0x38, 0x0E, 0x0C, 0x03, 0x87, 0x00,
  0xC1, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x0F, 0xF0, 0x1F, 0xFC, 0x3F, 0xFC, 0x79, 0x9E, 0x79, 0x9E, 0x71, 0x8E,
  0x71, 0x80, 0x79, 0x80, 0x79, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xF0,
  0x07, 0xFC, 0x01, 0xFC, 0x01, 0xBE, 0x01, 0x9E, 0x01, 0x8F, 0x01, 0x8F,
  0xF1, 0x8F, 0xF1, 0x8E, 0x79, 0x9E, 0x7F, 0xFC, 0x3F, 0xFC, 0x0F, 0xF0,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x3F, 0x00,
  0xF7, 0xF8, 0x0E, 0x73, 0xC1, 0xCE, 0x1C, 0x38, 0xE1, 0xC3, 0x0E, 0x1C,
  0x70, 0xE1, 0xCE, 0x06, 0x1C, 0xC0, 0x7F, 0x9C, 0x03, 0xFB, 0x80, 0x1E,
  0x30, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x78, 0x01, 0xDF, 0xC0,
  0x3B, 0xFE, 0x07, 0x38, 0xE0, 0x63, 0x86, 0x0E, 0x38, 0x61, 0xC3, 0x86,
  0x18, 0x38, 0x63, 0x83, 0xCE, 0x70, 0x1F, 0xCE, 0x00, 0xF8, 0x0F, 0xE0,
  0x1F, 0xF8, 0x0F, 0xFE, 0x0F, 0x07, 0x07, 0x83, 0xC3, 0xC0, 0x01, 0xE0,
  0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x0F, 0x80, 0x0F, 0xE0, 0x0F,
  0xF8, 0x7F, 0x1C, 0x7B, 0x8F, 0x39, 0xC3, 0xFC, 0xE0, 0xFC, 0x70, 0x7E,
  0x38, 0x1E, 0x1C, 0x0F, 0x8F, 0x0F, 0xC7, 0xFF, 0xF1, 0xFF, 0x3C, 0x7F,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0xEE, 0x00, 0x40, 0x70, 0x7C, 0x3F, 0x1F,
  0x0F, 0x87, 0x81, 0xE0, 0x70, 0x3C, 0x0F, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x3C, 0x0F, 0x03, 0xC0,
  0x78, 0x1E, 0x03, 0xC0, 0x7C, 0x1F, 0xC1, 0xF0, 0x3C, 0x03, 0x80, 0x38,
  0x0F, 0x83, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0E, 0x07, 0x83, 0xE1, 0xF0, 0xF8, 0xFC, 0x3E, 0x0F,
  0x02, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x41,
  0xC0, 0x9C, 0x31, 0xEF, 0xCC, 0xFB, 0xFF, 0xFF, 0x1F, 0xFE, 0x00, 0x70,
  0x00, 0x3F, 0x00, 0x1D, 0xE0, 0x0F, 0x3C, 0x03, 0x8F, 0x01, 0xE1, 0xE0,
  0xF0, 0x38, 0x0C, 0x08, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x1F, 0x3E, 0x3E, 0x3C, 0x3C, 0x78, 0x78, 0x70, 0x70, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x21, 0xEF, 0xFF, 0xFD, 0xE0, 0x00, 0x0F, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F,
  0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0x0F,
  0xF0, 0x7F, 0xF0, 0xFF, 0xF3, 0xC1, 0xF7, 0x01, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xCF, 0x3F, 0x9E, 0x7F, 0x3C, 0xFE,
  0x71, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1D, 0xC0, 0x3B, 0x80,
  0xF7, 0x83, 0xE7, 0xFF, 0x87, 0xFE, 0x07, 0xF8, 0x07, 0xC0, 0x3F, 0x80,
  0xFF, 0x07, 0xFE, 0x0F, 0x3C, 0x1C, 0x78, 0x30, 0xF0, 0x41, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xF0, 0x3F, 0xF8, 0x7F, 0xFC, 0x78,
  0x3E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x7F,
  0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFC, 0xFF, 0xF9, 0xFF, 0xF0, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0xE0,
  0x1F, 0xE0, 0x3F, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x00,
  0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x80, 0xF7, 0x83, 0xCF, 0xFF, 0x8F, 0xFE,
  0x07, 0xF8, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x79, 0xE0,
  0xF7, 0x81, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0xFF,
  0xFB, 0xFF, 0xEF, 0xFF, 0xBC, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF3, 0xC3, 0xFF, 0xCF, 0xFF, 0xBE, 0x1F, 0xF0, 0x3C, 0x00, 0xF0,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x7E, 0x01, 0xF8, 0x0F, 0xF0, 0x7D,
  0xFF, 0xE7, 0xFF, 0x07, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x03,
  0xC0, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3D,
  0xF0, 0x7B, 0xF8, 0x7F, 0xFC, 0x7C, 0x3E, 0xF0, 0x1E, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x70, 0x1E, 0x78, 0x3E, 0x3F,
  0xFC, 0x1F, 0xF8, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xF0, 0x0E, 0xF0, 0x1E, 0xF0, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x01,
  0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0xF0, 0x7F, 0xF0, 0xFF, 0xF3, 0xC1,
  0xF7, 0x81, 0xEE, 0x03, 0xDC, 0x07, 0xBC, 0x0F, 0x78, 0x3C, 0x78, 0xF8,
  0x7F, 0xE0, 0x3F, 0x01, 0xFF, 0x07, 0xCF, 0x9E, 0x0F, 0x38, 0x0F, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3B, 0x80, 0xF7, 0x83, 0xEF, 0xFF, 0x8F, 0xFE,
  0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xF8, 0x7F, 0xFC, 0x78, 0x1E, 0xF0, 0x1E,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x1E,
  0x7C, 0x3E, 0x3F, 0xFE, 0x3F, 0xFC, 0x0F, 0x3C, 0x00, 0x78, 0x00, 0x70,
  0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80,
  0x0F, 0x00, 0x7B, 0xFF, 0xFE, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xEF, 0xFF, 0xFD, 0xE0, 0x3E, 0x3F, 0x3F, 0x3F, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x1E, 0x3E, 0x3C, 0x3C, 0x38, 0x78,
  0x78, 0x70, 0xF0, 0x00, 0x04, 0x00, 0x30, 0x07, 0xC0, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x3F, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0x00, 0x1C, 0x00, 0x10, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0x00, 0x0F,
  0x00, 0x3F, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3C,
  0x00, 0x70, 0x0F, 0xC0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0x3E, 0x00,
  0xE0, 0x02, 0x00, 0x00, 0xFF, 0x0F, 0xFC, 0xFF, 0xE0, 0x3F, 0x00, 0xF0,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x03, 0xF1, 0xFE, 0x1F, 0xC1,
  0xF0, 0x1C, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x03,
  0xE0, 0x3E, 0x03, 0xC0, 0x07, 0xFC, 0x07, 0xFF, 0x83, 0xF1, 0xF0, 0xE0,
  0x1E, 0x78, 0x03, 0x9C, 0x00, 0xE7, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x79,
  0xF8, 0x3F, 0x7E, 0x1E, 0x7F, 0x87, 0x0F, 0xE1, 0xC1, 0xF8, 0x70, 0x7E,
  0x1C, 0x1F, 0x87, 0x07, 0xE1, 0xC1, 0xF8, 0x70, 0x7E, 0x1C, 0x3F, 0x87,
  0x8F, 0xE0, 0xFD, 0xF8, 0x1F, 0x7F, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1E, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3B,
  0xC0, 0x1C, 0xE0, 0x0E, 0x70, 0x0F, 0x38, 0x07, 0x1E, 0x03, 0x87, 0x01,
  0xC3, 0x81, 0xE1, 0xC0, 0xF0, 0xF0, 0x70, 0x38, 0x3F, 0xFC, 0x3F, 0xFE,
  0x1F, 0xFF, 0x8E, 0x03, 0xC7, 0x00, 0xE7, 0x80, 0x73, 0xC0, 0x3D, 0xC0,
  0x1F, 0xE0, 0x07, 0xFF, 0xE1, 0xFF, 0xE3, 0xFF, 0xE7, 0x03, 0xEE, 0x03,
  0xDC, 0x03, 0xB8, 0x07, 0x70, 0x0E, 0xE0, 0x3D, 0xC0, 0xF3, 0xFF, 0xC7,
  0xFF, 0x0F, 0xFF, 0x9C, 0x0F, 0xB8, 0x0F, 0x70, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x01, 0xEE, 0x07, 0xDF, 0xFF, 0x3F, 0xFC, 0x7F, 0xE0,
  0x1F, 0xE0, 0xFF, 0xC7, 0xFF, 0xBE, 0x0F, 0xF0, 0x3F, 0x80, 0x7E, 0x01,
  0xF8, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x7E, 0x01, 0xFC, 0x0F, 0xF8,
  0x7D, 0xFF, 0xE3, 0xFF, 0x07, 0xF8, 0xFF, 0xC3, 0xFF, 0xCF, 0xFF, 0xB8,
  0x3E, 0xE0, 0x3F, 0x80, 0xFE, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x03, 0xF8, 0x0F, 0xE0, 0xFB, 0xFF, 0xEF, 0xFF, 0x3F, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0xFF, 0xBF, 0xFE, 0xFF, 0xFB, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0x1F, 0xE0, 0xFF, 0xC7, 0xFF, 0xBE, 0x0F, 0xF0, 0x3F, 0x80, 0x7E, 0x01,
  0xF8, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0xFF, 0xE3, 0xFF, 0x8F,
  0xFE, 0x3F, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xFC, 0x0F, 0xF8,
  0x7D, 0xFF, 0xE3, 0xFF, 0x07, 0xF8, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x0E, 0x70, 0x1E, 0x78, 0x3E,
  0x3F, 0xFC, 0x3F, 0xF8, 0x0F, 0xF0, 0xE0, 0x1E, 0xE0, 0x1E, 0xE0, 0x3C,
  0xE0, 0x3C, 0xE0, 0x78, 0xE0, 0x78, 0xE0, 0xF0, 0xE0, 0xF0, 0xE1, 0xE0,
  0xE1, 0xE0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xE1, 0xE0, 0xE1, 0xE0,
  0xE0, 0xF0, 0xE0, 0xF0, 0xE0, 0x78, 0xE0, 0x78, 0xE0, 0x78, 0xE0, 0x3C,
  0xE0, 0x3C, 0xE0, 0x1E, 0xE0, 0x1F, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFC, 0x37, 0xEC, 0x37,
  0xEE, 0x77, 0xEE, 0x77, 0xE6, 0x67, 0xE7, 0xEF, 0xE7, 0xEF, 0xE3, 0xCF,
  0xE3, 0xCF, 0xE3, 0xCF, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xFC, 0x1F, 0xF0, 0x7E, 0xC1,
  0xFB, 0x87, 0xEE, 0x1F, 0x9C, 0x7E, 0x71, 0xF9, 0xC7, 0xE3, 0x9F, 0x8E,
  0x7E, 0x39, 0xF8, 0x77, 0xE1, 0xDF, 0x87, 0x7E, 0x0F, 0xF8, 0x3F, 0xE0,
  0xFF, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0x1F, 0xE0, 0xFF, 0xC7, 0xFF, 0xBC,
  0x1F, 0xF0, 0x3F, 0x80, 0xFE, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x03, 0xFC, 0x0F, 0xF8, 0x7D, 0xFF, 0xE3, 0xFF, 0x07, 0xF8,
  0xFF, 0xE1, 0xFF, 0xF3, 0xFF, 0xF7, 0x01, 0xEE, 0x01, 0xFC, 0x03, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0xFF, 0xFF, 0xEF, 0xFF,
  0x9F, 0xFE, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x0F, 0xF0, 0x1F,
  0xF8, 0x3F, 0xFC, 0x78, 0x3E, 0x78, 0x1E, 0xF0, 0x0E, 0xF0, 0x0E, 0xF0,
  0x0E, 0xF0, 0x0E, 0xF0, 0x0E, 0xF0, 0x0E, 0xF0, 0x0E, 0xF0, 0x0E, 0xF0,
  0x0E, 0xF0, 0x0E, 0xF0, 0x0E, 0xF0, 0x0E, 0xF0, 0x0E, 0x70, 0x0E, 0x78,
  0x1E, 0x7C, 0x3E, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0xFF, 0xE1, 0xFF,
  0xE3, 0xFF, 0xE7, 0x03, 0xEE, 0x03, 0xDC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x7B, 0x81, 0xF7, 0xFF, 0xCF, 0xFF, 0x1F, 0xFC, 0x38,
  0x78, 0x70, 0xF0, 0xE0, 0xF1, 0xC1, 0xE3, 0x81, 0xE7, 0x03, 0xCE, 0x03,
  0xDC, 0x07, 0xB8, 0x0F, 0x70, 0x0F, 0x0F, 0xF0, 0x1F, 0xFC, 0x3F, 0xFC,
  0x78, 0x1E, 0x78, 0x1E, 0x70, 0x0E, 0x70, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x7E, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFC, 0x00, 0x3E,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x0E, 0x78, 0x1E,
  0x7F, 0xFC, 0x3F, 0xFC, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x03, 0xFC, 0x0F, 0xF8, 0x7D, 0xFF, 0xE3, 0xFF, 0x07, 0xF8,
  0xF0, 0x03, 0xB8, 0x03, 0xDE, 0x01, 0xEF, 0x00, 0xE3, 0x80, 0x71, 0xC0,
  0x78, 0xF0, 0x3C, 0x78, 0x1C, 0x1C, 0x0E, 0x0E, 0x0F, 0x07, 0x87, 0x83,
  0xC3, 0x80, 0xE1, 0xC0, 0x70, 0xE0, 0x3C, 0xF0, 0x1E, 0x70, 0x07, 0x38,
  0x03, 0x9C, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xC0, 0xE1, 0xE1, 0xF8, 0x78, 0x7E, 0x1E, 0x1F, 0x87, 0x87,
  0xE1, 0xE1, 0xF8, 0x78, 0xFF, 0x3E, 0x39, 0xCD, 0x8E, 0x73, 0x33, 0x9C,
  0xCC, 0xE7, 0x33, 0x39, 0xCC, 0xCE, 0x73, 0x33, 0x9C, 0xCC, 0xE7, 0x33,
  0x31, 0xD8, 0xCC, 0x76, 0x37, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C,
  0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x78, 0x78, 0x07, 0x9E,
  0x01, 0xC3, 0xC0, 0xF0, 0xF0, 0x38, 0x1E, 0x1E, 0x03, 0x8F, 0x00, 0xF3,
  0xC0, 0x1D, 0xE0, 0x07, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x07, 0x80,
  0x03, 0xE0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1D, 0xE0, 0x0F, 0x3C, 0x03,
  0x8F, 0x01, 0xE1, 0xE0, 0x70, 0x78, 0x3C, 0x0F, 0x1E, 0x03, 0xC7, 0x80,
  0x7B, 0xC0, 0x1F, 0xF0, 0x03, 0xDC, 0x01, 0xE7, 0x80, 0x78, 0xE0, 0x3C,
  0x3C, 0x0F, 0x07, 0x03, 0x81, 0xE1, 0xE0, 0x38, 0x70, 0x0F, 0x3C, 0x03,
  0xCE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x01,
  0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFE, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x07, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0,
  0x01, 0xE0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x03,
  0xC0, 0x07, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0xE7, 0x01, 0xCE, 0x07, 0x1E,
  0x0E, 0x1C, 0x3C, 0x38, 0x70, 0x39, 0xE0, 0x73, 0x80, 0x7F, 0x00, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0xF1, 0xE1, 0xE0, 0x0F,
  0xF0, 0x7F, 0xF8, 0xFF, 0xF3, 0xC0, 0xF7, 0x01, 0xE0, 0x01, 0xC0, 0x03,
  0x83, 0xFF, 0x3F, 0xFE, 0xFF, 0xFF, 0xC0, 0x3F, 0x80, 0x7F, 0x01, 0xFE,
  0x03, 0xFC, 0x0F, 0xBE, 0x77, 0x7F, 0xEE, 0x7F, 0x9C, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x7F, 0x3B, 0xFE, 0xEF,
  0xFB, 0xE0, 0xFF, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xFC, 0x0F, 0xF8, 0x7F, 0xBF, 0xEE,
  0xFF, 0xB9, 0xF8, 0x1F, 0xE1, 0xFF, 0xE7, 0xFF, 0xBC, 0x0F, 0xF0, 0x3F,
  0x80, 0x7E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x1F, 0xC0, 0xFF, 0x87, 0xDF, 0xFE, 0x3F, 0xF0, 0x7F, 0x80, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF3, 0xFB, 0xDF,
  0xF7, 0xFF, 0xDF, 0xC1, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x7F,
  0xFF, 0xF7, 0xFF, 0xCF, 0xEF, 0x1F, 0xE1, 0xFF, 0xC7, 0xCF, 0xBC, 0x0F,
  0xE0, 0x3F, 0x80, 0x7E, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x7F, 0x03, 0xDF, 0xFE, 0x3F, 0xF0, 0x7F,
  0x80, 0x00, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x3F, 0xBD, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xF0, 0x3F, 0x80, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x3F,
  0xE3, 0x77, 0xFF, 0xCF, 0xEF, 0x0F, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x7C, 0xFF, 0xE3, 0xFF, 0x0F, 0xF8, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x7F, 0x3B, 0xFE, 0xEF, 0xFB, 0xC1,
  0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0x03, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xF7, 0xFF, 0x7F, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1E, 0x07, 0xEF, 0xFC, 0xFF,
  0x8F, 0xE0, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x1E, 0xE0, 0x3C, 0xE0, 0x3C, 0xE0, 0x78, 0xE0, 0xF0,
  0xE0, 0xF0, 0xE1, 0xE0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xE1, 0xE0,
  0xE1, 0xF0, 0xE0, 0xF0, 0xE0, 0x78, 0xE0, 0x78, 0xE0, 0x3C, 0xE0, 0x1E,
  0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F,
  0xFC, 0x07, 0xFE, 0x00, 0xFF, 0xEF, 0x3E, 0xFF, 0xFE, 0xF3, 0xCF, 0xE3,
  0x87, 0xE1, 0x87, 0xE1, 0x87, 0xE1, 0x87, 0xE1, 0x87, 0xE1, 0x87, 0xE1,
  0x87, 0xE1, 0x87, 0xE1, 0x87, 0xE1, 0x87, 0xE1, 0x87, 0xE1, 0x87, 0xE1,
  0x87, 0xE1, 0x87, 0xE1, 0x87, 0xE7, 0xF3, 0xBF, 0xEE, 0xFF, 0xBC, 0x1F,
  0xF0, 0x3F, 0xC0, 0xFE, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x70, 0x1F, 0xE1, 0xFF, 0xC7, 0xFF, 0xBC, 0x1F, 0xF0, 0x3F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0xC0, 0xFF, 0x87, 0xDF, 0xFE, 0x3F, 0xF0, 0x7F, 0x80, 0xE7, 0xF3, 0xBF,
  0xEE, 0xFF, 0xBE, 0x0F, 0xF0, 0x3F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0xFF, 0x87, 0xFB,
  0xFE, 0xEF, 0xFB, 0x9F, 0x8E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0x3F, 0xBD, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xF0, 0x3F,
  0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F,
  0xE0, 0x3F, 0xC0, 0xFF, 0x07, 0xDF, 0xF7, 0x7F, 0xFC, 0xFE, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0xF7, 0xF1, 0xFF,
  0xF3, 0xFF, 0xF7, 0xC1, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x3F, 0xF1, 0xFF, 0xEF, 0xFF,
  0xFC, 0x0F, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1F, 0xE0, 0x3F, 0xF0, 0x7F,
  0xE0, 0x0F, 0xC0, 0x0F, 0x00, 0x1F, 0x80, 0x7F, 0x03, 0xFF, 0xFF, 0x7F,
  0xF8, 0xFF, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x3C, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x7F, 0x80, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0xC0, 0xFF,
  0x87, 0x9F, 0xFE, 0x3F, 0xF0, 0x7F, 0x80, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0E, 0x70, 0x1E, 0x78, 0x1E, 0x78, 0x1C, 0x38, 0x1C, 0x3C, 0x3C, 0x3C,
  0x38, 0x1C, 0x38, 0x1E, 0x78, 0x1E, 0x70, 0x0E, 0x70, 0x0F, 0xF0, 0x0F,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0xE1, 0xE1, 0xF8, 0x78, 0x7E,
  0x1E, 0x1B, 0x87, 0x8E, 0x71, 0xE3, 0x9C, 0x58, 0xE7, 0x36, 0x39, 0xCC,
  0xCE, 0x73, 0x33, 0x9C, 0xCC, 0xC3, 0x33, 0x70, 0xEC, 0xDC, 0x3E, 0x37,
  0x0F, 0x85, 0xC3, 0xE1, 0xF0, 0xF8, 0x78, 0x1E, 0x1E, 0x07, 0x87, 0x80,
  0x78, 0x0F, 0x9E, 0x07, 0x87, 0x87, 0x83, 0xC3, 0xC0, 0xF3, 0xC0, 0x3B,
  0xC0, 0x1F, 0xE0, 0x07, 0xE0, 0x01, 0xE0, 0x01, 0xF8, 0x01, 0xFC, 0x00,
  0xFF, 0x00, 0xF3, 0xC0, 0xF1, 0xE0, 0x78, 0x78, 0x78, 0x1E, 0x78, 0x0F,
  0x7C, 0x03, 0xC0, 0xF0, 0x0F, 0xF0, 0x0F, 0x70, 0x0E, 0x78, 0x1E, 0x78,
  0x1E, 0x3C, 0x1C, 0x3C, 0x3C, 0x1C, 0x38, 0x1E, 0x78, 0x1E, 0x78, 0x0E,
  0x70, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1E, 0x00, 0xF8,
  0x07, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x7C, 0x07, 0xF0, 0x1F, 0xC0, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC3, 0xFE, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x7F,
  0x01, 0xFC, 0x03, 0xF0, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x03,
  0xF8, 0x0F, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x3F, 0xF0, 0x7F,
  0xC0, 0xFF, 0x07, 0xFC, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x3F, 0x80, 0xFE,
  0x03, 0xF0, 0x0E, 0x00, 0x00, 0x3E, 0x07, 0x7F, 0x07, 0xFF, 0x87, 0xE3,
  0xC7, 0xE1, 0xFF, 0xE0, 0xFE, 0xE0, 0x7C,
};

const GFXglyph JetBrainsMono_Medium33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 20, 0, -1 },
  { 1, 6, 24, 20, 7, -24 },
  { 19, 10, 10, 20, 5, -24 },
  { 32, 18, 24, 20, 1, -24 },
  { 86, 16, 34, 20, 2, -29 },
  { 154, 20, 24, 20, 0, -24 },
  { 214, 17, 24, 20, 2, -24 },
  { 265, 4, 10, 20, 8, -24 },
  { 270, 10, 32, 20, 6, -28 },
  { 310, 10, 32, 20, 4, -28 },
  { 350, 18, 17, 20, 1, -20 },
  { 389, 16, 16, 20, 2, -19 },
  { 421, 8, 10, 20, 5, -5 },
  { 431, 10, 4, 20, 5, -13 },
  { 436, 6, 6, 20, 7, -6 },
  { 441, 16, 31, 20, 2, -27 },
  { 503, 15, 24, 20, 2, -24 },
  { 548, 15, 24, 20, 3, -24 },
  { 593, 16, 24, 20, 2, -24 },
  { 641, 15, 24, 20, 2, -24 },
  { 686, 15, 24, 20, 2, -24 },
  { 731, 14, 24, 20, 3, -24 },
  { 773, 16, 24, 20, 2, -24 },
  { 821, 16, 24, 20, 2, -24 },
  { 869, 15, 24, 20, 2, -24 },
  { 914, 16, 24, 20, 2, -24 },
  { 962, 6, 18, 20, 7, -18 },
  { 976, 8, 23, 20, 5, -18 },
  { 999, 14, 18, 20, 3, -20 },
  { 1031, 14, 12, 20, 3, -17 },
  { 1052, 14, 18, 20, 3, -20 },
  { 1084, 12, 24, 20, 4, -24 },
  { 1120, 18, 30, 20, 1, -24 },
  { 1188, 17, 24, 20, 1, -24 },
  { 1239, 15, 24, 20, 3, -24 },
  { 1284, 14, 24, 20, 3, -24 },
  { 1326, 14, 24, 20, 3, -24 },
  { 1368, 14, 24, 20, 3, -24 },
  { 1410, 14, 24, 20, 3, -24 },
  { 1452, 14, 24, 20, 3, -24 },
  { 1494, 14, 24, 20, 3, -24 },
  { 1536, 14, 24, 20, 3, -24 },
  { 1578, 16, 24, 20, 1, -24 },
  { 1626, 16, 24, 20, 3, -24 },
  { 1674, 14, 24, 20, 4, -24 },
  { 1716, 16, 24, 20, 2, -24 },
  { 1764, 14, 24, 20, 3, -24 },
  { 1806, 14, 24, 20, 3, -24 },
  { 1848, 15, 24, 20, 3, -24 },
  { 1893, 16, 30, 20, 2, -24 },
  { 1953, 15, 24, 20, 3, -24 },
  { 1998, 16, 24, 20, 2, -24 },
  { 2046, 16, 24, 20, 2, -24 },
  { 2094, 14, 24, 20, 3, -24 },
  { 2136, 17, 24, 20, 1, -24 },
  { 2187, 18, 24, 20, 1, -24 },
  { 2241, 18, 24, 20, 1, -24 },
  { 2295, 18, 24, 20, 1, -24 },
  { 2349, 14, 24, 20, 3, -24 },
  { 2391, 9, 31, 20, 6, -27 },
  { 2426, 16, 31, 20, 2, -27 },
  { 2488, 8, 31, 20, 5, -27 },
  { 2519, 15, 13, 20, 2, -24 },
  { 2544, 16, 3, 20, 2, 1 },
  { 2550, 7, 5, 20, 6, -26 },
  { 2555, 15, 18, 20, 2, -18 },
  { 2589, 14, 24, 20, 3, -24 },
  { 2631, 14, 18, 20, 3, -18 },
  { 2663, 14, 24, 20, 3, -24 },
  { 2705, 14, 18, 20, 3, -18 },
  { 2737, 16, 24, 20, 2, -24 },
  { 2785, 14, 24, 20, 3, -18 },
  { 2827, 14, 24, 20, 3, -24 },
  { 2869, 15, 26, 20, 3, -26 },
  { 2918, 12, 32, 20, 3, -26 },
  { 2966, 16, 24, 20, 3, -24 },
  { 3014, 17, 24, 20, 1, -24 },
  { 3065, 16, 18, 20, 2, -18 },
  { 3101, 14, 18, 20, 3, -18 },
  { 3133, 14, 18, 20, 3, -18 },
  { 3165, 14, 24, 20, 3, -18 },
  { 3207, 14, 24, 20, 3, -18 },
  { 3249, 15, 18, 20, 3, -18 },
  { 3283, 14, 18, 20, 3, -18 },
  { 3315, 15, 23, 20, 2, -23 },
  { 3359, 14, 18, 20, 3, -18 },
  { 3391, 16, 18, 20, 2, -18 },
  { 3427, 18, 18, 20, 1, -18 },
  { 3468, 17, 18, 20, 1, -18 },
  { 3507, 16, 24, 20, 2, -18 },
  { 3555, 14, 18, 20, 3, -18 },
  { 3587, 14, 31, 20, 3, -27 },
  { 3642, 4, 31, 20, 8, -27 },
  { 3658, 14, 31, 20, 3, -27 },
  { 3713, 16, 7, 20, 2, -15 },
};

const GFXfont JetBrainsMono_Medium33pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Medium33pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Medium33pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _JETBRAINSMONO_MEDIUM33PT7B_H_
