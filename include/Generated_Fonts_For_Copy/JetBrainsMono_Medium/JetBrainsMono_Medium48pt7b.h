#ifndef _JETBRAINSMONO_MEDIUM48PT7B_H_
#define _JETBRAINSMONO_MEDIUM48PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Medium.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Medium48pt7bBitmaps[] PROGMEM = {
  0x00, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x1E, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xBF, 0xFF, 0xFF, 0xFD, 0xF0, 0xF8, 0x3F, 0xF0, 0x7F,
  0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8,
  0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xC0, 0x00,
  0x78, 0x0F, 0x00, 0x1E, 0x03, 0xC0, 0x07, 0x80, 0xF0, 0x03, 0xC0, 0x78,
  0x00, 0xF0, 0x1E, 0x00, 0x3C, 0x07, 0x80, 0x0F, 0x01, 0xE0, 0x03, 0xC0,
  0x78, 0x00, 0xE0, 0x1C, 0x0F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xC0, 0x78, 0x0F, 0x00, 0x3C, 0x07, 0x80,
  0x0F, 0x01, 0xE0, 0x03, 0xC0, 0x78, 0x00, 0xF0, 0x1E, 0x00, 0x3C, 0x07,
  0x80, 0x0E, 0x01, 0xE0, 0x07, 0x80, 0xF0, 0x01, 0xE0, 0x3C, 0x0F, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xE0,
  0xF0, 0x1E, 0x00, 0x3C, 0x07, 0x80, 0x0F, 0x01, 0xE0, 0x03, 0xC0, 0x78,
  0x00, 0xE0, 0x1E, 0x00, 0x78, 0x0F, 0x00, 0x1E, 0x03, 0xC0, 0x07, 0x80,
  0xF0, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xE1, 0xFD, 0xDF, 0xC7, 0xE3, 0x8F, 0xCF, 0xC7, 0x1F, 0x9F, 0x0E, 0x1F,
  0x3E, 0x1C, 0x3E, 0x7C, 0x38, 0x00, 0xF8, 0x70, 0x01, 0xF8, 0xE0, 0x03,
  0xF9, 0xC0, 0x03, 0xFB, 0x80, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x07,
  0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x01,
  0xFF, 0xC0, 0x03, 0x9F, 0xC0, 0x07, 0x1F, 0x80, 0x0E, 0x1F, 0x00, 0x1C,
  0x3F, 0x00, 0x38, 0x3F, 0xF0, 0x70, 0xFF, 0xF0, 0xE1, 0xFF, 0xE1, 0xC3,
  0xE7, 0xE3, 0x8F, 0xCF, 0xF7, 0x7F, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x0F, 0xE0, 0x00, 0xF8, 0xFF, 0x80, 0x0F, 0x8F, 0xFE, 0x00,
  0x78, 0xF8, 0xF8, 0x07, 0x87, 0x83, 0xC0, 0x78, 0x3C, 0x1E, 0x03, 0xC1,
  0xE0, 0xF0, 0x3C, 0x0F, 0x07, 0x83, 0xC0, 0x78, 0x3C, 0x1E, 0x03, 0xC1,
  0xE1, 0xE0, 0x1E, 0x0F, 0x1E, 0x00, 0xF0, 0x78, 0xF0, 0x07, 0xFF, 0xCF,
  0x00, 0x1F, 0xFC, 0xF0, 0x00, 0x7F, 0xCF, 0x00, 0x00, 0x70, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x3C, 0x00, 0x03, 0xC7, 0xFC, 0x00, 0x1E, 0x7F, 0xF0, 0x01, 0xE7,
  0xFF, 0x80, 0x1E, 0x3C, 0x1E, 0x00, 0xF3, 0xE0, 0xF0, 0x0F, 0x1E, 0x07,
  0x80, 0xF0, 0xF0, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0x78, 0x3C, 0x0F, 0x07,
  0x81, 0xE0, 0x78, 0x78, 0x07, 0x83, 0xC3, 0xC0, 0x3E, 0x3E, 0x3C, 0x01,
  0xFF, 0xE3, 0xC0, 0x07, 0xFE, 0x3E, 0x00, 0x0F, 0xE0, 0x00, 0x10, 0x00,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x00, 0xFC, 0x1F, 0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1E, 0x00,
  0xF8, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xDF, 0x81, 0xF7,
  0xC7, 0xC1, 0xF7, 0xE1, 0xF1, 0xFB, 0xE0, 0xFC, 0xF9, 0xF0, 0x3E, 0xFC,
  0xF8, 0x0F, 0xFC, 0x7C, 0x07, 0xFC, 0x3E, 0x01, 0xFE, 0x1F, 0x00, 0x7E,
  0x0F, 0x80, 0x1F, 0x07, 0xE0, 0x1F, 0xC1, 0xF0, 0x1F, 0xE0, 0xFC, 0x1F,
  0xF8, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0x9F, 0x87, 0xFF, 0x87, 0xC1, 0xFF,
  0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x06, 0x00, 0x7C, 0x01, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0x03, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF8,
  0x03, 0xF8, 0x03, 0xFE, 0x03, 0xFC, 0x03, 0xF8, 0x03, 0xF0, 0x01, 0xE0,
  0x00, 0x40, 0xC0, 0x03, 0xC0, 0x0F, 0xC0, 0x3F, 0x80, 0xFF, 0x80, 0xFF,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00,
  0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC,
  0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x1F, 0xC0, 0xFE, 0x0F, 0xF0,
  0xFF, 0x83, 0xFC, 0x0F, 0xE0, 0x3E, 0x00, 0xE0, 0x02, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x01, 0x00, 0xF8, 0x04, 0xF0, 0x78, 0x1E,
  0xFE, 0x1C, 0x3F, 0x7F, 0xCE, 0x7F, 0xFF, 0xF7, 0x7F, 0xE7, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xEF,
  0x00, 0x01, 0xF7, 0xC0, 0x01, 0xF1, 0xF0, 0x01, 0xF8, 0xF8, 0x00, 0xF8,
  0x7E, 0x00, 0xFC, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3C, 0x03, 0xE0, 0x0E,
  0x00, 0xE0, 0x02, 0x00, 0x40, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xC7,
  0xF1, 0xF8, 0xFE, 0x3F, 0x0F, 0xC3, 0xF1, 0xF8, 0x7E, 0x1F, 0x07, 0xC3,
  0xE0, 0xF8, 0x3E, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3E, 0x3F, 0xBF, 0xDF, 0xFF, 0xFF, 0xF9, 0xFC, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x87, 0xFF, 0xFE, 0x3F,
  0x83, 0xFB, 0xF0, 0x07, 0xDF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x0E, 0x1F, 0xF8, 0xF8, 0xFF, 0xCF, 0xC7, 0xFE, 0x7E, 0x3F,
  0xF1, 0xF1, 0xFF, 0x8F, 0x8F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xCF, 0xE0, 0xFE, 0x7F, 0xFF,
  0xE1, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x01, 0xFD,
  0xF8, 0x0F, 0xE7, 0xE0, 0x3E, 0x1F, 0x80, 0xF0, 0x7E, 0x03, 0x81, 0xF8,
  0x08, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x10,
  0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0,
  0xFE, 0x0F, 0xE7, 0xE0, 0x1F, 0x9F, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0x80, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x07, 0xFF, 0x00, 0x3F, 0x7C, 0x00, 0xF9, 0xF8, 0x07, 0xE7,
  0xF0, 0x3F, 0x8F, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x1F, 0x1F, 0x80, 0xF9, 0xF8,
  0x07, 0xDF, 0x80, 0x3E, 0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x7F, 0xFF,
  0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC7, 0xF0, 0x3E, 0xFF, 0xC1, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0x8F, 0xF7, 0xF0, 0x1F, 0xBF, 0x00, 0x7E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0x80, 0x1F, 0xFE, 0x01, 0xF9, 0xFC, 0x1F, 0xCF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xC0, 0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF1, 0xC0, 0x07, 0xDF,
  0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xDF, 0xF1, 0xFC, 0x07,
  0xF7, 0xF0, 0x07, 0xEF, 0xC0, 0x07, 0xDF, 0x00, 0x0F, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0xE0, 0x03, 0xE7, 0xC0, 0x0F, 0xCF, 0xC0, 0x1F, 0x8F, 0xE0, 0xFE, 0x1F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0x7E, 0x00, 0x3E, 0xFC, 0x00,
  0xF9, 0xF8, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x10, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xFC,
  0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFE, 0x0F, 0xE7, 0xE0, 0x1F, 0x9F,
  0x80, 0x3E, 0x7C, 0x00, 0xFD, 0xF0, 0x01, 0xF7, 0xC0, 0x0F, 0xDF, 0x00,
  0x3E, 0x3E, 0x00, 0xF8, 0xFC, 0x07, 0xE1, 0xF8, 0x3F, 0x03, 0xFB, 0xF8,
  0x07, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xF0, 0x1F,
  0xC7, 0xF0, 0xFC, 0x0F, 0xE3, 0xE0, 0x1F, 0x9F, 0x00, 0x3F, 0x7C, 0x00,
  0x7D, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0x7C, 0x00, 0x7D,
  0xF0, 0x01, 0xF7, 0xE0, 0x0F, 0xDF, 0xE0, 0xFE, 0x3F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xC0, 0xFF, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x10, 0x00, 0x07, 0xFF,
  0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xF0, 0x7F,
  0x1F, 0x80, 0x3F, 0x3E, 0x00, 0x3E, 0xFC, 0x00, 0x7D, 0xF0, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x1F, 0xFE, 0x00, 0x3F, 0x7E, 0x00, 0xFC, 0xFE, 0x03, 0xF8, 0xFF,
  0xBF, 0xF1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x80, 0xFF, 0xBE, 0x00, 0x30,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x3C, 0x3F, 0xBF, 0xDF, 0xFF, 0xFF, 0xF9, 0xFC, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xE3, 0xFB, 0xFD, 0xFF, 0xFF, 0xBF, 0x9F, 0x80, 0x0F, 0x83,
  0xF8, 0xFF, 0x1F, 0xF3, 0xFE, 0x7F, 0x87, 0xF0, 0x78, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x11, 0xFC, 0x3F, 0x87, 0xE0, 0xFC, 0x3F, 0x87, 0xE0, 0xFC, 0x1F,
  0x07, 0xE0, 0xFC, 0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x01, 0xC0, 0x00, 0x3E, 0x00, 0x07, 0xF0, 0x00, 0xFF,
  0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x01, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0x00, 0x00, 0x38, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x06, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0x3C, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x03,
  0xF8, 0x00, 0x1F, 0x00, 0x00, 0xE0, 0x00, 0x04, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xC3, 0xFF, 0xFC, 0xFF, 0xFF, 0x00, 0x0F,
  0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x03, 0xFE, 0x0F,
  0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xC0, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x01, 0xF8, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x01, 0xF8, 0x00, 0x00, 0x04, 0x00, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x81, 0xFE, 0x1F, 0xE1, 0xF8, 0x01,
  0xF0, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x1E, 0x7C, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x7F, 0x3F, 0xC0, 0x7F, 0xDF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3E, 0x1F, 0xF8,
  0x3E, 0x07, 0xFC, 0x1F, 0x01, 0xFE, 0x0F, 0x80, 0xFF, 0x07, 0xC0, 0x7F,
  0x83, 0xE0, 0x3F, 0xC1, 0xF0, 0x1F, 0xE0, 0xF8, 0x0F, 0xF0, 0x7C, 0x07,
  0xF8, 0x3E, 0x03, 0xFC, 0x1F, 0x01, 0xFE, 0x0F, 0x80, 0xFF, 0x07, 0xC0,
  0xFF, 0x81, 0xF0, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xEF, 0xF0, 0x0F,
  0xE7, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xBC, 0x00, 0x07, 0xDE,
  0x00, 0x03, 0xEF, 0x80, 0x01, 0xF7, 0xC0, 0x00, 0xF3, 0xE0, 0x00, 0xF8,
  0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x1E, 0x1F, 0x00, 0x1F,
  0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x07, 0xC0, 0xF8, 0x03,
  0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xC0,
  0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE,
  0x0F, 0x80, 0x1F, 0x87, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE3, 0xF0, 0x01,
  0xF1, 0xF0, 0x00, 0xFC, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x7E, 0x00,
  0x0F, 0xBE, 0x00, 0x07, 0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF8, 0xF8, 0x1F, 0xF3, 0xE0, 0x0F, 0xCF, 0x80, 0x1F,
  0xBE, 0x00, 0x3E, 0xF8, 0x00, 0xFB, 0xE0, 0x03, 0xEF, 0x80, 0x0F, 0xBE,
  0x00, 0x3E, 0xF8, 0x01, 0xF3, 0xE0, 0x0F, 0xCF, 0x81, 0xFE, 0x3F, 0xFF,
  0xF0, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x3E, 0x01, 0xFC,
  0xF8, 0x01, 0xFB, 0xE0, 0x03, 0xEF, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00,
  0xFB, 0xE0, 0x0F, 0xEF, 0x81, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x20, 0x00, 0x3F, 0xF8, 0x03,
  0xFF, 0xE0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0x83, 0xF9, 0xF8, 0x07,
  0xFF, 0x80, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0xFD, 0xF8, 0x07, 0xEF, 0xE0, 0xFE, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x03,
  0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7C, 0x03, 0xFB, 0xE0, 0x07, 0xDF,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x3F, 0x7C, 0x03, 0xFB,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xC7, 0xFF, 0xF8, 0x3F, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xCF, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x7F, 0xFF, 0xC3,
  0xFF, 0xFE, 0x3F, 0x83, 0xF9, 0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x00,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0,
  0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0xFD, 0xF8, 0x07, 0xEF, 0xE0,
  0xFE, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x03, 0xFF, 0xE0, 0x0F, 0xFE, 0x00,
  0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3E, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x01,
  0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0xFD, 0xF8, 0x07, 0xE7, 0xF0, 0x3F, 0x8F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0xF8, 0x00, 0x7F,
  0xF0, 0x01, 0xFB, 0xE0, 0x03, 0xE7, 0xC0, 0x0F, 0xCF, 0x80, 0x1F, 0x1F,
  0x00, 0x7E, 0x3E, 0x00, 0xF8, 0x7C, 0x03, 0xF0, 0xF8, 0x07, 0xE1, 0xF0,
  0x1F, 0x83, 0xE0, 0x3F, 0x07, 0xC0, 0xFC, 0x0F, 0x81, 0xF8, 0x1F, 0x07,
  0xE0, 0x3E, 0x0F, 0xC0, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC,
  0x03, 0xFF, 0xF8, 0x07, 0xC1, 0xF8, 0x0F, 0x83, 0xF0, 0x1F, 0x03, 0xF0,
  0x3E, 0x07, 0xE0, 0x7C, 0x07, 0xE0, 0xF8, 0x0F, 0xC1, 0xF0, 0x0F, 0xC3,
  0xE0, 0x1F, 0x87, 0xC0, 0x1F, 0x8F, 0x80, 0x3F, 0x1F, 0x00, 0x3E, 0x3E,
  0x00, 0x7E, 0x7C, 0x00, 0x7C, 0xF8, 0x00, 0xFD, 0xF0, 0x00, 0xFB, 0xE0,
  0x01, 0xF8, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0x00,
  0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F,
  0xFE, 0xE0, 0x3B, 0xFD, 0xE0, 0xF7, 0xFB, 0xC1, 0xEF, 0xF7, 0x83, 0x9F,
  0xE7, 0x8F, 0x7F, 0xCF, 0x1E, 0xFF, 0xDE, 0x39, 0xFF, 0x9C, 0xF3, 0xFF,
  0x3D, 0xE7, 0xFE, 0x7B, 0xCF, 0xFC, 0x77, 0x1F, 0xF8, 0xFE, 0x3F, 0xF1,
  0xFC, 0x7F, 0xE1, 0xF0, 0xFF, 0xC3, 0xE1, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0xF8, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFE,
  0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFE, 0x03, 0xFE, 0xF0, 0x1F,
  0xF7, 0x80, 0xFF, 0xBE, 0x07, 0xFE, 0xF0, 0x3F, 0xF7, 0x81, 0xFF, 0x9E,
  0x0F, 0xFC, 0xF0, 0x7F, 0xE7, 0xC3, 0xFF, 0x1E, 0x1F, 0xF8, 0xF0, 0xFF,
  0xC7, 0xC7, 0xFE, 0x1E, 0x3F, 0xF0, 0xF1, 0xFF, 0x87, 0xCF, 0xFC, 0x1E,
  0x7F, 0xE0, 0xF3, 0xFF, 0x07, 0xDF, 0xF8, 0x1E, 0xFF, 0xC0, 0xF7, 0xFE,
  0x07, 0xFF, 0xF0, 0x1E, 0xFF, 0x80, 0xF7, 0xFC, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFE, 0x00,
  0x20, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xFF, 0xFE,
  0x3F, 0x83, 0xF9, 0xF0, 0x0F, 0xDF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFD, 0xF8, 0x0F, 0xCF, 0xE0, 0xFE, 0x3F,
  0xFF, 0xE1, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0x9F, 0x00, 0x3F, 0xBE, 0x00, 0x3F, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x0F, 0xBE, 0x00, 0x3F, 0x7C, 0x00, 0xFE, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x20, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xE1, 0xFC, 0x1F, 0xCF, 0xC0, 0x3F, 0x3F, 0x00,
  0x7E, 0xF8, 0x00, 0xFB, 0xE0, 0x03, 0xEF, 0x80, 0x0F, 0xBE, 0x00, 0x3E,
  0xF8, 0x00, 0xFB, 0xE0, 0x03, 0xEF, 0x80, 0x0F, 0xBE, 0x00, 0x3E, 0xF8,
  0x00, 0xFB, 0xE0, 0x03, 0xEF, 0x80, 0x0F, 0xBE, 0x00, 0x3E, 0xF8, 0x00,
  0xFB, 0xE0, 0x03, 0xEF, 0x80, 0x0F, 0xBE, 0x00, 0x3E, 0xF8, 0x00, 0xFB,
  0xE0, 0x03, 0xEF, 0x80, 0x0F, 0xBE, 0x00, 0x3E, 0xF8, 0x00, 0xFB, 0xF0,
  0x07, 0xEF, 0xC0, 0x3F, 0x1F, 0xC1, 0xFC, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0xFF, 0xFE, 0x03, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xE0, 0x0F, 0xEF,
  0x80, 0x1F, 0xBE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x1F,
  0xBE, 0x00, 0xFE, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF8, 0x3E, 0x07,
  0xE0, 0xF8, 0x0F, 0x83, 0xE0, 0x3F, 0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xF8,
  0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0xCF, 0x80, 0x1F, 0x3E, 0x00, 0x7E, 0xF8,
  0x01, 0xFB, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x87, 0xF0,
  0x7F, 0x1F, 0x80, 0x3F, 0x3F, 0x00, 0x7E, 0x7C, 0x00, 0x7C, 0xF8, 0x00,
  0xF9, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x00,
  0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0x9F, 0x80,
  0x3F, 0x3F, 0xC1, 0xFC, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF,
  0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xBF, 0x01, 0xF9, 0xFC, 0x1F, 0xC7, 0xFF,
  0xFC, 0x3F, 0xFF, 0xC0, 0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0xFC, 0x00, 0x1F,
  0xFE, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xE7, 0xC0, 0x03,
  0xF3, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x3E, 0x00,
  0x7E, 0x1F, 0x80, 0x3E, 0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x0F, 0x81, 0xF0,
  0x07, 0xC0, 0xFC, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F,
  0x80, 0xF8, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x3E, 0x00,
  0x7C, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0xC7, 0xC0,
  0x03, 0xE3, 0xC0, 0x00, 0xFB, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x3E, 0xF8,
  0x00, 0x1F, 0x78, 0x00, 0x07, 0xBC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0xF8,
  0x1F, 0x03, 0xFF, 0x03, 0xE0, 0x7F, 0xE0, 0x7C, 0x0F, 0xFC, 0x0F, 0x81,
  0xE7, 0x81, 0xB0, 0x3C, 0xF0, 0x77, 0x07, 0x9E, 0x0E, 0xE0, 0xF3, 0xC1,
  0xDC, 0x1E, 0x78, 0x3B, 0x87, 0xCF, 0x87, 0x70, 0xF9, 0xF0, 0xEE, 0x1F,
  0x3E, 0x1D, 0xC3, 0xE7, 0xC3, 0xB8, 0x78, 0xF8, 0xE7, 0x0F, 0x0F, 0x1C,
  0x71, 0xE1, 0xE3, 0x8E, 0x3C, 0x3C, 0x71, 0xC7, 0x87, 0x8E, 0x38, 0xF0,
  0xF1, 0xC7, 0x3E, 0x1E, 0x38, 0xE7, 0xC3, 0xE7, 0x1C, 0xF8, 0x7C, 0xC3,
  0x9E, 0x0F, 0xB8, 0x73, 0xC0, 0xF7, 0x07, 0x78, 0x1E, 0xE0, 0xEF, 0x03,
  0xDC, 0x1D, 0xE0, 0x7B, 0x83, 0xBC, 0x0F, 0x70, 0x77, 0x81, 0xEE, 0x0E,
  0xF0, 0x3D, 0xC1, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x0F,
  0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x1F, 0xBF, 0x00, 0x1F, 0x8F, 0x80, 0x0F, 0x87, 0xE0, 0x0F, 0xC1, 0xF0,
  0x07, 0xC0, 0xFC, 0x07, 0xE0, 0x3E, 0x03, 0xE0, 0x1F, 0x83, 0xE0, 0x07,
  0xC1, 0xF0, 0x03, 0xF1, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x7E, 0xF8, 0x00,
  0x1F, 0x7C, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xDF, 0x00, 0x07, 0xCF,
  0xC0, 0x07, 0xE3, 0xE0, 0x03, 0xE1, 0xF8, 0x03, 0xF0, 0x7E, 0x01, 0xF0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0xF8, 0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x7C,
  0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xBF, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0xF8, 0xF8, 0x00,
  0x7E, 0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x0F, 0xC1, 0xF8, 0x03, 0xE0, 0x3E,
  0x00, 0xF8, 0x0F, 0xC0, 0x7C, 0x01, 0xF0, 0x1F, 0x00, 0x7E, 0x0F, 0x80,
  0x0F, 0x83, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0xBF,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3D, 0xE0, 0x03,
  0xEF, 0x00, 0x1E, 0x7C, 0x00, 0xF1, 0xE0, 0x0F, 0x8F, 0x80, 0x78, 0x3C,
  0x07, 0xC1, 0xF0, 0x3C, 0x0F, 0x83, 0xE0, 0x3C, 0x1F, 0x01, 0xF1, 0xF0,
  0x07, 0x8F, 0x80, 0x3E, 0x78, 0x00, 0xF7, 0xC0, 0x07, 0xFC, 0x00, 0x3E,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x0F, 0x81,
  0xF8, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFC,
  0x3F, 0xEF, 0xF8, 0xFC, 0x07, 0xE7, 0xE0, 0x0F, 0xDF, 0x00, 0x3F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x1F, 0xFF, 0x0F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0xDF, 0x80, 0x1F, 0xFC, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0xE0, 0x3F, 0xDF, 0xFF, 0xDF, 0x7F, 0xFF, 0x7C, 0xFF, 0xF9,
  0xF0, 0xFF, 0x87, 0xC0, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x3E, 0x07, 0xC7, 0xFC, 0x3E, 0x7F, 0xF1, 0xF7, 0xFF, 0xCF,
  0xFF, 0xFF, 0x7F, 0x01, 0xFB, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x00,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0x01, 0xFF, 0xFC,
  0x1F, 0xDF, 0x7F, 0xFE, 0xFB, 0xFF, 0xE7, 0xCF, 0xFE, 0x3E, 0x3F, 0xC0,
  0x01, 0xFC, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC7, 0xFF,
  0xFF, 0x3F, 0x01, 0xFB, 0xF0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFD, 0xFC, 0x1F,
  0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xE0, 0x7F, 0xFE, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x03, 0xE0, 0xF8, 0x7F,
  0xC7, 0xCF, 0xFF, 0x3E, 0x7F, 0xFD, 0xF7, 0xFF, 0xEF, 0xFF, 0x03, 0xFF,
  0xF0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x03,
  0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFD, 0xFC, 0x1B, 0xEF, 0xFF, 0xDF, 0x3F,
  0xFE, 0xF8, 0xFF, 0xE7, 0xC3, 0xFE, 0x3E, 0x01, 0xFC, 0x00, 0x3F, 0xF8,
  0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC7, 0xF8, 0xFE, 0x3F, 0x01, 0xFB, 0xF0,
  0x07, 0xDF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x0F, 0xFE, 0x00, 0xFD, 0xF8, 0x0F, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF,
  0xE0, 0x7F, 0xFE, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xFC,
  0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x3F, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x7F, 0xC7, 0xCF, 0xFF, 0x3E, 0x7F, 0xFD, 0xF7, 0xFF, 0xEF,
  0xBF, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x7F, 0xF8, 0x07, 0xF7, 0xF0, 0x6F, 0xBF, 0xFF, 0x7C, 0xFF, 0xFB, 0xE3,
  0xFF, 0x9F, 0x0F, 0xF0, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC3, 0xFF, 0xFE, 0x1F,
  0xFF, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x3E, 0x07, 0xC7, 0xFC,
  0x3E, 0xFF, 0xF1, 0xF7, 0xFF, 0xCF, 0xFF, 0xFF, 0x7F, 0x01, 0xFB, 0xF0,
  0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3E, 0x00, 0x10, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x02, 0x00, 0x03,
  0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0x9F, 0xFF, 0xE7, 0xFF, 0xF9, 0xFF, 0xFE, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x1F, 0xCF, 0xFF, 0xF3, 0xFF, 0xF8, 0xFF,
  0xFC, 0x3F, 0xFC, 0x0F, 0xF8, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x01, 0xFB, 0xE0,
  0x03, 0xF7, 0xC0, 0x0F, 0xCF, 0x80, 0x3F, 0x1F, 0x00, 0x7E, 0x3E, 0x01,
  0xF8, 0x7C, 0x07, 0xE0, 0xF8, 0x0F, 0xC1, 0xF0, 0x3F, 0x03, 0xE0, 0xFC,
  0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80,
  0x7F, 0xFF, 0x80, 0xF8, 0x1F, 0x81, 0xF0, 0x3F, 0x03, 0xE0, 0x3F, 0x07,
  0xC0, 0x7E, 0x0F, 0x80, 0x7E, 0x1F, 0x00, 0x7E, 0x3E, 0x00, 0xFC, 0x7C,
  0x00, 0xFC, 0xF8, 0x00, 0xF9, 0xF0, 0x01, 0xFB, 0xE0, 0x01, 0xF8, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x03,
  0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x01, 0xE0, 0xF1, 0xE7, 0xE7, 0xF3, 0xDF,
  0xEF, 0xF7, 0xBF, 0xFF, 0xEF, 0x87, 0xC7, 0xFF, 0x0F, 0x87, 0xFE, 0x1E,
  0x0F, 0xF8, 0x3C, 0x1F, 0xF0, 0x78, 0x3F, 0xE0, 0xF0, 0x7F, 0xC1, 0xE0,
  0xFF, 0x83, 0xC1, 0xFF, 0x07, 0x83, 0xFE, 0x0F, 0x07, 0xFC, 0x1E, 0x0F,
  0xF8, 0x3C, 0x1F, 0xF0, 0x78, 0x3F, 0xE0, 0xF0, 0x7F, 0xC1, 0xE0, 0xFF,
  0x83, 0xC1, 0xFF, 0x07, 0x83, 0xFE, 0x0F, 0x07, 0xFC, 0x1E, 0x0F, 0xF8,
  0x3C, 0x1F, 0xF0, 0x78, 0x3F, 0xE0, 0xF0, 0x7F, 0xC1, 0xE0, 0xF8, 0x00,
  0x3E, 0x07, 0xC7, 0xFC, 0x3E, 0xFF, 0xF1, 0xF7, 0xFF, 0xCF, 0xFF, 0xFF,
  0x7F, 0x01, 0xFB, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3E, 0x01, 0xFC,
  0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F,
  0x01, 0xFB, 0xF0, 0x07, 0xDF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xF9, 0xFC, 0x1F, 0xC7, 0xFF,
  0xFC, 0x3F, 0xFF, 0xC0, 0x7F, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0x3E, 0x07,
  0xC7, 0xFC, 0x3E, 0x7F, 0xF1, 0xF7, 0xFF, 0xCF, 0xFF, 0xFF, 0x7F, 0x01,
  0xFB, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF8,
  0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0x01, 0xFB, 0xFC, 0x1F, 0xDF, 0x7F, 0xFE,
  0xFB, 0xFF, 0xE7, 0xCF, 0xFE, 0x3E, 0x3F, 0xE1, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x7F,
  0xC7, 0xCF, 0xFF, 0x3E, 0x7F, 0xFD, 0xF7, 0xFF, 0xEF, 0xBF, 0x03, 0xFF,
  0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x03,
  0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFD, 0xFC, 0x1B, 0xEF, 0xFF, 0xDF, 0x3F,
  0xFE, 0xF8, 0xFF, 0xE7, 0xC3, 0xFE, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x7E, 0x07, 0xCF, 0xFC,
  0x3E, 0xFF, 0xF1, 0xF7, 0xFF, 0xCF, 0xFF, 0xFF, 0x7F, 0x01, 0xFB, 0xF0,
  0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xFC, 0x0F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xE7, 0xFF, 0xFF, 0x3E, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x0F, 0xEF, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x03, 0xFF, 0xE0, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x3F,
  0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFC, 0xF8, 0x00, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xF8, 0x03, 0xE7,
  0xE0, 0x3F, 0x3F, 0x83, 0xF8, 0xFF, 0xFF, 0x83, 0xFF, 0xF8, 0x0F, 0xFF,
  0x80, 0x3F, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0xBE, 0x00, 0x0F, 0x9F, 0x00,
  0x0F, 0xC7, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE1, 0xF0, 0x03, 0xF0, 0x7C,
  0x01, 0xF0, 0x3E, 0x00, 0xF8, 0x1F, 0x00, 0xFC, 0x07, 0xC0, 0x7C, 0x03,
  0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x0F, 0x80,
  0x1F, 0x07, 0xC0, 0x07, 0xC7, 0xC0, 0x03, 0xE3, 0xE0, 0x01, 0xF1, 0xF0,
  0x00, 0xFD, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xBC,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0xF8, 0x1F, 0x03, 0xDE, 0x07, 0xC0, 0xF7, 0x81, 0xF0, 0x3D,
  0xE0, 0x7C, 0x0F, 0x78, 0x3B, 0x03, 0xDF, 0x0E, 0xE1, 0xF7, 0xC3, 0xB8,
  0x78, 0xF0, 0xEE, 0x1E, 0x3C, 0x3B, 0x87, 0x8F, 0x0E, 0xE1, 0xE3, 0xC3,
  0x38, 0x78, 0xF1, 0xC6, 0x1E, 0x3E, 0x71, 0xCF, 0x0F, 0x9C, 0x73, 0xC1,
  0xE7, 0x1C, 0xF0, 0x79, 0xC7, 0x3C, 0x1E, 0x61, 0xCF, 0x07, 0xB8, 0x73,
  0xC1, 0xEE, 0x0F, 0xE0, 0x7B, 0x83, 0xF8, 0x0F, 0xE0, 0xFE, 0x03, 0xF8,
  0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x3F, 0x03, 0xF8, 0x0F, 0xC0, 0x7C, 0x03,
  0xF0, 0x1F, 0x00, 0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x3F, 0x07, 0xC0, 0x3F,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0x3E, 0x1F, 0x80, 0x1F, 0x8F,
  0xC0, 0x07, 0xEF, 0xC0, 0x01, 0xF7, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xF7, 0xC0, 0x01, 0xFB, 0xF0, 0x01,
  0xF8, 0xFC, 0x01, 0xF8, 0x3E, 0x00, 0xFC, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0xFC, 0x01, 0xF0, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x1F,
  0xC0, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x1F, 0x9F, 0x80, 0x0F, 0xC7, 0xC0,
  0x07, 0xC3, 0xF0, 0x07, 0xE0, 0xF8, 0x03, 0xE0, 0x7C, 0x01, 0xF0, 0x3F,
  0x01, 0xF8, 0x0F, 0x80, 0xF8, 0x07, 0xE0, 0x7C, 0x01, 0xF0, 0x7E, 0x00,
  0xF8, 0x3E, 0x00, 0x7E, 0x1F, 0x00, 0x1F, 0x1F, 0x80, 0x0F, 0x8F, 0x80,
  0x07, 0xE7, 0xC0, 0x01, 0xF7, 0xC0, 0x00, 0xFB, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x03,
  0xFF, 0x80, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xC0,
  0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xFF, 0x80,
  0x7F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC,
  0x00, 0x1F, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x3E, 0x7F, 0xC0, 0x7D, 0xFF, 0xC0, 0xFF,
  0xFF, 0xC1, 0xFF, 0x8F, 0xC3, 0xFE, 0x0F, 0xC7, 0xFC, 0x0F, 0xFF, 0xF8,
  0x0F, 0xFE, 0xF0, 0x1F, 0xF9, 0xE0, 0x0F, 0xE0,
};

const GFXglyph JetBrainsMono_Medium48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 29, 0, -1 },
  { 1, 7, 35, 29, 11, -35 },
  { 32, 15, 14, 29, 7, -35 },
  { 59, 26, 35, 29, 1, -35 },
  { 173, 23, 49, 29, 3, -42 },
  { 314, 29, 35, 29, 0, -35 },
  { 441, 25, 36, 29, 2, -36 },
  { 554, 5, 14, 29, 12, -35 },
  { 563, 15, 46, 29, 8, -40 },
  { 650, 14, 46, 29, 6, -40 },
  { 731, 25, 25, 29, 2, -29 },
  { 810, 23, 22, 29, 3, -27 },
  { 874, 10, 15, 29, 8, -7 },
  { 893, 15, 5, 29, 7, -18 },
  { 903, 9, 8, 29, 10, -8 },
  { 912, 23, 45, 29, 3, -40 },
  { 1042, 21, 36, 29, 4, -36 },
  { 1137, 22, 35, 29, 4, -35 },
  { 1234, 22, 36, 29, 3, -36 },
  { 1333, 22, 35, 29, 3, -35 },
  { 1430, 21, 35, 29, 3, -35 },
  { 1522, 21, 35, 29, 4, -35 },
  { 1614, 23, 35, 29, 3, -35 },
  { 1715, 23, 35, 29, 3, -35 },
  { 1816, 22, 36, 29, 3, -36 },
  { 1915, 23, 36, 29, 3, -36 },
  { 2019, 9, 27, 29, 10, -27 },
  { 2050, 11, 35, 29, 8, -27 },
  { 2099, 21, 26, 29, 4, -29 },
  { 2168, 21, 16, 29, 4, -24 },
  { 2210, 21, 26, 29, 4, -29 },
  { 2279, 18, 35, 29, 6, -35 },
  { 2358, 25, 45, 29, 2, -36 },
  { 2499, 25, 35, 29, 2, -35 },
  { 2609, 22, 35, 29, 4, -35 },
  { 2706, 21, 36, 29, 4, -36 },
  { 2801, 21, 35, 29, 4, -35 },
  { 2893, 20, 35, 29, 5, -35 },
  { 2981, 21, 35, 29, 4, -35 },
  { 3073, 21, 36, 29, 4, -36 },
  { 3168, 21, 35, 29, 4, -35 },
  { 3260, 19, 35, 29, 5, -35 },
  { 3344, 22, 35, 29, 2, -35 },
  { 3441, 23, 35, 29, 4, -35 },
  { 3542, 21, 35, 29, 5, -35 },
  { 3634, 23, 35, 29, 3, -35 },
  { 3735, 21, 35, 29, 4, -35 },
  { 3827, 21, 36, 29, 4, -36 },
  { 3922, 23, 35, 29, 4, -35 },
  { 4023, 22, 45, 29, 4, -36 },
  { 4147, 22, 35, 29, 4, -35 },
  { 4244, 23, 36, 29, 3, -36 },
  { 4348, 24, 35, 29, 2, -35 },
  { 4453, 21, 35, 29, 4, -35 },
  { 4545, 25, 35, 29, 2, -35 },
  { 4655, 27, 35, 29, 1, -35 },
  { 4774, 25, 35, 29, 2, -35 },
  { 4884, 26, 35, 29, 1, -35 },
  { 4998, 21, 35, 29, 4, -35 },
  { 5090, 13, 45, 29, 9, -40 },
  { 5164, 23, 45, 29, 3, -40 },
  { 5294, 12, 45, 29, 7, -40 },
  { 5362, 21, 19, 29, 4, -35 },
  { 5412, 23, 5, 29, 3, 1 },
  { 5427, 11, 7, 29, 8, -38 },
  { 5437, 22, 27, 29, 3, -27 },
  { 5512, 21, 35, 29, 4, -35 },
  { 5604, 21, 27, 29, 4, -27 },
  { 5675, 21, 35, 29, 4, -35 },
  { 5767, 21, 27, 29, 4, -27 },
  { 5838, 23, 35, 29, 3, -35 },
  { 5939, 21, 36, 29, 4, -27 },
  { 6034, 21, 35, 29, 4, -35 },
  { 6126, 23, 38, 29, 4, -38 },
  { 6236, 18, 47, 29, 4, -38 },
  { 6342, 23, 35, 29, 4, -35 },
  { 6443, 26, 35, 29, 1, -35 },
  { 6557, 23, 27, 29, 3, -27 },
  { 6635, 21, 27, 29, 4, -27 },
  { 6706, 21, 27, 29, 4, -27 },
  { 6777, 21, 36, 29, 4, -27 },
  { 6872, 21, 36, 29, 4, -27 },
  { 6967, 21, 27, 29, 5, -27 },
  { 7038, 21, 27, 29, 4, -27 },
  { 7109, 23, 34, 29, 2, -34 },
  { 7207, 21, 26, 29, 4, -26 },
  { 7276, 25, 26, 29, 2, -26 },
  { 7358, 26, 26, 29, 1, -26 },
  { 7443, 25, 26, 29, 2, -26 },
  { 7525, 25, 35, 29, 2, -26 },
  { 7635, 21, 26, 29, 4, -26 },
  { 7704, 21, 45, 29, 4, -40 },
  { 7823, 5, 45, 29, 12, -40 },
  { 7852, 21, 45, 29, 4, -40 },
  { 7971, 23, 10, 29, 3, -22 },
};

const GFXfont JetBrainsMono_Medium48pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Medium48pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Medium48pt7bGlyphs,
  0x20, 0x7E, 63
};

#endif // _JETBRAINSMONO_MEDIUM48PT7B_H_
