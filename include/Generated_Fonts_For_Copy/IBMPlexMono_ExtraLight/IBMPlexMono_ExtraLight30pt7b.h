#ifndef _IBMPLEXMONO_EXTRALIGHT30PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHT30PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLight.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLight30pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFA, 0xAA, 0x03, 0xC0, 0x86, 0x18, 0x61, 0x86, 0x18,
  0x61, 0x01, 0x08, 0x02, 0x08, 0x02, 0x08, 0x02, 0x10, 0x02, 0x10, 0x02,
  0x10, 0x02, 0x10, 0x7C, 0x1F, 0x04, 0x10, 0x04, 0x20, 0x04, 0x20, 0x04,
  0x20, 0x0C, 0x20, 0xF8, 0x3E, 0x08, 0x40, 0x08, 0x40, 0x08, 0x40, 0x08,
  0x40, 0x10, 0x40, 0x10, 0x40, 0x10, 0x80, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x03, 0xF0, 0x31, 0x31, 0x04, 0x24, 0x10, 0xF0, 0x40, 0x81, 0x01, 0x04,
  0x04, 0x10, 0x18, 0x40, 0x1D, 0x00, 0x1F, 0x80, 0x13, 0x00, 0x42, 0x01,
  0x04, 0x04, 0x10, 0x10, 0x40, 0x41, 0x81, 0x0D, 0x04, 0x23, 0x13, 0x03,
  0xF0, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x3C, 0x01, 0x42, 0x02, 0x81,
  0x02, 0x81, 0x04, 0x81, 0x04, 0x81, 0x08, 0x81, 0x10, 0x81, 0x10, 0x42,
  0x20, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x04, 0x42, 0x08, 0x81, 0x08,
  0x81, 0x10, 0x81, 0x20, 0x81, 0x20, 0x81, 0x40, 0x81, 0x40, 0x42, 0x80,
  0x3C, 0x07, 0x80, 0x30, 0xC0, 0x40, 0x81, 0x01, 0x82, 0x00, 0x04, 0x00,
  0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0xD8, 0x3B, 0x10, 0x44,
  0x10, 0x98, 0x11, 0x20, 0x12, 0x40, 0x38, 0x80, 0x31, 0x80, 0x31, 0x00,
  0xA1, 0x86, 0x21, 0xF0, 0x20, 0xFF, 0xFF, 0x06, 0x10, 0x20, 0x82, 0x04,
  0x10, 0x20, 0x41, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x03, 0x02,
  0x04, 0x04, 0x08, 0x08, 0x08, 0x10, 0x18, 0xC0, 0xC0, 0x80, 0x80, 0x81,
  0x01, 0x02, 0x04, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x10,
  0x20, 0x41, 0x02, 0x08, 0x20, 0xC3, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x40, 0x82, 0xB8, 0x9D, 0x07, 0xE0, 0x01,
  0x80, 0x02, 0x40, 0x02, 0x40, 0x04, 0x20, 0x08, 0x10, 0x18, 0x18, 0x10,
  0x08, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x3F, 0xFF, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x6D, 0x2D, 0x24, 0xFF, 0xF0, 0x00, 0x10, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x80, 0x10,
  0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80,
  0x10, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x80, 0x00, 0x0F, 0xC0, 0x61, 0x82, 0x01, 0x10, 0x02, 0x40, 0x09, 0x00,
  0x28, 0x00, 0x60, 0x01, 0x80, 0x06, 0x0C, 0x18, 0x30, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0xD0, 0x02, 0x40, 0x09, 0x00, 0x22, 0x01, 0x06,
  0x18, 0x0F, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x34, 0x00, 0x88, 0x06, 0x10,
  0x18, 0x20, 0x20, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x07, 0xFF, 0xE0, 0x0F, 0xC0, 0xC1, 0x86, 0x01,
  0x10, 0x04, 0x40, 0x1A, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0xFF, 0xFC, 0x0F, 0xC1, 0x83, 0x18,
  0x0C, 0x80, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x06, 0x00, 0x60, 0x7C,
  0x00, 0x38, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x20, 0x01, 0x00, 0x0C,
  0x00, 0x90, 0x0C, 0x60, 0xC1, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x50, 0x00, 0x90, 0x00, 0x90, 0x01, 0x10, 0x02, 0x10, 0x02, 0x10, 0x04,
  0x10, 0x08, 0x10, 0x18, 0x10, 0x10, 0x10, 0x20, 0x10, 0x40, 0x10, 0x40,
  0x10, 0xFF, 0xFF, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x10, 0x3F, 0xF9, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x08, 0x00, 0x4F, 0xC2, 0x81, 0x98, 0x04, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x0A, 0x00, 0x70, 0x04, 0x60, 0xC0, 0xFC, 0x00,
  0x00, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x40, 0x02, 0x00,
  0x08, 0x00, 0x47, 0xC1, 0x61, 0xC6, 0x01, 0x10, 0x02, 0xC0, 0x0B, 0x00,
  0x2C, 0x00, 0xD0, 0x02, 0x40, 0x09, 0x00, 0x22, 0x01, 0x06, 0x18, 0x0F,
  0xC0, 0xFF, 0xFE, 0x00, 0x28, 0x00, 0xA0, 0x04, 0x80, 0x12, 0x00, 0xC0,
  0x02, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00,
  0x04, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00,
  0x08, 0x00, 0x0F, 0xC0, 0xC0, 0xC6, 0x01, 0x90, 0x02, 0x40, 0x09, 0x00,
  0x24, 0x00, 0x98, 0x06, 0x30, 0x30, 0x3F, 0x03, 0x87, 0x10, 0x06, 0x40,
  0x0A, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x05, 0x00, 0x26, 0x01, 0x8C,
  0x0C, 0x0F, 0xC0, 0x1F, 0x81, 0x82, 0x10, 0x09, 0x00, 0x28, 0x01, 0x40,
  0x0A, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x90, 0x0C, 0xE0, 0xA1, 0xF9,
  0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0xC0, 0x0C, 0x01,
  0x80, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x6C, 0x00, 0x00, 0x00, 0x06, 0xD2,
  0xD2, 0x40, 0x00, 0x10, 0x03, 0x00, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x60,
  0x08, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x00, 0x10, 0x06, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00, 0xC0, 0x08,
  0x00, 0x1F, 0x83, 0x04, 0x40, 0x28, 0x01, 0x80, 0x10, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x20, 0x06, 0x01, 0xC0, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x1F, 0x83, 0x0C,
  0x60, 0x24, 0x02, 0x80, 0x18, 0x01, 0x83, 0xD8, 0x43, 0x88, 0x18, 0x81,
  0x88, 0x18, 0x81, 0x88, 0x18, 0x81, 0x88, 0x18, 0x81, 0x8C, 0x38, 0x7D,
  0x80, 0x08, 0x00, 0x40, 0x06, 0x00, 0x30, 0x00, 0xFE, 0x01, 0x80, 0x01,
  0x80, 0x03, 0xC0, 0x02, 0x40, 0x02, 0x40, 0x06, 0x60, 0x04, 0x20, 0x04,
  0x20, 0x0C, 0x30, 0x08, 0x10, 0x08, 0x10, 0x18, 0x18, 0x10, 0x08, 0x1F,
  0xF8, 0x10, 0x08, 0x20, 0x04, 0x20, 0x04, 0x20, 0x04, 0x40, 0x02, 0x40,
  0x02, 0xC0, 0x03, 0xFF, 0x84, 0x03, 0x20, 0x09, 0x00, 0x68, 0x01, 0x40,
  0x0A, 0x00, 0x50, 0x06, 0x80, 0x24, 0x02, 0x3F, 0xE1, 0x00, 0xC8, 0x01,
  0x40, 0x0A, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xA0, 0x05, 0x00, 0xCF,
  0xFC, 0x00, 0x07, 0xC0, 0x60, 0xC3, 0x01, 0x88, 0x02, 0x40, 0x0D, 0x00,
  0x04, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x08, 0x80, 0x33, 0x01, 0x86,
  0x0C, 0x07, 0xC0, 0xFF, 0x84, 0x06, 0x20, 0x09, 0x00, 0x68, 0x01, 0x40,
  0x0A, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x02, 0x80, 0x14, 0x01, 0xA0, 0x09, 0x01, 0x8F,
  0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0xFF, 0xF8, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0xFF, 0xF0, 0xFF, 0xFC,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x3F, 0xFD, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x00, 0x07, 0xC0, 0xC1,
  0x08, 0x04, 0xC0, 0x14, 0x00, 0xA0, 0x03, 0x00, 0x18, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x03, 0xF8, 0x00, 0xC0, 0x07, 0x00, 0x28, 0x01, 0x40,
  0x0B, 0x00, 0x48, 0x06, 0x30, 0x50, 0x7C, 0x80, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0xFF,
  0xF8, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x10, 0xFF, 0xF0, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0xFF, 0xF0,
  0x3F, 0xE0, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x30,
  0x0F, 0x01, 0x30, 0x41, 0xF0, 0x80, 0x0E, 0x00, 0x48, 0x02, 0x20, 0x10,
  0x80, 0xC2, 0x06, 0x08, 0x30, 0x20, 0x80, 0x84, 0x02, 0x30, 0x09, 0x60,
  0x28, 0x80, 0xC1, 0x03, 0x06, 0x08, 0x08, 0x20, 0x10, 0x80, 0x62, 0x00,
  0x88, 0x01, 0x20, 0x06, 0x80, 0x0C, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0xFF, 0xF0, 0xC0, 0x0F, 0x80, 0x7A, 0x01, 0x68, 0x05, 0x90, 0x26, 0x40,
  0x98, 0x84, 0x62, 0x11, 0x84, 0xC6, 0x12, 0x18, 0x48, 0x60, 0xC1, 0x83,
  0x06, 0x08, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x04, 0xC0, 0x1C, 0x01, 0xE0, 0x1A, 0x01, 0xB0, 0x19, 0x01,
  0x98, 0x18, 0x81, 0x8C, 0x18, 0x41, 0x86, 0x18, 0x21, 0x83, 0x18, 0x11,
  0x81, 0x98, 0x09, 0x80, 0xD8, 0x05, 0x80, 0x78, 0x03, 0x80, 0x30, 0x0F,
  0xC0, 0x61, 0x82, 0x01, 0x10, 0x02, 0x40, 0x09, 0x00, 0x28, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0xD0, 0x02, 0x40, 0x09, 0x00, 0x22, 0x01, 0x06, 0x18, 0x0F, 0xC0,
  0xFF, 0xC4, 0x01, 0x20, 0x05, 0x00, 0x38, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x1C, 0x00, 0xA0, 0x09, 0xFF, 0x88, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x00, 0x0F,
  0xC0, 0x61, 0x82, 0x01, 0x10, 0x02, 0x40, 0x09, 0x00, 0x28, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0xD0, 0x02, 0x40, 0x09, 0x00, 0x22, 0x01, 0x06, 0x18, 0x0F, 0xC0,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x01, 0xF0, 0xFF, 0xC4, 0x01, 0x20, 0x05,
  0x00, 0x38, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xA0,
  0x09, 0xFF, 0x88, 0x20, 0x40, 0x82, 0x06, 0x10, 0x10, 0x80, 0x44, 0x03,
  0x20, 0x09, 0x00, 0x28, 0x01, 0x80, 0x0F, 0xC0, 0xC0, 0xC4, 0x00, 0x90,
  0x03, 0xC0, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0x70, 0x00,
  0x7E, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x00, 0x06,
  0x00, 0x34, 0x00, 0x8C, 0x0C, 0x0F, 0xC0, 0xFF, 0xFF, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x40, 0x26, 0x06, 0x1F, 0x80, 0xC0, 0x03, 0x40,
  0x02, 0x40, 0x02, 0x20, 0x04, 0x20, 0x04, 0x20, 0x04, 0x10, 0x08, 0x10,
  0x08, 0x10, 0x08, 0x08, 0x10, 0x08, 0x10, 0x08, 0x10, 0x04, 0x30, 0x04,
  0x20, 0x04, 0x20, 0x06, 0x60, 0x02, 0x40, 0x02, 0x40, 0x03, 0xC0, 0x01,
  0x80, 0x01, 0x80, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x12, 0x14, 0x48, 0x91, 0x22,
  0x44, 0x89, 0x21, 0x24, 0x84, 0x92, 0x12, 0x50, 0x29, 0x40, 0xA5, 0x02,
  0x94, 0x0A, 0x60, 0x18, 0x40, 0x02, 0x20, 0x04, 0x30, 0x04, 0x10, 0x08,
  0x08, 0x10, 0x08, 0x10, 0x04, 0x20, 0x06, 0x60, 0x02, 0x40, 0x01, 0x80,
  0x01, 0x80, 0x01, 0xC0, 0x02, 0x40, 0x04, 0x20, 0x04, 0x20, 0x08, 0x10,
  0x18, 0x18, 0x10, 0x08, 0x20, 0x04, 0x60, 0x06, 0xC0, 0x03, 0x80, 0x01,
  0x40, 0x02, 0x60, 0x06, 0x20, 0x04, 0x10, 0x08, 0x18, 0x08, 0x08, 0x10,
  0x0C, 0x30, 0x04, 0x20, 0x02, 0x40, 0x03, 0xC0, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x7F, 0xFE, 0x00, 0x06, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x18, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80,
  0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0xFF, 0xFF, 0xFF, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x03, 0xF8, 0x80, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x01, 0x00, 0x10, 0x00,
  0x80, 0x08, 0x00, 0x40, 0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00,
  0x10, 0x00, 0x80, 0x08, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x10, 0xFE, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x07, 0xF8, 0x03, 0x00, 0x0C, 0x00, 0x48, 0x02, 0x10, 0x08, 0x40,
  0x40, 0x81, 0x02, 0x08, 0x04, 0x60, 0x19, 0x00, 0x28, 0x00, 0x60, 0x02,
  0xFF, 0xFC, 0x84, 0x22, 0x10, 0x1F, 0x80, 0xC1, 0x04, 0x02, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x07, 0xFC, 0x60, 0x13, 0x00, 0x48, 0x01,
  0x20, 0x0C, 0xC0, 0x51, 0x82, 0x41, 0xF1, 0xC0, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x09, 0xF0, 0xA0, 0xCC, 0x06, 0x80,
  0x28, 0x02, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x02, 0x80,
  0x28, 0x06, 0xE0, 0xC9, 0xF0, 0x0F, 0x83, 0x06, 0x60, 0x24, 0x01, 0xC0,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x01, 0x60,
  0x33, 0x06, 0x0F, 0x80, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x10, 0xF9, 0x30, 0x56, 0x03, 0x40, 0x14, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x14, 0x01, 0x40, 0x16, 0x01, 0x30, 0x70,
  0xF9, 0x1F, 0x83, 0x0C, 0x40, 0x2C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x1F,
  0xFF, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x40, 0x13, 0x06, 0x1F, 0x80,
  0x01, 0xFC, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x3F, 0xFF, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x01, 0xFF, 0xE0, 0x00, 0x7C, 0x3F, 0x03, 0x0C, 0x18, 0x08, 0x40, 0x21,
  0x00, 0x84, 0x02, 0x10, 0x08, 0x60, 0x20, 0xC3, 0x01, 0xF8, 0x18, 0x00,
  0x40, 0x01, 0x00, 0x03, 0xFE, 0x10, 0x06, 0x80, 0x0A, 0x00, 0x28, 0x00,
  0xA0, 0x02, 0xC0, 0x30, 0xFF, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0xF8, 0xA0, 0x98, 0x0A, 0x01, 0x40, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x40, 0x03, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x7F,
  0xFC, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x07, 0xFF,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x06, 0x80, 0x44, 0x04, 0x20, 0x41, 0x0C, 0x08, 0xC0, 0x4E, 0x02, 0x98,
  0x18, 0x40, 0x81, 0x04, 0x04, 0x20, 0x11, 0x00, 0x48, 0x03, 0x40, 0x0C,
  0xFE, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x0F, 0xFF, 0x9C, 0x7B, 0x8A,
  0x28, 0x30, 0x60, 0xC1, 0x81, 0x06, 0x04, 0x18, 0x10, 0x60, 0x41, 0x81,
  0x06, 0x04, 0x18, 0x10, 0x60, 0x41, 0x81, 0x06, 0x04, 0x18, 0x10, 0x40,
  0x9F, 0x14, 0x13, 0x01, 0x40, 0x28, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x08, 0x1F, 0x83, 0x0C,
  0x40, 0x28, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x40, 0x23, 0x0C, 0x1F, 0x80, 0x9F, 0x0A, 0x0C, 0xC0,
  0x68, 0x02, 0x80, 0x28, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x28, 0x02, 0x80, 0x6E, 0x0C, 0x9F, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x00, 0x0F, 0x93, 0x05, 0x60, 0x34, 0x01, 0x40, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x40, 0x14, 0x01, 0x60, 0x13,
  0x07, 0x0F, 0x90, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10,
  0xFE, 0x7E, 0x05, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x3F, 0xFE, 0x00, 0x1F, 0x83, 0x03, 0x10, 0x05, 0x00, 0x08,
  0x00, 0x20, 0x01, 0xC0, 0x01, 0xF8, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00,
  0x28, 0x01, 0x30, 0x30, 0x7F, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x3F, 0xFF, 0x81, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x3F, 0xE0, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xA0, 0x14, 0x02, 0x41, 0xC7, 0xC8, 0x80, 0x18, 0x01, 0x40, 0x24,
  0x02, 0x40, 0x22, 0x04, 0x20, 0x43, 0x04, 0x10, 0x81, 0x08, 0x09, 0x00,
  0x90, 0x09, 0x00, 0x60, 0x06, 0x00, 0x81, 0x81, 0x81, 0x81, 0x41, 0x82,
  0x42, 0x42, 0x42, 0x42, 0x42, 0x42, 0x42, 0x42, 0x44, 0x22, 0x24, 0x24,
  0x24, 0x24, 0x24, 0x24, 0x28, 0x14, 0x28, 0x14, 0x18, 0x18, 0x18, 0x18,
  0x40, 0x08, 0x80, 0x41, 0x02, 0x06, 0x18, 0x08, 0x40, 0x12, 0x00, 0x30,
  0x00, 0xC0, 0x07, 0x80, 0x12, 0x00, 0x84, 0x04, 0x08, 0x30, 0x30, 0x80,
  0x4C, 0x00, 0xC0, 0xC0, 0x0D, 0x00, 0x24, 0x00, 0x88, 0x04, 0x20, 0x10,
  0x40, 0x81, 0x02, 0x06, 0x18, 0x08, 0x40, 0x21, 0x00, 0x48, 0x01, 0x20,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x40,
  0x02, 0x00, 0x78, 0x00, 0xFF, 0xF0, 0x02, 0x00, 0x60, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x0C,
  0x00, 0xFF, 0xF0, 0x07, 0xF0, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x02, 0x0F, 0xC0,
  0x06, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x20, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFE, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x04, 0x00, 0x3F, 0x06, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0xFE, 0x00, 0x38, 0x05, 0x10, 0x14, 0x20, 0x60, 0x42,
  0x80, 0x8A, 0x01, 0xC0,
};

const GFXglyph IBMPlexMono_ExtraLight30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 2, 21, 18, 8, -21 },
  { 7, 6, 8, 18, 6, -22 },
  { 13, 16, 21, 18, 1, -21 },
  { 55, 14, 27, 18, 2, -24 },
  { 103, 16, 21, 18, 1, -21 },
  { 145, 15, 21, 18, 1, -21 },
  { 185, 2, 8, 18, 8, -22 },
  { 187, 7, 27, 18, 7, -23 },
  { 211, 7, 27, 18, 4, -23 },
  { 235, 16, 15, 18, 1, -16 },
  { 265, 14, 15, 18, 2, -17 },
  { 292, 3, 8, 18, 7, -3 },
  { 295, 8, 1, 18, 5, -10 },
  { 296, 2, 2, 18, 8, -2 },
  { 297, 12, 27, 18, 3, -23 },
  { 338, 14, 21, 18, 2, -21 },
  { 375, 15, 21, 18, 2, -21 },
  { 415, 14, 21, 18, 2, -21 },
  { 452, 13, 21, 18, 2, -21 },
  { 487, 16, 21, 18, 1, -21 },
  { 529, 13, 21, 18, 2, -21 },
  { 564, 14, 21, 18, 2, -21 },
  { 601, 14, 21, 18, 2, -21 },
  { 638, 14, 21, 18, 2, -21 },
  { 675, 13, 21, 18, 3, -21 },
  { 710, 2, 15, 18, 8, -15 },
  { 714, 3, 20, 18, 7, -15 },
  { 722, 12, 16, 18, 3, -17 },
  { 746, 14, 6, 18, 2, -12 },
  { 757, 12, 16, 18, 3, -17 },
  { 781, 12, 21, 18, 3, -21 },
  { 813, 12, 24, 18, 3, -21 },
  { 849, 16, 21, 18, 1, -21 },
  { 891, 13, 21, 18, 3, -21 },
  { 926, 14, 21, 18, 2, -21 },
  { 963, 13, 21, 18, 3, -21 },
  { 998, 12, 21, 18, 3, -21 },
  { 1030, 13, 21, 18, 3, -21 },
  { 1065, 13, 21, 18, 2, -21 },
  { 1100, 12, 21, 18, 3, -21 },
  { 1132, 12, 21, 18, 3, -21 },
  { 1164, 11, 21, 18, 3, -21 },
  { 1193, 14, 21, 18, 3, -21 },
  { 1230, 12, 21, 18, 4, -21 },
  { 1262, 14, 21, 18, 2, -21 },
  { 1299, 12, 21, 18, 3, -21 },
  { 1331, 14, 21, 18, 2, -21 },
  { 1368, 13, 21, 18, 3, -21 },
  { 1403, 14, 25, 18, 2, -21 },
  { 1447, 13, 21, 18, 3, -21 },
  { 1482, 14, 21, 18, 2, -21 },
  { 1519, 16, 21, 18, 1, -21 },
  { 1561, 12, 21, 18, 3, -21 },
  { 1593, 16, 21, 18, 1, -21 },
  { 1635, 14, 21, 18, 2, -21 },
  { 1672, 16, 21, 18, 1, -21 },
  { 1714, 16, 21, 18, 1, -21 },
  { 1756, 16, 21, 18, 1, -21 },
  { 1798, 7, 27, 18, 8, -23 },
  { 1822, 12, 27, 18, 3, -23 },
  { 1863, 7, 27, 18, 3, -23 },
  { 1887, 14, 12, 18, 2, -21 },
  { 1908, 14, 1, 18, 2, 3 },
  { 1910, 4, 5, 18, 6, -23 },
  { 1913, 14, 15, 18, 2, -15 },
  { 1940, 12, 22, 18, 4, -22 },
  { 1973, 12, 15, 18, 3, -15 },
  { 1996, 12, 22, 18, 2, -22 },
  { 2029, 12, 15, 18, 3, -15 },
  { 2052, 14, 22, 18, 2, -22 },
  { 2091, 14, 22, 18, 3, -16 },
  { 2130, 11, 22, 18, 4, -22 },
  { 2161, 13, 22, 18, 3, -22 },
  { 2197, 10, 28, 18, 3, -22 },
  { 2232, 13, 22, 18, 4, -22 },
  { 2268, 12, 22, 18, 3, -22 },
  { 2301, 14, 15, 18, 2, -15 },
  { 2328, 11, 15, 18, 4, -15 },
  { 2349, 12, 15, 18, 3, -15 },
  { 2372, 12, 21, 18, 4, -15 },
  { 2404, 12, 21, 18, 2, -15 },
  { 2436, 15, 15, 18, 2, -15 },
  { 2465, 13, 15, 18, 3, -15 },
  { 2490, 15, 21, 18, 1, -21 },
  { 2530, 11, 15, 18, 3, -15 },
  { 2551, 12, 15, 18, 3, -15 },
  { 2574, 16, 15, 18, 1, -15 },
  { 2604, 14, 15, 18, 2, -15 },
  { 2631, 14, 21, 18, 2, -15 },
  { 2668, 12, 15, 18, 3, -15 },
  { 2691, 12, 27, 18, 3, -23 },
  { 2732, 1, 27, 18, 9, -23 },
  { 2736, 12, 27, 18, 3, -23 },
  { 2777, 14, 6, 18, 2, -12 },
};

const GFXfont IBMPlexMono_ExtraLight30pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLight30pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLight30pt7bGlyphs,
  0x20, 0x7E, 39
};

#endif // _IBMPLEXMONO_EXTRALIGHT30PT7B_H_
