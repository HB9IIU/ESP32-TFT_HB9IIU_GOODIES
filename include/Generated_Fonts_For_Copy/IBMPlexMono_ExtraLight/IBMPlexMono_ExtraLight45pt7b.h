#ifndef _IBMPLEXMONO_EXTRALIGHT45PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHT45PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLight.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLight45pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x80, 0x00, 0x7F,
  0xF8, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83,
  0x83, 0x00, 0x30, 0x30, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x04,
  0x04, 0x00, 0x02, 0x02, 0x00, 0x01, 0x01, 0x00, 0x01, 0x81, 0x80, 0x00,
  0xC0, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x20, 0x20, 0x00, 0x10, 0x10, 0x07,
  0xF8, 0x1F, 0xF0, 0x0C, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x02, 0x02, 0x00,
  0x01, 0x01, 0x00, 0x00, 0x80, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0x60,
  0x1F, 0xF0, 0x3F, 0xE0, 0x10, 0x10, 0x00, 0x08, 0x08, 0x00, 0x0C, 0x04,
  0x00, 0x06, 0x06, 0x00, 0x03, 0x03, 0x00, 0x01, 0x81, 0x00, 0x00, 0x80,
  0x80, 0x00, 0x40, 0x40, 0x00, 0x60, 0x60, 0x00, 0x30, 0x30, 0x00, 0x18,
  0x18, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0xFF, 0x00, 0x38, 0x8F, 0x03, 0x04, 0x0C, 0x30,
  0x20, 0x33, 0x01, 0x00, 0xD8, 0x08, 0x00, 0x80, 0x40, 0x04, 0x02, 0x00,
  0x20, 0x10, 0x01, 0x00, 0x80, 0x0C, 0x04, 0x00, 0x60, 0x20, 0x01, 0x81,
  0x00, 0x0E, 0x08, 0x00, 0x18, 0x40, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x86, 0x00, 0x04, 0x0C, 0x00, 0x20, 0x30, 0x01, 0x01, 0x80, 0x08,
  0x06, 0x00, 0x40, 0x30, 0x02, 0x01, 0x80, 0x10, 0x0C, 0x00, 0x80, 0x60,
  0x04, 0x03, 0x80, 0x20, 0x1E, 0x01, 0x01, 0x98, 0x08, 0x0C, 0x60, 0x40,
  0xC1, 0xE2, 0x38, 0x01, 0xFF, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x0F, 0x80, 0x00, 0x0C, 0x30,
  0x00, 0xC8, 0x0C, 0x00, 0xCC, 0x02, 0x00, 0x44, 0x01, 0x80, 0x62, 0x00,
  0xC0, 0x23, 0x00, 0x20, 0x31, 0x80, 0x10, 0x10, 0xC0, 0x08, 0x10, 0x20,
  0x0C, 0x18, 0x10, 0x06, 0x08, 0x0C, 0x02, 0x0C, 0x02, 0x03, 0x04, 0x00,
  0xC3, 0x06, 0x00, 0x3E, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x20, 0x3E, 0x00, 0x30, 0x61, 0x80, 0x10, 0x60,
  0x20, 0x18, 0x20, 0x18, 0x08, 0x30, 0x04, 0x0C, 0x10, 0x02, 0x04, 0x08,
  0x01, 0x84, 0x04, 0x00, 0xC6, 0x02, 0x00, 0x62, 0x01, 0x00, 0x23, 0x00,
  0xC0, 0x11, 0x00, 0x20, 0x19, 0x80, 0x18, 0x09, 0x80, 0x06, 0x18, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x0C, 0x1C, 0x00, 0x30, 0x0C, 0x00,
  0x40, 0x0C, 0x01, 0x80, 0x10, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x19, 0x80, 0x3E, 0x61, 0x80, 0x41, 0x81, 0x81, 0x82, 0x01, 0x83,
  0x0C, 0x01, 0x06, 0x18, 0x01, 0x0C, 0x30, 0x03, 0x18, 0x40, 0x03, 0x20,
  0x80, 0x03, 0x41, 0x00, 0x03, 0x82, 0x00, 0x03, 0x06, 0x00, 0x0F, 0x04,
  0x00, 0x13, 0x0C, 0x00, 0x42, 0x0C, 0x01, 0x06, 0x0E, 0x0C, 0x06, 0x07,
  0xE0, 0x02, 0xFF, 0xF0, 0x00, 0x60, 0x18, 0x04, 0x01, 0x80, 0x60, 0x18,
  0x02, 0x00, 0xC0, 0x10, 0x06, 0x00, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x10,
  0x02, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x80, 0x30, 0x02, 0x00, 0x40, 0x0C, 0x00, 0x80,
  0x18, 0x01, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x20, 0x03, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x00,
  0x30, 0x02, 0x00, 0x40, 0x0C, 0x01, 0x80, 0x10, 0x02, 0x00, 0x40, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x40, 0x08, 0x03,
  0x00, 0x60, 0x08, 0x01, 0x00, 0x60, 0x08, 0x03, 0x00, 0x40, 0x10, 0x06,
  0x01, 0x80, 0x20, 0x18, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x08, 0x00, 0xE0, 0x10, 0x0E, 0xF8, 0x20, 0xF8, 0x1E,
  0x4F, 0x00, 0x07, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0D, 0x80, 0x00, 0x11,
  0x00, 0x00, 0x63, 0x00, 0x01, 0x83, 0x00, 0x06, 0x03, 0x00, 0x0C, 0x06,
  0x00, 0x30, 0x06, 0x00, 0xC0, 0x06, 0x01, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x39, 0xCC, 0x67, 0x31, 0x8C, 0x46,
  0x30, 0xFF, 0xF8, 0xFF, 0xF0, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x30, 0x38, 0x03,
  0x00, 0x60, 0x30, 0x01, 0x83, 0x00, 0x06, 0x10, 0x00, 0x11, 0x80, 0x00,
  0xCC, 0x00, 0x06, 0x40, 0x00, 0x12, 0x00, 0x00, 0xB0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x0E, 0x03,
  0xC0, 0x70, 0x1E, 0x03, 0x80, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x68, 0x00, 0x02, 0x40, 0x00, 0x13,
  0x00, 0x01, 0x98, 0x00, 0x0C, 0x40, 0x00, 0x43, 0x00, 0x06, 0x0C, 0x00,
  0x60, 0x30, 0x06, 0x00, 0xE0, 0xE0, 0x01, 0xFC, 0x00, 0x00, 0xF0, 0x00,
  0x0D, 0x80, 0x00, 0xCC, 0x00, 0x0C, 0x60, 0x00, 0xC3, 0x00, 0x1C, 0x18,
  0x01, 0x80, 0xC0, 0x18, 0x06, 0x00, 0x80, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xF8, 0x01, 0xC0, 0xE0,
  0x30, 0x03, 0x06, 0x00, 0x18, 0xC0, 0x00, 0x8C, 0x00, 0x0C, 0x80, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x0F, 0xFF, 0xFF, 0x03, 0xF8, 0x01, 0xC0, 0xC0, 0x60, 0x06, 0x18, 0x00,
  0x46, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x3F, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x3C, 0x00, 0x04,
  0xC0, 0x01, 0x8C, 0x00, 0x60, 0xE0, 0x30, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0B, 0x00, 0x00, 0x36, 0x00, 0x00, 0xCC,
  0x00, 0x01, 0x18, 0x00, 0x06, 0x30, 0x00, 0x18, 0x60, 0x00, 0x20, 0xC0,
  0x00, 0xC1, 0x80, 0x03, 0x03, 0x00, 0x04, 0x06, 0x00, 0x18, 0x0C, 0x00,
  0x60, 0x18, 0x00, 0x80, 0x30, 0x03, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x30,
  0x01, 0x80, 0x60, 0x03, 0x01, 0x80, 0x06, 0x06, 0x00, 0x0C, 0x0C, 0x00,
  0x18, 0x30, 0x00, 0x30, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x3F, 0xFF, 0xC4, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC7,
  0xF0, 0x1B, 0x01, 0x82, 0x80, 0x0C, 0x60, 0x00, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x60, 0x00, 0x6C, 0x00,
  0x18, 0xE0, 0x06, 0x07, 0x01, 0x80, 0x3F, 0xC0, 0x00, 0x1C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00,
  0x06, 0x1F, 0x80, 0x8C, 0x1C, 0x16, 0x00, 0xE7, 0x00, 0x0C, 0xE0, 0x00,
  0xD8, 0x00, 0x0B, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0D, 0x00, 0x01,
  0x30, 0x00, 0x62, 0x00, 0x18, 0x30, 0x06, 0x03, 0x03, 0x80, 0x1F, 0xC0,
  0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x06, 0xC0, 0x00,
  0x6C, 0x00, 0x04, 0xC0, 0x00, 0xCC, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x70, 0x18, 0x06,
  0x00, 0x30, 0x60, 0x00, 0xC2, 0x00, 0x06, 0x30, 0x00, 0x19, 0x80, 0x00,
  0xCC, 0x00, 0x06, 0x60, 0x00, 0x33, 0x00, 0x01, 0x98, 0x00, 0x0C, 0x60,
  0x00, 0xC3, 0x00, 0x06, 0x0C, 0x00, 0x60, 0x18, 0x0C, 0x00, 0x3F, 0x80,
  0x0E, 0x03, 0x80, 0xC0, 0x06, 0x0C, 0x00, 0x18, 0xC0, 0x00, 0x64, 0x00,
  0x01, 0x60, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x06, 0x80, 0x00, 0x26, 0x00, 0x03, 0x18, 0x00,
  0x30, 0x60, 0x03, 0x01, 0xC0, 0x70, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x01,
  0xC0, 0xC0, 0x60, 0x04, 0x18, 0x00, 0x46, 0x00, 0x0C, 0x80, 0x00, 0xB0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xD0, 0x00, 0x1B, 0x00, 0x05, 0x30,
  0x00, 0xE3, 0x00, 0x2C, 0x38, 0x19, 0x01, 0xFC, 0x60, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x38,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x39, 0xCE,
  0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x9C,
  0xC6, 0x73, 0x18, 0xC4, 0x63, 0x00, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x06, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x18, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xF8, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00,
  0x03, 0xF8, 0x01, 0xC0, 0xC0, 0xE0, 0x04, 0x18, 0x00, 0x46, 0x00, 0x0C,
  0x80, 0x00, 0xB0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x08,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x07, 0xE0, 0x00, 0xE0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0E, 0x00, 0x03, 0xF8, 0x01, 0xC0, 0xC0, 0x60, 0x0C, 0x08,
  0x00, 0xC3, 0x00, 0x08, 0x40, 0x01, 0x98, 0x00, 0x12, 0x00, 0x02, 0x40,
  0x00, 0x48, 0x07, 0xCB, 0x03, 0x05, 0x60, 0xC0, 0x7C, 0x10, 0x07, 0x82,
  0x00, 0xE0, 0xC0, 0x1C, 0x18, 0x03, 0x83, 0x00, 0x70, 0x40, 0x0E, 0x08,
  0x01, 0xC1, 0x00, 0x38, 0x20, 0x07, 0x06, 0x00, 0xE0, 0xC0, 0x1C, 0x18,
  0x03, 0xC1, 0x00, 0x78, 0x30, 0x1F, 0x03, 0x05, 0xE0, 0x3F, 0x34, 0x00,
  0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xA0, 0x00, 0x03, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x08,
  0x80, 0x00, 0x31, 0x80, 0x00, 0x63, 0x00, 0x00, 0x82, 0x00, 0x03, 0x06,
  0x00, 0x06, 0x0C, 0x00, 0x08, 0x08, 0x00, 0x30, 0x18, 0x00, 0x60, 0x30,
  0x00, 0x80, 0x20, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x08, 0x00, 0x80,
  0x30, 0x01, 0x80, 0x60, 0x03, 0x00, 0xFF, 0xFE, 0x03, 0x00, 0x06, 0x06,
  0x00, 0x0C, 0x08, 0x00, 0x08, 0x30, 0x00, 0x18, 0x60, 0x00, 0x30, 0x80,
  0x00, 0x23, 0x00, 0x00, 0x66, 0x00, 0x00, 0xC8, 0x00, 0x00, 0xB0, 0x00,
  0x01, 0x80, 0xFF, 0xFC, 0x18, 0x00, 0xC3, 0x00, 0x04, 0x60, 0x00, 0xCC,
  0x00, 0x0D, 0x80, 0x01, 0xB0, 0x00, 0x36, 0x00, 0x06, 0xC0, 0x00, 0xD8,
  0x00, 0x1B, 0x00, 0x03, 0x60, 0x00, 0x6C, 0x00, 0x19, 0x80, 0x02, 0x30,
  0x01, 0x87, 0xFF, 0xE0, 0xC0, 0x03, 0x18, 0x00, 0x1B, 0x00, 0x01, 0x60,
  0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x2C, 0x00, 0x0D, 0x80,
  0x07, 0x3F, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x18, 0x1C, 0x01, 0x00, 0x30,
  0x10, 0x00, 0xC1, 0x80, 0x03, 0x18, 0x00, 0x08, 0xC0, 0x00, 0xA4, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00,
  0x0C, 0x00, 0x08, 0x60, 0x00, 0x31, 0x80, 0x03, 0x04, 0x00, 0x30, 0x18,
  0x03, 0x00, 0x60, 0x30, 0x00, 0xFE, 0x00, 0xFF, 0xF0, 0x10, 0x03, 0x82,
  0x00, 0x18, 0x40, 0x01, 0x88, 0x00, 0x19, 0x00, 0x01, 0x20, 0x00, 0x34,
  0x00, 0x06, 0x80, 0x00, 0x50, 0x00, 0x0A, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xA0,
  0x00, 0x14, 0x00, 0x06, 0x80, 0x00, 0xD0, 0x00, 0x12, 0x00, 0x06, 0x40,
  0x01, 0x88, 0x00, 0x61, 0x00, 0x38, 0x3F, 0xFC, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x0F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE0, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x03, 0xFF, 0xFE, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x70, 0x38, 0x0C, 0x00,
  0xC1, 0x80, 0x06, 0x10, 0x00, 0x63, 0x00, 0x03, 0x20, 0x00, 0x26, 0x00,
  0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x1F, 0xFC, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0x40, 0x00, 0x14, 0x00, 0x01, 0x60, 0x00, 0x16, 0x00, 0x03, 0x20, 0x00,
  0x33, 0x00, 0x03, 0x10, 0x00, 0x51, 0x80, 0x05, 0x0C, 0x00, 0x90, 0x70,
  0x31, 0x01, 0xFC, 0x00, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x18, 0xFF, 0xFF, 0xE0, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xF0, 0x00, 0x58, 0x00, 0x66, 0x00, 0x31, 0x80, 0x30,
  0x60, 0x70, 0x0F, 0xE0, 0x80, 0x00, 0x78, 0x00, 0x0C, 0x80, 0x00, 0xC8,
  0x00, 0x18, 0x80, 0x03, 0x08, 0x00, 0x60, 0x80, 0x0C, 0x08, 0x01, 0x80,
  0x80, 0x30, 0x08, 0x06, 0x00, 0x80, 0xC0, 0x08, 0x0C, 0x00, 0x81, 0x80,
  0x08, 0x30, 0x00, 0x87, 0x80, 0x08, 0xCC, 0x00, 0x98, 0xC0, 0x0B, 0x06,
  0x00, 0xE0, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x18, 0x08, 0x00, 0xC0, 0x80,
  0x0C, 0x08, 0x00, 0x60, 0x80, 0x03, 0x08, 0x00, 0x30, 0x80, 0x01, 0x88,
  0x00, 0x0C, 0x80, 0x00, 0xC8, 0x00, 0x06, 0x80, 0x00, 0x30, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0F, 0xFF, 0xFC, 0xC0, 0x00, 0x7C, 0x00,
  0x1F, 0x80, 0x02, 0xD0, 0x00, 0x5B, 0x00, 0x1B, 0x20, 0x02, 0x66, 0x00,
  0xCC, 0x40, 0x11, 0x8C, 0x06, 0x30, 0x80, 0x86, 0x18, 0x30, 0xC3, 0x04,
  0x18, 0x30, 0x83, 0x06, 0x30, 0x60, 0x44, 0x0C, 0x0D, 0x81, 0x80, 0xA0,
  0x30, 0x1C, 0x06, 0x01, 0x00, 0xC0, 0x20, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xE8, 0x00, 0x3D, 0x80, 0x07, 0x90, 0x00,
  0xF3, 0x00, 0x1E, 0x20, 0x03, 0xC6, 0x00, 0x78, 0x40, 0x0F, 0x0C, 0x01,
  0xE0, 0x80, 0x3C, 0x18, 0x07, 0x81, 0x00, 0xF0, 0x30, 0x1E, 0x02, 0x03,
  0xC0, 0x60, 0x78, 0x04, 0x0F, 0x00, 0xC1, 0xE0, 0x08, 0x3C, 0x01, 0x87,
  0x80, 0x10, 0xF0, 0x03, 0x1E, 0x00, 0x23, 0xC0, 0x06, 0x78, 0x00, 0x4F,
  0x00, 0x0D, 0xE0, 0x00, 0xBC, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x38,
  0x01, 0xFC, 0x00, 0x30, 0x38, 0x03, 0x00, 0x60, 0x30, 0x01, 0x83, 0x00,
  0x06, 0x10, 0x00, 0x11, 0x80, 0x00, 0xCC, 0x00, 0x06, 0x40, 0x00, 0x12,
  0x00, 0x00, 0xB0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x68, 0x00, 0x02, 0x40, 0x00, 0x13, 0x00, 0x01, 0x98, 0x00, 0x0C, 0x40,
  0x00, 0x43, 0x00, 0x06, 0x0C, 0x00, 0x60, 0x30, 0x06, 0x00, 0xE0, 0xE0,
  0x01, 0xFC, 0x00, 0xFF, 0xFC, 0x10, 0x00, 0xE2, 0x00, 0x06, 0x40, 0x00,
  0x68, 0x00, 0x05, 0x00, 0x00, 0xA0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x28, 0x00, 0x0D, 0x00, 0x01,
  0xA0, 0x00, 0x64, 0x00, 0x38, 0xFF, 0xFC, 0x10, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x30, 0x38, 0x03, 0x00,
  0x60, 0x30, 0x01, 0x83, 0x00, 0x06, 0x10, 0x00, 0x11, 0x80, 0x00, 0xCC,
  0x00, 0x06, 0x40, 0x00, 0x12, 0x00, 0x00, 0xB0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x68, 0x00, 0x02, 0x40, 0x00, 0x13, 0x00,
  0x01, 0x98, 0x00, 0x0C, 0x40, 0x00, 0x43, 0x00, 0x06, 0x0C, 0x00, 0x60,
  0x30, 0x06, 0x00, 0xE0, 0xE0, 0x01, 0xFC, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0xFF, 0x80,
  0xFF, 0xFC, 0x10, 0x00, 0xE2, 0x00, 0x06, 0x40, 0x00, 0x68, 0x00, 0x05,
  0x00, 0x00, 0xA0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x28, 0x00, 0x0D, 0x00, 0x01, 0xA0, 0x00, 0x64,
  0x00, 0x38, 0xFF, 0xFC, 0x10, 0x18, 0x02, 0x01, 0x80, 0x40, 0x10, 0x08,
  0x03, 0x01, 0x00, 0x30, 0x20, 0x06, 0x04, 0x00, 0x60, 0x80, 0x06, 0x10,
  0x00, 0xC2, 0x00, 0x0C, 0x40, 0x00, 0xC8, 0x00, 0x19, 0x00, 0x01, 0xA0,
  0x00, 0x18, 0x03, 0xFE, 0x00, 0x70, 0x1E, 0x06, 0x00, 0x18, 0x60, 0x00,
  0x66, 0x00, 0x01, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x2C, 0x00, 0x03, 0x30, 0x00, 0x30, 0xC0, 0x03, 0x03,
  0xC0, 0x70, 0x03, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x40, 0x00, 0x48, 0x00,
  0x09, 0x00, 0x03, 0x30, 0x00, 0x62, 0x00, 0x08, 0x60, 0x03, 0x07, 0x01,
  0xC0, 0x3F, 0xC0, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x09, 0x80, 0x00, 0x33,
  0x00, 0x00, 0x62, 0x00, 0x00, 0x86, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x08,
  0x00, 0x08, 0x18, 0x00, 0x30, 0x30, 0x00, 0x60, 0x20, 0x00, 0x80, 0x60,
  0x03, 0x00, 0xC0, 0x06, 0x00, 0x80, 0x08, 0x01, 0x80, 0x30, 0x03, 0x00,
  0x60, 0x02, 0x00, 0x80, 0x06, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x08, 0x08,
  0x00, 0x18, 0x30, 0x00, 0x30, 0x60, 0x00, 0x20, 0x80, 0x00, 0x63, 0x00,
  0x00, 0xC6, 0x00, 0x00, 0x88, 0x00, 0x01, 0xB0, 0x00, 0x03, 0x60, 0x00,
  0x02, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x80, 0x00, 0x09, 0x00, 0x00, 0x12, 0x00, 0x00, 0x24, 0x00, 0x00, 0x48,
  0x00, 0x00, 0x90, 0x00, 0x01, 0x30, 0x00, 0x06, 0x60, 0x00, 0x0C, 0xC0,
  0x70, 0x19, 0x80, 0xE0, 0x33, 0x01, 0x40, 0x62, 0x02, 0x80, 0x84, 0x0D,
  0x81, 0x08, 0x11, 0x02, 0x10, 0x22, 0x04, 0x20, 0xC6, 0x08, 0x61, 0x8C,
  0x10, 0xC2, 0x08, 0x61, 0x84, 0x10, 0xC3, 0x18, 0x31, 0x86, 0x30, 0x63,
  0x0C, 0x40, 0x46, 0x09, 0x80, 0xC8, 0x13, 0x01, 0x90, 0x24, 0x01, 0x20,
  0x48, 0x02, 0x40, 0xB0, 0x06, 0x81, 0xE0, 0x0D, 0x03, 0x80, 0x0E, 0x07,
  0x00, 0x1C, 0x00, 0xE0, 0x00, 0x0E, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x60,
  0xC0, 0x01, 0x81, 0x80, 0x03, 0x01, 0x80, 0x0C, 0x01, 0x80, 0x30, 0x03,
  0x00, 0x60, 0x03, 0x01, 0x80, 0x03, 0x02, 0x00, 0x06, 0x0C, 0x00, 0x06,
  0x30, 0x00, 0x06, 0x40, 0x00, 0x0D, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xD8, 0x00, 0x03, 0x18, 0x00, 0x04, 0x10,
  0x00, 0x18, 0x30, 0x00, 0x60, 0x30, 0x00, 0x80, 0x20, 0x03, 0x00, 0x60,
  0x0C, 0x00, 0x60, 0x10, 0x00, 0xC0, 0x60, 0x00, 0xC1, 0x80, 0x00, 0xC3,
  0x00, 0x01, 0x8C, 0x00, 0x01, 0xB0, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x01,
  0xB0, 0x00, 0x01, 0x8C, 0x00, 0x01, 0x86, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0xC0, 0x60, 0x00, 0xC0, 0x30, 0x00, 0x60, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x60, 0x01, 0x80, 0x30, 0x00, 0x60, 0x30, 0x00, 0x18, 0x10, 0x00, 0x0C,
  0x18, 0x00, 0x03, 0x18, 0x00, 0x00, 0x88, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xF0, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x07, 0xFF, 0x80,
  0x00, 0x60, 0x00, 0x10, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00,
  0xC0, 0x00, 0x20, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80,
  0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00,
  0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00,
  0x00, 0xC0, 0x00, 0x20, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01,
  0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x04, 0x00, 0x03, 0x00,
  0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01,
  0xFF, 0xE0, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x0F, 0xFF, 0x00, 0x70, 0x00, 0x02, 0x80,
  0x00, 0x36, 0x00, 0x01, 0x10, 0x00, 0x18, 0xC0, 0x01, 0x83, 0x00, 0x08,
  0x18, 0x00, 0xC0, 0x60, 0x04, 0x01, 0x00, 0x60, 0x0C, 0x06, 0x00, 0x30,
  0x30, 0x01, 0x83, 0x00, 0x06, 0x10, 0x00, 0x11, 0x80, 0x00, 0xD8, 0x00,
  0x03, 0xC0, 0x00, 0x18, 0xFF, 0xFF, 0xF8, 0x83, 0x06, 0x08, 0x30, 0x60,
  0x81, 0x03, 0xF8, 0x00, 0x70, 0x70, 0x06, 0x00, 0xC0, 0x60, 0x02, 0x02,
  0x00, 0x18, 0x30, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x7F, 0xF8, 0x0E,
  0x00, 0x40, 0xC0, 0x02, 0x0C, 0x00, 0x10, 0x40, 0x00, 0x86, 0x00, 0x04,
  0x30, 0x00, 0x21, 0x80, 0x01, 0x04, 0x00, 0x18, 0x30, 0x01, 0x40, 0x80,
  0x1A, 0x03, 0x03, 0x9F, 0x07, 0xF0, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x7E, 0x03, 0x30, 0x30, 0x68, 0x01, 0x8E,
  0x00, 0x11, 0xC0, 0x03, 0x30, 0x00, 0x26, 0x00, 0x06, 0xC0, 0x00, 0x58,
  0x00, 0x0B, 0x00, 0x01, 0x60, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x58, 0x00, 0x0B, 0x00, 0x01, 0x60,
  0x00, 0x6C, 0x00, 0x09, 0xC0, 0x03, 0x38, 0x00, 0x46, 0x80, 0x18, 0xCC,
  0x0C, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x03, 0x03, 0x81, 0x80, 0x30, 0xC0,
  0x06, 0x60, 0x00, 0x90, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x00,
  0x02, 0x60, 0x00, 0xCC, 0x00, 0x61, 0x80, 0x30, 0x30, 0x38, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x3F,
  0x0C, 0x18, 0x19, 0x8C, 0x00, 0xB1, 0x00, 0x0E, 0x60, 0x01, 0xD8, 0x00,
  0x1B, 0x00, 0x03, 0x40, 0x00, 0x68, 0x00, 0x0D, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x40, 0x00,
  0x68, 0x00, 0x0D, 0x00, 0x01, 0xB0, 0x00, 0x36, 0x00, 0x06, 0x60, 0x01,
  0xC4, 0x00, 0x38, 0xC0, 0x0B, 0x06, 0x06, 0x60, 0x7F, 0x00, 0x03, 0xF8,
  0x01, 0xC1, 0xC0, 0x60, 0x0C, 0x18, 0x00, 0xC2, 0x00, 0x08, 0xC0, 0x01,
  0x90, 0x00, 0x16, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00,
  0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x01, 0x00, 0x01, 0x30, 0x00, 0x32, 0x00, 0x0C,
  0x60, 0x01, 0x06, 0x00, 0x40, 0x70, 0x30, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0xF0, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0xFF,
  0xFF, 0xF0, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xF8,
  0x0F, 0xC8, 0x01, 0x83, 0xC0, 0x30, 0x06, 0x01, 0x00, 0x10, 0x18, 0x00,
  0x40, 0x80, 0x02, 0x04, 0x00, 0x18, 0x20, 0x00, 0xC1, 0x00, 0x06, 0x08,
  0x00, 0x30, 0x40, 0x01, 0x03, 0x00, 0x08, 0x08, 0x00, 0xC0, 0x60, 0x0C,
  0x00, 0xC0, 0xC0, 0x07, 0xF8, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0xFF, 0xF0,
  0x30, 0x00, 0xE3, 0x00, 0x01, 0xB0, 0x00, 0x05, 0x80, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x58, 0x00, 0x06, 0x60, 0x00, 0x61,
  0xC0, 0x0E, 0x01, 0xFF, 0x80, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x61, 0xF8, 0x33, 0x03, 0x1A, 0x00, 0xCE, 0x00, 0x36, 0x00, 0x0B, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1E, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x7F, 0xFE, 0x80,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x03, 0x40, 0x01, 0x88, 0x00, 0x61, 0x00, 0x18, 0x20, 0x06, 0x04, 0x01,
  0x80, 0x80, 0x60, 0x10, 0x38, 0x02, 0x0C, 0x00, 0x43, 0x80, 0x08, 0xD8,
  0x01, 0x31, 0x80, 0x2C, 0x18, 0x07, 0x01, 0x80, 0x80, 0x30, 0x10, 0x03,
  0x02, 0x00, 0x30, 0x40, 0x03, 0x08, 0x00, 0x31, 0x00, 0x03, 0x20, 0x00,
  0x64, 0x00, 0x06, 0x80, 0x00, 0x60, 0xFF, 0xC0, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0xFF, 0xFF,
  0xE0, 0x0F, 0x83, 0xC6, 0x86, 0x61, 0xB8, 0x1C, 0x05, 0x80, 0xE0, 0x3C,
  0x02, 0x01, 0xE0, 0x10, 0x0F, 0x00, 0x80, 0x78, 0x04, 0x03, 0xC0, 0x20,
  0x1E, 0x01, 0x00, 0xF0, 0x08, 0x07, 0x80, 0x40, 0x3C, 0x02, 0x01, 0xE0,
  0x10, 0x0F, 0x00, 0x80, 0x78, 0x04, 0x03, 0xC0, 0x20, 0x1E, 0x01, 0x00,
  0xF0, 0x08, 0x07, 0x80, 0x40, 0x3C, 0x02, 0x01, 0xE0, 0x10, 0x0F, 0x00,
  0x80, 0x78, 0x04, 0x03, 0x03, 0xF0, 0x66, 0x06, 0x34, 0x01, 0x9C, 0x00,
  0x6C, 0x00, 0x16, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x03, 0xF8, 0x01, 0xC1, 0xC0,
  0x60, 0x0C, 0x18, 0x00, 0xC6, 0x00, 0x0C, 0xC0, 0x01, 0x90, 0x00, 0x16,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0D, 0x00, 0x01, 0x30, 0x00, 0x66, 0x00, 0x0C, 0x60, 0x03, 0x06,
  0x00, 0xC0, 0x70, 0x70, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x19, 0x81, 0x83,
  0x40, 0x0C, 0x70, 0x00, 0x8E, 0x00, 0x19, 0x80, 0x01, 0x30, 0x00, 0x36,
  0x00, 0x02, 0xC0, 0x00, 0x58, 0x00, 0x0B, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x02, 0xC0, 0x00, 0x58,
  0x00, 0x0B, 0x00, 0x03, 0x60, 0x00, 0x4E, 0x00, 0x19, 0xC0, 0x02, 0x34,
  0x00, 0xC6, 0x60, 0x60, 0xC3, 0xF0, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0xC0, 0xCC, 0x60, 0x05, 0x88, 0x00, 0x73,
  0x00, 0x0E, 0xC0, 0x00, 0xD8, 0x00, 0x1A, 0x00, 0x03, 0x40, 0x00, 0x68,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1A, 0x00, 0x03, 0x40, 0x00, 0x68, 0x00, 0x0D, 0x80, 0x01, 0xB0,
  0x00, 0x33, 0x00, 0x0E, 0x20, 0x01, 0xC6, 0x00, 0x58, 0x30, 0x33, 0x03,
  0xF8, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0xFF, 0x87, 0xF8,
  0x0C, 0xC0, 0x00, 0x68, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xF8,
  0x03, 0x80, 0xE0, 0xC0, 0x06, 0x10, 0x00, 0x66, 0x00, 0x06, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x06,
  0xC0, 0x00, 0x8C, 0x00, 0x30, 0xF0, 0x18, 0x03, 0xFC, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0xFF, 0xFF, 0xFC, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x68, 0x00, 0x36, 0x00, 0x39, 0x80, 0x2C, 0x60,
  0x66, 0x0F, 0xC0, 0xC0, 0x00, 0x78, 0x00, 0x0D, 0x00, 0x01, 0x30, 0x00,
  0x62, 0x00, 0x08, 0x60, 0x01, 0x0C, 0x00, 0x60, 0x80, 0x08, 0x18, 0x03,
  0x03, 0x00, 0x60, 0x20, 0x08, 0x06, 0x03, 0x00, 0x40, 0x40, 0x08, 0x08,
  0x01, 0x83, 0x00, 0x10, 0x40, 0x03, 0x18, 0x00, 0x63, 0x00, 0x04, 0x40,
  0x00, 0xD8, 0x00, 0x0A, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x80, 0x38,
  0x03, 0x00, 0x70, 0x07, 0x00, 0xA0, 0x0E, 0x01, 0x40, 0x3C, 0x06, 0xC0,
  0x68, 0x08, 0x80, 0x90, 0x11, 0x01, 0x20, 0x22, 0x02, 0x60, 0xC6, 0x0C,
  0xC1, 0x04, 0x18, 0x82, 0x08, 0x21, 0x04, 0x10, 0x42, 0x18, 0x30, 0x84,
  0x20, 0x21, 0x0C, 0x40, 0x46, 0x18, 0x80, 0x8C, 0x13, 0x01, 0x90, 0x24,
  0x01, 0x20, 0x48, 0x02, 0x40, 0xD0, 0x04, 0x81, 0xE0, 0x0F, 0x01, 0x80,
  0x0C, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x6C, 0x00, 0x18, 0xC0, 0x06,
  0x08, 0x00, 0x81, 0x80, 0x30, 0x18, 0x0C, 0x01, 0x83, 0x00, 0x10, 0x40,
  0x03, 0x18, 0x00, 0x36, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0A, 0x00,
  0x03, 0x60, 0x00, 0xC6, 0x00, 0x30, 0x60, 0x04, 0x04, 0x01, 0x80, 0xC0,
  0x60, 0x0C, 0x18, 0x00, 0xC2, 0x00, 0x18, 0xC0, 0x01, 0xB0, 0x00, 0x18,
  0xC0, 0x00, 0x1B, 0x00, 0x01, 0x98, 0x00, 0x0C, 0x60, 0x00, 0xC3, 0x00,
  0x06, 0x08, 0x00, 0x20, 0x60, 0x03, 0x01, 0x00, 0x10, 0x0C, 0x01, 0x80,
  0x60, 0x0C, 0x01, 0x00, 0x40, 0x0C, 0x06, 0x00, 0x20, 0x20, 0x01, 0x83,
  0x00, 0x0C, 0x18, 0x00, 0x20, 0x80, 0x01, 0x8C, 0x00, 0x04, 0x40, 0x00,
  0x36, 0x00, 0x00, 0xA0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x0F, 0xC0, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0x80, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x1F,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x20, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x07, 0xF0, 0x1C, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x01,
  0xFF, 0x80, 0x1E, 0x00, 0x09, 0x8C, 0x00, 0x58, 0x30, 0x02, 0x80, 0xC0,
  0x3C, 0x03, 0x01, 0x40, 0x0C, 0x1A, 0x00, 0x31, 0x90, 0x00, 0xF8,
};

const GFXglyph IBMPlexMono_ExtraLight45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 27, 0, -1 },
  { 1, 3, 31, 27, 12, -31 },
  { 13, 8, 12, 27, 10, -33 },
  { 25, 25, 31, 27, 1, -31 },
  { 122, 21, 43, 27, 3, -37 },
  { 235, 25, 33, 27, 1, -32 },
  { 339, 23, 33, 27, 2, -32 },
  { 434, 1, 12, 27, 13, -33 },
  { 436, 11, 40, 27, 10, -34 },
  { 491, 11, 40, 27, 6, -34 },
  { 546, 23, 22, 27, 2, -25 },
  { 610, 21, 21, 27, 3, -24 },
  { 666, 5, 11, 27, 10, -4 },
  { 673, 13, 1, 27, 7, -14 },
  { 675, 3, 4, 27, 12, -4 },
  { 677, 17, 40, 27, 5, -34 },
  { 762, 21, 33, 27, 3, -32 },
  { 849, 21, 31, 27, 4, -31 },
  { 931, 20, 32, 27, 4, -32 },
  { 1011, 19, 33, 27, 3, -32 },
  { 1090, 23, 31, 27, 2, -31 },
  { 1180, 19, 32, 27, 4, -31 },
  { 1256, 19, 32, 27, 4, -31 },
  { 1332, 20, 31, 27, 3, -31 },
  { 1410, 21, 33, 27, 3, -32 },
  { 1497, 19, 32, 27, 4, -32 },
  { 1573, 3, 24, 27, 12, -24 },
  { 1582, 5, 31, 27, 10, -24 },
  { 1602, 19, 24, 27, 4, -26 },
  { 1659, 21, 9, 27, 3, -18 },
  { 1683, 19, 24, 27, 4, -26 },
  { 1740, 19, 32, 27, 4, -32 },
  { 1816, 19, 37, 27, 4, -32 },
  { 1904, 23, 31, 27, 2, -31 },
  { 1994, 19, 31, 27, 4, -31 },
  { 2068, 21, 33, 27, 3, -32 },
  { 2155, 19, 31, 27, 5, -31 },
  { 2229, 18, 31, 27, 5, -31 },
  { 2299, 18, 31, 27, 5, -31 },
  { 2369, 20, 33, 27, 3, -32 },
  { 2452, 19, 31, 27, 4, -31 },
  { 2526, 19, 31, 27, 4, -31 },
  { 2600, 17, 32, 27, 4, -31 },
  { 2668, 20, 31, 27, 5, -31 },
  { 2746, 18, 31, 27, 6, -31 },
  { 2816, 19, 31, 27, 4, -31 },
  { 2890, 19, 31, 27, 4, -31 },
  { 2964, 21, 33, 27, 3, -32 },
  { 3051, 19, 31, 27, 5, -31 },
  { 3125, 21, 39, 27, 3, -32 },
  { 3228, 19, 31, 27, 5, -31 },
  { 3302, 21, 33, 27, 3, -32 },
  { 3389, 23, 31, 27, 2, -31 },
  { 3479, 19, 32, 27, 4, -31 },
  { 3555, 23, 31, 27, 2, -31 },
  { 3645, 23, 31, 27, 2, -31 },
  { 3735, 23, 31, 27, 2, -31 },
  { 3825, 25, 31, 27, 1, -31 },
  { 3922, 23, 31, 27, 2, -31 },
  { 4012, 11, 40, 27, 12, -34 },
  { 4067, 17, 40, 27, 5, -34 },
  { 4152, 11, 40, 27, 4, -34 },
  { 4207, 21, 17, 27, 3, -31 },
  { 4252, 21, 1, 27, 3, 5 },
  { 4255, 6, 8, 27, 9, -35 },
  { 4261, 21, 25, 27, 3, -24 },
  { 4327, 19, 34, 27, 5, -33 },
  { 4408, 18, 25, 27, 5, -24 },
  { 4465, 19, 34, 27, 3, -33 },
  { 4546, 19, 25, 27, 4, -24 },
  { 4606, 20, 33, 27, 4, -33 },
  { 4689, 21, 35, 27, 4, -25 },
  { 4781, 17, 33, 27, 5, -33 },
  { 4852, 19, 33, 27, 5, -33 },
  { 4931, 16, 42, 27, 4, -33 },
  { 5015, 19, 33, 27, 6, -33 },
  { 5094, 19, 33, 27, 4, -33 },
  { 5173, 21, 24, 27, 3, -24 },
  { 5236, 17, 24, 27, 5, -24 },
  { 5287, 19, 25, 27, 4, -24 },
  { 5347, 19, 33, 27, 5, -24 },
  { 5426, 19, 33, 27, 3, -24 },
  { 5505, 21, 23, 27, 4, -23 },
  { 5566, 19, 25, 27, 4, -24 },
  { 5626, 22, 31, 27, 2, -31 },
  { 5712, 17, 24, 27, 5, -23 },
  { 5763, 19, 23, 27, 4, -23 },
  { 5818, 23, 23, 27, 2, -23 },
  { 5885, 19, 23, 27, 4, -23 },
  { 5940, 21, 32, 27, 3, -23 },
  { 6024, 19, 23, 27, 4, -23 },
  { 6079, 17, 40, 27, 5, -34 },
  { 6164, 1, 40, 27, 13, -34 },
  { 6169, 17, 40, 27, 5, -34 },
  { 6254, 21, 8, 27, 3, -18 },
};

const GFXfont IBMPlexMono_ExtraLight45pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLight45pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLight45pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _IBMPLEXMONO_EXTRALIGHT45PT7B_H_
