#pragma once

// Auto-generated by fontMaker.py
#include <TFT_eSPI.h>

struct FontEntry
{
  const GFXfont *font;
  uint16_t sizePt;
  const char *name;
};

// Includes are in all_fonts.h (include that before this file)
static const FontEntry kFonts[] = {
  { &IBMPlexMono_ExtraLight6pt7b, 6, "IBMPlexMono_ExtraLight6pt7b" },
  { &IBMPlexMono_ExtraLight7pt7b, 7, "IBMPlexMono_ExtraLight7pt7b" },
  { &IBMPlexMono_ExtraLight8pt7b, 8, "IBMPlexMono_ExtraLight8pt7b" },
  { &IBMPlexMono_ExtraLight9pt7b, 9, "IBMPlexMono_ExtraLight9pt7b" },
  { &IBMPlexMono_ExtraLight10pt7b, 10, "IBMPlexMono_ExtraLight10pt7b" },
  { &IBMPlexMono_ExtraLight11pt7b, 11, "IBMPlexMono_ExtraLight11pt7b" },
  { &IBMPlexMono_ExtraLight12pt7b, 12, "IBMPlexMono_ExtraLight12pt7b" },
  { &IBMPlexMono_ExtraLight13pt7b, 13, "IBMPlexMono_ExtraLight13pt7b" },
  { &IBMPlexMono_ExtraLight14pt7b, 14, "IBMPlexMono_ExtraLight14pt7b" },
  { &IBMPlexMono_ExtraLight15pt7b, 15, "IBMPlexMono_ExtraLight15pt7b" },
  { &IBMPlexMono_ExtraLight16pt7b, 16, "IBMPlexMono_ExtraLight16pt7b" },
  { &IBMPlexMono_ExtraLight17pt7b, 17, "IBMPlexMono_ExtraLight17pt7b" },
  { &IBMPlexMono_ExtraLight18pt7b, 18, "IBMPlexMono_ExtraLight18pt7b" },
  { &IBMPlexMono_ExtraLight19pt7b, 19, "IBMPlexMono_ExtraLight19pt7b" },
  { &IBMPlexMono_ExtraLight20pt7b, 20, "IBMPlexMono_ExtraLight20pt7b" },
  { &IBMPlexMono_ExtraLight21pt7b, 21, "IBMPlexMono_ExtraLight21pt7b" },
  { &IBMPlexMono_ExtraLight22pt7b, 22, "IBMPlexMono_ExtraLight22pt7b" },
  { &IBMPlexMono_ExtraLight23pt7b, 23, "IBMPlexMono_ExtraLight23pt7b" },
  { &IBMPlexMono_ExtraLight24pt7b, 24, "IBMPlexMono_ExtraLight24pt7b" },
  { &IBMPlexMono_ExtraLight25pt7b, 25, "IBMPlexMono_ExtraLight25pt7b" },
  { &IBMPlexMono_ExtraLight26pt7b, 26, "IBMPlexMono_ExtraLight26pt7b" },
  { &IBMPlexMono_ExtraLight27pt7b, 27, "IBMPlexMono_ExtraLight27pt7b" },
  { &IBMPlexMono_ExtraLight28pt7b, 28, "IBMPlexMono_ExtraLight28pt7b" },
  { &IBMPlexMono_ExtraLight29pt7b, 29, "IBMPlexMono_ExtraLight29pt7b" },
  { &IBMPlexMono_ExtraLight30pt7b, 30, "IBMPlexMono_ExtraLight30pt7b" },
  { &IBMPlexMono_ExtraLight31pt7b, 31, "IBMPlexMono_ExtraLight31pt7b" },
  { &IBMPlexMono_ExtraLight32pt7b, 32, "IBMPlexMono_ExtraLight32pt7b" },
  { &IBMPlexMono_ExtraLight33pt7b, 33, "IBMPlexMono_ExtraLight33pt7b" },
  { &IBMPlexMono_ExtraLight34pt7b, 34, "IBMPlexMono_ExtraLight34pt7b" },
  { &IBMPlexMono_ExtraLight35pt7b, 35, "IBMPlexMono_ExtraLight35pt7b" },
  { &IBMPlexMono_ExtraLight36pt7b, 36, "IBMPlexMono_ExtraLight36pt7b" },
  { &IBMPlexMono_ExtraLight37pt7b, 37, "IBMPlexMono_ExtraLight37pt7b" },
  { &IBMPlexMono_ExtraLight38pt7b, 38, "IBMPlexMono_ExtraLight38pt7b" },
  { &IBMPlexMono_ExtraLight39pt7b, 39, "IBMPlexMono_ExtraLight39pt7b" },
  { &IBMPlexMono_ExtraLight40pt7b, 40, "IBMPlexMono_ExtraLight40pt7b" },
  { &IBMPlexMono_ExtraLight41pt7b, 41, "IBMPlexMono_ExtraLight41pt7b" },
  { &IBMPlexMono_ExtraLight42pt7b, 42, "IBMPlexMono_ExtraLight42pt7b" },
  { &IBMPlexMono_ExtraLight43pt7b, 43, "IBMPlexMono_ExtraLight43pt7b" },
  { &IBMPlexMono_ExtraLight44pt7b, 44, "IBMPlexMono_ExtraLight44pt7b" },
  { &IBMPlexMono_ExtraLight45pt7b, 45, "IBMPlexMono_ExtraLight45pt7b" },
  { &IBMPlexMono_ExtraLight46pt7b, 46, "IBMPlexMono_ExtraLight46pt7b" },
  { &IBMPlexMono_ExtraLight47pt7b, 47, "IBMPlexMono_ExtraLight47pt7b" },
  { &IBMPlexMono_ExtraLight48pt7b, 48, "IBMPlexMono_ExtraLight48pt7b" },
  { &IBMPlexMono_ExtraLight49pt7b, 49, "IBMPlexMono_ExtraLight49pt7b" },
  { &IBMPlexMono_ExtraLight50pt7b, 50, "IBMPlexMono_ExtraLight50pt7b" },
  { &IBMPlexMono_ExtraLight51pt7b, 51, "IBMPlexMono_ExtraLight51pt7b" },
  { &IBMPlexMono_ExtraLight52pt7b, 52, "IBMPlexMono_ExtraLight52pt7b" },
  { &IBMPlexMono_ExtraLight53pt7b, 53, "IBMPlexMono_ExtraLight53pt7b" },
  { &IBMPlexMono_ExtraLight54pt7b, 54, "IBMPlexMono_ExtraLight54pt7b" },
  { &IBMPlexMono_ExtraLight55pt7b, 55, "IBMPlexMono_ExtraLight55pt7b" },
  { &IBMPlexMono_ExtraLight56pt7b, 56, "IBMPlexMono_ExtraLight56pt7b" },
  { &IBMPlexMono_ExtraLight57pt7b, 57, "IBMPlexMono_ExtraLight57pt7b" },
  { &IBMPlexMono_ExtraLight58pt7b, 58, "IBMPlexMono_ExtraLight58pt7b" },
  { &IBMPlexMono_ExtraLight59pt7b, 59, "IBMPlexMono_ExtraLight59pt7b" },
  { &IBMPlexMono_ExtraLight60pt7b, 60, "IBMPlexMono_ExtraLight60pt7b" },
  { &IBMPlexMono_ExtraLight61pt7b, 61, "IBMPlexMono_ExtraLight61pt7b" },
  { &IBMPlexMono_ExtraLight62pt7b, 62, "IBMPlexMono_ExtraLight62pt7b" },
  { &IBMPlexMono_ExtraLight63pt7b, 63, "IBMPlexMono_ExtraLight63pt7b" },
  { &IBMPlexMono_ExtraLight64pt7b, 64, "IBMPlexMono_ExtraLight64pt7b" },
  { &IBMPlexMono_ExtraLight65pt7b, 65, "IBMPlexMono_ExtraLight65pt7b" },
  { &IBMPlexMono_ExtraLight66pt7b, 66, "IBMPlexMono_ExtraLight66pt7b" },
  { &IBMPlexMono_ExtraLight67pt7b, 67, "IBMPlexMono_ExtraLight67pt7b" },
  { &IBMPlexMono_ExtraLight68pt7b, 68, "IBMPlexMono_ExtraLight68pt7b" },
  { &IBMPlexMono_ExtraLight69pt7b, 69, "IBMPlexMono_ExtraLight69pt7b" },
  { &IBMPlexMono_ExtraLight70pt7b, 70, "IBMPlexMono_ExtraLight70pt7b" },
  { &IBMPlexMono_ExtraLight71pt7b, 71, "IBMPlexMono_ExtraLight71pt7b" },
  { &IBMPlexMono_ExtraLight72pt7b, 72, "IBMPlexMono_ExtraLight72pt7b" },
};
static constexpr size_t kFontCount = sizeof(kFonts) / sizeof(kFonts[0]);
