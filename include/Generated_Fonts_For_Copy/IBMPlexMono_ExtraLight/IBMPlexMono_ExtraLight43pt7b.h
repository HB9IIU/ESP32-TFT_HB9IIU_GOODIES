#ifndef _IBMPLEXMONO_EXTRALIGHT43PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHT43PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLight.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLight43pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x64, 0x44, 0x44,
  0x00, 0x00, 0x0E, 0xFE, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0x00, 0x20, 0x20, 0x00, 0x20, 0x60, 0x00, 0x20, 0x60,
  0x00, 0x60, 0x60, 0x00, 0x60, 0x40, 0x00, 0x60, 0x40, 0x00, 0x40, 0x40,
  0x00, 0x40, 0xC0, 0x00, 0x40, 0xC0, 0x00, 0xC0, 0x80, 0x7F, 0xC0, 0xFF,
  0x00, 0x80, 0x80, 0x00, 0x81, 0x80, 0x00, 0x81, 0x80, 0x01, 0x81, 0x80,
  0x01, 0x81, 0x00, 0x01, 0x81, 0x00, 0x01, 0x01, 0x00, 0x01, 0x03, 0x00,
  0xFF, 0x03, 0xFC, 0x03, 0x03, 0x00, 0x03, 0x02, 0x00, 0x03, 0x02, 0x00,
  0x02, 0x02, 0x00, 0x02, 0x06, 0x00, 0x02, 0x06, 0x00, 0x06, 0x04, 0x00,
  0x06, 0x04, 0x00, 0x04, 0x04, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x03, 0xFC, 0x00, 0xC2, 0x38,
  0x30, 0x20, 0xC6, 0x02, 0x06, 0x60, 0x20, 0x34, 0x02, 0x00, 0xC0, 0x20,
  0x0C, 0x02, 0x00, 0xC0, 0x20, 0x04, 0x02, 0x00, 0x60, 0x20, 0x02, 0x02,
  0x00, 0x38, 0x20, 0x00, 0xE2, 0x00, 0x03, 0xF8, 0x00, 0x02, 0xF0, 0x00,
  0x21, 0x80, 0x02, 0x04, 0x00, 0x20, 0x60, 0x02, 0x03, 0x00, 0x20, 0x30,
  0x02, 0x03, 0x00, 0x20, 0x30, 0x02, 0x03, 0x80, 0x20, 0x3C, 0x02, 0x02,
  0x60, 0x20, 0x67, 0x02, 0x0C, 0x1C, 0x23, 0x00, 0x7F, 0xC0, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x0F, 0x80, 0x03, 0x30,
  0xE0, 0x06, 0x60, 0x20, 0x04, 0x40, 0x30, 0x0C, 0x40, 0x10, 0x08, 0xC0,
  0x10, 0x18, 0xC0, 0x10, 0x30, 0xC0, 0x10, 0x20, 0xC0, 0x10, 0x60, 0x40,
  0x10, 0x40, 0x40, 0x30, 0xC0, 0x60, 0x20, 0x80, 0x30, 0xE1, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x01,
  0x86, 0x0C, 0x01, 0x0C, 0x04, 0x03, 0x08, 0x06, 0x02, 0x08, 0x02, 0x04,
  0x18, 0x02, 0x0C, 0x18, 0x02, 0x08, 0x18, 0x02, 0x18, 0x18, 0x02, 0x10,
  0x08, 0x02, 0x30, 0x08, 0x06, 0x20, 0x0C, 0x04, 0x40, 0x06, 0x0C, 0xC0,
  0x01, 0xF0, 0x01, 0xF0, 0x00, 0x18, 0x30, 0x00, 0xC0, 0x60, 0x06, 0x00,
  0xC0, 0x10, 0x02, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x08, 0x00, 0x00, 0xD0, 0x00, 0x0C, 0x60, 0x1F, 0x20, 0xC0,
  0x41, 0x01, 0x81, 0x0C, 0x03, 0x0C, 0x30, 0x06, 0x30, 0x80, 0x08, 0xC2,
  0x00, 0x32, 0x08, 0x00, 0x68, 0x20, 0x00, 0xE0, 0x80, 0x01, 0x83, 0x00,
  0x0B, 0x04, 0x00, 0x26, 0x18, 0x01, 0x08, 0x18, 0x18, 0x10, 0x1F, 0x80,
  0x70, 0xFF, 0xFF, 0xFC, 0x00, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x02, 0x01,
  0x80, 0x40, 0x30, 0x08, 0x06, 0x01, 0x00, 0x40, 0x10, 0x0C, 0x03, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x03, 0x00, 0xC0, 0x10,
  0x04, 0x01, 0x00, 0x60, 0x08, 0x03, 0x00, 0x40, 0x18, 0x02, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0xE0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40,
  0x04, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x10, 0x02, 0x00, 0x60, 0x04, 0x00,
  0x80, 0x10, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x40, 0x08, 0x01, 0x00, 0x60, 0x08, 0x01, 0x00, 0x60,
  0x08, 0x03, 0x00, 0x40, 0x10, 0x06, 0x01, 0x80, 0x60, 0x38, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x20, 0x0C, 0x02, 0xF0, 0x30, 0x3C,
  0x78, 0xC7, 0x80, 0x3F, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03,
  0x20, 0x00, 0x08, 0xC0, 0x00, 0x61, 0x80, 0x03, 0x03, 0x00, 0x08, 0x04,
  0x00, 0x60, 0x18, 0x03, 0x00, 0x30, 0x18, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0xFF, 0xFF,
  0xF0, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x39, 0x9C, 0xC6, 0x31, 0x18, 0xC4, 0x20, 0xFF, 0xF0, 0xEF,
  0xE0, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30,
  0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02,
  0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00,
  0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x60, 0x60, 0x18, 0x01, 0x01, 0x00, 0x08, 0x20, 0x00,
  0xC6, 0x00, 0x04, 0x60, 0x00, 0x64, 0x00, 0x02, 0xC0, 0x00, 0x2C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x06, 0x03, 0xC0,
  0xE0, 0x3C, 0x06, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x02, 0x40, 0x00, 0x26, 0x00, 0x06,
  0x60, 0x00, 0x42, 0x00, 0x0C, 0x10, 0x00, 0x81, 0x80, 0x10, 0x06, 0x06,
  0x00, 0x3F, 0x80, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0xCC, 0x00, 0x0C,
  0x60, 0x00, 0xC3, 0x00, 0x0C, 0x18, 0x00, 0xC0, 0xC0, 0x0C, 0x06, 0x00,
  0xC0, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x3F, 0xFF, 0xFC, 0x07, 0xF0,
  0x03, 0x01, 0x80, 0xC0, 0x18, 0x30, 0x01, 0x8C, 0x00, 0x11, 0x00, 0x03,
  0x20, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xF8,
  0x07, 0x03, 0x83, 0x00, 0x31, 0x80, 0x06, 0x60, 0x00, 0x80, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x7F, 0x00, 0x00, 0x38, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x19, 0xC0,
  0x0C, 0x1C, 0x0E, 0x01, 0xFE, 0x00, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x78, 0x00, 0x03, 0x60, 0x00, 0x09, 0x80, 0x00, 0x66, 0x00, 0x03,
  0x18, 0x00, 0x08, 0x60, 0x00, 0x61, 0x80, 0x03, 0x06, 0x00, 0x08, 0x18,
  0x00, 0x60, 0x60, 0x03, 0x01, 0x80, 0x18, 0x06, 0x00, 0x40, 0x18, 0x03,
  0x00, 0x60, 0x18, 0x01, 0x80, 0x40, 0x06, 0x03, 0x00, 0x18, 0x18, 0x00,
  0x60, 0x40, 0x01, 0x83, 0x00, 0x06, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x1F, 0xFF, 0xC2, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x1F, 0xC0,
  0x4C, 0x0E, 0x0A, 0x00, 0x61, 0x80, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x48, 0x00, 0x1B, 0x80, 0x02, 0x18, 0x00, 0xC1,
  0xC0, 0x60, 0x07, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x43, 0xF8, 0x33, 0x03,
  0x8F, 0x00, 0x32, 0x80, 0x06, 0xC0, 0x00, 0xB0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0xC0,
  0x00, 0xD0, 0x00, 0x26, 0x00, 0x18, 0xC0, 0x0C, 0x1C, 0x0C, 0x01, 0xFC,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x6C, 0x00,
  0x0D, 0x80, 0x01, 0x30, 0x00, 0x66, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0xE0, 0x70, 0x18, 0x01, 0x83, 0x00, 0x0C, 0x60,
  0x00, 0x46, 0x00, 0x06, 0x60, 0x00, 0x66, 0x00, 0x06, 0x60, 0x00, 0x66,
  0x00, 0x06, 0x60, 0x00, 0x43, 0x00, 0x0C, 0x18, 0x01, 0x80, 0xE0, 0x70,
  0x03, 0xF8, 0x00, 0xC0, 0x70, 0x30, 0x00, 0xC6, 0x00, 0x04, 0x40, 0x00,
  0x6C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x34, 0x00, 0x06, 0x60, 0x00, 0x43, 0x00, 0x0C, 0x0C,
  0x03, 0x00, 0x3F, 0xC0, 0x03, 0xF0, 0x07, 0x03, 0x83, 0x00, 0x31, 0x80,
  0x06, 0x40, 0x00, 0xB0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xD0, 0x00, 0x36,
  0x00, 0x14, 0xC0, 0x0B, 0x1C, 0x0C, 0xC1, 0xFC, 0x20, 0x00, 0x18, 0x00,
  0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00,
  0xEF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0xFE, 0x73,
  0xDC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x67,
  0x31, 0x8C, 0x46, 0x31, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x02, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x04, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x30,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0x00, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x70, 0x00, 0x30, 0x00, 0x08, 0x00,
  0x00, 0x07, 0xF8, 0x07, 0x03, 0x83, 0x00, 0x31, 0x80, 0x04, 0x40, 0x01,
  0xB0, 0x00, 0x24, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x20,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x03, 0xC0, 0x07,
  0x80, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x03, 0xF0, 0x03,
  0x03, 0x01, 0x80, 0x60, 0xC0, 0x0C, 0x20, 0x01, 0x18, 0x00, 0x64, 0x00,
  0x09, 0x00, 0x02, 0xC0, 0x00, 0xB0, 0x1F, 0x28, 0x0C, 0x2E, 0x04, 0x07,
  0x83, 0x00, 0xE0, 0x80, 0x38, 0x20, 0x0E, 0x08, 0x03, 0x82, 0x00, 0xE1,
  0x80, 0x38, 0x60, 0x0E, 0x08, 0x03, 0x82, 0x00, 0xE0, 0x80, 0x38, 0x30,
  0x0E, 0x04, 0x07, 0x81, 0x82, 0xF0, 0x3F, 0xBC, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x12, 0x00, 0x00, 0xC8, 0x00, 0x03, 0x30, 0x00, 0x08, 0x40, 0x00,
  0x61, 0x00, 0x01, 0x86, 0x00, 0x04, 0x18, 0x00, 0x30, 0x20, 0x00, 0xC0,
  0xC0, 0x02, 0x03, 0x00, 0x18, 0x04, 0x00, 0x60, 0x18, 0x01, 0x00, 0x60,
  0x0C, 0x00, 0x80, 0x30, 0x03, 0x00, 0x80, 0x0C, 0x07, 0xFF, 0xF0, 0x18,
  0x00, 0x60, 0x40, 0x01, 0x83, 0x00, 0x02, 0x0C, 0x00, 0x0C, 0x20, 0x00,
  0x31, 0x80, 0x00, 0x46, 0x00, 0x01, 0x90, 0x00, 0x06, 0x40, 0x00, 0x0B,
  0x00, 0x00, 0x30, 0xFF, 0xF8, 0x30, 0x03, 0x8C, 0x00, 0x33, 0x00, 0x04,
  0xC0, 0x01, 0xB0, 0x00, 0x6C, 0x00, 0x1B, 0x00, 0x06, 0xC0, 0x01, 0xB0,
  0x00, 0x6C, 0x00, 0x1B, 0x00, 0x04, 0xC0, 0x03, 0x30, 0x03, 0x8F, 0xFF,
  0x83, 0x00, 0x1C, 0xC0, 0x01, 0xB0, 0x00, 0x2C, 0x00, 0x0F, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x3C, 0x00, 0x0B, 0x00, 0x06, 0xC0, 0x07, 0x3F, 0xFF, 0x00, 0x01,
  0xFC, 0x00, 0xE0, 0x60, 0x30, 0x02, 0x0C, 0x00, 0x23, 0x00, 0x06, 0x60,
  0x00, 0x58, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x26, 0x00,
  0x0C, 0x60, 0x01, 0x06, 0x00, 0x40, 0x70, 0x30, 0x03, 0xF8, 0x00, 0xFF,
  0xE0, 0x20, 0x06, 0x08, 0x00, 0xC2, 0x00, 0x18, 0x80, 0x03, 0x20, 0x00,
  0x48, 0x00, 0x1A, 0x00, 0x06, 0x80, 0x00, 0xA0, 0x00, 0x28, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xA0, 0x00,
  0x28, 0x00, 0x1A, 0x00, 0x06, 0x80, 0x01, 0x20, 0x00, 0xC8, 0x00, 0x62,
  0x00, 0x30, 0x80, 0x18, 0x3F, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0F, 0xFF,
  0xFB, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0xC0, 0xE0, 0x30, 0x06, 0x08, 0x00, 0x63, 0x00, 0x04, 0x40,
  0x00, 0xD8, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x3F, 0xF8, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x02, 0x80, 0x00, 0x50, 0x00, 0x0B, 0x00, 0x03, 0x20, 0x00, 0x66, 0x00,
  0x14, 0x40, 0x02, 0x84, 0x00, 0x90, 0x60, 0x62, 0x03, 0xF0, 0x40, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x30, 0xFF, 0xFF, 0xC0, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x02, 0x40, 0x06, 0x60, 0x0C, 0x38,
  0x18, 0x0F, 0xE0, 0xC0, 0x00, 0x7C, 0x00, 0x0C, 0xC0, 0x00, 0xCC, 0x00,
  0x18, 0xC0, 0x03, 0x0C, 0x00, 0x60, 0xC0, 0x0C, 0x0C, 0x01, 0x80, 0xC0,
  0x30, 0x0C, 0x06, 0x00, 0xC0, 0xC0, 0x0C, 0x0C, 0x00, 0xC1, 0x80, 0x0C,
  0x38, 0x00, 0xC6, 0xC0, 0x0C, 0xCC, 0x00, 0xD8, 0x60, 0x0F, 0x03, 0x00,
  0xE0, 0x30, 0x0C, 0x01, 0x80, 0xC0, 0x0C, 0x0C, 0x00, 0xC0, 0xC0, 0x06,
  0x0C, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x18, 0xC0, 0x00, 0xCC, 0x00,
  0x0C, 0xC0, 0x00, 0x6C, 0x00, 0x03, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0xFF, 0xFC, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0xC0, 0x02, 0xE8, 0x00, 0x5D, 0x80, 0x1B, 0x90, 0x02,
  0x73, 0x00, 0xCE, 0x60, 0x11, 0xC4, 0x06, 0x38, 0xC0, 0x87, 0x08, 0x30,
  0xE1, 0x84, 0x1C, 0x10, 0x83, 0x83, 0x30, 0x70, 0x24, 0x0E, 0x07, 0x81,
  0xC0, 0x60, 0x38, 0x0C, 0x07, 0x01, 0x00, 0xE0, 0x20, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x40, 0xE0, 0x00,
  0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xD8, 0x00, 0xF6, 0x00, 0x3C,
  0xC0, 0x0F, 0x30, 0x03, 0xC6, 0x00, 0xF1, 0x80, 0x3C, 0x30, 0x0F, 0x0C,
  0x03, 0xC1, 0x00, 0xF0, 0x60, 0x3C, 0x08, 0x0F, 0x03, 0x03, 0xC0, 0x40,
  0xF0, 0x18, 0x3C, 0x02, 0x0F, 0x00, 0xC3, 0xC0, 0x10, 0xF0, 0x06, 0x3C,
  0x00, 0x8F, 0x00, 0x33, 0xC0, 0x04, 0xF0, 0x01, 0xBC, 0x00, 0x2F, 0x00,
  0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x70, 0x01, 0xF8, 0x00, 0x60, 0x60, 0x18,
  0x01, 0x01, 0x00, 0x08, 0x20, 0x00, 0xC6, 0x00, 0x04, 0x60, 0x00, 0x64,
  0x00, 0x02, 0xC0, 0x00, 0x2C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x02, 0x40, 0x00, 0x26, 0x00, 0x06, 0x60, 0x00, 0x42, 0x00, 0x0C, 0x10,
  0x00, 0x81, 0x80, 0x10, 0x06, 0x06, 0x00, 0x3F, 0x80, 0xFF, 0xFC, 0x18,
  0x00, 0x63, 0x00, 0x06, 0x60, 0x00, 0x6C, 0x00, 0x05, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x2C, 0x00, 0x0D, 0x80, 0x03, 0x30, 0x00, 0xC7, 0xFF, 0xE0, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x60, 0x60, 0x18, 0x01, 0x01, 0x00, 0x08, 0x20, 0x00, 0xC6, 0x00, 0x04,
  0x60, 0x00, 0x64, 0x00, 0x02, 0xC0, 0x00, 0x2C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x02, 0x40, 0x00, 0x26, 0x00, 0x06, 0x60, 0x00, 0x42,
  0x00, 0x0C, 0x30, 0x00, 0x81, 0x80, 0x10, 0x06, 0x06, 0x00, 0x1F, 0x80,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x3F,
  0xC0, 0xFF, 0xFC, 0x18, 0x00, 0x63, 0x00, 0x06, 0x60, 0x00, 0x6C, 0x00,
  0x05, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x2C, 0x00, 0x0D, 0x80, 0x03, 0x30, 0x00,
  0xC7, 0xFF, 0xE0, 0xC0, 0x40, 0x18, 0x0C, 0x03, 0x00, 0xC0, 0x60, 0x08,
  0x0C, 0x01, 0x81, 0x80, 0x18, 0x30, 0x03, 0x06, 0x00, 0x30, 0xC0, 0x02,
  0x18, 0x00, 0x63, 0x00, 0x06, 0x60, 0x00, 0xCC, 0x00, 0x0D, 0x80, 0x00,
  0xC0, 0x03, 0xFC, 0x01, 0xC0, 0x38, 0x30, 0x00, 0xC6, 0x00, 0x06, 0x60,
  0x00, 0x24, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x04,
  0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x80, 0x00, 0x3C, 0x00, 0x06, 0x60, 0x00, 0x63, 0x00, 0x0C, 0x1C,
  0x03, 0x00, 0x7F, 0xC0, 0xFF, 0xFF, 0xFC, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0B, 0x00, 0x02, 0x40, 0x00, 0x90,
  0x00, 0x66, 0x00, 0x10, 0xC0, 0x0C, 0x18, 0x0E, 0x01, 0xFE, 0x00, 0xC0,
  0x00, 0x0D, 0x00, 0x00, 0x26, 0x00, 0x01, 0x98, 0x00, 0x06, 0x20, 0x00,
  0x10, 0xC0, 0x00, 0xC3, 0x00, 0x03, 0x04, 0x00, 0x08, 0x18, 0x00, 0x60,
  0x60, 0x01, 0x80, 0x80, 0x04, 0x03, 0x00, 0x30, 0x0C, 0x00, 0xC0, 0x10,
  0x02, 0x00, 0x40, 0x18, 0x01, 0x80, 0x60, 0x06, 0x01, 0x00, 0x08, 0x0C,
  0x00, 0x30, 0x30, 0x00, 0xC0, 0x80, 0x01, 0x06, 0x00, 0x06, 0x18, 0x00,
  0x18, 0x40, 0x00, 0x21, 0x00, 0x00, 0xCC, 0x00, 0x03, 0x20, 0x00, 0x04,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x24, 0x00, 0x00, 0x90, 0x00, 0x02, 0x40, 0x00, 0x09,
  0x00, 0x00, 0x24, 0x00, 0x00, 0x90, 0x00, 0x06, 0x40, 0x00, 0x19, 0x80,
  0xC0, 0x66, 0x03, 0x01, 0x98, 0x1E, 0x04, 0x60, 0x58, 0x10, 0x81, 0x20,
  0x42, 0x0C, 0x81, 0x08, 0x33, 0x04, 0x20, 0x84, 0x10, 0x82, 0x10, 0x42,
  0x18, 0x63, 0x0C, 0x41, 0x8C, 0x31, 0x02, 0x30, 0xCC, 0x08, 0xC3, 0x30,
  0x32, 0x0C, 0x80, 0xC8, 0x12, 0x01, 0x20, 0x58, 0x04, 0x81, 0x60, 0x1A,
  0x05, 0x00, 0x28, 0x1C, 0x00, 0xE0, 0x70, 0x03, 0x80, 0xE0, 0x00, 0x1D,
  0x80, 0x00, 0x63, 0x00, 0x03, 0x04, 0x00, 0x18, 0x18, 0x00, 0x60, 0x30,
  0x03, 0x00, 0x40, 0x08, 0x01, 0x80, 0x60, 0x03, 0x03, 0x00, 0x04, 0x08,
  0x00, 0x18, 0x60, 0x00, 0x33, 0x00, 0x00, 0xC8, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x78, 0x00, 0x03, 0x30, 0x00, 0x08,
  0x40, 0x00, 0x61, 0x80, 0x03, 0x03, 0x00, 0x08, 0x04, 0x00, 0x60, 0x18,
  0x03, 0x00, 0x30, 0x08, 0x00, 0x40, 0x60, 0x01, 0x83, 0x00, 0x03, 0x08,
  0x00, 0x0C, 0x60, 0x00, 0x1B, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x60,
  0x00, 0x06, 0x20, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x08,
  0x00, 0x10, 0x0C, 0x00, 0x30, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x03,
  0x00, 0xC0, 0x01, 0x01, 0x80, 0x01, 0x81, 0x80, 0x00, 0xC3, 0x00, 0x00,
  0x42, 0x00, 0x00, 0x66, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0xFF, 0xF0, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x3F, 0xF8, 0xC0, 0x00, 0x20, 0x00, 0x18,
  0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00,
  0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10,
  0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00,
  0x18, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0xFF, 0xE0, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xFF, 0xF8,
  0x00, 0x60, 0x00, 0x0F, 0x00, 0x00, 0x90, 0x00, 0x19, 0x80, 0x03, 0x08,
  0x00, 0x20, 0xC0, 0x06, 0x06, 0x00, 0x40, 0x20, 0x0C, 0x03, 0x01, 0x80,
  0x10, 0x10, 0x01, 0x83, 0x00, 0x0C, 0x20, 0x00, 0xC6, 0x00, 0x06, 0xC0,
  0x00, 0x2C, 0x00, 0x03, 0x80, 0x00, 0x20, 0xFF, 0xFF, 0xF0, 0x86, 0x18,
  0x41, 0x0C, 0x20, 0x07, 0xF0, 0x01, 0xC0, 0xC0, 0x30, 0x06, 0x06, 0x00,
  0x30, 0x40, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x07, 0xFF, 0x83, 0x80, 0x18, 0x60, 0x01, 0x84,
  0x00, 0x18, 0xC0, 0x01, 0x8C, 0x00, 0x18, 0xC0, 0x01, 0x8C, 0x00, 0x18,
  0x40, 0x03, 0x86, 0x00, 0x58, 0x38, 0x19, 0x80, 0xFE, 0x0F, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x7F, 0x03, 0x20,
  0x70, 0xF0, 0x06, 0x38, 0x00, 0xCC, 0x00, 0x13, 0x00, 0x06, 0xC0, 0x00,
  0xB0, 0x00, 0x2C, 0x00, 0x0B, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x02, 0xC0, 0x00, 0xB0, 0x00, 0x2C, 0x00, 0x1B, 0x00,
  0x04, 0xE0, 0x03, 0x3C, 0x01, 0x8C, 0x81, 0xC3, 0x1F, 0xC0, 0x03, 0xF8,
  0x03, 0x81, 0x81, 0x80, 0x30, 0xC0, 0x06, 0x20, 0x00, 0x98, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00,
  0x08, 0x00, 0x33, 0x00, 0x18, 0x60, 0x0C, 0x0E, 0x06, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x3F,
  0x0C, 0x38, 0x33, 0x18, 0x02, 0xCC, 0x00, 0x76, 0x00, 0x0D, 0x80, 0x03,
  0x40, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xD0, 0x00, 0x36, 0x00,
  0x0D, 0x80, 0x03, 0x30, 0x01, 0xC6, 0x00, 0xB0, 0xE0, 0xCC, 0x0F, 0xC3,
  0x03, 0xF0, 0x03, 0x03, 0x03, 0x00, 0x20, 0x80, 0x04, 0x60, 0x01, 0x90,
  0x00, 0x2C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0x40, 0x00, 0xD8, 0x00, 0x22, 0x00, 0x18, 0xC0, 0x0C, 0x0C, 0x0E, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0xFF, 0xFF, 0xF0, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x07, 0xFF, 0xFE, 0x00, 0x03,
  0xF0, 0x3F, 0x20, 0x0C, 0x0E, 0x01, 0x80, 0x60, 0x30, 0x03, 0x02, 0x00,
  0x10, 0x60, 0x01, 0x06, 0x00, 0x18, 0x60, 0x01, 0x86, 0x00, 0x18, 0x20,
  0x01, 0x82, 0x00, 0x10, 0x10, 0x03, 0x01, 0x80, 0x60, 0x04, 0x0C, 0x00,
  0xFF, 0x00, 0x38, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xFF, 0xF0, 0x30, 0x00, 0xC4, 0x00, 0x06, 0xC0, 0x00,
  0x28, 0x00, 0x02, 0x80, 0x00, 0x38, 0x00, 0x02, 0xC0, 0x00, 0x66, 0x00,
  0x0C, 0x30, 0x03, 0x80, 0xFF, 0xC0, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC7, 0xF0, 0xC8, 0x18, 0xF0, 0x04, 0xE0, 0x06, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x03, 0xFF, 0xFF, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x7F, 0xFC, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x1A, 0x00, 0x18, 0x80, 0x0C, 0x20, 0x06, 0x08, 0x03,
  0x02, 0x01, 0x80, 0x80, 0xC0, 0x20, 0x60, 0x08, 0x60, 0x02, 0x3C, 0x00,
  0x99, 0x80, 0x2C, 0x30, 0x0E, 0x04, 0x03, 0x01, 0x80, 0x80, 0x30, 0x20,
  0x06, 0x08, 0x00, 0xC2, 0x00, 0x18, 0x80, 0x02, 0x20, 0x00, 0xC8, 0x00,
  0x1A, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x03, 0xFF, 0xFF, 0x8F, 0x07, 0xCB, 0x08, 0x86, 0xC0, 0x50, 0x2C, 0x06,
  0x03, 0xC0, 0x60, 0x38, 0x06, 0x03, 0x80, 0x60, 0x38, 0x06, 0x03, 0x80,
  0x60, 0x38, 0x06, 0x03, 0x80, 0x60, 0x38, 0x06, 0x03, 0x80, 0x60, 0x38,
  0x06, 0x03, 0x80, 0x60, 0x38, 0x06, 0x03, 0x80, 0x60, 0x38, 0x06, 0x03,
  0x80, 0x60, 0x38, 0x06, 0x03, 0x80, 0x60, 0x38, 0x06, 0x03, 0xC7, 0xF0,
  0xC8, 0x18, 0xF0, 0x04, 0xE0, 0x06, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x03, 0xF0, 0x03, 0x03, 0x03, 0x00,
  0x20, 0x80, 0x04, 0x40, 0x01, 0xB0, 0x00, 0x2C, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x90, 0x00, 0x62, 0x00,
  0x10, 0xC0, 0x08, 0x0C, 0x0C, 0x00, 0xFC, 0x00, 0xC7, 0xF0, 0x32, 0x07,
  0x0F, 0x00, 0x63, 0x80, 0x0C, 0xC0, 0x01, 0x30, 0x00, 0x6C, 0x00, 0x0B,
  0x00, 0x02, 0xC0, 0x00, 0xB0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x2C, 0x00, 0x0B, 0x00, 0x02, 0xC0, 0x01, 0xB0, 0x00,
  0x4E, 0x00, 0x33, 0xC0, 0x18, 0xC8, 0x1C, 0x31, 0xFC, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xF0, 0xC3, 0x83, 0x31, 0x80,
  0x2C, 0xC0, 0x07, 0x60, 0x00, 0xD8, 0x00, 0x34, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0D, 0x00, 0x03, 0x60, 0x00, 0xD8, 0x00, 0x33, 0x00,
  0x1C, 0x60, 0x0B, 0x0E, 0x0C, 0xC0, 0xFC, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0xFF, 0x87, 0xF8, 0x04, 0x40, 0x00, 0x24, 0x00,
  0x01, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x7F,
  0xFF, 0xF0, 0x07, 0xF8, 0x06, 0x03, 0x83, 0x00, 0x19, 0x80, 0x03, 0x40,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x06, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x0D, 0x80, 0x06, 0x1C,
  0x07, 0x01, 0xFF, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0xFF, 0xFF, 0xF0, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x40, 0x07, 0x60, 0x0F, 0x38,
  0x3B, 0x0F, 0xE3, 0x80, 0x00, 0xF0, 0x00, 0x34, 0x00, 0x09, 0x80, 0x06,
  0x60, 0x01, 0x08, 0x00, 0x43, 0x00, 0x30, 0x40, 0x08, 0x10, 0x06, 0x06,
  0x01, 0x80, 0x80, 0x40, 0x30, 0x30, 0x0C, 0x08, 0x01, 0x02, 0x00, 0x61,
  0x80, 0x08, 0x40, 0x02, 0x30, 0x00, 0xCC, 0x00, 0x12, 0x00, 0x05, 0x80,
  0x01, 0xC0, 0x00, 0x30, 0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x07,
  0x80, 0xF0, 0x12, 0x03, 0xC0, 0x48, 0x09, 0x01, 0x20, 0x24, 0x0C, 0x80,
  0x90, 0x21, 0x02, 0x40, 0x84, 0x19, 0x82, 0x10, 0x66, 0x18, 0x41, 0x08,
  0x40, 0x84, 0x21, 0x02, 0x10, 0x84, 0x08, 0x42, 0x30, 0x23, 0x0C, 0x80,
  0xC8, 0x12, 0x01, 0x20, 0x48, 0x04, 0x81, 0x60, 0x12, 0x05, 0x00, 0x78,
  0x1C, 0x00, 0xE0, 0x70, 0x03, 0x00, 0xC0, 0x00, 0xD8, 0x00, 0x62, 0x00,
  0x30, 0xC0, 0x08, 0x18, 0x06, 0x03, 0x03, 0x00, 0x41, 0x80, 0x18, 0x40,
  0x03, 0x30, 0x00, 0x78, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x60, 0x00,
  0xCC, 0x00, 0x61, 0x80, 0x30, 0x20, 0x08, 0x0C, 0x06, 0x01, 0x83, 0x00,
  0x31, 0x80, 0x04, 0x40, 0x01, 0xB0, 0x00, 0x30, 0xC0, 0x00, 0x34, 0x00,
  0x06, 0x60, 0x00, 0x62, 0x00, 0x04, 0x30, 0x00, 0xC1, 0x00, 0x08, 0x18,
  0x01, 0x81, 0x80, 0x10, 0x08, 0x01, 0x00, 0xC0, 0x30, 0x04, 0x02, 0x00,
  0x60, 0x60, 0x06, 0x04, 0x00, 0x20, 0xC0, 0x03, 0x0C, 0x00, 0x10, 0x80,
  0x01, 0x98, 0x00, 0x19, 0x00, 0x00, 0xB0, 0x00, 0x0F, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x7E,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x08, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0xFE, 0x00, 0x03, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0,
  0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x80, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x7F,
  0x01, 0xC0, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0xFF, 0x80, 0x0F, 0x00, 0x08, 0x84, 0x00, 0x4C, 0x10, 0x02, 0x40, 0x40,
  0x36, 0x01, 0x01, 0x20, 0x0C, 0x19, 0x00, 0x31, 0x98, 0x00, 0x78,
};

const GFXglyph IBMPlexMono_ExtraLight43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 26, 0, -1 },
  { 1, 4, 30, 26, 11, -30 },
  { 16, 8, 11, 26, 9, -32 },
  { 27, 24, 30, 26, 1, -30 },
  { 117, 20, 38, 26, 3, -34 },
  { 212, 24, 30, 26, 1, -30 },
  { 302, 22, 30, 26, 2, -30 },
  { 385, 2, 11, 26, 12, -32 },
  { 388, 10, 39, 26, 10, -33 },
  { 437, 11, 39, 26, 5, -33 },
  { 491, 22, 21, 26, 2, -24 },
  { 549, 20, 21, 26, 3, -24 },
  { 602, 5, 11, 26, 10, -4 },
  { 609, 12, 1, 26, 7, -14 },
  { 611, 4, 3, 26, 11, -3 },
  { 613, 17, 39, 26, 4, -33 },
  { 696, 20, 30, 26, 3, -30 },
  { 771, 21, 30, 26, 3, -30 },
  { 850, 19, 30, 26, 4, -30 },
  { 922, 18, 30, 26, 3, -30 },
  { 990, 22, 30, 26, 2, -30 },
  { 1073, 19, 30, 26, 3, -30 },
  { 1145, 18, 30, 26, 4, -30 },
  { 1213, 19, 30, 26, 3, -30 },
  { 1285, 20, 30, 26, 3, -30 },
  { 1360, 18, 30, 26, 4, -30 },
  { 1428, 4, 22, 26, 11, -22 },
  { 1439, 5, 29, 26, 10, -22 },
  { 1458, 18, 23, 26, 4, -25 },
  { 1510, 20, 9, 26, 3, -18 },
  { 1533, 18, 23, 26, 4, -25 },
  { 1585, 18, 30, 26, 4, -30 },
  { 1653, 18, 35, 26, 4, -30 },
  { 1732, 22, 30, 26, 2, -30 },
  { 1815, 18, 30, 26, 4, -30 },
  { 1883, 19, 30, 26, 3, -30 },
  { 1955, 18, 30, 26, 5, -30 },
  { 2023, 18, 30, 26, 4, -30 },
  { 2091, 18, 30, 26, 4, -30 },
  { 2159, 19, 30, 26, 3, -30 },
  { 2231, 18, 30, 26, 4, -30 },
  { 2299, 18, 30, 26, 4, -30 },
  { 2367, 16, 30, 26, 4, -30 },
  { 2427, 20, 30, 26, 4, -30 },
  { 2502, 17, 30, 26, 6, -30 },
  { 2566, 19, 30, 26, 3, -30 },
  { 2638, 18, 30, 26, 4, -30 },
  { 2706, 20, 30, 26, 3, -30 },
  { 2781, 19, 30, 26, 4, -30 },
  { 2853, 20, 35, 26, 3, -30 },
  { 2941, 19, 30, 26, 4, -30 },
  { 3013, 20, 30, 26, 3, -30 },
  { 3088, 22, 30, 26, 2, -30 },
  { 3171, 18, 30, 26, 4, -30 },
  { 3239, 22, 30, 26, 2, -30 },
  { 3322, 22, 30, 26, 2, -30 },
  { 3405, 22, 30, 26, 2, -30 },
  { 3488, 24, 30, 26, 1, -30 },
  { 3578, 22, 30, 26, 2, -30 },
  { 3661, 11, 39, 26, 11, -33 },
  { 3715, 17, 39, 26, 4, -33 },
  { 3798, 11, 39, 26, 4, -33 },
  { 3852, 20, 17, 26, 3, -30 },
  { 3895, 20, 1, 26, 3, 5 },
  { 3898, 5, 7, 26, 9, -33 },
  { 3903, 20, 22, 26, 3, -22 },
  { 3958, 18, 32, 26, 5, -32 },
  { 4030, 18, 22, 26, 4, -22 },
  { 4080, 18, 32, 26, 3, -32 },
  { 4152, 18, 22, 26, 4, -22 },
  { 4202, 20, 32, 26, 3, -32 },
  { 4282, 20, 32, 26, 4, -23 },
  { 4362, 16, 32, 26, 5, -32 },
  { 4426, 18, 32, 26, 5, -32 },
  { 4498, 15, 41, 26, 4, -32 },
  { 4575, 18, 32, 26, 6, -32 },
  { 4647, 18, 32, 26, 4, -32 },
  { 4719, 20, 22, 26, 3, -22 },
  { 4774, 16, 22, 26, 5, -22 },
  { 4818, 18, 22, 26, 4, -22 },
  { 4868, 18, 31, 26, 5, -22 },
  { 4938, 18, 31, 26, 3, -22 },
  { 5008, 21, 22, 26, 3, -22 },
  { 5066, 18, 22, 26, 4, -22 },
  { 5116, 20, 30, 26, 2, -30 },
  { 5191, 16, 22, 26, 5, -22 },
  { 5235, 18, 22, 26, 4, -22 },
  { 5285, 22, 22, 26, 2, -22 },
  { 5346, 18, 22, 26, 4, -22 },
  { 5396, 20, 31, 26, 3, -22 },
  { 5474, 18, 22, 26, 4, -22 },
  { 5524, 16, 39, 26, 5, -33 },
  { 5602, 2, 39, 26, 12, -33 },
  { 5612, 16, 39, 26, 5, -33 },
  { 5690, 21, 8, 26, 2, -17 },
};

const GFXfont IBMPlexMono_ExtraLight43pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLight43pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLight43pt7bGlyphs,
  0x20, 0x7E, 56
};

#endif // _IBMPLEXMONO_EXTRALIGHT43PT7B_H_
