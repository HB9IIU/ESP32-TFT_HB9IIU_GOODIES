#ifndef _IBMPLEXMONO_EXTRALIGHT16PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHT16PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLight.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLight16pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x20, 0xB6, 0xD0, 0x0A, 0x09, 0x04, 0x8E, 0x71, 0x20, 0xA0,
  0x91, 0xC7, 0x24, 0x12, 0x09, 0x00, 0x10, 0x10, 0x3C, 0x52, 0x90, 0x90,
  0x50, 0x3C, 0x12, 0x11, 0x92, 0x52, 0x3C, 0x10, 0x10, 0x70, 0xC4, 0xA2,
  0x51, 0x47, 0x20, 0x00, 0x5C, 0x51, 0x48, 0xA4, 0x61, 0xC0, 0x38, 0x48,
  0x84, 0x80, 0x40, 0x63, 0x94, 0x8C, 0x84, 0x8A, 0x73, 0xF0, 0x34, 0x88,
  0x88, 0x88, 0x88, 0x88, 0x43, 0x84, 0x22, 0x11, 0x11, 0x11, 0x22, 0x48,
  0x10, 0x10, 0x10, 0xD7, 0x38, 0x28, 0x44, 0x42, 0x10, 0x10, 0x10, 0x10,
  0xFF, 0x10, 0x10, 0x10, 0x10, 0xF0, 0xF0, 0x80, 0x04, 0x20, 0x82, 0x10,
  0x42, 0x08, 0x41, 0x04, 0x20, 0x82, 0x00, 0x3C, 0x42, 0x82, 0x82, 0x82,
  0x91, 0x82, 0x82, 0x82, 0x42, 0x3C, 0x18, 0x28, 0x48, 0x88, 0x08, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x7F, 0x3C, 0x86, 0x08, 0x10, 0x20, 0x82, 0x08,
  0x20, 0x83, 0xF8, 0x3C, 0x86, 0x08, 0x23, 0x80, 0x80, 0x81, 0x82, 0x88,
  0xE0, 0x04, 0x0C, 0x14, 0x24, 0x24, 0x44, 0x84, 0x84, 0xFF, 0x04, 0x04,
  0x7E, 0x81, 0x04, 0x0B, 0xC8, 0x40, 0x81, 0x82, 0x84, 0xF0, 0x08, 0x60,
  0x82, 0x0B, 0xD8, 0x60, 0xC1, 0x82, 0x84, 0xF0, 0xFF, 0x06, 0x10, 0x20,
  0x81, 0x02, 0x08, 0x10, 0x40, 0x80, 0x3C, 0x42, 0x82, 0x82, 0x42, 0x3C,
  0x46, 0x82, 0x81, 0xC2, 0x3C, 0x3C, 0x86, 0x0C, 0x18, 0x28, 0xCE, 0x82,
  0x04, 0x10, 0xC0, 0x81, 0x81, 0xE0, 0x02, 0x08, 0x61, 0x0C, 0x0C, 0x04,
  0x06, 0x02, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0xC0, 0x40, 0x60, 0x20, 0x86,
  0x10, 0xC0, 0x7A, 0x18, 0x41, 0x08, 0x42, 0x08, 0x00, 0x02, 0x00, 0x3C,
  0x8A, 0x0C, 0xF9, 0x34, 0x68, 0xD1, 0xA3, 0x3E, 0x02, 0x03, 0xC0, 0x10,
  0x28, 0x28, 0x28, 0x44, 0x44, 0x44, 0x7E, 0x82, 0x82, 0x81, 0xFA, 0x18,
  0x61, 0x8B, 0xE8, 0x61, 0x86, 0x1F, 0x80, 0x3C, 0x86, 0x0C, 0x08, 0x10,
  0x20, 0x40, 0x82, 0x84, 0xF0, 0xF9, 0x0A, 0x14, 0x28, 0x50, 0x61, 0x42,
  0x85, 0x0B, 0xE0, 0xFE, 0x08, 0x20, 0x83, 0xF8, 0x20, 0x82, 0x0F, 0xC0,
  0xFE, 0x08, 0x20, 0x83, 0xF8, 0x20, 0x82, 0x08, 0x00, 0x3C, 0x8A, 0x0C,
  0x08, 0x10, 0x23, 0xC1, 0x82, 0x8C, 0xF8, 0x83, 0x06, 0x0C, 0x18, 0x3F,
  0xE0, 0xC1, 0x83, 0x06, 0x08, 0xFE, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x23, 0xF8, 0x7C, 0x10, 0x41, 0x04, 0x10, 0x41, 0x85, 0x13, 0x80,
  0x87, 0x12, 0x24, 0x8A, 0x1C, 0x24, 0x44, 0x89, 0x0A, 0x08, 0x82, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x0F, 0xC0, 0x83, 0x8F, 0x1D, 0x3A, 0xB5,
  0x64, 0xC9, 0x83, 0x06, 0x08, 0xC3, 0x86, 0x8D, 0x19, 0x32, 0x62, 0xC5,
  0x87, 0x0E, 0x08, 0x3C, 0x42, 0x82, 0x82, 0x82, 0x81, 0x82, 0x82, 0x82,
  0x42, 0x3C, 0xFA, 0x18, 0x61, 0x86, 0x1F, 0xA0, 0x82, 0x08, 0x00, 0x3C,
  0x42, 0x82, 0x82, 0x82, 0x81, 0x82, 0x82, 0x82, 0x42, 0x3C, 0x10, 0x10,
  0x0E, 0xFA, 0x18, 0x61, 0x86, 0x1F, 0xA4, 0x92, 0x28, 0x40, 0x3C, 0x42,
  0x80, 0x80, 0x40, 0x3C, 0x02, 0x02, 0x83, 0x42, 0x3C, 0xFF, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x82, 0x84, 0xF0, 0x81, 0x82, 0x82, 0x42, 0x44, 0x44,
  0x24, 0x28, 0x28, 0x28, 0x10, 0x81, 0x81, 0x81, 0x92, 0x9A, 0xAA, 0xAA,
  0xAA, 0xC6, 0xC6, 0x42, 0x83, 0x42, 0x44, 0x28, 0x18, 0x10, 0x28, 0x24,
  0x44, 0x82, 0x81, 0x80, 0xA0, 0x88, 0x44, 0x41, 0x40, 0xA0, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x00, 0xFE, 0x02, 0x04, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x40, 0x80, 0xFF, 0xF8, 0x88, 0x88, 0x88, 0x88, 0x88, 0x8F, 0x82, 0x08,
  0x10, 0x41, 0x02, 0x08, 0x10, 0x40, 0x82, 0x08, 0x10, 0xF1, 0x11, 0x11,
  0x11, 0x11, 0x11, 0x1F, 0x10, 0x28, 0x24, 0x44, 0x82, 0x83, 0xFF, 0x94,
  0x78, 0x84, 0x04, 0x7C, 0x84, 0x84, 0x8C, 0x7B, 0x82, 0x08, 0x20, 0xFA,
  0x18, 0x61, 0x86, 0x18, 0x7E, 0x7A, 0x18, 0x60, 0x82, 0x18, 0x5E, 0x02,
  0x04, 0x08, 0x13, 0xA8, 0xE0, 0xC1, 0x83, 0x05, 0x19, 0xD0, 0x3C, 0x86,
  0x0F, 0xF8, 0x10, 0x10, 0x9E, 0x0F, 0x10, 0x10, 0x10, 0xFF, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x10, 0xFE, 0x03, 0x3C, 0x44, 0x42, 0x42, 0x44, 0x7C,
  0x40, 0x7E, 0x81, 0x81, 0x7E, 0x82, 0x08, 0x20, 0xFA, 0x18, 0x61, 0x86,
  0x18, 0x61, 0x10, 0x00, 0x07, 0x81, 0x02, 0x04, 0x08, 0x10, 0x23, 0xF8,
  0x08, 0x01, 0xF0, 0x84, 0x21, 0x08, 0x42, 0x10, 0xFC, 0x81, 0x02, 0x04,
  0x08, 0x71, 0x24, 0x70, 0x91, 0x12, 0x14, 0x10, 0xF0, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x47, 0xF0, 0xE6, 0x9A, 0x91, 0x91, 0x91,
  0x91, 0x91, 0x91, 0xFA, 0x18, 0x61, 0x86, 0x18, 0x61, 0x3C, 0x86, 0x0C,
  0x18, 0x30, 0x50, 0x9E, 0xFA, 0x18, 0x61, 0x86, 0x18, 0x7E, 0x82, 0x08,
  0x00, 0x3A, 0x8E, 0x0C, 0x18, 0x30, 0x51, 0x9D, 0x02, 0x04, 0x08, 0xF7,
  0x18, 0x10, 0x10, 0x10, 0x10, 0x10, 0xFE, 0x3C, 0x86, 0x03, 0xC0, 0x60,
  0x70, 0x9E, 0x20, 0x40, 0x87, 0xF2, 0x04, 0x08, 0x10, 0x20, 0x40, 0x78,
  0x86, 0x18, 0x61, 0x86, 0x18, 0xDD, 0x82, 0x85, 0x12, 0x22, 0x85, 0x0A,
  0x08, 0x91, 0x99, 0xA9, 0xAA, 0xAA, 0xA6, 0xC6, 0x42, 0x82, 0x88, 0xA0,
  0x81, 0x85, 0x11, 0x41, 0x83, 0x05, 0x12, 0x22, 0x85, 0x06, 0x08, 0x10,
  0x43, 0x80, 0xFC, 0x21, 0x04, 0x21, 0x08, 0x3F, 0x3C, 0x82, 0x08, 0x10,
  0x4E, 0x0C, 0x10, 0x82, 0x08, 0x20, 0xF0, 0xFF, 0xFC, 0xE0, 0x82, 0x08,
  0x41, 0x03, 0xC8, 0x40, 0x82, 0x08, 0x23, 0x80, 0x61, 0x92, 0x8E,
};

const GFXglyph IBMPlexMono_ExtraLight16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 1, 11, 10, 4, -11 },
  { 3, 3, 4, 10, 3, -12 },
  { 5, 9, 11, 10, 0, -11 },
  { 18, 8, 15, 10, 1, -13 },
  { 33, 9, 11, 10, 0, -11 },
  { 46, 8, 11, 10, 1, -11 },
  { 57, 1, 4, 10, 4, -12 },
  { 58, 4, 14, 10, 4, -12 },
  { 65, 4, 14, 10, 2, -12 },
  { 72, 8, 8, 10, 1, -9 },
  { 80, 8, 9, 10, 1, -9 },
  { 89, 1, 4, 10, 4, -1 },
  { 90, 4, 1, 10, 3, -5 },
  { 91, 1, 1, 10, 4, -1 },
  { 92, 6, 14, 10, 2, -12 },
  { 103, 8, 11, 10, 1, -11 },
  { 114, 8, 11, 10, 1, -11 },
  { 125, 7, 11, 10, 1, -11 },
  { 135, 7, 11, 10, 1, -11 },
  { 145, 8, 11, 10, 1, -11 },
  { 156, 7, 11, 10, 1, -11 },
  { 166, 7, 11, 10, 1, -11 },
  { 176, 7, 11, 10, 1, -11 },
  { 186, 8, 11, 10, 1, -11 },
  { 197, 7, 11, 10, 1, -11 },
  { 207, 1, 8, 10, 4, -8 },
  { 208, 1, 11, 10, 4, -8 },
  { 210, 7, 9, 10, 1, -9 },
  { 218, 8, 4, 10, 1, -7 },
  { 222, 7, 9, 10, 1, -9 },
  { 230, 6, 11, 10, 2, -11 },
  { 239, 7, 13, 10, 1, -11 },
  { 251, 8, 11, 10, 1, -11 },
  { 262, 6, 11, 10, 2, -11 },
  { 271, 7, 11, 10, 1, -11 },
  { 281, 7, 11, 10, 2, -11 },
  { 291, 6, 11, 10, 2, -11 },
  { 300, 6, 11, 10, 2, -11 },
  { 309, 7, 11, 10, 1, -11 },
  { 319, 7, 11, 10, 1, -11 },
  { 329, 7, 11, 10, 1, -11 },
  { 339, 6, 11, 10, 1, -11 },
  { 348, 7, 11, 10, 2, -11 },
  { 358, 6, 11, 10, 2, -11 },
  { 367, 7, 11, 10, 1, -11 },
  { 377, 7, 11, 10, 1, -11 },
  { 387, 8, 11, 10, 1, -11 },
  { 398, 6, 11, 10, 2, -11 },
  { 407, 8, 14, 10, 1, -11 },
  { 421, 6, 11, 10, 2, -11 },
  { 430, 8, 11, 10, 1, -11 },
  { 441, 8, 11, 10, 1, -11 },
  { 452, 7, 11, 10, 1, -11 },
  { 462, 8, 11, 10, 1, -11 },
  { 473, 8, 11, 10, 1, -11 },
  { 484, 8, 11, 10, 1, -11 },
  { 495, 9, 11, 10, 0, -11 },
  { 508, 8, 11, 10, 1, -11 },
  { 519, 4, 14, 10, 4, -12 },
  { 526, 6, 14, 10, 2, -12 },
  { 537, 4, 14, 10, 2, -12 },
  { 544, 8, 6, 10, 1, -11 },
  { 550, 8, 1, 10, 1, 2 },
  { 551, 2, 3, 10, 3, -13 },
  { 552, 8, 8, 10, 1, -8 },
  { 560, 6, 12, 10, 2, -12 },
  { 569, 6, 8, 10, 2, -8 },
  { 575, 7, 12, 10, 1, -12 },
  { 586, 7, 8, 10, 1, -8 },
  { 593, 8, 12, 10, 1, -12 },
  { 605, 8, 12, 10, 1, -9 },
  { 617, 6, 12, 10, 2, -12 },
  { 626, 7, 11, 10, 2, -11 },
  { 636, 5, 14, 10, 2, -11 },
  { 645, 7, 12, 10, 2, -12 },
  { 656, 7, 12, 10, 1, -12 },
  { 667, 8, 8, 10, 1, -8 },
  { 675, 6, 8, 10, 2, -8 },
  { 681, 7, 8, 10, 1, -8 },
  { 688, 6, 11, 10, 2, -8 },
  { 697, 7, 11, 10, 1, -8 },
  { 707, 8, 8, 10, 1, -8 },
  { 715, 7, 8, 10, 1, -8 },
  { 722, 7, 11, 10, 1, -11 },
  { 732, 6, 8, 10, 2, -8 },
  { 738, 7, 8, 10, 1, -8 },
  { 745, 8, 8, 10, 1, -8 },
  { 753, 7, 8, 10, 1, -8 },
  { 760, 7, 11, 10, 1, -8 },
  { 770, 6, 8, 10, 2, -8 },
  { 776, 6, 14, 10, 2, -12 },
  { 787, 1, 14, 10, 4, -12 },
  { 789, 6, 14, 10, 2, -12 },
  { 800, 8, 3, 10, 1, -7 },
};

const GFXfont IBMPlexMono_ExtraLight16pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLight16pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLight16pt7bGlyphs,
  0x20, 0x7E, 21
};

#endif // _IBMPLEXMONO_EXTRALIGHT16PT7B_H_
