#ifndef _IBMPLEXMONO_EXTRALIGHT8PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHT8PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLight.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLight8pt7bBitmaps[] PROGMEM = {
  0x00, 0xF4, 0xC0, 0x52, 0xB6, 0xCF, 0x50, 0x6B, 0xA7, 0x3B, 0x60, 0x4E,
  0xB8, 0x2E, 0xD8, 0x68, 0x8D, 0xBF, 0xC0, 0xEA, 0xAC, 0x95, 0x58, 0x2F,
  0x69, 0x2F, 0x22, 0xC0, 0xC0, 0x80, 0x29, 0x29, 0x20, 0x56, 0xFB, 0xC0,
  0x59, 0x25, 0xC0, 0x54, 0xA9, 0xC0, 0xC4, 0xF3, 0xC0, 0x13, 0x59, 0x97,
  0xF2, 0x33, 0xC0, 0x52, 0x7B, 0xC0, 0xF5, 0x29, 0x00, 0xD6, 0xFB, 0xC0,
  0x56, 0xF2, 0x80, 0x90, 0x98, 0x2A, 0x22, 0xF0, 0x88, 0xA8, 0x54, 0xE8,
  0x80, 0x57, 0xDB, 0xB8, 0x26, 0x69, 0xF9, 0xD6, 0xFB, 0xC0, 0x56, 0x49,
  0xC0, 0xD6, 0xDB, 0xC0, 0xF2, 0x79, 0xC0, 0xF2, 0x79, 0x00, 0x56, 0x7B,
  0xC0, 0xB6, 0xFB, 0x40, 0xE9, 0x25, 0xC0, 0xE4, 0x93, 0x80, 0xBB, 0x6D,
  0x40, 0x92, 0x49, 0xC0, 0xB7, 0xFB, 0x40, 0xB6, 0xFF, 0x40, 0x56, 0xDB,
  0xC0, 0xD6, 0xE9, 0x00, 0x56, 0xDB, 0x58, 0xD6, 0xED, 0x40, 0x69, 0x87,
  0x1F, 0xF9, 0x08, 0x42, 0x10, 0xB6, 0xDB, 0xC0, 0x99, 0x96, 0x62, 0x99,
  0xBF, 0xF5, 0x99, 0x62, 0x69, 0x8C, 0x98, 0x42, 0x10, 0x71, 0x24, 0x4F,
  0xEA, 0xAC, 0x92, 0x24, 0x88, 0xD5, 0x5C, 0x26, 0x90, 0xF0, 0x80, 0xE7,
  0xF0, 0x93, 0xDB, 0xC0, 0xF2, 0x70, 0x27, 0xDB, 0xC0, 0xF7, 0x70, 0x6B,
  0xA5, 0xC0, 0x3E, 0xA9, 0xF8, 0x93, 0xDB, 0x40, 0x43, 0x25, 0xC0, 0x23,
  0x24, 0x96, 0x88, 0xAC, 0xCB, 0xC9, 0x25, 0xC0, 0xFF, 0xF0, 0xF6, 0xD0,
  0xF6, 0xF0, 0xF6, 0xDD, 0x00, 0xF6, 0xF2, 0x40, 0xF2, 0x70, 0xF1, 0xF0,
  0x44, 0xF4, 0x47, 0xB6, 0xF0, 0xB7, 0x60, 0xFF, 0xBC, 0xE0, 0xBB, 0x50,
  0xB7, 0x29, 0x00, 0xEA, 0x70, 0xF1, 0x45, 0x38, 0xFE, 0xCA, 0x3C, 0xB0,
  0xF0,
};

const GFXglyph IBMPlexMono_ExtraLight8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 1, 6, 5, 2, -6 },
  { 2, 1, 2, 5, 2, -6 },
  { 3, 5, 6, 5, 0, -6 },
  { 7, 4, 7, 5, 0, -6 },
  { 11, 5, 6, 5, 0, -6 },
  { 15, 4, 6, 5, 0, -6 },
  { 18, 1, 2, 5, 2, -6 },
  { 19, 2, 7, 5, 2, -6 },
  { 21, 2, 7, 5, 1, -6 },
  { 23, 4, 4, 5, 0, -4 },
  { 25, 4, 4, 5, 0, -4 },
  { 27, 1, 2, 5, 2, -1 },
  { 28, 2, 1, 5, 1, -3 },
  { 29, 1, 1, 5, 2, -1 },
  { 30, 3, 7, 5, 1, -6 },
  { 33, 3, 6, 5, 1, -6 },
  { 36, 3, 6, 5, 1, -6 },
  { 39, 3, 6, 5, 1, -6 },
  { 42, 3, 6, 5, 1, -6 },
  { 45, 4, 6, 5, 0, -6 },
  { 48, 3, 6, 5, 1, -6 },
  { 51, 3, 6, 5, 1, -6 },
  { 54, 3, 6, 5, 1, -6 },
  { 57, 3, 6, 5, 1, -6 },
  { 60, 3, 6, 5, 1, -6 },
  { 63, 1, 4, 5, 2, -4 },
  { 64, 1, 5, 5, 2, -4 },
  { 65, 3, 5, 5, 1, -5 },
  { 67, 4, 1, 5, 0, -3 },
  { 68, 3, 5, 5, 1, -5 },
  { 70, 3, 6, 5, 1, -6 },
  { 73, 3, 7, 5, 1, -6 },
  { 76, 4, 6, 5, 0, -6 },
  { 79, 3, 6, 5, 1, -6 },
  { 82, 3, 6, 5, 1, -6 },
  { 85, 3, 6, 5, 1, -6 },
  { 88, 3, 6, 5, 1, -6 },
  { 91, 3, 6, 5, 1, -6 },
  { 94, 3, 6, 5, 1, -6 },
  { 97, 3, 6, 5, 1, -6 },
  { 100, 3, 6, 5, 1, -6 },
  { 103, 3, 6, 5, 1, -6 },
  { 106, 3, 6, 5, 1, -6 },
  { 109, 3, 6, 5, 1, -6 },
  { 112, 3, 6, 5, 1, -6 },
  { 115, 3, 6, 5, 1, -6 },
  { 118, 3, 6, 5, 1, -6 },
  { 121, 3, 6, 5, 1, -6 },
  { 124, 3, 7, 5, 1, -6 },
  { 127, 3, 6, 5, 1, -6 },
  { 130, 4, 6, 5, 0, -6 },
  { 133, 5, 6, 5, 0, -6 },
  { 137, 3, 6, 5, 1, -6 },
  { 140, 4, 6, 5, 0, -6 },
  { 143, 4, 6, 5, 0, -6 },
  { 146, 4, 6, 5, 0, -6 },
  { 149, 5, 6, 5, 0, -6 },
  { 153, 4, 6, 5, 0, -6 },
  { 156, 2, 7, 5, 2, -6 },
  { 158, 3, 7, 5, 1, -6 },
  { 161, 2, 7, 5, 1, -6 },
  { 163, 4, 3, 5, 0, -6 },
  { 165, 4, 1, 5, 0, 1 },
  { 166, 1, 1, 5, 2, -6 },
  { 167, 3, 4, 5, 1, -4 },
  { 169, 3, 6, 5, 1, -6 },
  { 172, 3, 4, 5, 1, -4 },
  { 174, 3, 6, 5, 1, -6 },
  { 177, 3, 4, 5, 1, -4 },
  { 179, 3, 6, 5, 1, -6 },
  { 182, 3, 7, 5, 1, -5 },
  { 185, 3, 6, 5, 1, -6 },
  { 188, 3, 6, 5, 1, -6 },
  { 191, 3, 8, 5, 1, -6 },
  { 194, 4, 6, 5, 1, -6 },
  { 197, 3, 6, 5, 1, -6 },
  { 200, 3, 4, 5, 1, -4 },
  { 202, 3, 4, 5, 1, -4 },
  { 204, 3, 4, 5, 1, -4 },
  { 206, 3, 6, 5, 1, -4 },
  { 209, 3, 6, 5, 1, -4 },
  { 212, 3, 4, 5, 1, -4 },
  { 214, 3, 4, 5, 1, -4 },
  { 216, 4, 6, 5, 0, -6 },
  { 219, 3, 4, 5, 1, -4 },
  { 221, 3, 4, 5, 1, -4 },
  { 223, 5, 4, 5, 0, -4 },
  { 226, 3, 4, 5, 1, -4 },
  { 228, 3, 6, 5, 1, -4 },
  { 231, 3, 4, 5, 1, -4 },
  { 233, 3, 7, 5, 1, -6 },
  { 236, 1, 7, 5, 2, -6 },
  { 237, 3, 7, 5, 1, -6 },
  { 240, 4, 1, 5, 0, -3 },
};

const GFXfont IBMPlexMono_ExtraLight8pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLight8pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLight8pt7bGlyphs,
  0x20, 0x7E, 10
};

#endif // _IBMPLEXMONO_EXTRALIGHT8PT7B_H_
