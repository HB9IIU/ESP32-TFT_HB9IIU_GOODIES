#ifndef _IBMPLEXMONO_EXTRALIGHT29PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHT29PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLight.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLight29pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x92, 0x49, 0x24, 0x80, 0x01, 0xF0, 0x8C, 0x63, 0x18,
  0xC6, 0x20, 0x02, 0x18, 0x02, 0x10, 0x02, 0x10, 0x02, 0x10, 0x02, 0x10,
  0x04, 0x10, 0x04, 0x20, 0x7C, 0x3F, 0x04, 0x20, 0x04, 0x20, 0x04, 0x20,
  0x08, 0x40, 0xF8, 0x7E, 0x08, 0x40, 0x08, 0x40, 0x08, 0x40, 0x10, 0x40,
  0x10, 0x80, 0x10, 0x80, 0x10, 0x80, 0x02, 0x00, 0x10, 0x00, 0x80, 0x1F,
  0x83, 0x23, 0x21, 0x0F, 0x08, 0x30, 0x40, 0x82, 0x02, 0x10, 0x10, 0x80,
  0x64, 0x01, 0xF0, 0x01, 0x70, 0x08, 0x40, 0x41, 0x02, 0x08, 0x10, 0x40,
  0x83, 0x04, 0x14, 0x21, 0x99, 0x18, 0x3F, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x3C, 0x03, 0x42, 0x02, 0x81, 0x04, 0x81, 0x04, 0x81, 0x08, 0x81,
  0x10, 0x81, 0x10, 0x81, 0x20, 0x42, 0x20, 0x3C, 0x00, 0x00, 0x78, 0x04,
  0xC6, 0x08, 0x82, 0x11, 0x02, 0x11, 0x02, 0x21, 0x03, 0x21, 0x02, 0x40,
  0x82, 0x40, 0xC6, 0x80, 0x78, 0x0F, 0x80, 0x30, 0x80, 0xC0, 0x81, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x38, 0x1C,
  0x98, 0x22, 0x18, 0x8C, 0x19, 0x10, 0x12, 0x20, 0x14, 0x40, 0x18, 0x80,
  0x30, 0x80, 0x51, 0x83, 0x30, 0xF8, 0x30, 0xFE, 0x06, 0x10, 0x41, 0x02,
  0x08, 0x10, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x02, 0x04, 0x04, 0x08, 0x08, 0x08, 0x0C, 0x80, 0x80, 0x80, 0x80, 0x81,
  0x01, 0x02, 0x04, 0x08, 0x08, 0x10, 0x20, 0x40, 0x81, 0x04, 0x08, 0x10,
  0x20, 0x81, 0x04, 0x10, 0x41, 0x00, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x18, 0x20, 0xCF, 0x4E, 0x03, 0xE0, 0x03, 0x80, 0x05,
  0x80, 0x11, 0x00, 0x41, 0x00, 0x81, 0x02, 0x03, 0x00, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x3F, 0xFF, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x32, 0x26, 0x44, 0x4C, 0xFF, 0x7C, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20,
  0x04, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40,
  0x10, 0x02, 0x00, 0x80, 0x10, 0x00, 0x0F, 0x81, 0x83, 0x08, 0x0C, 0x80,
  0x24, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x18, 0x60, 0xC3,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x28, 0x01, 0x40, 0x11, 0x01, 0x8C,
  0x18, 0x1F, 0x00, 0x03, 0x00, 0x14, 0x01, 0x90, 0x0C, 0x40, 0x61, 0x03,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x1F, 0xFF, 0x0F, 0x81, 0x83, 0x18, 0x0C, 0x80, 0x28, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x00, 0x10, 0x01, 0x80, 0x18, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0xFF, 0xF0, 0x0F,
  0x83, 0x06, 0x40, 0x24, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x02, 0x00,
  0x41, 0xF8, 0x00, 0xE0, 0x03, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x80,
  0x1C, 0x03, 0x60, 0x61, 0xF8, 0x00, 0x30, 0x00, 0xA0, 0x01, 0x40, 0x04,
  0x80, 0x11, 0x00, 0x22, 0x00, 0x84, 0x02, 0x08, 0x04, 0x10, 0x10, 0x20,
  0x40, 0x40, 0x80, 0x82, 0x01, 0x08, 0x02, 0x10, 0x04, 0x7F, 0xFF, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x3F, 0xF1, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x4F, 0xC2, 0x83, 0x18,
  0x04, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x80, 0x12, 0x00,
  0x8C, 0x18, 0x1F, 0x00, 0x01, 0xC0, 0x18, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x18, 0x00, 0x80, 0x0C, 0x00, 0x4F, 0xC2, 0x83, 0x18, 0x05, 0x80, 0x3C,
  0x00, 0xC0, 0x06, 0x00, 0x28, 0x01, 0x40, 0x1B, 0x00, 0x8C, 0x18, 0x1F,
  0x00, 0xFF, 0xFC, 0x00, 0x60, 0x05, 0x00, 0x28, 0x02, 0x00, 0x10, 0x01,
  0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x01, 0x00,
  0x08, 0x00, 0x80, 0x04, 0x00, 0x60, 0x02, 0x00, 0x30, 0x00, 0x0F, 0xC1,
  0x83, 0x18, 0x04, 0x80, 0x34, 0x00, 0xA0, 0x05, 0x00, 0x6C, 0x02, 0x30,
  0x60, 0x7C, 0x0C, 0x18, 0x80, 0x28, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0A, 0x00, 0xCC, 0x0C, 0x1F, 0x80, 0x0F, 0x81, 0x83, 0x18, 0x04,
  0x80, 0x34, 0x00, 0xE0, 0x07, 0x00, 0x28, 0x01, 0x40, 0x1B, 0x00, 0xCC,
  0x1A, 0x1F, 0x20, 0x01, 0x00, 0x18, 0x00, 0x80, 0x08, 0x00, 0xC0, 0x0C,
  0x00, 0x80, 0x18, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x37, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x32, 0x26, 0x44, 0x4C, 0x00, 0x08, 0x01, 0x80,
  0x18, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x08, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x18,
  0x01, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x10, 0x00, 0x1F,
  0x82, 0x0C, 0x40, 0x28, 0x02, 0x80, 0x20, 0x03, 0x00, 0x20, 0x02, 0x00,
  0x40, 0x78, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0xC0, 0x0F, 0x80, 0xC3, 0x08, 0x0C, 0x40, 0x24,
  0x01, 0x20, 0x09, 0x0F, 0x48, 0xC5, 0x44, 0x1A, 0x20, 0x62, 0x03, 0x10,
  0x18, 0x80, 0xC4, 0x05, 0x10, 0x68, 0x85, 0x43, 0xEA, 0x00, 0x10, 0x00,
  0x40, 0x02, 0x00, 0x0C, 0x00, 0x3F, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0A,
  0x00, 0x12, 0x00, 0x64, 0x00, 0x88, 0x01, 0x18, 0x02, 0x10, 0x08, 0x20,
  0x10, 0x60, 0x20, 0x40, 0x80, 0x81, 0x01, 0x83, 0xFF, 0x08, 0x02, 0x10,
  0x06, 0x20, 0x04, 0x80, 0x09, 0x00, 0x1E, 0x00, 0x10, 0xFF, 0x88, 0x0C,
  0x80, 0x28, 0x02, 0x80, 0x28, 0x02, 0x80, 0x28, 0x02, 0x80, 0xCF, 0xF8,
  0x80, 0x68, 0x02, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x02,
  0x80, 0x6F, 0xF8, 0x07, 0xC0, 0xC1, 0x08, 0x04, 0xC0, 0x14, 0x00, 0xA0,
  0x03, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x60, 0x01, 0x00, 0x08, 0x02, 0x60, 0x09, 0x00, 0x86, 0x08, 0x0F, 0x80,
  0xFF, 0x08, 0x0C, 0x80, 0x68, 0x02, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x28, 0x06, 0x80, 0xCF, 0xF0, 0xFF, 0xF8, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x0F, 0xFF, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x0F, 0xFF,
  0xFF, 0xF8, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x0F, 0xFE, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x0F, 0xC0, 0x83, 0x08, 0x04, 0x80,
  0x24, 0x01, 0xE0, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x03, 0xF8, 0x00, 0xC0, 0x07, 0x00, 0x28, 0x01, 0x40, 0x19, 0x00, 0xC6,
  0x1A, 0x1F, 0x10, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x1F, 0xFF, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0xFF, 0xF0, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x0F, 0xFF, 0x7F, 0xE0, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x02, 0x80, 0x50, 0x09, 0x86, 0x1F, 0x80, 0x80, 0x1C, 0x01, 0xA0, 0x19,
  0x00, 0x88, 0x08, 0x40, 0x82, 0x08, 0x10, 0x80, 0x88, 0x04, 0xA0, 0x2C,
  0x81, 0xC4, 0x0C, 0x10, 0x40, 0x42, 0x02, 0x10, 0x08, 0x80, 0x24, 0x01,
  0x20, 0x05, 0x00, 0x10, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x7F, 0xF0, 0xC0, 0x1F, 0x00, 0xE8,
  0x0B, 0x40, 0x59, 0x04, 0xC8, 0x26, 0x21, 0x31, 0x11, 0x84, 0x8C, 0x28,
  0x60, 0xC3, 0x04, 0x18, 0x20, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x10, 0x80, 0x1C, 0x01, 0xC0, 0x1A, 0x01, 0xB0,
  0x19, 0x01, 0x98, 0x18, 0x81, 0x8C, 0x18, 0x41, 0x86, 0x18, 0x21, 0x83,
  0x18, 0x11, 0x81, 0x98, 0x09, 0x80, 0xD8, 0x05, 0x80, 0x78, 0x03, 0x0F,
  0x81, 0x83, 0x08, 0x0C, 0x80, 0x24, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x28,
  0x01, 0x40, 0x11, 0x01, 0x8C, 0x18, 0x1F, 0x00, 0xFF, 0xC8, 0x06, 0x80,
  0x38, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x06, 0xFF,
  0xC8, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x0F, 0x81, 0x83, 0x08, 0x0C, 0x80, 0x24, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x28, 0x01, 0x40, 0x11, 0x01, 0x8C, 0x18, 0x1F, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x7E, 0xFF, 0xC8, 0x06, 0x80, 0x38, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x06, 0xFF, 0xC8, 0x20, 0x83,
  0x08, 0x10, 0x80, 0x88, 0x08, 0x80, 0x48, 0x06, 0x80, 0x28, 0x01, 0x1F,
  0xC1, 0x81, 0x90, 0x07, 0x80, 0x28, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00,
  0x30, 0x00, 0xF8, 0x00, 0x38, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x80, 0x0A, 0x00, 0xCC, 0x0C, 0x1F, 0x80, 0xFF, 0xFE, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x38, 0x02, 0x80, 0x24,
  0x02, 0x60, 0xC1, 0xF8, 0xC0, 0x02, 0x80, 0x09, 0x00, 0x11, 0x00, 0x22,
  0x00, 0xC4, 0x01, 0x04, 0x02, 0x08, 0x0C, 0x10, 0x10, 0x10, 0x20, 0x20,
  0xC0, 0x41, 0x00, 0x42, 0x00, 0x8C, 0x01, 0x10, 0x03, 0x20, 0x02, 0x40,
  0x05, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x0A, 0x00, 0x28, 0x20, 0xA0, 0xC2, 0x85, 0x0A, 0x14, 0x28,
  0x48, 0x92, 0x22, 0x48, 0x89, 0x22, 0x24, 0x84, 0x94, 0x14, 0x50, 0x51,
  0x40, 0xC5, 0x03, 0x18, 0x0C, 0x40, 0x06, 0x40, 0x08, 0x80, 0x20, 0x80,
  0xC0, 0x81, 0x01, 0x04, 0x01, 0x18, 0x01, 0x20, 0x02, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x16, 0x00, 0x44, 0x00, 0x84, 0x02, 0x0C, 0x08, 0x08, 0x10,
  0x08, 0x40, 0x19, 0x00, 0x16, 0x00, 0x10, 0x80, 0x03, 0x40, 0x02, 0x40,
  0x04, 0x20, 0x0C, 0x30, 0x08, 0x10, 0x10, 0x08, 0x10, 0x0C, 0x20, 0x04,
  0x40, 0x02, 0x40, 0x02, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x7F,
  0xFC, 0x00, 0x08, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x04, 0x00, 0x18,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x07, 0xFF,
  0xF0, 0xFF, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0xFF, 0x80, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04,
  0x00, 0x80, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x08, 0x00, 0x80,
  0x10, 0x01, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x20, 0x04, 0xFE, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x03, 0xFC, 0x03, 0x00, 0x14, 0x00, 0x48, 0x02, 0x20, 0x18, 0x40, 0x41,
  0x82, 0x02, 0x08, 0x04, 0x40, 0x11, 0x00, 0x28, 0x00, 0xC0, 0xFF, 0xFC,
  0x8C, 0x42, 0x10, 0x1F, 0x80, 0x83, 0x04, 0x06, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x07, 0xF8, 0x60, 0x23, 0x00, 0x88, 0x02, 0x20, 0x08,
  0xC0, 0x61, 0x82, 0x83, 0xF3, 0xC0, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x8F, 0x8B, 0x0C, 0xC0, 0x2C, 0x03, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x1C, 0x03, 0xC0, 0x2B, 0x0C,
  0x8F, 0x80, 0x0F, 0x83, 0x04, 0x60, 0x24, 0x02, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x04, 0x01, 0x40, 0x23, 0x04, 0x0F,
  0x80, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x0F, 0x93,
  0x05, 0x60, 0x34, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0xC0, 0x14, 0x01, 0x60, 0x33, 0x05, 0x0F, 0x90, 0x0F, 0x80, 0x83,
  0x08, 0x0C, 0x80, 0x24, 0x00, 0xA0, 0x05, 0x00, 0x3F, 0xFF, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x12, 0x01, 0x08, 0x30, 0x3F, 0x00, 0x03, 0xFC,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x0F, 0xFF, 0xC0, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x7F, 0xF8, 0x00,
  0x3C, 0x3E, 0x81, 0x06, 0x08, 0x08, 0x20, 0x10, 0x80, 0x42, 0x01, 0x08,
  0x04, 0x20, 0x20, 0x41, 0x80, 0xF8, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x01,
  0xFF, 0x08, 0x02, 0x40, 0x05, 0x00, 0x1C, 0x00, 0x50, 0x02, 0x60, 0x18,
  0x7F, 0x80, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x33, 0xE7,
  0x86, 0xC0, 0x78, 0x06, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x02, 0x03, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x0F, 0xFF, 0x80, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x2F, 0xF8, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x38, 0x04, 0x81, 0x88, 0x30, 0x86, 0x08, 0x80, 0x98, 0x0A,
  0x40, 0xC2, 0x08, 0x10, 0x81, 0x88, 0x0C, 0x80, 0x48, 0x02, 0x80, 0x10,
  0xFC, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0xFF, 0xF0, 0xBC, 0x76, 0x3C, 0x60,
  0xC3, 0x04, 0x18, 0x20, 0xC1, 0x06, 0x08, 0x30, 0x41, 0x82, 0x0C, 0x10,
  0x60, 0x83, 0x04, 0x18, 0x20, 0xC1, 0x06, 0x08, 0x20, 0xCF, 0x9E, 0x1B,
  0x01, 0xE0, 0x18, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x08, 0x0F, 0x81, 0x83, 0x08, 0x0C, 0x80,
  0x24, 0x00, 0xA0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0A, 0x00, 0x50, 0x02,
  0x80, 0x22, 0x03, 0x18, 0x30, 0x3E, 0x00, 0x8F, 0x8B, 0x0C, 0xC0, 0x2C,
  0x03, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x1C,
  0x03, 0xC0, 0x2B, 0x0C, 0x8F, 0x88, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x00, 0x0F, 0x93, 0x05, 0x60, 0x34, 0x01, 0xC0, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0xC0, 0x14, 0x01, 0x60, 0x33, 0x05,
  0x0F, 0x90, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0xFC,
  0x7C, 0x12, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x0F,
  0xFF, 0x80, 0x0F, 0xC1, 0x81, 0x98, 0x06, 0x80, 0x04, 0x00, 0x30, 0x00,
  0xE0, 0x00, 0xFC, 0x00, 0x30, 0x00, 0x40, 0x02, 0x00, 0x1C, 0x01, 0x98,
  0x18, 0x3F, 0x00, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x03,
  0xFF, 0xF0, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0xFF, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xE0, 0x14, 0x06, 0xC1, 0x47, 0xC8, 0xC0,
  0x0A, 0x00, 0x90, 0x04, 0x40, 0x22, 0x02, 0x08, 0x10, 0x41, 0x82, 0x08,
  0x08, 0x40, 0x44, 0x02, 0x20, 0x09, 0x00, 0x50, 0x02, 0x80, 0x0C, 0x00,
  0x81, 0x03, 0x03, 0x06, 0x0A, 0x0A, 0x14, 0x14, 0x28, 0x28, 0x48, 0x91,
  0x11, 0x22, 0x22, 0x44, 0x44, 0x48, 0x48, 0xA0, 0xA1, 0x41, 0x42, 0x82,
  0x85, 0x03, 0x04, 0x06, 0x00, 0xC0, 0x19, 0x00, 0x8C, 0x08, 0x20, 0x80,
  0x8C, 0x02, 0x40, 0x1C, 0x00, 0x40, 0x05, 0x00, 0x24, 0x02, 0x30, 0x20,
  0x82, 0x02, 0x30, 0x0B, 0x00, 0x60, 0x80, 0x0A, 0x00, 0x50, 0x04, 0x40,
  0x22, 0x02, 0x18, 0x10, 0x40, 0x82, 0x08, 0x08, 0x40, 0x44, 0x03, 0x20,
  0x0B, 0x00, 0x50, 0x01, 0x80, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x10, 0x07, 0x80, 0x00, 0xFF, 0xE0, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x00, 0xFF, 0xF0, 0x07, 0xE1, 0x00, 0x20, 0x04, 0x00, 0x80, 0x08,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x20, 0x04, 0x03, 0x0F, 0x80, 0x0C, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x40, 0x10, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x00, 0xFC, 0xFF, 0xFF, 0xFF, 0xC0, 0xFE, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0x20, 0x06,
  0x00, 0x3E, 0x1C, 0x02, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x02, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x1F, 0xC0, 0x38, 0x05, 0x10, 0x28,
  0x20, 0xA0, 0x66, 0x80, 0xF0,
};

const GFXglyph IBMPlexMono_ExtraLight29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 3, 20, 17, 7, -20 },
  { 9, 5, 7, 17, 6, -21 },
  { 14, 16, 20, 17, 1, -20 },
  { 54, 13, 26, 17, 2, -23 },
  { 97, 16, 20, 17, 1, -20 },
  { 137, 15, 20, 17, 1, -20 },
  { 175, 1, 7, 17, 8, -21 },
  { 176, 7, 26, 17, 7, -22 },
  { 199, 7, 26, 17, 4, -22 },
  { 222, 15, 14, 17, 1, -16 },
  { 249, 14, 15, 17, 2, -16 },
  { 276, 4, 8, 17, 6, -3 },
  { 280, 8, 1, 17, 5, -9 },
  { 281, 3, 2, 17, 7, -2 },
  { 282, 11, 26, 17, 3, -22 },
  { 318, 13, 20, 17, 2, -20 },
  { 351, 14, 20, 17, 2, -20 },
  { 386, 13, 20, 17, 2, -20 },
  { 419, 12, 20, 17, 2, -20 },
  { 449, 15, 20, 17, 1, -20 },
  { 487, 13, 20, 17, 2, -20 },
  { 520, 13, 20, 17, 2, -20 },
  { 553, 13, 20, 17, 2, -20 },
  { 586, 13, 20, 17, 2, -20 },
  { 619, 13, 20, 17, 2, -20 },
  { 652, 3, 15, 17, 7, -15 },
  { 658, 4, 20, 17, 6, -15 },
  { 668, 13, 16, 17, 2, -17 },
  { 694, 14, 6, 17, 2, -12 },
  { 705, 13, 16, 17, 2, -17 },
  { 731, 12, 20, 17, 3, -20 },
  { 761, 13, 23, 17, 2, -20 },
  { 799, 15, 20, 17, 1, -20 },
  { 837, 12, 20, 17, 3, -20 },
  { 867, 13, 20, 17, 2, -20 },
  { 900, 12, 20, 17, 3, -20 },
  { 930, 12, 20, 17, 3, -20 },
  { 960, 12, 20, 17, 3, -20 },
  { 990, 13, 20, 17, 2, -20 },
  { 1023, 12, 20, 17, 3, -20 },
  { 1053, 12, 20, 17, 3, -20 },
  { 1083, 11, 20, 17, 3, -20 },
  { 1111, 13, 20, 17, 3, -20 },
  { 1144, 11, 20, 17, 4, -20 },
  { 1172, 13, 20, 17, 2, -20 },
  { 1205, 12, 20, 17, 3, -20 },
  { 1235, 13, 20, 17, 2, -20 },
  { 1268, 12, 20, 17, 3, -20 },
  { 1298, 13, 24, 17, 2, -20 },
  { 1337, 12, 20, 17, 3, -20 },
  { 1367, 13, 20, 17, 2, -20 },
  { 1400, 15, 20, 17, 1, -20 },
  { 1438, 12, 20, 17, 3, -20 },
  { 1468, 15, 20, 17, 1, -20 },
  { 1506, 14, 20, 17, 2, -20 },
  { 1541, 15, 20, 17, 1, -20 },
  { 1579, 16, 20, 17, 1, -20 },
  { 1619, 15, 20, 17, 1, -20 },
  { 1657, 8, 26, 17, 7, -22 },
  { 1683, 11, 26, 17, 3, -22 },
  { 1719, 7, 26, 17, 3, -22 },
  { 1742, 14, 11, 17, 2, -20 },
  { 1762, 14, 1, 17, 2, 3 },
  { 1764, 4, 5, 17, 6, -22 },
  { 1767, 14, 15, 17, 2, -15 },
  { 1794, 12, 21, 17, 3, -21 },
  { 1826, 12, 15, 17, 3, -15 },
  { 1849, 12, 21, 17, 2, -21 },
  { 1881, 13, 15, 17, 2, -15 },
  { 1906, 14, 21, 17, 2, -21 },
  { 1943, 14, 22, 17, 2, -16 },
  { 1982, 11, 21, 17, 3, -21 },
  { 2011, 13, 21, 17, 3, -21 },
  { 2046, 10, 27, 17, 3, -21 },
  { 2080, 12, 21, 17, 4, -21 },
  { 2112, 12, 21, 17, 3, -21 },
  { 2144, 13, 15, 17, 2, -15 },
  { 2169, 11, 15, 17, 3, -15 },
  { 2190, 13, 15, 17, 2, -15 },
  { 2215, 12, 21, 17, 3, -15 },
  { 2247, 12, 21, 17, 2, -15 },
  { 2279, 14, 15, 17, 2, -15 },
  { 2306, 13, 15, 17, 2, -15 },
  { 2331, 14, 20, 17, 1, -20 },
  { 2366, 11, 15, 17, 3, -15 },
  { 2387, 13, 15, 17, 2, -15 },
  { 2412, 15, 15, 17, 1, -15 },
  { 2441, 13, 15, 17, 2, -15 },
  { 2466, 13, 21, 17, 2, -15 },
  { 2501, 12, 15, 17, 3, -15 },
  { 2524, 11, 26, 17, 3, -22 },
  { 2560, 1, 26, 17, 8, -22 },
  { 2564, 11, 26, 17, 3, -22 },
  { 2600, 14, 5, 17, 2, -12 },
};

const GFXfont IBMPlexMono_ExtraLight29pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLight29pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLight29pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _IBMPLEXMONO_EXTRALIGHT29PT7B_H_
