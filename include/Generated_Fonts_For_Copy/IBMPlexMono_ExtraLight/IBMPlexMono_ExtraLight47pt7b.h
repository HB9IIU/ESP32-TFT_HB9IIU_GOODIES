#ifndef _IBMPLEXMONO_EXTRALIGHT47PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHT47PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLight.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLight47pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x62, 0x22,
  0x22, 0x00, 0x00, 0x07, 0xFF, 0x70, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1,
  0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0x00, 0x18, 0x18, 0x00, 0x04, 0x06,
  0x00, 0x01, 0x01, 0x80, 0x00, 0xC0, 0x40, 0x00, 0x30, 0x10, 0x00, 0x0C,
  0x0C, 0x00, 0x02, 0x03, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x20, 0x30, 0x00,
  0x18, 0x08, 0x00, 0x06, 0x02, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x40, 0x60,
  0x00, 0x10, 0x18, 0x00, 0x0C, 0x04, 0x00, 0x03, 0x01, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x30, 0x30, 0x00, 0x08, 0x0C, 0x00, 0x02, 0x03, 0x00, 0x00,
  0x80, 0x80, 0x3F, 0xE0, 0x3F, 0xE0, 0x18, 0x18, 0x00, 0x06, 0x06, 0x00,
  0x01, 0x01, 0x80, 0x00, 0x40, 0x60, 0x00, 0x30, 0x10, 0x00, 0x0C, 0x04,
  0x00, 0x03, 0x03, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x20, 0x30, 0x00, 0x08,
  0x08, 0x00, 0x06, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x07, 0xFC, 0x00, 0xE1,
  0x1E, 0x06, 0x04, 0x1C, 0x30, 0x10, 0x18, 0x80, 0x40, 0x36, 0x01, 0x00,
  0x18, 0x04, 0x00, 0x40, 0x10, 0x01, 0x00, 0x40, 0x06, 0x01, 0x00, 0x18,
  0x04, 0x00, 0x60, 0x10, 0x00, 0xC0, 0x40, 0x03, 0x01, 0x00, 0x07, 0x04,
  0x00, 0x07, 0x90, 0x00, 0x03, 0xF0, 0x00, 0x01, 0x78, 0x00, 0x04, 0x18,
  0x00, 0x10, 0x30, 0x00, 0x40, 0x60, 0x01, 0x00, 0x80, 0x04, 0x03, 0x00,
  0x10, 0x0C, 0x00, 0x40, 0x30, 0x01, 0x00, 0xC0, 0x04, 0x03, 0x00, 0x10,
  0x0D, 0x00, 0x40, 0x2C, 0x01, 0x01, 0x9C, 0x04, 0x04, 0x38, 0x10, 0x60,
  0x78, 0x47, 0x00, 0x3F, 0xE0, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x0F, 0xC0, 0x00, 0xC6, 0x18,
  0x00, 0x23, 0x01, 0x00, 0x19, 0x80, 0x60, 0x0C, 0x40, 0x08, 0x02, 0x10,
  0x02, 0x01, 0x84, 0x00, 0xC0, 0x43, 0x00, 0x30, 0x30, 0xC0, 0x0C, 0x18,
  0x10, 0x03, 0x04, 0x04, 0x00, 0x83, 0x01, 0x00, 0x20, 0x80, 0x60, 0x18,
  0x60, 0x0C, 0x04, 0x10, 0x01, 0x86, 0x08, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x03, 0x06, 0x18,
  0x01, 0x83, 0x01, 0x00, 0x41, 0x80, 0x60, 0x30, 0x40, 0x08, 0x08, 0x10,
  0x03, 0x06, 0x04, 0x00, 0xC1, 0x03, 0x00, 0x30, 0xC0, 0xC0, 0x0C, 0x60,
  0x10, 0x03, 0x10, 0x04, 0x00, 0xCC, 0x01, 0x00, 0x22, 0x00, 0x60, 0x19,
  0x80, 0x0C, 0x04, 0x40, 0x01, 0x86, 0x20, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0x07, 0x00, 0x04, 0x01, 0x80, 0x0C, 0x00, 0x80, 0x08, 0x00,
  0xC0, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x0D, 0x80,
  0x00, 0x18, 0xC0, 0x3F, 0x30, 0x60, 0x30, 0x60, 0x30, 0x30, 0x40, 0x10,
  0x30, 0xC0, 0x08, 0x30, 0xC0, 0x04, 0x30, 0xC0, 0x06, 0x20, 0xC0, 0x03,
  0x20, 0xC0, 0x01, 0xA0, 0xC0, 0x00, 0xE0, 0xC0, 0x00, 0x60, 0xC0, 0x00,
  0xB0, 0x40, 0x01, 0x98, 0x60, 0x01, 0x0C, 0x30, 0x02, 0x0C, 0x1C, 0x0C,
  0x06, 0x07, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x10, 0x04, 0x01,
  0x80, 0x60, 0x18, 0x02, 0x00, 0xC0, 0x10, 0x06, 0x00, 0x80, 0x30, 0x06,
  0x00, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x20, 0x04, 0x00, 0xC0,
  0x18, 0x01, 0x00, 0x30, 0x02, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x08, 0x00, 0x80, 0x0C, 0xC0, 0x06, 0x00, 0x60, 0x04, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x02, 0x00, 0x60, 0x04, 0x00,
  0x80, 0x18, 0x03, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80, 0x30,
  0x04, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x60, 0x18, 0x02, 0x00, 0xC0,
  0x30, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0xC0, 0x18, 0x03, 0xF8, 0x18, 0x1F, 0x1F, 0x18, 0xF8,
  0x01, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x66, 0x00, 0x00, 0xC3, 0x00, 0x01, 0x81, 0x80, 0x01, 0x80, 0xC0,
  0x03, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x10,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x39, 0x9C, 0xE6, 0x31, 0x98, 0xC6, 0x21, 0x00,
  0xFF, 0xF0, 0x7F, 0xF7, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00,
  0x20, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x0C, 0x0E, 0x00, 0xC0, 0x0C, 0x06,
  0x00, 0x18, 0x10, 0x00, 0x30, 0xC0, 0x00, 0xC2, 0x00, 0x01, 0x18, 0x00,
  0x06, 0x60, 0x00, 0x19, 0x80, 0x00, 0x24, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x0C, 0x03, 0xC0,
  0x78, 0x0F, 0x00, 0xC0, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xD0, 0x00, 0x03, 0x40, 0x00, 0x09,
  0x80, 0x00, 0x66, 0x00, 0x01, 0x88, 0x00, 0x06, 0x30, 0x00, 0x30, 0x40,
  0x00, 0xC1, 0x80, 0x06, 0x03, 0x00, 0x30, 0x03, 0x03, 0x80, 0x03, 0xF0,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x40, 0x00, 0x19, 0x00, 0x01, 0xC4, 0x00,
  0x0C, 0x10, 0x00, 0x60, 0x40, 0x03, 0x01, 0x00, 0x18, 0x04, 0x00, 0xC0,
  0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x00, 0x00, 0x04, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xF8, 0x00, 0xE0,
  0x38, 0x0E, 0x00, 0x60, 0xC0, 0x01, 0x86, 0x00, 0x0C, 0x60, 0x00, 0x33,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x03,
  0xFC, 0x00, 0xE0, 0x70, 0x18, 0x01, 0x83, 0x00, 0x0C, 0x60, 0x00, 0x62,
  0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x70, 0x03, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x3C,
  0x00, 0x06, 0x60, 0x00, 0x63, 0x00, 0x0C, 0x1E, 0x03, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0x60, 0x00, 0x03, 0x60,
  0x00, 0x06, 0x60, 0x00, 0x04, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x18, 0x60,
  0x00, 0x10, 0x60, 0x00, 0x30, 0x60, 0x00, 0x60, 0x60, 0x00, 0x40, 0x60,
  0x00, 0xC0, 0x60, 0x01, 0x80, 0x60, 0x01, 0x80, 0x60, 0x03, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0C, 0x00, 0x60, 0x18, 0x00, 0x60,
  0x18, 0x00, 0x60, 0x30, 0x00, 0x60, 0x60, 0x00, 0x60, 0x60, 0x00, 0x60,
  0xC0, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x3F, 0xFF, 0xE3, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06,
  0x00, 0x00, 0x61, 0xFC, 0x06, 0x60, 0x70, 0x68, 0x01, 0x87, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x80, 0x00, 0x6C, 0x00, 0x06, 0x60, 0x00, 0xC3, 0x00, 0x18, 0x1C,
  0x07, 0x00, 0x7F, 0x80, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00,
  0x06, 0x1F, 0xC0, 0x66, 0x07, 0x04, 0x80, 0x18, 0xD0, 0x00, 0xCE, 0x00,
  0x06, 0xE0, 0x00, 0x2C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x34,
  0x00, 0x03, 0x60, 0x00, 0x26, 0x00, 0x06, 0x30, 0x00, 0xC1, 0x80, 0x18,
  0x0E, 0x07, 0x00, 0x3F, 0xC0, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x6C, 0x00, 0x03, 0x60, 0x00, 0x1B, 0x00, 0x01, 0x98,
  0x00, 0x0C, 0xC0, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x1C,
  0x0E, 0x00, 0xC0, 0x0E, 0x06, 0x00, 0x08, 0x30, 0x00, 0x30, 0x80, 0x00,
  0x46, 0x00, 0x01, 0x98, 0x00, 0x06, 0x60, 0x00, 0x19, 0x80, 0x00, 0x66,
  0x00, 0x01, 0x88, 0x00, 0x04, 0x30, 0x00, 0x30, 0x60, 0x00, 0x80, 0xC0,
  0x0E, 0x01, 0xC0, 0xE0, 0x01, 0xFE, 0x00, 0x18, 0x07, 0x01, 0x80, 0x06,
  0x0C, 0x00, 0x0C, 0x60, 0x00, 0x19, 0x80, 0x00, 0x2C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xD0, 0x00,
  0x03, 0x60, 0x00, 0x09, 0x80, 0x00, 0x63, 0x00, 0x03, 0x06, 0x00, 0x18,
  0x0E, 0x01, 0xC0, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0xE0, 0x70, 0x18,
  0x01, 0x83, 0x00, 0x0C, 0x60, 0x00, 0x66, 0x00, 0x02, 0x40, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0x60, 0x00, 0x36, 0x00, 0x07, 0x30, 0x00,
  0xB1, 0x80, 0x1B, 0x0E, 0x06, 0x20, 0x3F, 0x86, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x07, 0x80, 0x00, 0x7F, 0xF7, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x70, 0x3B, 0xDE, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0xCE, 0x73, 0x18, 0xCC,
  0x63, 0x10, 0x80, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00,
  0x18, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x08,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0xE0, 0x30, 0x18, 0x01, 0x83, 0x00, 0x0C,
  0x60, 0x00, 0x66, 0x00, 0x06, 0x40, 0x00, 0x28, 0x00, 0x02, 0x00, 0x00,
  0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x60, 0x70, 0x0C, 0x01, 0x81, 0x80, 0x08, 0x30,
  0x00, 0x42, 0x00, 0x06, 0x20, 0x00, 0x66, 0x00, 0x02, 0x40, 0x00, 0x24,
  0x00, 0x02, 0x40, 0x3E, 0x2C, 0x06, 0x1A, 0xC0, 0xC0, 0x7C, 0x18, 0x07,
  0xC1, 0x80, 0x3C, 0x10, 0x03, 0xC1, 0x00, 0x3C, 0x30, 0x03, 0xC3, 0x00,
  0x3C, 0x30, 0x03, 0xC3, 0x00, 0x3C, 0x30, 0x03, 0xC1, 0x00, 0x3C, 0x10,
  0x03, 0xC1, 0x00, 0x3C, 0x18, 0x03, 0xC0, 0x80, 0x74, 0x0C, 0x0B, 0x40,
  0x3F, 0x34, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x18, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x24, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x66, 0x00, 0x00, 0x42, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x81, 0x80, 0x01, 0x81, 0x80,
  0x01, 0x80, 0x80, 0x01, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x03, 0x00, 0x40,
  0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0x30,
  0x0C, 0x00, 0x30, 0x0F, 0xFF, 0xF0, 0x08, 0x00, 0x18, 0x18, 0x00, 0x18,
  0x18, 0x00, 0x08, 0x10, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C,
  0x20, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x40, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x08, 0x00, 0x60, 0x80, 0x03, 0x08, 0x00,
  0x18, 0x80, 0x00, 0x88, 0x00, 0x0C, 0x80, 0x00, 0xC8, 0x00, 0x0C, 0x80,
  0x00, 0xC8, 0x00, 0x0C, 0x80, 0x00, 0xC8, 0x00, 0x0C, 0x80, 0x00, 0xC8,
  0x00, 0x18, 0x80, 0x03, 0x08, 0x00, 0x60, 0xFF, 0xFC, 0x08, 0x00, 0x30,
  0x80, 0x00, 0x88, 0x00, 0x0C, 0x80, 0x00, 0x68, 0x00, 0x06, 0x80, 0x00,
  0x28, 0x00, 0x02, 0x80, 0x00, 0x38, 0x00, 0x02, 0x80, 0x00, 0x28, 0x00,
  0x06, 0x80, 0x00, 0x68, 0x00, 0x0C, 0x80, 0x00, 0x88, 0x00, 0x30, 0xFF,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x38, 0x1C, 0x03, 0x00, 0x30, 0x30, 0x00,
  0xC3, 0x00, 0x03, 0x10, 0x00, 0x09, 0x80, 0x00, 0x6C, 0x00, 0x00, 0x40,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x22, 0x00, 0x01, 0x98, 0x00, 0x18, 0x60, 0x01, 0x81,
  0x80, 0x18, 0x07, 0x03, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0xF0, 0x0C, 0x00,
  0xE0, 0xC0, 0x03, 0x0C, 0x00, 0x18, 0xC0, 0x00, 0x8C, 0x00, 0x0C, 0xC0,
  0x00, 0x4C, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x02, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x02, 0xC0, 0x00, 0x6C, 0x00,
  0x06, 0xC0, 0x00, 0x4C, 0x00, 0x0C, 0xC0, 0x00, 0x8C, 0x00, 0x18, 0xC0,
  0x03, 0x0C, 0x00, 0xE0, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xFF, 0xFF, 0xD8, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x1C, 0x0C, 0x01, 0x80, 0x38, 0x10, 0x00, 0xC1, 0x80, 0x03, 0x18, 0x00,
  0x0C, 0xC0, 0x00, 0x44, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x03, 0xFF, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x05, 0x00, 0x00, 0x28, 0x00, 0x01,
  0x60, 0x00, 0x0B, 0x00, 0x00, 0xD8, 0x00, 0x06, 0x60, 0x00, 0x33, 0x00,
  0x01, 0x8C, 0x00, 0x14, 0x20, 0x01, 0xA1, 0x80, 0x19, 0x03, 0x03, 0x88,
  0x07, 0xF0, 0x00, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x30, 0xFF, 0xFF, 0xF0, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0xC0, 0x00, 0x98, 0x00, 0x66, 0x00, 0x10, 0xC0,
  0x08, 0x1C, 0x0C, 0x01, 0xFC, 0x00, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xB0,
  0x00, 0x19, 0x80, 0x01, 0x8C, 0x00, 0x18, 0x60, 0x01, 0x83, 0x00, 0x18,
  0x18, 0x01, 0x80, 0xC0, 0x18, 0x06, 0x01, 0xC0, 0x30, 0x0C, 0x01, 0x80,
  0xC0, 0x0C, 0x0C, 0x00, 0x60, 0xC0, 0x03, 0x0E, 0x00, 0x18, 0xD8, 0x00,
  0xCC, 0xC0, 0x06, 0xC3, 0x00, 0x36, 0x0C, 0x01, 0xE0, 0x60, 0x0E, 0x01,
  0x80, 0x60, 0x06, 0x03, 0x00, 0x30, 0x18, 0x00, 0xC0, 0xC0, 0x07, 0x06,
  0x00, 0x18, 0x30, 0x00, 0x61, 0x80, 0x03, 0x8C, 0x00, 0x0C, 0x60, 0x00,
  0x33, 0x00, 0x01, 0x98, 0x00, 0x06, 0xC0, 0x00, 0x18, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0xC0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7B, 0x00, 0x05, 0xB0, 0x00,
  0xD9, 0x80, 0x0D, 0x98, 0x01, 0x98, 0x80, 0x19, 0x8C, 0x03, 0x18, 0x40,
  0x31, 0x86, 0x02, 0x18, 0x60, 0x61, 0x83, 0x04, 0x18, 0x30, 0xC1, 0x81,
  0x0C, 0x18, 0x19, 0x81, 0x80, 0x98, 0x18, 0x0D, 0x01, 0x80, 0x70, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x04, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0xE0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3D, 0x80, 0x03, 0xD8, 0x00, 0x3C,
  0xC0, 0x03, 0xCC, 0x00, 0x3C, 0x60, 0x03, 0xC6, 0x00, 0x3C, 0x30, 0x03,
  0xC3, 0x00, 0x3C, 0x18, 0x03, 0xC1, 0x80, 0x3C, 0x0C, 0x03, 0xC0, 0xC0,
  0x3C, 0x06, 0x03, 0xC0, 0x60, 0x3C, 0x02, 0x03, 0xC0, 0x30, 0x3C, 0x01,
  0x03, 0xC0, 0x18, 0x3C, 0x00, 0x83, 0xC0, 0x0C, 0x3C, 0x00, 0x43, 0xC0,
  0x06, 0x3C, 0x00, 0x23, 0xC0, 0x03, 0x3C, 0x00, 0x13, 0xC0, 0x01, 0xBC,
  0x00, 0x0B, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x70, 0x00, 0xFE,
  0x00, 0x0C, 0x0E, 0x00, 0xC0, 0x0C, 0x06, 0x00, 0x18, 0x10, 0x00, 0x30,
  0xC0, 0x00, 0xC2, 0x00, 0x01, 0x18, 0x00, 0x06, 0x60, 0x00, 0x19, 0x80,
  0x00, 0x24, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xD0, 0x00, 0x03, 0x40, 0x00, 0x09, 0x80, 0x00, 0x66, 0x00, 0x01,
  0x88, 0x00, 0x06, 0x30, 0x00, 0x30, 0x40, 0x00, 0xC1, 0x80, 0x06, 0x03,
  0x00, 0x30, 0x03, 0x03, 0x80, 0x03, 0xF0, 0x00, 0xFF, 0xFE, 0x0C, 0x00,
  0x38, 0xC0, 0x00, 0xCC, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x02, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x2C, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x0C,
  0xC0, 0x03, 0x8F, 0xFF, 0xE0, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x0C, 0x0E,
  0x00, 0xC0, 0x0C, 0x06, 0x00, 0x18, 0x10, 0x00, 0x20, 0xC0, 0x00, 0xC2,
  0x00, 0x01, 0x18, 0x00, 0x06, 0x60, 0x00, 0x19, 0x80, 0x00, 0x24, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xD0, 0x00,
  0x03, 0x40, 0x00, 0x09, 0x80, 0x00, 0x66, 0x00, 0x01, 0x88, 0x00, 0x04,
  0x30, 0x00, 0x30, 0x40, 0x00, 0x81, 0x80, 0x06, 0x03, 0x00, 0x30, 0x07,
  0x03, 0x80, 0x03, 0xF8, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x07, 0xFC, 0xFF, 0xFE, 0x0C,
  0x00, 0x38, 0xC0, 0x00, 0xCC, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x02,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x2C, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00,
  0x0C, 0xC0, 0x03, 0x8F, 0xFF, 0xE0, 0xC0, 0x60, 0x0C, 0x06, 0x00, 0xC0,
  0x30, 0x0C, 0x01, 0x80, 0xC0, 0x18, 0x0C, 0x00, 0xC0, 0xC0, 0x04, 0x0C,
  0x00, 0x60, 0xC0, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x01, 0x8C, 0x00, 0x0C,
  0xC0, 0x00, 0xCC, 0x00, 0x06, 0xC0, 0x00, 0x20, 0x01, 0xFF, 0x00, 0x38,
  0x07, 0x81, 0x80, 0x07, 0x0C, 0x00, 0x06, 0x60, 0x00, 0x09, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x40, 0x00, 0x0B, 0x00, 0x00, 0x67, 0x00, 0x03, 0x0E, 0x00, 0x18,
  0x1E, 0x01, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x34, 0x00, 0x03, 0x40, 0x00, 0x34,
  0x00, 0x02, 0x40, 0x00, 0x26, 0x00, 0x02, 0x60, 0x00, 0x62, 0x00, 0x06,
  0x30, 0x00, 0xC1, 0x80, 0x08, 0x0E, 0x03, 0x00, 0x3F, 0xC0, 0xC0, 0x00,
  0x03, 0x60, 0x00, 0x02, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x30, 0x00,
  0x04, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x08, 0x18, 0x00,
  0x18, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x0C, 0x00,
  0x30, 0x04, 0x00, 0x30, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x02, 0x00,
  0x60, 0x03, 0x00, 0x40, 0x03, 0x00, 0xC0, 0x01, 0x00, 0xC0, 0x01, 0x80,
  0x80, 0x01, 0x81, 0x80, 0x00, 0x81, 0x80, 0x00, 0xC1, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x43, 0x00, 0x00, 0x62, 0x00, 0x00, 0x66, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x34, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x18,
  0x00, 0xC0, 0x00, 0x03, 0x40, 0x00, 0x03, 0x40, 0x00, 0x02, 0x40, 0x00,
  0x02, 0x40, 0x00, 0x02, 0x60, 0x00, 0x02, 0x60, 0x00, 0x02, 0x60, 0x00,
  0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x18, 0x06, 0x20, 0x1C,
  0x06, 0x20, 0x3C, 0x06, 0x20, 0x34, 0x04, 0x20, 0x24, 0x04, 0x20, 0x26,
  0x04, 0x30, 0x66, 0x04, 0x30, 0x62, 0x04, 0x30, 0x43, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0x81, 0x0C, 0x10, 0x81, 0x8C, 0x11, 0x81,
  0x8C, 0x11, 0x80, 0x88, 0x11, 0x00, 0x88, 0x13, 0x00, 0xC8, 0x1B, 0x00,
  0xC8, 0x1A, 0x00, 0x48, 0x1A, 0x00, 0x78, 0x1E, 0x00, 0x78, 0x1E, 0x00,
  0x38, 0x1C, 0x00, 0x38, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x06, 0x30, 0x00,
  0x0C, 0x18, 0x00, 0x08, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x06, 0x00,
  0x30, 0x06, 0x00, 0x60, 0x03, 0x00, 0xC0, 0x01, 0x80, 0xC0, 0x01, 0x81,
  0x80, 0x00, 0xC3, 0x00, 0x00, 0x63, 0x00, 0x00, 0x66, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x26,
  0x00, 0x00, 0x66, 0x00, 0x00, 0xC3, 0x00, 0x00, 0xC1, 0x80, 0x01, 0x81,
  0x80, 0x03, 0x00, 0xC0, 0x03, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0C, 0x00,
  0x30, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x30, 0x00,
  0x06, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x0C, 0x18, 0x00, 0x06, 0x02,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0x18, 0x00, 0x20, 0x06, 0x00, 0x18,
  0x00, 0xC0, 0x0C, 0x00, 0x18, 0x03, 0x00, 0x06, 0x01, 0x80, 0x00, 0xC0,
  0xC0, 0x00, 0x30, 0x30, 0x00, 0x06, 0x18, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0x33, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x0F,
  0xFF, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00,
  0x01, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00,
  0x10, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01,
  0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10,
  0xFF, 0xE0, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x3F, 0xFC, 0x00, 0x30,
  0x00, 0x01, 0xE0, 0x00, 0x04, 0x80, 0x00, 0x33, 0x00, 0x00, 0x86, 0x00,
  0x06, 0x18, 0x00, 0x30, 0x30, 0x00, 0xC0, 0x40, 0x06, 0x01, 0x80, 0x10,
  0x03, 0x00, 0xC0, 0x0C, 0x06, 0x00, 0x18, 0x18, 0x00, 0x20, 0xC0, 0x00,
  0xC2, 0x00, 0x01, 0x98, 0x00, 0x06, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x10,
  0xFF, 0xFF, 0xFC, 0x41, 0xC0, 0xC1, 0x81, 0x81, 0x81, 0x03, 0x07, 0xF0,
  0x00, 0xE0, 0x60, 0x0C, 0x00, 0x80, 0xC0, 0x06, 0x04, 0x00, 0x18, 0x60,
  0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x7F, 0xF8, 0x1C, 0x00, 0x41, 0x80,
  0x02, 0x18, 0x00, 0x10, 0xC0, 0x00, 0x84, 0x00, 0x04, 0x20, 0x00, 0x21,
  0x00, 0x01, 0x08, 0x00, 0x18, 0x60, 0x01, 0x43, 0x00, 0x0A, 0x0C, 0x00,
  0x90, 0x38, 0x18, 0xF8, 0x7F, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x0F, 0xC0, 0x46, 0x06, 0x0B,
  0x00, 0x61, 0x40, 0x06, 0x30, 0x00, 0x66, 0x00, 0x04, 0x80, 0x00, 0xD0,
  0x00, 0x1A, 0x00, 0x01, 0x40, 0x00, 0x28, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x40,
  0x00, 0x28, 0x00, 0x0D, 0x00, 0x01, 0xA0, 0x00, 0x26, 0x00, 0x0C, 0xA0,
  0x03, 0x16, 0x00, 0xC2, 0x30, 0x30, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0xC0, 0xE0, 0x60, 0x06, 0x18, 0x00, 0x62, 0x00, 0x04, 0xC0, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x04, 0x40,
  0x00, 0xCC, 0x00, 0x30, 0xC0, 0x0C, 0x06, 0x07, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x0F,
  0xE1, 0x87, 0x03, 0x31, 0x80, 0x36, 0x60, 0x03, 0xD8, 0x00, 0x3A, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xD0, 0x00,
  0x1B, 0x00, 0x07, 0x30, 0x00, 0xE3, 0x00, 0x6C, 0x38, 0x19, 0x81, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x60, 0x70, 0x08, 0x01, 0x81, 0x00, 0x0C, 0x30,
  0x00, 0x46, 0x00, 0x06, 0x60, 0x00, 0x24, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00,
  0x06, 0x00, 0x02, 0x60, 0x00, 0x33, 0x00, 0x06, 0x10, 0x00, 0xC0, 0x80,
  0x18, 0x06, 0x07, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xF8, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x01, 0xFF,
  0xFF, 0xF0, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x00, 0xFC, 0x07, 0xE4, 0x00, 0x60, 0x70, 0x03, 0x00,
  0x40, 0x18, 0x00, 0x80, 0x40, 0x03, 0x03, 0x00, 0x04, 0x0C, 0x00, 0x18,
  0x30, 0x00, 0x60, 0xC0, 0x01, 0x83, 0x00, 0x06, 0x0C, 0x00, 0x10, 0x30,
  0x00, 0xC0, 0x60, 0x03, 0x01, 0xC0, 0x18, 0x03, 0x81, 0xC0, 0x03, 0xFC,
  0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x08, 0x00, 0x70, 0xC0,
  0x00, 0x64, 0x00, 0x00, 0xB0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x02, 0x60, 0x00, 0x19, 0xC0, 0x00, 0xC1,
  0xC0, 0x1C, 0x01, 0xFF, 0xC0, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x21, 0xFC, 0x13, 0x03, 0x8B, 0x00, 0x67, 0x00, 0x1B, 0x00,
  0x05, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xCF, 0xFF, 0xC0, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0xCC, 0x00, 0x1C, 0x60, 0x01, 0x83, 0x00,
  0x18, 0x18, 0x01, 0x80, 0xC0, 0x18, 0x06, 0x01, 0x80, 0x30, 0x38, 0x01,
  0x83, 0x80, 0x0C, 0x38, 0x00, 0x63, 0xC0, 0x03, 0x33, 0x00, 0x1B, 0x0C,
  0x00, 0xF0, 0x30, 0x07, 0x00, 0xC0, 0x30, 0x07, 0x01, 0x80, 0x18, 0x0C,
  0x00, 0x60, 0x60, 0x01, 0x83, 0x00, 0x06, 0x18, 0x00, 0x18, 0xC0, 0x00,
  0xC6, 0x00, 0x03, 0x30, 0x00, 0x0E, 0xFF, 0xE0, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0x81,
  0xE3, 0x63, 0x18, 0x6E, 0x06, 0x80, 0xB0, 0x0C, 0x03, 0xC0, 0x30, 0x0F,
  0x00, 0xC0, 0x3C, 0x03, 0x00, 0xF0, 0x0C, 0x03, 0xC0, 0x30, 0x0F, 0x00,
  0xC0, 0x3C, 0x03, 0x00, 0xF0, 0x0C, 0x03, 0xC0, 0x30, 0x0F, 0x00, 0xC0,
  0x3C, 0x03, 0x00, 0xF0, 0x0C, 0x03, 0xC0, 0x30, 0x0F, 0x00, 0xC0, 0x3C,
  0x03, 0x00, 0xF0, 0x0C, 0x03, 0xC0, 0x30, 0x0F, 0x00, 0xC0, 0x3C, 0x03,
  0x00, 0xF0, 0x0C, 0x03, 0xC0, 0x30, 0x0C, 0x07, 0xF0, 0x4C, 0x0E, 0x2C,
  0x01, 0x9C, 0x00, 0x6C, 0x00, 0x14, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0x80, 0x01, 0xF8, 0x00, 0x60, 0x70, 0x18, 0x01, 0x83, 0x00, 0x0C, 0x20,
  0x00, 0x46, 0x00, 0x06, 0x40, 0x00, 0x24, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x40, 0x00,
  0x34, 0x00, 0x02, 0x60, 0x00, 0x62, 0x00, 0x04, 0x30, 0x00, 0xC1, 0x80,
  0x18, 0x06, 0x07, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x11, 0x81, 0x82, 0xC0,
  0x18, 0x50, 0x01, 0x8C, 0x00, 0x19, 0x80, 0x01, 0x20, 0x00, 0x34, 0x00,
  0x06, 0x80, 0x00, 0x50, 0x00, 0x0A, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x50, 0x00,
  0x0A, 0x00, 0x03, 0x40, 0x00, 0x68, 0x00, 0x09, 0x80, 0x03, 0x28, 0x00,
  0xC5, 0x80, 0x30, 0x8C, 0x0C, 0x10, 0xFE, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x00, 0x03, 0xF8, 0x01, 0xC0, 0xCC, 0x60, 0x0D, 0x98, 0x00,
  0xF6, 0x00, 0x0E, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x34, 0x00, 0x06, 0xC0, 0x01, 0xCC, 0x00, 0x38, 0xC0, 0x1B,
  0x0E, 0x06, 0x60, 0x7F, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0xFF, 0x83, 0xFC, 0x02, 0x30, 0x00, 0x09, 0x00, 0x00, 0x28, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x08, 0x00, 0x3F, 0xFF, 0xFC, 0x03, 0xFC, 0x00, 0xE0, 0x78, 0x18,
  0x00, 0xC3, 0x00, 0x06, 0x60, 0x00, 0x36, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00,
  0x03, 0x60, 0x00, 0x23, 0x80, 0x06, 0x0E, 0x03, 0x80, 0x1F, 0xE0, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x01, 0xFF, 0xFF, 0xFC, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x3F, 0xFE, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0D, 0x00, 0x03, 0x60, 0x01, 0xD8, 0x00, 0x73,
  0x00, 0x2C, 0x70, 0x33, 0x07, 0xF0, 0x00, 0xC0, 0x00, 0x34, 0x00, 0x03,
  0x60, 0x00, 0x26, 0x00, 0x06, 0x20, 0x00, 0x43, 0x00, 0x0C, 0x30, 0x00,
  0xC1, 0x80, 0x08, 0x18, 0x01, 0x80, 0x80, 0x18, 0x0C, 0x01, 0x00, 0xC0,
  0x30, 0x04, 0x02, 0x00, 0x60, 0x60, 0x06, 0x06, 0x00, 0x20, 0x40, 0x03,
  0x0C, 0x00, 0x10, 0xC0, 0x01, 0x88, 0x00, 0x19, 0x80, 0x00, 0x90, 0x00,
  0x0D, 0x00, 0x00, 0xF0, 0x00, 0x06, 0x00, 0x80, 0x18, 0x01, 0xC0, 0x0E,
  0x00, 0xB0, 0x0F, 0x00, 0x58, 0x06, 0x80, 0x64, 0x02, 0x40, 0x32, 0x01,
  0x30, 0x19, 0x01, 0x98, 0x08, 0xC0, 0xC4, 0x04, 0x60, 0x42, 0x02, 0x30,
  0x21, 0x83, 0x08, 0x30, 0xC1, 0x84, 0x18, 0x20, 0x82, 0x08, 0x10, 0x41,
  0x84, 0x0C, 0x20, 0xC6, 0x06, 0x30, 0x23, 0x01, 0x18, 0x11, 0x00, 0x8C,
  0x08, 0x80, 0x44, 0x04, 0x40, 0x32, 0x03, 0x60, 0x09, 0x01, 0xA0, 0x05,
  0x80, 0x50, 0x02, 0xC0, 0x28, 0x01, 0xC0, 0x1C, 0x00, 0x60, 0xC0, 0x00,
  0x36, 0x00, 0x06, 0x30, 0x00, 0xC1, 0x80, 0x08, 0x18, 0x01, 0x80, 0xC0,
  0x30, 0x06, 0x06, 0x00, 0x30, 0x40, 0x01, 0x0C, 0x00, 0x19, 0x80, 0x00,
  0xF0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x01, 0x98, 0x00,
  0x30, 0xC0, 0x02, 0x06, 0x00, 0x60, 0x60, 0x0C, 0x03, 0x01, 0x80, 0x18,
  0x10, 0x00, 0xC3, 0x00, 0x0C, 0x60, 0x00, 0x6C, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x01, 0x90, 0x00, 0x0C, 0xC0, 0x00, 0xC6, 0x00, 0x06, 0x18,
  0x00, 0x20, 0xC0, 0x03, 0x02, 0x00, 0x10, 0x18, 0x01, 0x80, 0x40, 0x0C,
  0x03, 0x00, 0x40, 0x18, 0x06, 0x00, 0x60, 0x20, 0x03, 0x03, 0x00, 0x08,
  0x18, 0x00, 0x61, 0x80, 0x03, 0x0C, 0x00, 0x0C, 0x40, 0x00, 0x66, 0x00,
  0x01, 0x20, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0xFF,
  0xC0, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x04, 0x00, 0x03, 0x00, 0x03, 0x00, 0xFF, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x3F, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xE0, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x3F, 0xC0, 0x38, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x3F, 0xF8, 0x00, 0x0F, 0x00, 0x06, 0x63, 0x00,
  0x08, 0x81, 0x00, 0x12, 0x01, 0x00, 0x64, 0x01, 0x00, 0x98, 0x01, 0x03,
  0x20, 0x01, 0x8C, 0x40, 0x01, 0xF0,
};

const GFXglyph IBMPlexMono_ExtraLight47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 28, 0, -1 },
  { 1, 4, 33, 28, 12, -33 },
  { 18, 8, 12, 28, 10, -35 },
  { 30, 26, 33, 28, 1, -33 },
  { 138, 22, 44, 28, 3, -38 },
  { 259, 26, 34, 28, 1, -33 },
  { 370, 24, 34, 28, 2, -33 },
  { 472, 2, 12, 28, 13, -35 },
  { 475, 11, 42, 28, 11, -36 },
  { 533, 11, 42, 28, 6, -36 },
  { 591, 24, 23, 28, 2, -26 },
  { 660, 22, 23, 28, 3, -26 },
  { 724, 5, 12, 28, 11, -4 },
  { 732, 12, 1, 28, 8, -15 },
  { 734, 4, 4, 28, 12, -4 },
  { 736, 18, 42, 28, 5, -36 },
  { 831, 22, 34, 28, 3, -33 },
  { 925, 22, 33, 28, 4, -33 },
  { 1016, 21, 33, 28, 4, -33 },
  { 1103, 20, 34, 28, 3, -33 },
  { 1188, 24, 33, 28, 2, -33 },
  { 1287, 20, 34, 28, 4, -33 },
  { 1372, 20, 34, 28, 4, -33 },
  { 1457, 21, 33, 28, 3, -33 },
  { 1544, 22, 34, 28, 3, -33 },
  { 1638, 20, 33, 28, 4, -33 },
  { 1721, 4, 25, 28, 12, -25 },
  { 1734, 5, 33, 28, 11, -25 },
  { 1755, 20, 26, 28, 4, -27 },
  { 1820, 22, 9, 28, 3, -19 },
  { 1845, 20, 26, 28, 4, -27 },
  { 1910, 20, 33, 28, 4, -33 },
  { 1993, 20, 38, 28, 4, -33 },
  { 2088, 24, 33, 28, 2, -33 },
  { 2187, 20, 33, 28, 5, -33 },
  { 2270, 21, 34, 28, 4, -33 },
  { 2360, 20, 33, 28, 5, -33 },
  { 2443, 19, 33, 28, 5, -33 },
  { 2522, 19, 33, 28, 5, -33 },
  { 2601, 21, 34, 28, 3, -33 },
  { 2691, 20, 33, 28, 4, -33 },
  { 2774, 20, 33, 28, 4, -33 },
  { 2857, 18, 34, 28, 4, -33 },
  { 2934, 21, 33, 28, 5, -33 },
  { 3021, 18, 33, 28, 7, -33 },
  { 3096, 20, 33, 28, 4, -33 },
  { 3179, 20, 33, 28, 4, -33 },
  { 3262, 22, 34, 28, 3, -33 },
  { 3356, 20, 33, 28, 5, -33 },
  { 3439, 22, 40, 28, 3, -33 },
  { 3549, 20, 33, 28, 5, -33 },
  { 3632, 22, 34, 28, 3, -33 },
  { 3726, 24, 33, 28, 2, -33 },
  { 3825, 20, 34, 28, 4, -33 },
  { 3910, 24, 33, 28, 2, -33 },
  { 4009, 24, 33, 28, 2, -33 },
  { 4108, 24, 33, 28, 2, -33 },
  { 4207, 26, 33, 28, 1, -33 },
  { 4315, 24, 33, 28, 2, -33 },
  { 4414, 12, 42, 28, 12, -36 },
  { 4477, 18, 42, 28, 5, -36 },
  { 4572, 11, 42, 28, 5, -36 },
  { 4630, 22, 18, 28, 3, -33 },
  { 4680, 22, 1, 28, 3, 6 },
  { 4683, 7, 8, 28, 9, -36 },
  { 4690, 21, 26, 28, 4, -25 },
  { 4759, 19, 36, 28, 6, -35 },
  { 4845, 19, 26, 28, 5, -25 },
  { 4907, 19, 36, 28, 4, -35 },
  { 4993, 20, 26, 28, 4, -25 },
  { 5058, 21, 35, 28, 4, -35 },
  { 5150, 22, 36, 28, 4, -26 },
  { 5249, 17, 35, 28, 6, -35 },
  { 5324, 20, 35, 28, 5, -35 },
  { 5412, 17, 44, 28, 4, -35 },
  { 5506, 21, 35, 28, 6, -35 },
  { 5598, 20, 35, 28, 4, -35 },
  { 5686, 22, 25, 28, 3, -25 },
  { 5755, 17, 25, 28, 6, -25 },
  { 5809, 20, 26, 28, 4, -25 },
  { 5874, 19, 34, 28, 6, -25 },
  { 5955, 19, 34, 28, 4, -25 },
  { 6036, 22, 24, 28, 4, -24 },
  { 6102, 20, 26, 28, 4, -25 },
  { 6167, 23, 33, 28, 2, -33 },
  { 6262, 18, 25, 28, 5, -24 },
  { 6319, 20, 24, 28, 4, -24 },
  { 6379, 25, 24, 28, 2, -24 },
  { 6454, 20, 24, 28, 4, -24 },
  { 6514, 21, 33, 28, 4, -24 },
  { 6601, 19, 24, 28, 5, -24 },
  { 6658, 18, 42, 28, 5, -36 },
  { 6753, 2, 42, 28, 13, -36 },
  { 6764, 18, 42, 28, 5, -36 },
  { 6859, 23, 8, 28, 3, -18 },
};

const GFXfont IBMPlexMono_ExtraLight47pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLight47pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLight47pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _IBMPLEXMONO_EXTRALIGHT47PT7B_H_
