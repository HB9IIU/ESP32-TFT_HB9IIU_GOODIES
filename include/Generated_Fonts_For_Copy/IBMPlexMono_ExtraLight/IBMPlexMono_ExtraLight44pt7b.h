#ifndef _IBMPLEXMONO_EXTRALIGHT44PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHT44PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLight.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLight44pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x62, 0x22, 0x22, 0x22,
  0x00, 0x00, 0x07, 0xFF, 0x70, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1,
  0xC1, 0xC1, 0xC1, 0xC1, 0x00, 0x30, 0x30, 0x00, 0x18, 0x10, 0x00, 0x08,
  0x08, 0x00, 0x04, 0x0C, 0x00, 0x02, 0x06, 0x00, 0x03, 0x03, 0x00, 0x01,
  0x81, 0x80, 0x00, 0x80, 0x80, 0x00, 0x40, 0x40, 0x00, 0x20, 0x60, 0x00,
  0x10, 0x30, 0x0F, 0xF8, 0x1F, 0xF0, 0x0C, 0x08, 0x00, 0x04, 0x04, 0x00,
  0x02, 0x02, 0x00, 0x01, 0x03, 0x00, 0x01, 0x81, 0x80, 0x00, 0xC0, 0xC0,
  0x00, 0x60, 0x40, 0x1F, 0xE0, 0x3F, 0xC0, 0x10, 0x10, 0x00, 0x18, 0x18,
  0x00, 0x0C, 0x0C, 0x00, 0x06, 0x04, 0x00, 0x02, 0x02, 0x00, 0x01, 0x01,
  0x00, 0x00, 0x81, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x30,
  0x20, 0x00, 0x10, 0x10, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x03, 0xFE, 0x00, 0xE2, 0x38, 0x18, 0x20, 0xE2, 0x02,
  0x03, 0x60, 0x20, 0x24, 0x02, 0x00, 0x40, 0x20, 0x04, 0x02, 0x00, 0x40,
  0x20, 0x04, 0x02, 0x00, 0x60, 0x20, 0x06, 0x02, 0x00, 0x30, 0x20, 0x01,
  0x82, 0x00, 0x0F, 0x20, 0x00, 0x1F, 0x80, 0x00, 0x2F, 0x00, 0x02, 0x1C,
  0x00, 0x20, 0x60, 0x02, 0x03, 0x00, 0x20, 0x30, 0x02, 0x01, 0x00, 0x20,
  0x10, 0x02, 0x01, 0x00, 0x20, 0x10, 0x02, 0x01, 0x80, 0x20, 0x3C, 0x02,
  0x03, 0x60, 0x20, 0x63, 0x02, 0x0C, 0x1E, 0x23, 0x80, 0x3F, 0xC0, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x0F, 0x80, 0x03,
  0x30, 0x60, 0x02, 0x20, 0x20, 0x06, 0x60, 0x10, 0x04, 0x40, 0x10, 0x0C,
  0xC0, 0x18, 0x08, 0xC0, 0x18, 0x10, 0xC0, 0x18, 0x30, 0xC0, 0x18, 0x20,
  0xC0, 0x18, 0x60, 0x40, 0x10, 0x40, 0x60, 0x10, 0xC0, 0x20, 0x30, 0x80,
  0x30, 0x61, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x01, 0x83, 0x0C, 0x01, 0x04, 0x06, 0x03, 0x0C, 0x02,
  0x02, 0x08, 0x03, 0x06, 0x08, 0x03, 0x0C, 0x08, 0x01, 0x08, 0x08, 0x01,
  0x18, 0x08, 0x01, 0x10, 0x08, 0x03, 0x30, 0x08, 0x03, 0x20, 0x0C, 0x02,
  0x40, 0x04, 0x06, 0xC0, 0x03, 0x0C, 0x00, 0x01, 0xF0, 0x01, 0xF8, 0x00,
  0x18, 0x38, 0x00, 0xC0, 0x30, 0x02, 0x00, 0x40, 0x18, 0x01, 0x80, 0x40,
  0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x40, 0x00, 0x10, 0x80, 0x7C, 0x83, 0x01, 0x86, 0x06,
  0x04, 0x30, 0x0C, 0x10, 0xC0, 0x18, 0x42, 0x00, 0x21, 0x08, 0x00, 0x44,
  0x20, 0x00, 0xB0, 0x80, 0x03, 0x82, 0x00, 0x06, 0x0C, 0x00, 0x1C, 0x30,
  0x00, 0x58, 0x60, 0x02, 0x30, 0xC0, 0x10, 0x61, 0x81, 0x80, 0xC1, 0xF8,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xE0, 0x30, 0x0C, 0x01, 0x00, 0x40, 0x18,
  0x06, 0x00, 0x80, 0x30, 0x04, 0x00, 0x80, 0x30, 0x04, 0x00, 0x80, 0x10,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x30, 0x02, 0x00, 0x40, 0x0C, 0x00, 0x80,
  0x18, 0x01, 0x80, 0x10, 0x01, 0x00, 0x30, 0x03, 0x00, 0x38, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x60, 0x08, 0x03, 0x00, 0x40, 0x18,
  0x02, 0x00, 0x80, 0x30, 0x0C, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x01, 0x80, 0x40,
  0x30, 0x08, 0x06, 0x01, 0x00, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0xF0, 0x30, 0x1C,
  0xF8, 0xC3, 0xC0, 0x7F, 0x78, 0x00, 0x3F, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xA0, 0x00, 0x0C, 0xC0, 0x00, 0x61, 0x80, 0x01, 0x83, 0x00, 0x0C, 0x04,
  0x00, 0x60, 0x18, 0x01, 0x00, 0x30, 0x0C, 0x00, 0x60, 0x60, 0x01, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x39, 0x8C, 0xE6, 0x31,
  0x88, 0xC6, 0x20, 0xFF, 0xF0, 0x7F, 0xF7, 0x00, 0x00, 0xC0, 0x00, 0x20,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00,
  0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00,
  0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04,
  0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00,
  0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03,
  0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x60, 0x70, 0x0C, 0x01, 0x81, 0x00, 0x0C, 0x30, 0x00, 0x42,
  0x00, 0x06, 0x60, 0x00, 0x24, 0x00, 0x02, 0x40, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x60,
  0x1C, 0x07, 0x01, 0xC0, 0x60, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x34, 0x00, 0x03, 0x40,
  0x00, 0x26, 0x00, 0x02, 0x20, 0x00, 0x63, 0x00, 0x04, 0x10, 0x00, 0xC0,
  0x80, 0x18, 0x06, 0x07, 0x00, 0x1F, 0x80, 0x00, 0x70, 0x00, 0x06, 0x80,
  0x00, 0x64, 0x00, 0x06, 0x20, 0x00, 0xC1, 0x00, 0x0C, 0x08, 0x00, 0xC0,
  0x40, 0x0C, 0x02, 0x00, 0xC0, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xF0, 0x03, 0x81, 0x80, 0xC0, 0x0C,
  0x30, 0x00, 0x8C, 0x00, 0x19, 0x80, 0x01, 0x20, 0x00, 0x20, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18,
  0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xF8, 0x01, 0x81, 0xC0,
  0xE0, 0x0C, 0x10, 0x00, 0xC6, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x3F, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x60,
  0x00, 0x6E, 0x00, 0x08, 0xE0, 0x06, 0x07, 0x01, 0x80, 0x3F, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x68, 0x00, 0x01, 0x20, 0x00, 0x0C,
  0x80, 0x00, 0x62, 0x00, 0x01, 0x08, 0x00, 0x0C, 0x20, 0x00, 0x60, 0x80,
  0x01, 0x02, 0x00, 0x0C, 0x08, 0x00, 0x60, 0x20, 0x01, 0x00, 0x80, 0x0C,
  0x02, 0x00, 0x60, 0x08, 0x01, 0x00, 0x20, 0x0C, 0x00, 0x80, 0x60, 0x02,
  0x01, 0x00, 0x08, 0x0C, 0x00, 0x20, 0x60, 0x00, 0x81, 0x00, 0x02, 0x0C,
  0x00, 0x08, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08,
  0x00, 0x3F, 0xFF, 0x84, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x87, 0xF0, 0x13, 0x03,
  0x82, 0x80, 0x18, 0x60, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x03, 0x40, 0x00, 0x4C, 0x00, 0x18, 0xC0, 0x06,
  0x0F, 0x03, 0x80, 0x3F, 0x80, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x3F, 0x80,
  0x98, 0x1C, 0x34, 0x00, 0xC7, 0x00, 0x0C, 0xA0, 0x00, 0xD8, 0x00, 0x1B,
  0x00, 0x01, 0x40, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x58, 0x00, 0x09, 0x00, 0x03, 0x30, 0x00, 0x42,
  0x00, 0x18, 0x60, 0x06, 0x03, 0x03, 0x80, 0x1F, 0xC0, 0xFF, 0xFF, 0xFC,
  0x00, 0x03, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x4C, 0x00, 0x0C,
  0xC0, 0x00, 0xCC, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00,
  0x06, 0x00, 0x00, 0x03, 0xFC, 0x00, 0xE0, 0x70, 0x18, 0x01, 0x83, 0x00,
  0x0C, 0x20, 0x00, 0x66, 0x00, 0x06, 0x60, 0x00, 0x26, 0x00, 0x02, 0x60,
  0x00, 0x26, 0x00, 0x02, 0x60, 0x00, 0x62, 0x00, 0x06, 0x30, 0x00, 0xC1,
  0x80, 0x18, 0x0E, 0x07, 0x00, 0x1F, 0xC0, 0x0E, 0x03, 0x01, 0x80, 0x0C,
  0x20, 0x00, 0x66, 0x00, 0x02, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x36, 0x00,
  0x02, 0x20, 0x00, 0x61, 0x80, 0x0C, 0x0E, 0x03, 0x00, 0x3F, 0xC0, 0x03,
  0xF8, 0x01, 0x81, 0xC0, 0xC0, 0x0C, 0x10, 0x00, 0xC6, 0x00, 0x0D, 0x80,
  0x00, 0xB0, 0x00, 0x16, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xD8, 0x00, 0x3B, 0x00,
  0x0E, 0x30, 0x03, 0x43, 0x81, 0xC8, 0x0F, 0xC3, 0x00, 0x00, 0x40, 0x00,
  0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0xC0,
  0x00, 0x7F, 0xF7, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xF7, 0x3B, 0xDE, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x98, 0xCE, 0x63, 0x18, 0x8C, 0x62, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x30, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x30, 0x00,
  0x04, 0x00, 0x00, 0x03, 0xF8, 0x03, 0x01, 0x83, 0x00, 0x31, 0x80, 0x06,
  0x60, 0x00, 0xB0, 0x00, 0x34, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x03,
  0xC0, 0x07, 0xC0, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1C,
  0x00, 0x03, 0xF8, 0x03, 0x83, 0x01, 0x80, 0x30, 0xC0, 0x04, 0x20, 0x01,
  0x98, 0x00, 0x24, 0x00, 0x0D, 0x00, 0x03, 0x40, 0x00, 0xF0, 0x1F, 0x1C,
  0x0C, 0x37, 0x06, 0x05, 0x81, 0x00, 0xE0, 0xC0, 0x38, 0x20, 0x06, 0x08,
  0x01, 0x82, 0x00, 0x60, 0x80, 0x18, 0x20, 0x06, 0x08, 0x01, 0x82, 0x00,
  0x60, 0x80, 0x18, 0x30, 0x06, 0x0C, 0x03, 0x81, 0x00, 0xF0, 0x20, 0x5C,
  0x07, 0xE5, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x07, 0xFE, 0x00, 0x30,
  0x00, 0x00, 0xE0, 0x00, 0x06, 0x80, 0x00, 0x1A, 0x00, 0x00, 0x4C, 0x00,
  0x03, 0x30, 0x00, 0x0C, 0x40, 0x00, 0x21, 0x80, 0x01, 0x86, 0x00, 0x06,
  0x08, 0x00, 0x10, 0x30, 0x00, 0xC0, 0xC0, 0x03, 0x01, 0x00, 0x08, 0x06,
  0x00, 0x60, 0x18, 0x01, 0x80, 0x20, 0x04, 0x00, 0xC0, 0x30, 0x03, 0x00,
  0xC0, 0x04, 0x03, 0x00, 0x18, 0x1F, 0xFF, 0xE0, 0x60, 0x00, 0x81, 0x80,
  0x03, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x10, 0xC0, 0x00, 0x62, 0x00, 0x01,
  0x98, 0x00, 0x02, 0x60, 0x00, 0x0D, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xC0,
  0xFF, 0xF8, 0x18, 0x00, 0xC3, 0x00, 0x0C, 0x60, 0x00, 0xCC, 0x00, 0x19,
  0x80, 0x01, 0x30, 0x00, 0x36, 0x00, 0x06, 0xC0, 0x00, 0xD8, 0x00, 0x1B,
  0x00, 0x02, 0x60, 0x00, 0xCC, 0x00, 0x19, 0x80, 0x06, 0x30, 0x01, 0x87,
  0xFF, 0xE0, 0xC0, 0x03, 0x18, 0x00, 0x33, 0x00, 0x03, 0x60, 0x00, 0x2C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0x60, 0x00, 0x6C, 0x00, 0x19, 0x80, 0x06, 0x3F,
  0xFF, 0x00, 0x00, 0xFE, 0x00, 0x30, 0x38, 0x0C, 0x00, 0xC1, 0x80, 0x06,
  0x10, 0x00, 0x23, 0x00, 0x03, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x31, 0x00, 0x02,
  0x18, 0x00, 0x60, 0xC0, 0x0C, 0x03, 0x03, 0x80, 0x0F, 0xE0, 0xFF, 0xE0,
  0x20, 0x06, 0x08, 0x00, 0x62, 0x00, 0x0C, 0x80, 0x01, 0x20, 0x00, 0x68,
  0x00, 0x1A, 0x00, 0x02, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x02, 0x80, 0x00, 0xA0, 0x00, 0x68, 0x00, 0x12, 0x00,
  0x0C, 0x80, 0x06, 0x20, 0x07, 0x0F, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x03, 0xFF, 0xFE, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x0F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE0, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x03, 0xFF, 0xFE, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x70, 0x30, 0x0C, 0x01, 0x81,
  0x80, 0x0C, 0x30, 0x00, 0x62, 0x00, 0x02, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x01,
  0xFF, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x40,
  0x00, 0x34, 0x00, 0x03, 0x60, 0x00, 0x36, 0x00, 0x03, 0x20, 0x00, 0x73,
  0x00, 0x07, 0x18, 0x00, 0xB0, 0xC0, 0x1B, 0x07, 0x07, 0x30, 0x1F, 0xC0,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x04, 0xFF, 0xFF,
  0xC0, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0xB0, 0x00, 0xD8, 0x00, 0x66, 0x00, 0x63, 0x80, 0x20,
  0x60, 0x60, 0x0F, 0xC0, 0x80, 0x00, 0x70, 0x00, 0x1A, 0x00, 0x06, 0x40,
  0x01, 0x88, 0x00, 0x61, 0x00, 0x18, 0x20, 0x03, 0x04, 0x00, 0xC0, 0x80,
  0x30, 0x10, 0x0C, 0x02, 0x03, 0x00, 0x40, 0xC0, 0x08, 0x30, 0x01, 0x0E,
  0x00, 0x21, 0xE0, 0x04, 0x6C, 0x00, 0x98, 0xC0, 0x16, 0x0C, 0x03, 0x81,
  0x80, 0x60, 0x18, 0x08, 0x01, 0x81, 0x00, 0x30, 0x20, 0x03, 0x04, 0x00,
  0x30, 0x80, 0x06, 0x10, 0x00, 0x62, 0x00, 0x04, 0x40, 0x00, 0xC8, 0x00,
  0x0D, 0x00, 0x00, 0xA0, 0x00, 0x18, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0xFF, 0xFE,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xD0, 0x00, 0xFB, 0x00, 0x1F,
  0x20, 0x06, 0xE6, 0x00, 0xDC, 0xC0, 0x33, 0x88, 0x06, 0x71, 0x80, 0x8E,
  0x10, 0x31, 0xC3, 0x04, 0x38, 0x21, 0x87, 0x06, 0x30, 0xE0, 0xC4, 0x1C,
  0x09, 0x83, 0x81, 0xA0, 0x70, 0x1C, 0x0E, 0x03, 0x01, 0xC0, 0x20, 0x38,
  0x08, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x18, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xD8,
  0x00, 0x76, 0x00, 0x1C, 0xC0, 0x07, 0x30, 0x01, 0xC6, 0x00, 0x71, 0x80,
  0x1C, 0x30, 0x07, 0x0C, 0x01, 0xC1, 0x80, 0x70, 0x60, 0x1C, 0x0C, 0x07,
  0x03, 0x01, 0xC0, 0x60, 0x70, 0x18, 0x1C, 0x03, 0x07, 0x00, 0xC1, 0xC0,
  0x18, 0x70, 0x06, 0x1C, 0x00, 0x87, 0x00, 0x31, 0xC0, 0x04, 0x70, 0x01,
  0x9C, 0x00, 0x27, 0x00, 0x0D, 0xC0, 0x01, 0x70, 0x00, 0x7C, 0x00, 0x0C,
  0x01, 0xFC, 0x00, 0x60, 0x70, 0x0C, 0x01, 0x81, 0x00, 0x0C, 0x30, 0x00,
  0x42, 0x00, 0x06, 0x60, 0x00, 0x24, 0x00, 0x02, 0x40, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x34, 0x00, 0x03,
  0x40, 0x00, 0x26, 0x00, 0x02, 0x20, 0x00, 0x63, 0x00, 0x04, 0x10, 0x00,
  0xC0, 0x80, 0x18, 0x06, 0x07, 0x00, 0x1F, 0x80, 0xFF, 0xFC, 0x20, 0x01,
  0x88, 0x00, 0x12, 0x00, 0x02, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x28, 0x00, 0x12, 0x00, 0x1C, 0xFF, 0xFC, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x60, 0x70, 0x08,
  0x01, 0x81, 0x00, 0x0C, 0x30, 0x00, 0x42, 0x00, 0x06, 0x60, 0x00, 0x24,
  0x00, 0x03, 0x40, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0x40, 0x00, 0x34, 0x00, 0x03, 0x60, 0x00, 0x22, 0x00, 0x06, 0x30,
  0x00, 0x41, 0x00, 0x0C, 0x08, 0x01, 0x80, 0x60, 0x70, 0x01, 0xF8, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0xFC,
  0xFF, 0xFC, 0x20, 0x01, 0x88, 0x00, 0x12, 0x00, 0x02, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x28, 0x00, 0x12, 0x00, 0x18,
  0xFF, 0xF8, 0x20, 0x30, 0x08, 0x04, 0x02, 0x01, 0x80, 0x80, 0x30, 0x20,
  0x0C, 0x08, 0x01, 0x82, 0x00, 0x30, 0x80, 0x0C, 0x20, 0x01, 0x88, 0x00,
  0x22, 0x00, 0x0C, 0x80, 0x01, 0xA0, 0x00, 0x68, 0x00, 0x0C, 0x03, 0xFE,
  0x00, 0xE0, 0x38, 0x30, 0x00, 0xE2, 0x00, 0x07, 0x60, 0x00, 0x24, 0x00,
  0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x02,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x80, 0x00, 0x3C, 0x00, 0x03, 0x60, 0x00, 0x63, 0x00,
  0x0C, 0x1E, 0x03, 0x80, 0x7F, 0xC0, 0xFF, 0xFF, 0xFE, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xD0, 0x00, 0x34, 0x00,
  0x0D, 0x80, 0x02, 0x20, 0x01, 0x8C, 0x00, 0xC1, 0xC0, 0x60, 0x1F, 0xE0,
  0xC0, 0x00, 0x0D, 0x00, 0x00, 0x36, 0x00, 0x00, 0x98, 0x00, 0x06, 0x20,
  0x00, 0x18, 0xC0, 0x00, 0x43, 0x00, 0x03, 0x04, 0x00, 0x0C, 0x18, 0x00,
  0x30, 0x60, 0x00, 0x80, 0x80, 0x06, 0x03, 0x00, 0x18, 0x0C, 0x00, 0x40,
  0x10, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x06, 0x01, 0x80, 0x08,
  0x06, 0x00, 0x30, 0x10, 0x00, 0xC0, 0xC0, 0x01, 0x03, 0x00, 0x06, 0x08,
  0x00, 0x18, 0x60, 0x00, 0x21, 0x80, 0x00, 0xC4, 0x00, 0x03, 0x30, 0x00,
  0x04, 0xC0, 0x00, 0x1A, 0x00, 0x00, 0x68, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x14, 0x00, 0x00, 0xD0, 0x00,
  0x03, 0x40, 0x00, 0x0D, 0x00, 0x00, 0x34, 0x00, 0x00, 0x90, 0x00, 0x02,
  0x60, 0x00, 0x09, 0x80, 0xC0, 0x26, 0x03, 0x80, 0x98, 0x0E, 0x02, 0x60,
  0x68, 0x18, 0x81, 0x20, 0x62, 0x04, 0xC1, 0x88, 0x33, 0x06, 0x20, 0xC4,
  0x18, 0x82, 0x18, 0x42, 0x08, 0x61, 0x0C, 0x60, 0x84, 0x31, 0x82, 0x10,
  0xC4, 0x0C, 0x43, 0x10, 0x31, 0x0C, 0xC0, 0x4C, 0x12, 0x01, 0x30, 0x48,
  0x06, 0xC1, 0x60, 0x1B, 0x05, 0x80, 0x2C, 0x14, 0x00, 0xE0, 0x70, 0x03,
  0x81, 0xC0, 0x06, 0x00, 0xE0, 0x00, 0x0C, 0xC0, 0x00, 0x30, 0xC0, 0x00,
  0x40, 0xC0, 0x01, 0x81, 0x80, 0x06, 0x01, 0x80, 0x0C, 0x01, 0x00, 0x30,
  0x03, 0x00, 0xC0, 0x03, 0x01, 0x80, 0x02, 0x06, 0x00, 0x06, 0x18, 0x00,
  0x06, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x0D, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x78, 0x00, 0x00, 0xD8, 0x00, 0x03, 0x10, 0x00, 0x0C,
  0x30, 0x00, 0x18, 0x30, 0x00, 0x60, 0x60, 0x00, 0x80, 0x60, 0x03, 0x00,
  0x60, 0x0C, 0x00, 0xC0, 0x10, 0x00, 0xC0, 0x60, 0x00, 0xC1, 0x80, 0x01,
  0x82, 0x00, 0x01, 0x8C, 0x00, 0x01, 0xB0, 0x00, 0x03, 0x80, 0xC0, 0x00,
  0x03, 0x60, 0x00, 0x02, 0x30, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x18, 0x00,
  0x08, 0x08, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x06, 0x00, 0x30, 0x02, 0x00,
  0x60, 0x03, 0x00, 0xC0, 0x01, 0x80, 0xC0, 0x01, 0x81, 0x80, 0x00, 0xC3,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x66, 0x00, 0x00, 0x34, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xF8, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x3F, 0xF8, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00,
  0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x03,
  0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x30,
  0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x0C, 0xFF, 0xE0, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x7F,
  0xF8, 0x00, 0x60, 0x00, 0x07, 0x80, 0x00, 0x36, 0x00, 0x03, 0x30, 0x00,
  0x10, 0xC0, 0x01, 0x82, 0x00, 0x08, 0x18, 0x00, 0xC0, 0x40, 0x0C, 0x03,
  0x00, 0x40, 0x0C, 0x06, 0x00, 0x20, 0x20, 0x01, 0x83, 0x00, 0x04, 0x30,
  0x00, 0x31, 0x00, 0x00, 0xD8, 0x00, 0x02, 0x80, 0x00, 0x18, 0xFF, 0xFF,
  0xF8, 0x83, 0x04, 0x18, 0x30, 0x40, 0x83, 0x03, 0xF0, 0x00, 0x60, 0x60,
  0x04, 0x00, 0x80, 0x40, 0x06, 0x06, 0x00, 0x18, 0x20, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x0F, 0xFF, 0x01, 0x80, 0x18, 0x10, 0x00, 0xC1, 0x80, 0x06, 0x08, 0x00,
  0x30, 0xC0, 0x01, 0x86, 0x00, 0x0C, 0x30, 0x00, 0x60, 0x80, 0x03, 0x04,
  0x00, 0x38, 0x30, 0x02, 0xC0, 0xE0, 0x63, 0xE1, 0xFC, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x3F, 0x03, 0x30,
  0x70, 0xD0, 0x06, 0x38, 0x00, 0xCC, 0x00, 0x1B, 0x00, 0x06, 0xC0, 0x00,
  0xB0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x02, 0xC0, 0x01, 0xB0, 0x00, 0x6E, 0x00, 0x33, 0x40, 0x18, 0xCC, 0x1C,
  0x00, 0xFC, 0x00, 0x03, 0xF8, 0x06, 0x07, 0x04, 0x00, 0xC4, 0x00, 0x26,
  0x00, 0x1A, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x12, 0x00, 0x18,
  0x80, 0x18, 0x30, 0x38, 0x07, 0xF0, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x10, 0x3F, 0x84, 0x38, 0x19, 0x18, 0x03, 0x4C,
  0x00, 0x52, 0x00, 0x0D, 0x80, 0x03, 0x60, 0x00, 0x50, 0x00, 0x14, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x50, 0x00, 0x14, 0x00, 0x05, 0x80, 0x01, 0x60, 0x00, 0xC8,
  0x00, 0x33, 0x00, 0x14, 0x60, 0x0D, 0x0E, 0x04, 0x40, 0xFE, 0x00, 0x03,
  0xF8, 0x01, 0x81, 0xC0, 0x60, 0x0C, 0x18, 0x00, 0xC6, 0x00, 0x08, 0x80,
  0x01, 0xB0, 0x00, 0x36, 0x00, 0x02, 0xC0, 0x00, 0x58, 0x00, 0x0E, 0x00,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x08, 0x00, 0x09, 0x00, 0x03, 0x30, 0x00, 0x43, 0x00,
  0x18, 0x30, 0x06, 0x03, 0x83, 0x80, 0x1F, 0xC0, 0x00, 0x7F, 0xF0, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0xFF, 0xFF, 0xF0,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x20,
  0x03, 0xF2, 0x00, 0xC0, 0xE0, 0x18, 0x03, 0x03, 0x00, 0x10, 0x30, 0x01,
  0x82, 0x00, 0x18, 0x60, 0x00, 0x86, 0x00, 0x08, 0x60, 0x00, 0x82, 0x00,
  0x18, 0x20, 0x01, 0x83, 0x00, 0x10, 0x18, 0x02, 0x00, 0xC0, 0xC0, 0x07,
  0xF0, 0x01, 0x80, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x00, 0xFF, 0xF8, 0x30, 0x00, 0xC6, 0x00, 0x02,
  0xC0, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00,
  0x26, 0x00, 0x06, 0x38, 0x01, 0x80, 0x7F, 0xC0, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0xFC, 0x19, 0x83, 0x8D, 0x00, 0x67,
  0x00, 0x13, 0x00, 0x0D, 0x80, 0x02, 0xC0, 0x01, 0x60, 0x00, 0xB0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x06, 0x00, 0x0F, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x7F, 0xFC, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x07, 0x40, 0x01, 0x88, 0x00, 0x61, 0x00, 0x18, 0x20,
  0x06, 0x04, 0x03, 0x80, 0x80, 0xC0, 0x10, 0x30, 0x02, 0x0C, 0x00, 0x43,
  0x80, 0x08, 0xD8, 0x01, 0x31, 0x80, 0x2C, 0x30, 0x06, 0x03, 0x00, 0x80,
  0x30, 0x10, 0x03, 0x02, 0x00, 0x30, 0x40, 0x06, 0x08, 0x00, 0x61, 0x00,
  0x06, 0x20, 0x00, 0x64, 0x00, 0x06, 0x80, 0x00, 0x60, 0xFF, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0xFF, 0xFF, 0xE0, 0x8F, 0x07, 0xC9, 0x0C, 0x86, 0xA0, 0x50, 0x3C,
  0x06, 0x01, 0xC0, 0x60, 0x1C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x10, 0xC3, 0xF0, 0x66, 0x0E, 0x34, 0x01, 0x9C, 0x00, 0x4C, 0x00,
  0x36, 0x00, 0x0B, 0x00, 0x05, 0x80, 0x02, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x06, 0x03, 0xF0, 0x01, 0x81, 0xC0, 0x60, 0x0C, 0x10, 0x00,
  0xC6, 0x00, 0x08, 0x80, 0x01, 0xB0, 0x00, 0x36, 0x00, 0x02, 0xC0, 0x00,
  0x50, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1E, 0x00, 0x02, 0xC0, 0x00, 0x58, 0x00, 0x19, 0x00, 0x03,
  0x30, 0x00, 0x42, 0x00, 0x18, 0x20, 0x06, 0x03, 0x03, 0x00, 0x1F, 0xC0,
  0xC3, 0xF0, 0x33, 0x07, 0x0D, 0x00, 0x63, 0x80, 0x0C, 0xC0, 0x01, 0xB0,
  0x00, 0x6C, 0x00, 0x0B, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x2C, 0x00, 0x1B, 0x00, 0x06, 0xE0, 0x03, 0x34,
  0x01, 0x8C, 0xC1, 0xC3, 0x0F, 0xC0, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0x03, 0xF8, 0x43, 0x81, 0x91, 0x80, 0x34, 0xC0, 0x05, 0x20, 0x00, 0xD8,
  0x00, 0x36, 0x00, 0x05, 0x00, 0x01, 0x40, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x05, 0x00, 0x01,
  0x40, 0x00, 0x58, 0x00, 0x16, 0x00, 0x0C, 0x80, 0x03, 0x30, 0x01, 0x46,
  0x00, 0xD0, 0xE0, 0x44, 0x0F, 0xE1, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01,
  0xFF, 0xC3, 0xFC, 0x03, 0x30, 0x00, 0x0D, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xF8, 0x03, 0x80, 0xC0, 0xC0, 0x06, 0x30,
  0x00, 0x66, 0x00, 0x08, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0xE0, 0x00, 0x26, 0x00, 0x0C, 0x60, 0x03, 0x07, 0x01, 0xC0, 0x1F,
  0xE0, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0xFF, 0xFF,
  0xF8, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0xFF, 0xE0, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x01, 0xC0,
  0x03, 0x40, 0x03, 0x60, 0x05, 0x20, 0x05, 0x18, 0x19, 0x07, 0xE0, 0xC0,
  0x00, 0x78, 0x00, 0x09, 0x00, 0x03, 0x30, 0x00, 0x46, 0x00, 0x18, 0x40,
  0x03, 0x0C, 0x00, 0x40, 0x80, 0x18, 0x10, 0x03, 0x03, 0x00, 0x40, 0x20,
  0x18, 0x06, 0x02, 0x00, 0xC0, 0x40, 0x08, 0x18, 0x01, 0x82, 0x00, 0x30,
  0xC0, 0x02, 0x18, 0x00, 0x62, 0x00, 0x04, 0xC0, 0x00, 0x90, 0x00, 0x1A,
  0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x80, 0x30, 0x07, 0x00, 0x70, 0x0E,
  0x00, 0xA0, 0x16, 0x03, 0x40, 0x2C, 0x04, 0x80, 0x48, 0x09, 0x80, 0x90,
  0x11, 0x03, 0x20, 0x62, 0x04, 0x40, 0x84, 0x08, 0xC1, 0x08, 0x11, 0x82,
  0x18, 0x21, 0x0C, 0x10, 0xC2, 0x10, 0x21, 0x84, 0x20, 0x42, 0x08, 0x40,
  0xC4, 0x18, 0x80, 0x88, 0x12, 0x01, 0x10, 0x24, 0x02, 0x60, 0x48, 0x06,
  0xC0, 0x90, 0x05, 0x01, 0xE0, 0x0A, 0x03, 0x80, 0x14, 0x03, 0x00, 0x38,
  0x00, 0xC0, 0x00, 0xEC, 0x00, 0x18, 0x80, 0x06, 0x18, 0x01, 0x81, 0x80,
  0x60, 0x18, 0x0C, 0x01, 0x03, 0x00, 0x30, 0xC0, 0x03, 0x10, 0x00, 0x36,
  0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1E, 0x00, 0x03, 0x60, 0x00, 0xC4,
  0x00, 0x30, 0xC0, 0x0C, 0x0C, 0x01, 0x80, 0xC0, 0x60, 0x08, 0x18, 0x01,
  0x86, 0x00, 0x18, 0xC0, 0x01, 0xB0, 0x00, 0x18, 0xC0, 0x00, 0x36, 0x00,
  0x02, 0x60, 0x00, 0x62, 0x00, 0x06, 0x30, 0x00, 0x41, 0x00, 0x0C, 0x18,
  0x00, 0x81, 0x80, 0x18, 0x08, 0x01, 0x80, 0xC0, 0x10, 0x04, 0x03, 0x00,
  0x60, 0x20, 0x06, 0x06, 0x00, 0x20, 0x60, 0x03, 0x04, 0x00, 0x10, 0xC0,
  0x01, 0x88, 0x00, 0x19, 0x80, 0x00, 0x98, 0x00, 0x0D, 0x00, 0x00, 0x70,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C,
  0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03,
  0x00, 0x07, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x08, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x10, 0x00, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x01, 0xC0, 0xFE, 0x00,
  0x03, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20,
  0x00, 0x60, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xC0, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x03, 0x00,
  0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00,
  0x01, 0x80, 0x00, 0x7F, 0x01, 0xC0, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x40, 0xFF, 0xC0, 0x1E, 0x00, 0x09, 0x8C, 0x00, 0xD8,
  0x30, 0x04, 0x80, 0xC0, 0x2C, 0x02, 0x03, 0x40, 0x08, 0x12, 0x00, 0x31,
  0x10, 0x00, 0xF0,
};

const GFXglyph IBMPlexMono_ExtraLight44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 26, 0, -1 },
  { 1, 4, 31, 26, 11, -31 },
  { 17, 8, 11, 26, 9, -33 },
  { 28, 25, 31, 26, 1, -31 },
  { 125, 20, 40, 26, 3, -35 },
  { 225, 24, 32, 26, 1, -31 },
  { 321, 22, 32, 26, 2, -31 },
  { 409, 2, 11, 26, 12, -33 },
  { 412, 11, 39, 26, 10, -33 },
  { 466, 10, 39, 26, 6, -33 },
  { 515, 22, 22, 26, 2, -24 },
  { 576, 21, 21, 26, 3, -24 },
  { 632, 5, 11, 26, 10, -4 },
  { 639, 12, 1, 26, 7, -14 },
  { 641, 4, 4, 26, 11, -4 },
  { 643, 18, 39, 26, 4, -33 },
  { 731, 20, 32, 26, 3, -31 },
  { 811, 21, 31, 26, 3, -31 },
  { 893, 19, 31, 26, 4, -31 },
  { 967, 19, 32, 26, 3, -31 },
  { 1043, 22, 31, 26, 2, -31 },
  { 1129, 19, 32, 26, 4, -31 },
  { 1205, 19, 32, 26, 4, -31 },
  { 1281, 20, 31, 26, 3, -31 },
  { 1359, 20, 32, 26, 3, -31 },
  { 1439, 19, 31, 26, 4, -31 },
  { 1513, 4, 24, 26, 11, -24 },
  { 1525, 5, 31, 26, 10, -24 },
  { 1545, 19, 24, 26, 4, -25 },
  { 1602, 21, 9, 26, 3, -18 },
  { 1626, 19, 24, 26, 4, -25 },
  { 1683, 18, 31, 26, 4, -31 },
  { 1753, 18, 36, 26, 4, -31 },
  { 1834, 22, 31, 26, 2, -31 },
  { 1920, 19, 31, 26, 4, -31 },
  { 1994, 20, 32, 26, 3, -31 },
  { 2074, 18, 31, 26, 5, -31 },
  { 2144, 18, 31, 26, 5, -31 },
  { 2214, 18, 31, 26, 5, -31 },
  { 2284, 20, 32, 26, 3, -31 },
  { 2364, 18, 31, 26, 4, -31 },
  { 2434, 18, 31, 26, 4, -31 },
  { 2504, 17, 32, 26, 4, -31 },
  { 2572, 19, 31, 26, 5, -31 },
  { 2646, 17, 31, 26, 6, -31 },
  { 2712, 19, 31, 26, 4, -31 },
  { 2786, 18, 31, 26, 4, -31 },
  { 2856, 20, 32, 26, 3, -31 },
  { 2936, 18, 31, 26, 5, -31 },
  { 3006, 20, 36, 26, 3, -31 },
  { 3096, 18, 31, 26, 5, -31 },
  { 3166, 20, 32, 26, 3, -31 },
  { 3246, 23, 31, 26, 2, -31 },
  { 3336, 18, 32, 26, 4, -31 },
  { 3408, 22, 31, 26, 2, -31 },
  { 3494, 22, 31, 26, 2, -31 },
  { 3580, 23, 31, 26, 2, -31 },
  { 3670, 24, 31, 26, 1, -31 },
  { 3763, 22, 31, 26, 2, -31 },
  { 3849, 11, 39, 26, 11, -33 },
  { 3903, 18, 39, 26, 4, -33 },
  { 3991, 11, 39, 26, 4, -33 },
  { 4045, 21, 17, 26, 3, -31 },
  { 4090, 21, 1, 26, 3, 5 },
  { 4093, 6, 8, 26, 9, -34 },
  { 4099, 21, 24, 26, 3, -23 },
  { 4162, 18, 34, 26, 5, -33 },
  { 4239, 17, 24, 26, 5, -23 },
  { 4290, 18, 34, 26, 3, -33 },
  { 4367, 19, 24, 26, 4, -23 },
  { 4424, 20, 33, 26, 4, -33 },
  { 4507, 20, 34, 26, 4, -25 },
  { 4592, 17, 33, 26, 5, -33 },
  { 4663, 19, 33, 26, 5, -33 },
  { 4742, 16, 42, 26, 4, -33 },
  { 4826, 19, 33, 26, 6, -33 },
  { 4905, 19, 33, 26, 4, -33 },
  { 4984, 20, 23, 26, 3, -23 },
  { 5042, 17, 23, 26, 5, -23 },
  { 5091, 19, 24, 26, 4, -23 },
  { 5148, 18, 32, 26, 5, -23 },
  { 5220, 18, 32, 26, 3, -23 },
  { 5292, 22, 23, 26, 3, -23 },
  { 5356, 19, 24, 26, 4, -23 },
  { 5413, 21, 31, 26, 2, -31 },
  { 5495, 16, 24, 26, 5, -23 },
  { 5543, 19, 23, 26, 4, -23 },
  { 5598, 23, 23, 26, 2, -23 },
  { 5665, 19, 23, 26, 4, -23 },
  { 5720, 20, 32, 26, 3, -23 },
  { 5800, 18, 23, 26, 4, -23 },
  { 5852, 16, 39, 26, 5, -33 },
  { 5930, 2, 39, 26, 12, -33 },
  { 5940, 16, 39, 26, 5, -33 },
  { 6018, 21, 8, 26, 3, -17 },
};

const GFXfont IBMPlexMono_ExtraLight44pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLight44pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLight44pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _IBMPLEXMONO_EXTRALIGHT44PT7B_H_
