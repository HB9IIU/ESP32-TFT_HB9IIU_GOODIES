#ifndef _IBMPLEXMONO_EXTRALIGHT10PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHT10PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLight.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLight10pt7bBitmaps[] PROGMEM = {
  0x00, 0xFA, 0xFC, 0x28, 0xC4, 0xD4, 0xC9, 0x45, 0x00, 0x4E, 0xDC, 0x75,
  0xD7, 0x40, 0x6E, 0xA7, 0x00, 0x5A, 0x99, 0x80, 0x74, 0x90, 0xD9, 0xC9,
  0xE0, 0xE0, 0x72, 0x49, 0x24, 0x60, 0x89, 0x12, 0x52, 0x80, 0x20, 0x8F,
  0xCC, 0x48, 0x44, 0xF4, 0x40, 0xE0, 0xC0, 0x80, 0x12, 0x22, 0x44, 0x88,
  0x80, 0x69, 0x9D, 0x99, 0x60, 0x46, 0x30, 0x84, 0x23, 0xE0, 0x69, 0x11,
  0x2C, 0xF0, 0x79, 0x61, 0x19, 0x60, 0x10, 0xC5, 0x24, 0x7E, 0x41, 0x00,
  0xF8, 0xE9, 0x19, 0x60, 0x68, 0x8F, 0x99, 0x70, 0xF9, 0x22, 0x44, 0x80,
  0xF9, 0x96, 0x99, 0xF0, 0x79, 0x9F, 0x12, 0x40, 0x88, 0x8E, 0x16, 0x84,
  0x30, 0xFF, 0x86, 0x12, 0xC0, 0x79, 0x12, 0x40, 0x40, 0x69, 0xBD, 0xDF,
  0x87, 0x20, 0xC5, 0x14, 0x7A, 0x28, 0xC0, 0xF9, 0x9E, 0x99, 0xF0, 0x69,
  0x88, 0x89, 0x60, 0xE9, 0x99, 0x99, 0xE0, 0xF8, 0x8F, 0x88, 0xF0, 0xF8,
  0x8F, 0x88, 0x80, 0x69, 0x8B, 0x99, 0x70, 0x99, 0x9F, 0x99, 0x90, 0xF4,
  0x44, 0x44, 0xF0, 0x71, 0x11, 0x19, 0x60, 0x9D, 0x31, 0x8A, 0x4A, 0x60,
  0x88, 0x88, 0x88, 0xF0, 0x99, 0xBF, 0xD9, 0x90, 0x99, 0xDD, 0xBB, 0x90,
  0x69, 0x99, 0x99, 0x60, 0xF9, 0x99, 0xF8, 0x80, 0x69, 0x99, 0x99, 0x64,
  0x30, 0xF9, 0x99, 0xFA, 0x90, 0xE9, 0x87, 0x19, 0x70, 0xFC, 0x82, 0x08,
  0x20, 0x82, 0x00, 0x99, 0x99, 0x99, 0xF0, 0x8E, 0x24, 0x94, 0x50, 0xC2,
  0x00, 0x99, 0xDF, 0xBB, 0xB0, 0x89, 0x43, 0x08, 0x51, 0x28, 0xC0, 0x8D,
  0x25, 0x0C, 0x20, 0x82, 0x00, 0x78, 0x21, 0x08, 0x42, 0x0F, 0xC0, 0xEA,
  0xAA, 0xC0, 0x88, 0x84, 0x42, 0x22, 0x10, 0xD5, 0x55, 0xC0, 0x4A, 0x99,
  0xF0, 0xC0, 0xE1, 0xF9, 0xF0, 0x88, 0xF9, 0x99, 0xF0, 0x69, 0x89, 0x60,
  0x11, 0xF9, 0x99, 0xF0, 0x69, 0xF8, 0x70, 0x34, 0xF4, 0x44, 0xF0, 0x1B,
  0x25, 0xC8, 0x3A, 0x5E, 0x88, 0xE9, 0x99, 0x90, 0x20, 0xE2, 0x22, 0xF0,
  0x23, 0x92, 0x49, 0xE0, 0x84, 0x25, 0x4E, 0x52, 0x60, 0xC4, 0x44, 0x44,
  0xF0, 0xDF, 0xDD, 0xD0, 0xE9, 0x99, 0x90, 0x69, 0x99, 0x60, 0xF9, 0x99,
  0xF8, 0x80, 0xF9, 0x99, 0xF1, 0x10, 0xFA, 0x10, 0x8F, 0x00, 0xE9, 0x71,
  0xF0, 0x21, 0x3E, 0x42, 0x10, 0xE0, 0x99, 0x99, 0x70, 0x99, 0xA6, 0x40,
  0xA6, 0xED, 0xB6, 0xD8, 0x9A, 0x4A, 0x90, 0x99, 0xA6, 0x44, 0x80, 0xF2,
  0x48, 0xF0, 0x34, 0x42, 0xC2, 0x44, 0x30, 0xFF, 0x80, 0xC4, 0x44, 0x34,
  0x44, 0xC0, 0xDD, 0xB0,
};

const GFXglyph IBMPlexMono_ExtraLight10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 1, 7, 6, 3, -7 },
  { 2, 2, 3, 6, 2, -7 },
  { 3, 6, 7, 6, 0, -7 },
  { 9, 4, 9, 6, 1, -8 },
  { 14, 6, 7, 6, 0, -7 },
  { 20, 5, 7, 6, 0, -7 },
  { 25, 1, 3, 6, 3, -7 },
  { 26, 3, 9, 6, 2, -8 },
  { 30, 3, 9, 6, 1, -8 },
  { 34, 6, 5, 6, 0, -5 },
  { 38, 4, 5, 6, 1, -6 },
  { 41, 1, 3, 6, 2, -1 },
  { 42, 2, 1, 6, 2, -4 },
  { 43, 1, 1, 6, 3, -1 },
  { 44, 4, 9, 6, 1, -8 },
  { 49, 4, 7, 6, 1, -7 },
  { 53, 5, 7, 6, 1, -7 },
  { 58, 4, 7, 6, 1, -7 },
  { 62, 4, 7, 6, 1, -7 },
  { 66, 6, 7, 6, 0, -7 },
  { 72, 4, 7, 6, 1, -7 },
  { 76, 4, 7, 6, 1, -7 },
  { 80, 4, 7, 6, 1, -7 },
  { 84, 4, 7, 6, 1, -7 },
  { 88, 4, 7, 6, 1, -7 },
  { 92, 1, 5, 6, 3, -5 },
  { 93, 1, 7, 6, 2, -5 },
  { 94, 4, 5, 6, 1, -6 },
  { 97, 4, 2, 6, 1, -4 },
  { 98, 4, 5, 6, 1, -6 },
  { 101, 4, 7, 6, 1, -7 },
  { 105, 4, 8, 6, 1, -7 },
  { 109, 6, 7, 6, 0, -7 },
  { 115, 4, 7, 6, 1, -7 },
  { 119, 4, 7, 6, 1, -7 },
  { 123, 4, 7, 6, 1, -7 },
  { 127, 4, 7, 6, 1, -7 },
  { 131, 4, 7, 6, 1, -7 },
  { 135, 4, 7, 6, 1, -7 },
  { 139, 4, 7, 6, 1, -7 },
  { 143, 4, 7, 6, 1, -7 },
  { 147, 4, 7, 6, 1, -7 },
  { 151, 5, 7, 6, 1, -7 },
  { 156, 4, 7, 6, 1, -7 },
  { 160, 4, 7, 6, 1, -7 },
  { 164, 4, 7, 6, 1, -7 },
  { 168, 4, 7, 6, 1, -7 },
  { 172, 4, 7, 6, 1, -7 },
  { 176, 4, 9, 6, 1, -7 },
  { 181, 4, 7, 6, 1, -7 },
  { 185, 4, 7, 6, 1, -7 },
  { 189, 6, 7, 6, 0, -7 },
  { 195, 4, 7, 6, 1, -7 },
  { 199, 6, 7, 6, 0, -7 },
  { 205, 4, 7, 6, 1, -7 },
  { 209, 6, 7, 6, 0, -7 },
  { 215, 6, 7, 6, 0, -7 },
  { 221, 6, 7, 6, 0, -7 },
  { 227, 2, 9, 6, 3, -8 },
  { 230, 4, 9, 6, 1, -8 },
  { 235, 2, 9, 6, 1, -8 },
  { 238, 4, 4, 6, 1, -7 },
  { 240, 4, 1, 6, 1, 1 },
  { 241, 1, 2, 6, 2, -8 },
  { 242, 4, 5, 6, 1, -5 },
  { 245, 4, 7, 6, 1, -7 },
  { 249, 4, 5, 6, 1, -5 },
  { 252, 4, 7, 6, 1, -7 },
  { 256, 4, 5, 6, 1, -5 },
  { 259, 4, 7, 6, 1, -7 },
  { 263, 5, 8, 6, 1, -6 },
  { 268, 4, 7, 6, 1, -7 },
  { 272, 4, 7, 6, 1, -7 },
  { 276, 3, 9, 6, 1, -7 },
  { 280, 5, 7, 6, 1, -7 },
  { 285, 4, 7, 6, 1, -7 },
  { 289, 4, 5, 6, 1, -5 },
  { 292, 4, 5, 6, 1, -5 },
  { 295, 4, 5, 6, 1, -5 },
  { 298, 4, 7, 6, 1, -5 },
  { 302, 4, 7, 6, 1, -5 },
  { 306, 5, 5, 6, 1, -5 },
  { 310, 4, 5, 6, 1, -5 },
  { 313, 5, 7, 6, 0, -7 },
  { 318, 4, 5, 6, 1, -5 },
  { 321, 4, 5, 6, 1, -5 },
  { 324, 6, 5, 6, 0, -5 },
  { 328, 4, 5, 6, 1, -5 },
  { 331, 4, 7, 6, 1, -5 },
  { 335, 4, 5, 6, 1, -5 },
  { 338, 4, 9, 6, 1, -8 },
  { 343, 1, 9, 6, 3, -8 },
  { 345, 4, 9, 6, 1, -8 },
  { 350, 4, 3, 6, 1, -4 },
};

const GFXfont IBMPlexMono_ExtraLight10pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLight10pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLight10pt7bGlyphs,
  0x20, 0x7E, 13
};

#endif // _IBMPLEXMONO_EXTRALIGHT10PT7B_H_
