#ifndef _IBMPLEXMONO_EXTRALIGHT68PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHT68PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLight.ttf
// Size: 68pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLight68pt7bBitmaps[] PROGMEM = {
  0x00, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3,
  0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x0C, 0x30, 0xC1, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xDF, 0xFD, 0xF7,
  0xC0, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x30, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x38,
  0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x01, 0xC0,
  0x00, 0x00, 0x60, 0x07, 0x00, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFC,
  0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x00, 0x60, 0x07, 0x00, 0x00, 0x01, 0x80,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00,
  0x00, 0xE0, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0x0C, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00,
  0x07, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x03, 0xFF, 0xE0, 0x07,
  0xFF, 0xCF, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x00, 0x03, 0x80, 0x38,
  0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x06, 0x00,
  0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x03,
  0xF0, 0xC7, 0xE0, 0x07, 0x80, 0xC0, 0xF8, 0x0E, 0x00, 0xC0, 0x3C, 0x1C,
  0x00, 0xC0, 0x1E, 0x18, 0x00, 0xC0, 0x0F, 0x38, 0x00, 0xC0, 0x04, 0x30,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x70, 0x00, 0xC0, 0x00, 0x70,
  0x00, 0xC0, 0x00, 0x70, 0x00, 0xC0, 0x00, 0x70, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x38, 0x00, 0xC0, 0x00, 0x38,
  0x00, 0xC0, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x07,
  0x00, 0xC0, 0x00, 0x03, 0xE0, 0xC0, 0x00, 0x01, 0xFE, 0xC0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xCF, 0xE0, 0x00,
  0x00, 0xC1, 0xF0, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x00, 0xC0, 0x1C, 0x00,
  0x00, 0xC0, 0x0E, 0x00, 0x00, 0xC0, 0x0E, 0x00, 0x00, 0xC0, 0x07, 0x00,
  0x00, 0xC0, 0x07, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0xC0, 0x03, 0x00,
  0x00, 0xC0, 0x03, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0xC0, 0x03, 0x00,
  0x00, 0xC0, 0x03, 0x00, 0x00, 0xC0, 0x07, 0x60, 0x00, 0xC0, 0x07, 0xF0,
  0x00, 0xC0, 0x06, 0x70, 0x00, 0xC0, 0x0E, 0x3C, 0x00, 0xC0, 0x1C, 0x1E,
  0x00, 0xC0, 0x38, 0x0F, 0x80, 0xC0, 0xF0, 0x03, 0xF0, 0xC3, 0xE0, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xC7, 0x83, 0xC0, 0x00,
  0x0C, 0x70, 0x07, 0x00, 0x00, 0xE3, 0x00, 0x1C, 0x00, 0x06, 0x30, 0x00,
  0x60, 0x00, 0x61, 0x80, 0x03, 0x80, 0x03, 0x0C, 0x00, 0x0C, 0x00, 0x30,
  0xC0, 0x00, 0x60, 0x03, 0x86, 0x00, 0x03, 0x00, 0x18, 0x30, 0x00, 0x18,
  0x01, 0xC1, 0x80, 0x00, 0xC0, 0x0C, 0x0C, 0x00, 0x06, 0x00, 0xC0, 0x60,
  0x00, 0x30, 0x06, 0x03, 0x00, 0x01, 0x80, 0x60, 0x0C, 0x00, 0x0C, 0x07,
  0x00, 0x60, 0x00, 0xE0, 0x30, 0x03, 0x00, 0x06, 0x03, 0x00, 0x0C, 0x00,
  0x70, 0x18, 0x00, 0x70, 0x07, 0x01, 0x80, 0x01, 0xE0, 0xF0, 0x1C, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xC0, 0x70,
  0x3C, 0x00, 0x1C, 0x07, 0x00, 0x70, 0x00, 0xC0, 0x70, 0x01, 0x80, 0x0E,
  0x03, 0x00, 0x0E, 0x00, 0x60, 0x30, 0x00, 0x30, 0x06, 0x01, 0x80, 0x01,
  0x80, 0x30, 0x0C, 0x00, 0x0C, 0x03, 0x00, 0x60, 0x00, 0x70, 0x38, 0x03,
  0x00, 0x03, 0x81, 0x80, 0x18, 0x00, 0x1C, 0x1C, 0x00, 0xC0, 0x00, 0xE0,
  0xC0, 0x06, 0x00, 0x07, 0x0C, 0x00, 0x30, 0x00, 0x30, 0x60, 0x01, 0x80,
  0x01, 0x86, 0x00, 0x0C, 0x00, 0x0C, 0x70, 0x00, 0x30, 0x00, 0xE3, 0x00,
  0x01, 0xC0, 0x06, 0x30, 0x00, 0x07, 0x00, 0x71, 0x80, 0x00, 0x1C, 0x0F,
  0x18, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x07,
  0x00, 0x3C, 0x00, 0x03, 0x80, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x60, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x04, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x1F, 0xC3, 0x83, 0x80, 0x07,
  0xF1, 0xC0, 0x70, 0x01, 0x80, 0xE0, 0x0C, 0x00, 0xE0, 0x30, 0x03, 0x80,
  0x38, 0x1C, 0x00, 0x70, 0x0E, 0x06, 0x00, 0x0E, 0x03, 0x03, 0x80, 0x01,
  0xC0, 0xC0, 0xC0, 0x00, 0x38, 0x30, 0x30, 0x00, 0x07, 0x0C, 0x0C, 0x00,
  0x00, 0xC3, 0x03, 0x00, 0x00, 0x38, 0xC0, 0xC0, 0x00, 0x07, 0x60, 0x30,
  0x00, 0x00, 0xF8, 0x0C, 0x00, 0x00, 0x1E, 0x03, 0x00, 0x00, 0x03, 0x80,
  0xE0, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x00, 0x6E, 0x07, 0x00, 0x00, 0x31,
  0xC1, 0xC0, 0x00, 0x1C, 0x30, 0x38, 0x00, 0x0E, 0x0E, 0x07, 0x80, 0x07,
  0x01, 0xC0, 0xF8, 0x0F, 0x80, 0x38, 0x0F, 0xFF, 0x80, 0x07, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x07,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0xC0,
  0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07,
  0xE0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70,
  0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x07,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38,
  0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1D, 0xFC,
  0x01, 0xC0, 0x1F, 0xC7, 0xF0, 0x38, 0x1F, 0xC0, 0x1F, 0xC7, 0x1F, 0xC0,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x0E,
  0x30, 0x00, 0x00, 0x01, 0x87, 0x00, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00,
  0x1C, 0x07, 0x00, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x07, 0x00,
  0x00, 0x18, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0F, 0x0F, 0x1E, 0x1E, 0x1E, 0x1C, 0x3C, 0x3C,
  0x38, 0x38, 0x30, 0x70, 0x70, 0x60, 0x60, 0x60, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x7D, 0xFF, 0xDF, 0x7C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x70, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x1C, 0x0C,
  0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x38, 0x60, 0x00, 0x00, 0x31, 0xC0,
  0x00, 0x00, 0x63, 0x80, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x01, 0xB8, 0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0xE0,
  0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80,
  0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x33,
  0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x03, 0x9C,
  0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x38, 0x30,
  0x00, 0x00, 0x60, 0x70, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x07, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x70, 0x00, 0x70, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x00, 0x78,
  0xE0, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x03, 0xC0,
  0xE0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x3C, 0x00,
  0xE0, 0x00, 0x78, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x60, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7C, 0x03,
  0xE0, 0x03, 0x80, 0x03, 0xC0, 0x1C, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x00, 0xE3,
  0x00, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3E, 0x01,
  0xF0, 0x01, 0xE0, 0x00, 0xF0, 0x0E, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x03,
  0x81, 0x80, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x1C, 0x10, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x39,
  0x80, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x38, 0x1C,
  0x00, 0x01, 0xE0, 0x3C, 0x00, 0x0F, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x00, 0x07, 0x38,
  0x00, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x00, 0x0E,
  0x1C, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x00, 0x60, 0x70, 0x00, 0x00,
  0x1C, 0x0E, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x38, 0x00,
  0x00, 0x30, 0x07, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x1C,
  0x00, 0x00, 0x60, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x03, 0x00,
  0x0E, 0x00, 0x00, 0xC0, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x38, 0x00, 0x06,
  0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x0C, 0x00, 0x03, 0x80, 0x03, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x18, 0x00, 0x01, 0xC0, 0x06, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x00, 0x1C, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x7F, 0xC0, 0x03, 0x0F, 0xFF, 0xC0,
  0x19, 0xE0, 0x0F, 0x80, 0xDC, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x78, 0x38,
  0x00, 0x01, 0xE2, 0x80, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00,
  0x67, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x70, 0x70, 0x00, 0x07, 0x01,
  0xE0, 0x00, 0x70, 0x07, 0xE0, 0x1F, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x3F, 0xC0, 0x07, 0x0F, 0xFF, 0xC0, 0x31, 0xE0, 0x1F, 0x81, 0x9C, 0x00,
  0x1E, 0x1D, 0x80, 0x00, 0x78, 0xF8, 0x00, 0x01, 0xE6, 0x80, 0x00, 0x07,
  0x3C, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x71, 0x80, 0x00, 0x07, 0x06, 0x00,
  0x00, 0x70, 0x38, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x78, 0x01, 0xE0, 0x1F,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3B, 0x00, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x03, 0x30, 0x00,
  0x00, 0x1C, 0xC0, 0x00, 0x00, 0x63, 0x00, 0x00, 0x03, 0x8C, 0x00, 0x00,
  0x0C, 0x30, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x0F, 0x80, 0x3E, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x1C,
  0x30, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x00, 0x73,
  0x80, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x03, 0x9C,
  0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x38, 0x30,
  0x00, 0x00, 0x60, 0x70, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x07, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x03, 0x80, 0x70, 0x00,
  0x03, 0xC1, 0xC0, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x01, 0x8E, 0x00, 0x00,
  0x03, 0xB8, 0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00, 0x39,
  0xC0, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0x3C, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xF8,
  0x0F, 0x80, 0x1E, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x1C, 0x0C, 0x00, 0x00,
  0x60, 0xE0, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x33,
  0x00, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x76, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x3C, 0xE0,
  0x00, 0x01, 0x67, 0x00, 0x00, 0x1F, 0x1E, 0x00, 0x01, 0xB8, 0x78, 0x00,
  0x39, 0x81, 0xF8, 0x07, 0x8C, 0x03, 0xFF, 0xF0, 0xE0, 0x03, 0xFC, 0x06,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7D, 0xFF, 0xDF,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xDF, 0xFD, 0xF7, 0xC0,
  0x1F, 0x1F, 0x3F, 0x1F, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x0F, 0x1E, 0x1E, 0x1E, 0x1C, 0x3C,
  0x3C, 0x38, 0x38, 0x30, 0x70, 0x70, 0x60, 0x60, 0x60, 0xC0, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xE0, 0x1E,
  0x00, 0xF0, 0x00, 0x78, 0x1E, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x1C, 0x38,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x76, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xE0, 0x3E,
  0x00, 0x78, 0x00, 0xF0, 0x06, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x18, 0x1C,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x06, 0x30, 0x00, 0x00, 0x67, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x76,
  0x00, 0x00, 0x03, 0x60, 0x01, 0xF8, 0x36, 0x00, 0x7F, 0xE3, 0xE0, 0x0F,
  0x03, 0x3E, 0x01, 0xC0, 0x1B, 0xC0, 0x18, 0x00, 0xBC, 0x03, 0x80, 0x07,
  0xC0, 0x30, 0x00, 0x7C, 0x03, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x3C, 0x07,
  0x00, 0x03, 0xC0, 0x60, 0x00, 0x3C, 0x06, 0x00, 0x03, 0xC0, 0x60, 0x00,
  0x3C, 0x06, 0x00, 0x03, 0xC0, 0x60, 0x00, 0x3C, 0x06, 0x00, 0x03, 0xC0,
  0x60, 0x00, 0x3C, 0x06, 0x00, 0x03, 0xC0, 0x60, 0x00, 0x3C, 0x07, 0x00,
  0x03, 0xC0, 0x30, 0x00, 0x3C, 0x03, 0x00, 0x03, 0xC0, 0x30, 0x00, 0x7C,
  0x03, 0x80, 0x07, 0xE0, 0x1C, 0x00, 0xB6, 0x00, 0xE0, 0x1B, 0x60, 0x07,
  0xCF, 0x36, 0x00, 0x3F, 0xE3, 0x60, 0x00, 0x60, 0x07, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x00, 0x3B, 0x80,
  0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x00, 0x38,
  0xE0, 0x00, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x00,
  0x38, 0x38, 0x00, 0x00, 0x06, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x60, 0x00,
  0x00, 0x38, 0x0E, 0x00, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x18,
  0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x06, 0x00, 0x70, 0x00, 0x00, 0xC0,
  0x06, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x00,
  0xC0, 0x01, 0x80, 0x00, 0x38, 0x00, 0x38, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x38, 0x00, 0x03, 0x80, 0x07, 0x00,
  0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0x30,
  0x07, 0x00, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00,
  0x0C, 0x07, 0x00, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x00, 0x38, 0x38, 0x00,
  0x00, 0x03, 0x07, 0x00, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x00, 0x0E, 0x38,
  0x00, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00, 0x01,
  0xB8, 0x00, 0x00, 0x00, 0x38, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0,
  0x30, 0x00, 0x0F, 0x81, 0x80, 0x00, 0x1E, 0x0C, 0x00, 0x00, 0x78, 0x60,
  0x00, 0x01, 0xC3, 0x00, 0x00, 0x07, 0x18, 0x00, 0x00, 0x38, 0xC0, 0x00,
  0x00, 0xC6, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x31, 0x80, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x63, 0x00, 0x00, 0x03, 0x18,
  0x00, 0x00, 0x18, 0xC0, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x0C, 0x30, 0x00,
  0x00, 0xE1, 0x80, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x1E,
  0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0xC0, 0x00, 0x0F, 0x06,
  0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0x71, 0x80, 0x00, 0x01, 0xCC, 0x00,
  0x00, 0x06, 0x60, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x01, 0xD8, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x1B, 0x00,
  0x00, 0x00, 0xD8, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x07, 0x30, 0x00, 0x00, 0x71, 0x80, 0x00, 0x07, 0x0C, 0x00, 0x00, 0xF0,
  0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x38, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x0E, 0x06,
  0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x1C, 0xE0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x0C, 0x38,
  0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x01, 0x80, 0x38,
  0x00, 0x0F, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0x80, 0x38, 0x00, 0x1F, 0x01, 0xC0, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x70,
  0x70, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x38, 0xE0,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x19, 0xC0, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x00,
  0xDC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x37, 0x00, 0x00, 0x01, 0xB8, 0x00, 0x00,
  0x1D, 0xC0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x73,
  0x80, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x01, 0xC7, 0x00,
  0x00, 0x1C, 0x38, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x3C, 0x0E, 0x00, 0x07,
  0xC0, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x07, 0x00, 0x01, 0xE0, 0x38, 0x00,
  0x03, 0x80, 0xC0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00,
  0x18, 0xE0, 0x00, 0x00, 0x73, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x00, 0xD8, 0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0x0D, 0xC0, 0x00,
  0x00, 0x73, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00,
  0x3C, 0x70, 0x00, 0x00, 0xB1, 0xC0, 0x00, 0x06, 0xC3, 0x80, 0x00, 0x13,
  0x07, 0x00, 0x00, 0xCC, 0x0F, 0x00, 0x0E, 0x30, 0x1F, 0x00, 0xF0, 0xC0,
  0x1F, 0xFF, 0x03, 0x00, 0x0F, 0xF0, 0x00, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x62, 0x00,
  0x00, 0x1B, 0x80, 0x00, 0x0E, 0x60, 0x00, 0x03, 0x9C, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x70, 0xE0, 0x00, 0x38, 0x1E, 0x00, 0x1C, 0x03, 0xE0, 0x3E,
  0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0xC0, 0x00, 0x00, 0x1D, 0x80,
  0x00, 0x00, 0x73, 0x00, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x07, 0x0C, 0x00,
  0x00, 0x1C, 0x18, 0x00, 0x00, 0x38, 0x30, 0x00, 0x00, 0xE0, 0x60, 0x00,
  0x03, 0x80, 0xC0, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x38, 0x03, 0x00, 0x00,
  0xE0, 0x06, 0x00, 0x03, 0x80, 0x0C, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x38,
  0x00, 0x30, 0x00, 0xF0, 0x00, 0x60, 0x01, 0xC0, 0x00, 0xC0, 0x07, 0x00,
  0x01, 0x80, 0x1C, 0x00, 0x03, 0x00, 0x70, 0x00, 0x06, 0x01, 0xC0, 0x00,
  0x0C, 0x07, 0x80, 0x00, 0x18, 0x1F, 0x80, 0x00, 0x30, 0x73, 0x80, 0x00,
  0x61, 0xC7, 0x00, 0x00, 0xC3, 0x07, 0x00, 0x01, 0x8E, 0x07, 0x00, 0x03,
  0x38, 0x0E, 0x00, 0x06, 0xE0, 0x0E, 0x00, 0x0F, 0x80, 0x0E, 0x00, 0x1E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x18, 0x00, 0xC0,
  0x00, 0x38, 0x01, 0x80, 0x00, 0x38, 0x03, 0x00, 0x00, 0x30, 0x06, 0x00,
  0x00, 0x70, 0x0C, 0x00, 0x00, 0x70, 0x18, 0x00, 0x00, 0x60, 0x30, 0x00,
  0x00, 0xE0, 0x60, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x01, 0xC1, 0x80, 0x00,
  0x01, 0xC3, 0x00, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x03, 0x8C, 0x00, 0x00,
  0x03, 0x98, 0x00, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x07, 0x80, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xBF, 0x80, 0x00,
  0x0D, 0xEC, 0x00, 0x00, 0xEF, 0x70, 0x00, 0x06, 0x79, 0x80, 0x00, 0x33,
  0xCE, 0x00, 0x03, 0x1E, 0x30, 0x00, 0x18, 0xF1, 0xC0, 0x01, 0x87, 0x86,
  0x00, 0x0C, 0x3C, 0x38, 0x00, 0xE1, 0xE0, 0xC0, 0x06, 0x0F, 0x06, 0x00,
  0x70, 0x78, 0x38, 0x03, 0x03, 0xC0, 0xC0, 0x38, 0x1E, 0x07, 0x01, 0x80,
  0xF0, 0x18, 0x0C, 0x07, 0x80, 0xE0, 0xC0, 0x3C, 0x03, 0x06, 0x01, 0xE0,
  0x1C, 0x70, 0x0F, 0x00, 0x63, 0x00, 0x78, 0x03, 0xB8, 0x03, 0xC0, 0x0D,
  0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00,
  0x3C, 0x00, 0x60, 0x01, 0xE0, 0x01, 0x00, 0x0F, 0x00, 0x08, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x60, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xEC, 0x00, 0x00, 0x3E, 0xE0, 0x00, 0x03, 0xE6, 0x00, 0x00, 0x3E, 0x70,
  0x00, 0x03, 0xE3, 0x00, 0x00, 0x3E, 0x38, 0x00, 0x03, 0xE1, 0x80, 0x00,
  0x3E, 0x1C, 0x00, 0x03, 0xE0, 0xC0, 0x00, 0x3E, 0x0E, 0x00, 0x03, 0xE0,
  0x60, 0x00, 0x3E, 0x07, 0x00, 0x03, 0xE0, 0x30, 0x00, 0x3E, 0x03, 0x80,
  0x03, 0xE0, 0x18, 0x00, 0x3E, 0x01, 0xC0, 0x03, 0xE0, 0x0C, 0x00, 0x3E,
  0x00, 0xE0, 0x03, 0xE0, 0x06, 0x00, 0x3E, 0x00, 0x70, 0x03, 0xE0, 0x03,
  0x00, 0x3E, 0x00, 0x38, 0x03, 0xE0, 0x01, 0x80, 0x3E, 0x00, 0x1C, 0x03,
  0xE0, 0x00, 0xC0, 0x3E, 0x00, 0x0E, 0x03, 0xE0, 0x00, 0x60, 0x3E, 0x00,
  0x07, 0x03, 0xE0, 0x00, 0x30, 0x3E, 0x00, 0x03, 0x83, 0xE0, 0x00, 0x18,
  0x3E, 0x00, 0x01, 0xC3, 0xE0, 0x00, 0x0C, 0x3E, 0x00, 0x00, 0xE3, 0xE0,
  0x00, 0x06, 0x3E, 0x00, 0x00, 0x73, 0xE0, 0x00, 0x03, 0x3E, 0x00, 0x00,
  0x3B, 0xE0, 0x00, 0x01, 0xBE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x70,
  0x00, 0x1C, 0x01, 0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x1C, 0x0C, 0x00,
  0x00, 0x18, 0x38, 0x00, 0x00, 0x38, 0x60, 0x00, 0x00, 0x31, 0xC0, 0x00,
  0x00, 0x63, 0x80, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0x01, 0xB8, 0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x03, 0x9C, 0x00,
  0x00, 0x06, 0x18, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x38, 0x30, 0x00,
  0x00, 0x60, 0x70, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x07, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x70, 0x00, 0x70, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0,
  0x38, 0x00, 0x03, 0xE1, 0xC0, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x0E, 0x70,
  0x00, 0x00, 0x33, 0x80, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x06, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0D, 0xC0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00,
  0x73, 0x80, 0x00, 0x0F, 0x1C, 0x00, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xC0, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x70, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x1C, 0x0C,
  0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x38, 0x60, 0x00, 0x00, 0x31, 0xC0,
  0x00, 0x00, 0x63, 0x80, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x01, 0xB8, 0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x33,
  0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x03, 0x9C,
  0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x38, 0x30,
  0x00, 0x00, 0x60, 0x70, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x07, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x70, 0x00, 0x70, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0,
  0x38, 0x00, 0x03, 0xE1, 0xC0, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x0E, 0x70,
  0x00, 0x00, 0x33, 0x80, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x06, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0D, 0xC0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00,
  0x73, 0x80, 0x00, 0x0F, 0x1C, 0x00, 0x01, 0xF0, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xC0, 0x38, 0x01, 0xC0, 0x01, 0xC0, 0x06, 0x00, 0x0E, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0xE0, 0x00, 0x70, 0x07, 0x00, 0x03, 0x80, 0x38, 0x00, 0x0E, 0x01,
  0xC0, 0x00, 0x30, 0x0E, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x07, 0x03, 0x80,
  0x00, 0x18, 0x1C, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x03, 0x87, 0x00, 0x00,
  0x0C, 0x38, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x0E,
  0x70, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0x80, 0x00, 0xF8,
  0x0E, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x1E, 0x18, 0x00, 0x00, 0x0E,
  0x38, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07,
  0x60, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E,
  0x3C, 0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x38, 0x0F, 0x80, 0x00, 0xF0,
  0x03, 0xF0, 0x07, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x03, 0x60, 0x00, 0x00, 0x36, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x77, 0x00, 0x00, 0x06, 0x30, 0x00,
  0x00, 0x63, 0x80, 0x00, 0x0E, 0x18, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x1C,
  0x0E, 0x00, 0x07, 0x80, 0x7C, 0x01, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00, 0x06, 0x38, 0x00, 0x00, 0x03, 0x8E,
  0x00, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x00, 0x30, 0x70, 0x00, 0x00, 0x1C,
  0x1C, 0x00, 0x00, 0x07, 0x03, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00,
  0xE0, 0x38, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00,
  0x07, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x60, 0x03, 0x00,
  0x00, 0x38, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x03, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x03, 0x80, 0x00, 0xE0, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x06,
  0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x30, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x07,
  0x01, 0xC0, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00,
  0x0E, 0x0E, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x00, 0x61, 0xC0, 0x00,
  0x00, 0x1C, 0x70, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x00, 0xCE, 0x00,
  0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0x70,
  0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x19, 0x80, 0x07, 0x00, 0x0C,
  0xC0, 0x03, 0x80, 0x06, 0x60, 0x03, 0xE0, 0x07, 0x30, 0x01, 0xB0, 0x03,
  0x9C, 0x00, 0xD8, 0x01, 0xCE, 0x00, 0xEC, 0x00, 0xC3, 0x00, 0x67, 0x00,
  0x61, 0x80, 0x31, 0x80, 0x30, 0xC0, 0x18, 0xC0, 0x18, 0x60, 0x1C, 0x70,
  0x0C, 0x30, 0x0C, 0x18, 0x06, 0x18, 0x06, 0x0C, 0x03, 0x0C, 0x07, 0x06,
  0x01, 0x86, 0x03, 0x03, 0x81, 0xC3, 0x81, 0x80, 0xC0, 0xE1, 0xC0, 0xC0,
  0x60, 0x60, 0xE0, 0xE0, 0x38, 0x30, 0x30, 0x60, 0x0C, 0x18, 0x18, 0x30,
  0x06, 0x0C, 0x0C, 0x38, 0x03, 0x06, 0x06, 0x18, 0x01, 0xC3, 0x03, 0x0C,
  0x00, 0x61, 0x81, 0x86, 0x00, 0x30, 0xC0, 0xC7, 0x00, 0x1C, 0x60, 0x63,
  0x00, 0x06, 0x70, 0x39, 0x80, 0x03, 0x38, 0x1D, 0xC0, 0x01, 0x98, 0x0E,
  0xC0, 0x00, 0xEC, 0x03, 0x60, 0x00, 0x36, 0x01, 0xB0, 0x00, 0x1B, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x01, 0xE0,
  0x70, 0x00, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00,
  0x0E, 0x0E, 0x00, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0xE0, 0x1C, 0x00,
  0x00, 0x1C, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0x80,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x03,
  0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x0C,
  0x06, 0x00, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00, 0x03,
  0x8E, 0x00, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00,
  0x07, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x30, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x38, 0x00, 0x03, 0x80, 0x03, 0x80, 0x00, 0x60, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0xC0,
  0x00, 0x0E, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x0E, 0x01,
  0x80, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x01,
  0xC3, 0x00, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00,
  0x00, 0x38, 0xE0, 0x00, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x03, 0x9C,
  0x00, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x00,
  0x1C, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x0E, 0x01, 0xC0,
  0x00, 0x00, 0x60, 0x07, 0x00, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0xE0, 0x00, 0x03, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x0C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x70, 0x00, 0x00, 0x03, 0x83, 0x00, 0x00, 0x00, 0x0E, 0x38, 0x00,
  0x00, 0x00, 0x33, 0x80, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xF8, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x00, 0xE3, 0x00, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x38, 0x03,
  0x00, 0x00, 0x18, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x06, 0x00,
  0x01, 0xC0, 0x07, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x38, 0x03, 0x80,
  0x00, 0x0E, 0x01, 0x80, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x0E, 0x60,
  0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x20, 0x18, 0x0F, 0x00, 0xE0, 0x18, 0x07,
  0x00, 0xE0, 0x18, 0x03, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x70, 0x00, 0x70, 0x01,
  0xC0, 0x00, 0x70, 0x07, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0xE0, 0x38,
  0x00, 0x00, 0xC0, 0x20, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0xFC, 0x00,
  0x0E, 0x03, 0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00,
  0x70, 0x30, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x03,
  0x83, 0x80, 0x00, 0x07, 0x07, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x1C,
  0x1C, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0xB0, 0x38, 0x00, 0x03, 0x60,
  0x70, 0x00, 0x0C, 0xC0, 0x78, 0x00, 0x31, 0x80, 0x7C, 0x03, 0xC3, 0xF8,
  0x3F, 0xFF, 0x03, 0xF0, 0x0F, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x3F, 0xC0,
  0x0C, 0x1F, 0xFF, 0x00, 0xC3, 0xC0, 0x7C, 0x0C, 0x60, 0x01, 0xE0, 0xCC,
  0x00, 0x07, 0x0D, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x03, 0x8E, 0x00, 0x00,
  0x1C, 0xE0, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0xEC,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x0E, 0xE0,
  0x00, 0x00, 0xCE, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x03, 0x8D, 0x80, 0x00,
  0x38, 0xCC, 0x00, 0x07, 0x0C, 0x60, 0x01, 0xE0, 0xC3, 0xC0, 0x7C, 0x0C,
  0x1F, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xFF, 0x80, 0x0F, 0x80, 0xF8, 0x03, 0xC0, 0x03, 0x80, 0xE0, 0x00, 0x38,
  0x38, 0x00, 0x03, 0x86, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x07, 0x30, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x04, 0x70, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x80, 0xF0,
  0x00, 0xE0, 0x0F, 0x80, 0x78, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x3F, 0xC0, 0x70, 0x0F, 0xFF, 0x87, 0x03, 0xE0, 0x3C, 0x70,
  0x78, 0x00, 0x67, 0x0E, 0x00, 0x03, 0x71, 0xC0, 0x00, 0x1F, 0x18, 0x00,
  0x00, 0xF3, 0x80, 0x00, 0x07, 0x30, 0x00, 0x00, 0x77, 0x00, 0x00, 0x07,
  0x60, 0x00, 0x00, 0x76, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0x60, 0x00, 0x00, 0x76, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0x73, 0x80, 0x00, 0x07, 0x18, 0x00,
  0x00, 0xF1, 0xC0, 0x00, 0x1F, 0x0E, 0x00, 0x03, 0x70, 0x78, 0x00, 0x67,
  0x03, 0xE0, 0x3C, 0x70, 0x0F, 0xFF, 0x87, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xF8, 0x0F, 0x80, 0x0E, 0x00,
  0x0E, 0x00, 0xE0, 0x00, 0x38, 0x0E, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x03,
  0x07, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0x63, 0x80, 0x00, 0x03, 0x98,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x43, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x38,
  0x60, 0x00, 0x01, 0x83, 0x80, 0x00, 0x1C, 0x0E, 0x00, 0x01, 0xC0, 0x38,
  0x00, 0x3C, 0x00, 0xF8, 0x07, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xE3, 0x00, 0x00, 0xFF,
  0xFB, 0x00, 0x01, 0xE0, 0x3F, 0x00, 0x07, 0x80, 0x07, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x01, 0xC0, 0x18, 0x00,
  0x00, 0xC0, 0x18, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0xE0, 0x38, 0x00,
  0x00, 0xE0, 0x38, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0xE0, 0x18, 0x00,
  0x00, 0xE0, 0x18, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x00, 0xC0, 0x1C, 0x00,
  0x01, 0xC0, 0x0E, 0x00, 0x01, 0x80, 0x0E, 0x00, 0x03, 0x80, 0x07, 0x80,
  0x07, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x0E, 0x00,
  0x00, 0xF8, 0x38, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x0C, 0x60, 0x00,
  0x00, 0x0E, 0xE0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0x06, 0xC0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x06, 0xE0, 0x00,
  0x00, 0x0E, 0xE0, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x38, 0x3C, 0x00,
  0x00, 0x78, 0x1F, 0x00, 0x03, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xF8, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x81, 0xFE,
  0x01, 0xC3, 0xFF, 0xE0, 0xE7, 0x80, 0xF8, 0x77, 0x00, 0x0E, 0x3A, 0x00,
  0x03, 0x9E, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x77, 0x00, 0x00, 0x1B, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1E, 0xC0, 0x00, 0x01,
  0xC6, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x03, 0xC1, 0x80, 0x00, 0x38, 0x0C,
  0x00, 0x03, 0x80, 0x60, 0x00, 0x38, 0x03, 0x00, 0x03, 0x80, 0x18, 0x00,
  0x38, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x78, 0x00, 0x30, 0x07, 0x80,
  0x01, 0x80, 0x70, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x60, 0x7C, 0x00, 0x03,
  0x07, 0xE0, 0x00, 0x18, 0x73, 0x80, 0x00, 0xCF, 0x0E, 0x00, 0x06, 0xE0,
  0x38, 0x00, 0x3E, 0x00, 0xE0, 0x01, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x1C,
  0x00, 0x60, 0x00, 0x70, 0x03, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x07, 0x00,
  0xC0, 0x00, 0x1C, 0x06, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x03, 0x81, 0x80,
  0x00, 0x0E, 0x0C, 0x00, 0x00, 0x38, 0x60, 0x00, 0x00, 0xE3, 0x00, 0x00,
  0x03, 0x98, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00, 0x76, 0x00, 0x00, 0x01,
  0xC0, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x03, 0xF0, 0x07, 0xE1, 0x9F, 0xF8, 0x3F, 0xF3, 0x30,
  0x78, 0xE0, 0xE6, 0x80, 0x33, 0x00, 0xEE, 0x00, 0x74, 0x00, 0xDC, 0x00,
  0x70, 0x01, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03,
  0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0,
  0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00,
  0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00,
  0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03,
  0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E,
  0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0,
  0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80,
  0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x30, 0x00,
  0x7F, 0x80, 0x70, 0xFF, 0xF8, 0x39, 0xE0, 0x3E, 0x1D, 0xC0, 0x03, 0x8E,
  0x80, 0x00, 0xE7, 0x80, 0x00, 0x3B, 0xC0, 0x00, 0x1D, 0xC0, 0x00, 0x06,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x30, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0xF8, 0x0F, 0x80, 0x0E, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x38, 0x0E, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x03, 0x06, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x03, 0x98, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x00, 0x6E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0x98, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x06, 0x18, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x03, 0x03, 0x80, 0x00, 0x38,
  0x0E, 0x00, 0x03, 0x80, 0x38, 0x00, 0x38, 0x00, 0xF8, 0x0F, 0x80, 0x01,
  0xFF, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x0C, 0x1F,
  0xFF, 0x00, 0xC3, 0xC0, 0x7C, 0x0C, 0x60, 0x01, 0xE0, 0xCC, 0x00, 0x07,
  0x0D, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x1C, 0xE0,
  0x00, 0x00, 0xCE, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0xEC, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x06, 0xC0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00,
  0xCE, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x03, 0x8D, 0x80, 0x00, 0x38, 0xCC,
  0x00, 0x07, 0x0C, 0x60, 0x01, 0xE0, 0xC3, 0xC0, 0x7C, 0x0C, 0x1F, 0xFF,
  0x00, 0xC0, 0x7F, 0x80, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFF, 0x87, 0x03, 0xE0, 0x3C,
  0x70, 0x78, 0x00, 0x67, 0x0E, 0x00, 0x03, 0x71, 0xC0, 0x00, 0x1F, 0x18,
  0x00, 0x00, 0xF3, 0x80, 0x00, 0x07, 0x30, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x07, 0x60, 0x00, 0x00, 0x76, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0x60, 0x00, 0x00, 0x76, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00,
  0x77, 0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0x73, 0x80, 0x00, 0x07, 0x18,
  0x00, 0x00, 0xF1, 0xC0, 0x00, 0x1F, 0x0E, 0x00, 0x03, 0x70, 0x78, 0x00,
  0x67, 0x03, 0xE0, 0x3C, 0x70, 0x0F, 0xFF, 0x87, 0x00, 0x3F, 0xC0, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xC0, 0x03, 0x0F, 0x00, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x00, 0x64, 0x00, 0x00, 0x00, 0x34,
  0x00, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xF0, 0x07, 0xC0, 0x1C, 0x00, 0x07,
  0x81, 0xC0, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x00, 0x86,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0xE0, 0xF8, 0x00,
  0x0E, 0x01, 0xF8, 0x03, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFE, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3B, 0x00, 0x00,
  0x3D, 0xC0, 0x00, 0x3E, 0x70, 0x00, 0x17, 0x3C, 0x00, 0x33, 0x8F, 0x80,
  0x71, 0xC1, 0xFF, 0xF0, 0xE0, 0x3F, 0xE0, 0x00, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00, 0xE3, 0x00,
  0x00, 0x06, 0x18, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x03, 0x83, 0x00, 0x00,
  0x18, 0x18, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x60,
  0x1C, 0x00, 0x07, 0x00, 0x60, 0x00, 0x30, 0x03, 0x00, 0x01, 0x80, 0x1C,
  0x00, 0x1C, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x60, 0x00, 0x60, 0x03, 0x00, 0x03, 0x00, 0x38, 0x00, 0x1C, 0x01, 0x80,
  0x00, 0x60, 0x0C, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x0C, 0x06, 0x00, 0x00,
  0x60, 0x30, 0x00, 0x03, 0x83, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x61,
  0xC0, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x01, 0xB0, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x36, 0x00, 0x07, 0x00, 0x03,
  0x60, 0x00, 0xD8, 0x00, 0x36, 0x00, 0x0D, 0x80, 0x03, 0x60, 0x00, 0xD8,
  0x00, 0x77, 0x00, 0x0D, 0x80, 0x06, 0x30, 0x01, 0x8C, 0x00, 0x63, 0x00,
  0x18, 0xC0, 0x06, 0x30, 0x01, 0x8C, 0x00, 0x63, 0x00, 0x18, 0xC0, 0x06,
  0x30, 0x03, 0x06, 0x00, 0xC1, 0x80, 0x30, 0x60, 0x0C, 0x18, 0x03, 0x06,
  0x00, 0xC1, 0x80, 0x30, 0x60, 0x0C, 0x18, 0x06, 0x03, 0x00, 0xC1, 0x80,
  0x60, 0x30, 0x1C, 0x1C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x0C, 0x01, 0x81, 0x80, 0xC0, 0xC0, 0x18, 0x18, 0x0C, 0x0C, 0x01,
  0x81, 0x80, 0xC0, 0xC0, 0x18, 0x30, 0x06, 0x18, 0x00, 0xC3, 0x00, 0x61,
  0x80, 0x0C, 0x30, 0x06, 0x18, 0x00, 0xC3, 0x00, 0x61, 0x80, 0x0C, 0x30,
  0x06, 0x30, 0x00, 0x63, 0x00, 0x73, 0x00, 0x06, 0x60, 0x03, 0x30, 0x00,
  0x66, 0x00, 0x33, 0x00, 0x06, 0x60, 0x03, 0x60, 0x00, 0x36, 0x00, 0x36,
  0x00, 0x03, 0x60, 0x03, 0x60, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x03, 0xC0,
  0x01, 0xC0, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x03,
  0x8E, 0x00, 0x00, 0x38, 0x70, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x1C, 0x07,
  0x00, 0x01, 0xC0, 0x1C, 0x00, 0x1C, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80,
  0x0E, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x38, 0x0E, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x07, 0x06, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x01, 0xB0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x18, 0x70,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0xC0, 0x38, 0x00,
  0x0C, 0x00, 0xE0, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x0E, 0x00, 0xE0,
  0x00, 0x70, 0x06, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x07, 0x07, 0x00, 0x00,
  0x1C, 0x70, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x0E,
  0xE0, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x00, 0x71,
  0x80, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x03, 0x87, 0x00, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0x60, 0x1C,
  0x00, 0x01, 0xC0, 0x38, 0x00, 0x03, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x60, 0x00, 0x30, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0,
  0x01, 0x80, 0x01, 0x80, 0x07, 0x00, 0x03, 0x80, 0x0C, 0x00, 0x03, 0x00,
  0x18, 0x00, 0x07, 0x00, 0x70, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x0C, 0x03,
  0x80, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x38, 0x38,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x00, 0xE3, 0x00,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x01, 0xB0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0x80, 0x1F, 0xFF, 0xC0, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0xE0, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x1F,
  0xFE, 0x00, 0x7C, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0x83, 0xFC, 0x00, 0x00, 0xC7, 0x87, 0x00, 0x00, 0xE3,
  0x01, 0xC0, 0x00, 0x63, 0x00, 0x70, 0x00, 0x31, 0x80, 0x1C, 0x00, 0x39,
  0x80, 0x07, 0x00, 0x18, 0xC0, 0x01, 0xC0, 0x1C, 0x60, 0x00, 0x78, 0x0C,
  0x60, 0x00, 0x1E, 0x1C, 0x30, 0x00, 0x03, 0xFC, 0x18, 0x00, 0x00, 0xFC,
  0x00,
};

const GFXglyph IBMPlexMono_ExtraLight68pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 41, 0, -1 },
  { 1, 6, 47, 41, 17, -47 },
  { 37, 12, 17, 41, 14, -50 },
  { 63, 38, 47, 41, 1, -47 },
  { 287, 32, 63, 41, 4, -55 },
  { 539, 37, 49, 41, 2, -48 },
  { 766, 34, 49, 41, 3, -48 },
  { 975, 3, 17, 41, 19, -50 },
  { 982, 16, 61, 41, 16, -52 },
  { 1104, 16, 61, 41, 9, -52 },
  { 1226, 35, 34, 41, 3, -37 },
  { 1375, 33, 34, 41, 4, -38 },
  { 1516, 8, 17, 41, 15, -6 },
  { 1533, 19, 2, 41, 11, -22 },
  { 1538, 6, 5, 41, 17, -5 },
  { 1542, 27, 61, 41, 7, -52 },
  { 1748, 31, 49, 41, 5, -48 },
  { 1938, 32, 47, 41, 5, -47 },
  { 2126, 30, 48, 41, 6, -48 },
  { 2306, 30, 49, 41, 4, -48 },
  { 2490, 35, 47, 41, 3, -47 },
  { 2696, 29, 48, 41, 6, -47 },
  { 2870, 29, 48, 41, 6, -47 },
  { 3044, 30, 47, 41, 5, -47 },
  { 3221, 31, 49, 41, 5, -48 },
  { 3411, 29, 48, 41, 6, -48 },
  { 3585, 6, 35, 41, 17, -35 },
  { 3612, 8, 46, 41, 15, -35 },
  { 3658, 29, 37, 41, 6, -39 },
  { 3793, 33, 14, 41, 4, -28 },
  { 3851, 29, 37, 41, 6, -39 },
  { 3986, 28, 48, 41, 6, -48 },
  { 4154, 28, 55, 41, 6, -48 },
  { 4347, 35, 47, 41, 3, -47 },
  { 4553, 29, 47, 41, 7, -47 },
  { 4724, 31, 49, 41, 5, -48 },
  { 4914, 29, 47, 41, 7, -47 },
  { 5085, 28, 47, 41, 7, -47 },
  { 5250, 28, 47, 41, 7, -47 },
  { 5415, 30, 49, 41, 5, -48 },
  { 5599, 28, 47, 41, 6, -47 },
  { 5764, 29, 47, 41, 6, -47 },
  { 5935, 26, 48, 41, 6, -47 },
  { 6091, 31, 47, 41, 7, -47 },
  { 6274, 26, 47, 41, 10, -47 },
  { 6427, 29, 47, 41, 6, -47 },
  { 6598, 28, 47, 41, 6, -47 },
  { 6763, 31, 49, 41, 5, -48 },
  { 6953, 29, 47, 41, 7, -47 },
  { 7124, 31, 58, 41, 5, -48 },
  { 7349, 29, 47, 41, 7, -47 },
  { 7520, 32, 49, 41, 4, -48 },
  { 7716, 35, 47, 41, 3, -47 },
  { 7922, 28, 48, 41, 6, -47 },
  { 8090, 34, 47, 41, 3, -47 },
  { 8290, 33, 47, 41, 4, -47 },
  { 8484, 35, 47, 41, 3, -47 },
  { 8690, 37, 47, 41, 2, -47 },
  { 8908, 35, 47, 41, 3, -47 },
  { 9114, 17, 61, 41, 17, -52 },
  { 9244, 27, 61, 41, 7, -52 },
  { 9450, 16, 61, 41, 7, -52 },
  { 9572, 33, 26, 41, 4, -47 },
  { 9680, 33, 2, 41, 4, 8 },
  { 9689, 10, 12, 41, 13, -52 },
  { 9704, 31, 37, 41, 5, -36 },
  { 9848, 28, 51, 41, 8, -50 },
  { 10027, 27, 37, 41, 7, -36 },
  { 10152, 28, 51, 41, 5, -50 },
  { 10331, 29, 37, 41, 6, -36 },
  { 10466, 30, 50, 41, 6, -50 },
  { 10654, 32, 52, 41, 6, -38 },
  { 10862, 25, 50, 41, 8, -50 },
  { 11019, 29, 51, 41, 8, -51 },
  { 11204, 24, 65, 41, 6, -51 },
  { 11399, 29, 50, 41, 9, -50 },
  { 11581, 29, 50, 41, 6, -50 },
  { 11763, 31, 36, 41, 5, -36 },
  { 11903, 25, 36, 41, 8, -36 },
  { 12016, 29, 37, 41, 6, -36 },
  { 12151, 28, 50, 41, 8, -36 },
  { 12326, 28, 50, 41, 5, -36 },
  { 12501, 33, 35, 41, 5, -35 },
  { 12646, 29, 37, 41, 6, -36 },
  { 12781, 33, 47, 41, 3, -47 },
  { 12975, 25, 36, 41, 8, -35 },
  { 13088, 29, 35, 41, 6, -35 },
  { 13215, 36, 35, 41, 2, -35 },
  { 13373, 29, 35, 41, 6, -35 },
  { 13500, 31, 49, 41, 5, -35 },
  { 13690, 27, 35, 41, 7, -35 },
  { 13809, 25, 61, 41, 8, -52 },
  { 14000, 2, 61, 41, 19, -52 },
  { 14016, 25, 61, 41, 8, -52 },
  { 14207, 33, 12, 41, 4, -27 },
};

const GFXfont IBMPlexMono_ExtraLight68pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLight68pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLight68pt7bGlyphs,
  0x20, 0x7E, 88
};

#endif // _IBMPLEXMONO_EXTRALIGHT68PT7B_H_
