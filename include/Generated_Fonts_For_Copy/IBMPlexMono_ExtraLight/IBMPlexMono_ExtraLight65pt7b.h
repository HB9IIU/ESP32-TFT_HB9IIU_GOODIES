#ifndef _IBMPLEXMONO_EXTRALIGHT65PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHT65PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLight.ttf
// Size: 65pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLight65pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x18, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xF7, 0x80, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x60, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00,
  0x0E, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x03, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x0E,
  0x00, 0xC0, 0x00, 0x00, 0x70, 0x06, 0x00, 0x00, 0x03, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x1C, 0x00, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0x00, 0x70, 0x06, 0x00, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x01, 0x80, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x1F, 0xFE, 0x00, 0xFF,
  0xF8, 0x00, 0x30, 0x06, 0x00, 0x00, 0x03, 0x80, 0x30, 0x00, 0x00, 0x18,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x06, 0x00, 0xE0, 0x00,
  0x00, 0x30, 0x06, 0x00, 0x00, 0x03, 0x80, 0x30, 0x00, 0x00, 0x1C, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x00,
  0x30, 0x07, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x7F, 0xFC, 0x01, 0xFF,
  0xE0, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x07, 0x00, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00,
  0x00, 0xE0, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0x30, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x38, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x00,
  0xE0, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0x30, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x38, 0x00, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xC3,
  0x1F, 0x80, 0x3C, 0x06, 0x07, 0x80, 0xF0, 0x0C, 0x03, 0x81, 0x80, 0x18,
  0x03, 0x87, 0x00, 0x30, 0x03, 0x8C, 0x00, 0x60, 0x02, 0x38, 0x00, 0xC0,
  0x00, 0x70, 0x01, 0x80, 0x00, 0xE0, 0x03, 0x00, 0x01, 0xC0, 0x06, 0x00,
  0x03, 0x80, 0x0C, 0x00, 0x07, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x60, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x18, 0x01, 0x80, 0x00,
  0x38, 0x03, 0x00, 0x00, 0x3C, 0x06, 0x00, 0x00, 0x3E, 0x0C, 0x00, 0x00,
  0x1F, 0xD8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0xCF, 0xC0, 0x00, 0x01, 0x83, 0xE0, 0x00, 0x03, 0x01, 0xE0, 0x00,
  0x06, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x18, 0x01, 0xC0, 0x00,
  0x30, 0x01, 0x80, 0x00, 0x60, 0x03, 0x00, 0x00, 0xC0, 0x07, 0x00, 0x01,
  0x80, 0x0E, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x38, 0x00, 0x0C,
  0x00, 0x70, 0x00, 0x18, 0x00, 0xC8, 0x00, 0x30, 0x01, 0xB8, 0x00, 0x60,
  0x07, 0x38, 0x00, 0xC0, 0x0C, 0x38, 0x01, 0x80, 0x38, 0x38, 0x03, 0x00,
  0xE0, 0x3C, 0x06, 0x07, 0x80, 0x3F, 0x0C, 0x3E, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x0C, 0x70, 0x3C, 0x00, 0x03, 0x1C, 0x01, 0x80,
  0x00, 0x67, 0x00, 0x18, 0x00, 0x18, 0xC0, 0x03, 0x00, 0x03, 0x18, 0x00,
  0x30, 0x00, 0xC6, 0x00, 0x06, 0x00, 0x38, 0xC0, 0x00, 0xC0, 0x06, 0x18,
  0x00, 0x18, 0x01, 0x83, 0x00, 0x03, 0x00, 0x30, 0x60, 0x00, 0x60, 0x0C,
  0x0C, 0x00, 0x0C, 0x03, 0x81, 0x80, 0x01, 0x80, 0x60, 0x30, 0x00, 0x30,
  0x18, 0x03, 0x00, 0x06, 0x03, 0x00, 0x60, 0x01, 0x80, 0xC0, 0x0E, 0x00,
  0x30, 0x18, 0x00, 0xE0, 0x0C, 0x06, 0x00, 0x0E, 0x07, 0x81, 0xC0, 0x00,
  0xFF, 0xC0, 0x30, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x60, 0x1F, 0xF8, 0x00, 0x1C, 0x0F, 0x07, 0x80, 0x03,
  0x01, 0x80, 0x38, 0x00, 0xC0, 0x60, 0x03, 0x80, 0x18, 0x0C, 0x00, 0x30,
  0x06, 0x03, 0x00, 0x06, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x30, 0x0C, 0x00,
  0x0C, 0x0E, 0x01, 0x80, 0x01, 0x81, 0x80, 0x30, 0x00, 0x30, 0x60, 0x06,
  0x00, 0x06, 0x0C, 0x00, 0xC0, 0x00, 0xC3, 0x00, 0x18, 0x00, 0x18, 0xE0,
  0x03, 0x00, 0x03, 0x18, 0x00, 0x60, 0x00, 0xC6, 0x00, 0x06, 0x00, 0x18,
  0xC0, 0x00, 0xC0, 0x07, 0x30, 0x00, 0x0C, 0x01, 0xC6, 0x00, 0x01, 0xE0,
  0x71, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x07,
  0x00, 0x38, 0x00, 0x01, 0x80, 0x07, 0x00, 0x00, 0xC0, 0x00, 0xE0, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0E, 0x70, 0x00, 0xFF, 0x06, 0x0E, 0x00, 0x3F, 0xC3, 0x01, 0xC0, 0x0C,
  0x01, 0x80, 0x38, 0x03, 0x00, 0xE0, 0x07, 0x00, 0xC0, 0x30, 0x00, 0xC0,
  0x30, 0x1C, 0x00, 0x18, 0x0C, 0x06, 0x00, 0x07, 0x03, 0x01, 0x80, 0x00,
  0xE0, 0xC0, 0x60, 0x00, 0x1C, 0x30, 0x38, 0x00, 0x03, 0x98, 0x0E, 0x00,
  0x00, 0x76, 0x03, 0x80, 0x00, 0x0D, 0x80, 0x60, 0x00, 0x01, 0xE0, 0x18,
  0x00, 0x00, 0x70, 0x06, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x07, 0xC0,
  0x30, 0x00, 0x03, 0x38, 0x0E, 0x00, 0x01, 0xC7, 0x01, 0xC0, 0x00, 0xE0,
  0xE0, 0x38, 0x00, 0x70, 0x1C, 0x07, 0xC0, 0x78, 0x03, 0x00, 0xFF, 0xF8,
  0x00, 0x60, 0x07, 0xF8, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C,
  0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F, 0xE0, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01,
  0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x08, 0x00, 0x38, 0x00, 0x2F, 0x80, 0x1C, 0x00, 0xFB, 0xF8,
  0x0E, 0x03, 0xF8, 0x1F, 0x87, 0x0F, 0xE0, 0x01, 0xFF, 0xBF, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0x71, 0xC0, 0x00,
  0x00, 0x70, 0x70, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x30, 0x06, 0x00,
  0x00, 0x38, 0x03, 0x80, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x3C, 0xF1,
  0xE3, 0xC7, 0x0E, 0x3C, 0x70, 0xE1, 0xC3, 0x0E, 0x1C, 0x30, 0x60, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF7, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x70, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x1C, 0x03, 0x00,
  0x00, 0x18, 0x0E, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x30, 0x70, 0x00,
  0x00, 0x70, 0xC0, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0xC7, 0x00, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0x03, 0x98, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00,
  0x06, 0x60, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00,
  0x37, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0xE0, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F,
  0xC0, 0x07, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x76,
  0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x03, 0x30,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00, 0x39, 0xC0,
  0x00, 0x00, 0x71, 0x80, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x01, 0x87, 0x00,
  0x00, 0x07, 0x06, 0x00, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x38, 0x0C, 0x00,
  0x00, 0x60, 0x1C, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x07, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x76,
  0x00, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x0F, 0x18, 0x00, 0x00, 0x3C, 0x30,
  0x00, 0x00, 0xF0, 0x60, 0x00, 0x03, 0xC0, 0xC0, 0x00, 0x0F, 0x01, 0x80,
  0x00, 0x38, 0x03, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x07, 0x80, 0x0C, 0x00,
  0x06, 0x00, 0x18, 0x00, 0x08, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xF0, 0x0F, 0x80, 0x1E, 0x00, 0x1E, 0x01,
  0xC0, 0x00, 0x78, 0x1C, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0x18, 0x60, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x07, 0x08, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xFF, 0xC0, 0x03, 0xE0, 0x3E, 0x00, 0x70, 0x00, 0x70, 0x0E, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x76, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x1C, 0x3C,
  0x00, 0x03, 0x81, 0xE0, 0x00, 0x70, 0x07, 0xC0, 0x3E, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x01,
  0xDC, 0x00, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x00,
  0x70, 0x70, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x30, 0x1C, 0x00, 0x00,
  0x30, 0x0E, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x18, 0x03, 0x80, 0x00,
  0x18, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x70, 0x00,
  0x0C, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x0E, 0x00,
  0x06, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x00, 0x01, 0xC0,
  0x03, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x70, 0x01, 0x80, 0x00, 0x38,
  0x01, 0x80, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0xC0, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x01, 0xC0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x0F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x1F, 0xE0, 0x03, 0x0F, 0xFF, 0xC0, 0x31, 0xC0, 0x1E,
  0x03, 0x70, 0x00, 0x78, 0x34, 0x00, 0x03, 0x83, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x01, 0xC3, 0xC0,
  0x00, 0x38, 0x1E, 0x00, 0x07, 0x00, 0x7C, 0x03, 0xE0, 0x03, 0xFF, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x07, 0xF8,
  0x00, 0x61, 0xFF, 0xF8, 0x03, 0x1E, 0x03, 0xE0, 0x39, 0x80, 0x03, 0xC1,
  0x98, 0x00, 0x0F, 0x0D, 0x80, 0x00, 0x38, 0x78, 0x00, 0x00, 0xE3, 0x80,
  0x00, 0x03, 0x3C, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x6E, 0x00, 0x00,
  0x03, 0x70, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x0C, 0xC0,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x03, 0x38, 0x00, 0x00, 0x38, 0xC0, 0x00,
  0x01, 0x87, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x1C,
  0x01, 0xC0, 0x01, 0xC0, 0x07, 0xC0, 0x7C, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x0D, 0x80, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00,
  0x33, 0x00, 0x00, 0x03, 0x98, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x01, 0xC6,
  0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0xE0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x0E, 0x07, 0x00,
  0x00, 0x1C, 0x1C, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x38, 0x70, 0x00,
  0x00, 0x70, 0xC0, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x01, 0x87, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x0E, 0x0C, 0x00, 0x00,
  0x18, 0x1C, 0x00, 0x00, 0x70, 0x18, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x03,
  0x80, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x07, 0x00, 0x01, 0xC0,
  0x1C, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x01, 0xC3,
  0x00, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x03, 0x98, 0x00, 0x00, 0x03, 0x30,
  0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x76, 0x00, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x01, 0x9C, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x0C, 0x38, 0x00,
  0x00, 0x38, 0x38, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x03, 0xC0, 0x78, 0x00,
  0x0F, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xC0, 0x7C,
  0x00, 0xE0, 0x00, 0xF0, 0x1C, 0x00, 0x07, 0x03, 0x80, 0x00, 0x38, 0x70,
  0x00, 0x01, 0xC6, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0x60, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x01, 0x61, 0xC0,
  0x00, 0x26, 0x1E, 0x00, 0x0C, 0xE0, 0x7C, 0x03, 0x8E, 0x03, 0xFF, 0xF0,
  0xC0, 0x07, 0xF8, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0xFF, 0xF7, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFB, 0xC0, 0x3E, 0x7C, 0xF9, 0xF1, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE3, 0xCF, 0x1E, 0x3C, 0x70, 0xE3,
  0xC7, 0x0E, 0x1C, 0x30, 0xE1, 0xC3, 0x06, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0x00, 0xF0,
  0x07, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x07, 0x0C, 0x00,
  0x00, 0x63, 0x80, 0x00, 0x0E, 0x60, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x19,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0x01, 0xF0,
  0x03, 0x80, 0x0F, 0x00, 0xE0, 0x00, 0x60, 0x38, 0x00, 0x06, 0x06, 0x00,
  0x00, 0xE1, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x01, 0x86, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x03, 0x30, 0x00, 0x00, 0x66, 0x00, 0x00, 0x0C, 0xC0, 0x00,
  0x01, 0xB0, 0x00, 0xFC, 0x36, 0x00, 0x7F, 0xE6, 0xC0, 0x1E, 0x06, 0xF8,
  0x07, 0x00, 0x7F, 0x00, 0xC0, 0x07, 0xE0, 0x38, 0x00, 0x7C, 0x06, 0x00,
  0x0F, 0x80, 0xC0, 0x01, 0xF0, 0x18, 0x00, 0x3E, 0x03, 0x00, 0x07, 0xC0,
  0xE0, 0x00, 0xF8, 0x1C, 0x00, 0x1F, 0x03, 0x80, 0x03, 0xE0, 0x70, 0x00,
  0x7C, 0x0E, 0x00, 0x0F, 0x81, 0xC0, 0x01, 0xF0, 0x38, 0x00, 0x3E, 0x03,
  0x00, 0x07, 0xC0, 0x60, 0x00, 0xF8, 0x0C, 0x00, 0x1F, 0x01, 0xC0, 0x03,
  0xE0, 0x18, 0x00, 0x7C, 0x03, 0x80, 0x1F, 0x80, 0x38, 0x05, 0xF0, 0x03,
  0xEF, 0xBF, 0x00, 0x3F, 0xC7, 0x60, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF,
  0xF0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x0C,
  0x18, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x03,
  0x01, 0x80, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00,
  0xC0, 0x18, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00,
  0x30, 0x01, 0x80, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x70, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x18, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00,
  0x70, 0x0E, 0x00, 0x00, 0x38, 0x06, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00,
  0x06, 0x03, 0x80, 0x00, 0x03, 0x81, 0x80, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x00, 0x60, 0xE0, 0x00, 0x00, 0x38, 0x60, 0x00, 0x00, 0x0C, 0x30, 0x00,
  0x00, 0x06, 0x38, 0x00, 0x00, 0x03, 0x98, 0x00, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x00, 0x6E, 0x00, 0x00, 0x00, 0x38, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0x80, 0xE0, 0x00, 0x3E, 0x0E, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x07,
  0x0E, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x1C, 0xE0,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0x1C, 0xE0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x01, 0xCE,
  0x00, 0x00, 0x1C, 0xE0, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x38, 0xE0, 0x00,
  0x07, 0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x3C, 0x0F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFC, 0x0E, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x03, 0x8E, 0x00,
  0x00, 0x1C, 0xE0, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00,
  0x6E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x0C, 0xE0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x38, 0xE0, 0x00,
  0x0F, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7C, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x00,
  0x70, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x70, 0x30, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0x06, 0x38, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x8C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x08, 0xE0, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x06, 0x0C, 0x00,
  0x00, 0x70, 0x70, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x70, 0x07, 0x80, 0x07,
  0x00, 0x1F, 0x00, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0xC0, 0x00, 0xF8, 0x0C, 0x00,
  0x03, 0xC0, 0xC0, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x1C, 0xC0,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0xEC, 0x00, 0x00,
  0x0E, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x06, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x0C, 0xC0,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0x38, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x0E, 0x0C,
  0x00, 0x03, 0xC0, 0xC0, 0x00, 0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE6, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xE0, 0x1E, 0x00,
  0x78, 0x00, 0x70, 0x0F, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x1C, 0x1C, 0x00,
  0x00, 0xE3, 0x80, 0x00, 0x06, 0x38, 0x00, 0x00, 0x73, 0x00, 0x00, 0x02,
  0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0x60, 0x00, 0x00, 0x36, 0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0x37, 0x00,
  0x00, 0x03, 0x30, 0x00, 0x00, 0x73, 0x80, 0x00, 0x07, 0x1C, 0x00, 0x00,
  0xF0, 0xC0, 0x00, 0x1B, 0x0F, 0x00, 0x03, 0x30, 0x78, 0x00, 0x73, 0x03,
  0xE0, 0x1E, 0x30, 0x0F, 0xFF, 0x83, 0x00, 0x1F, 0xE0, 0x00, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x06, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x06, 0x60,
  0x00, 0x0E, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x0F,
  0x00, 0xF0, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x39, 0x80, 0x00, 0x03, 0x8C, 0x00,
  0x00, 0x38, 0x60, 0x00, 0x03, 0x83, 0x00, 0x00, 0x38, 0x18, 0x00, 0x03,
  0x80, 0xC0, 0x00, 0x38, 0x06, 0x00, 0x03, 0x80, 0x30, 0x00, 0x1C, 0x01,
  0x80, 0x01, 0xC0, 0x0C, 0x00, 0x1C, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00,
  0x1C, 0x00, 0x18, 0x01, 0xC0, 0x00, 0xC0, 0x1C, 0x00, 0x06, 0x01, 0xC0,
  0x00, 0x30, 0x1C, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x0C, 0x0F, 0x80, 0x00,
  0x60, 0xEE, 0x00, 0x03, 0x0E, 0x70, 0x00, 0x18, 0xE1, 0xC0, 0x00, 0xCE,
  0x07, 0x00, 0x06, 0xE0, 0x38, 0x00, 0x3E, 0x00, 0xE0, 0x01, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x70, 0x03, 0x00, 0x01, 0x80,
  0x18, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x38, 0x06, 0x00, 0x00, 0xC0, 0x30,
  0x00, 0x07, 0x01, 0x80, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0x60, 0x60, 0x00,
  0x03, 0x83, 0x00, 0x00, 0x0E, 0x18, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x01,
  0xC6, 0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0xEC,
  0x00, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x01, 0xBD, 0xC0, 0x00, 0x0D, 0xE6, 0x00, 0x00, 0xCF, 0x30,
  0x00, 0x06, 0x78, 0xC0, 0x00, 0x63, 0xC6, 0x00, 0x03, 0x1E, 0x38, 0x00,
  0x30, 0xF0, 0xC0, 0x01, 0x87, 0x87, 0x00, 0x1C, 0x3C, 0x18, 0x00, 0xC1,
  0xE0, 0xE0, 0x0E, 0x0F, 0x03, 0x00, 0x60, 0x78, 0x1C, 0x03, 0x03, 0xC0,
  0x60, 0x30, 0x1E, 0x03, 0x01, 0x80, 0xF0, 0x0C, 0x18, 0x07, 0x80, 0x60,
  0xC0, 0x3C, 0x03, 0x8E, 0x01, 0xE0, 0x0C, 0x60, 0x0F, 0x00, 0x77, 0x00,
  0x78, 0x01, 0xB0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x38, 0x00, 0xF0,
  0x01, 0xC0, 0x07, 0x80, 0x04, 0x00, 0x3C, 0x00, 0x20, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0x80, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xEC, 0x00, 0x00, 0x3D, 0xC0,
  0x00, 0x07, 0x98, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x1E, 0x30, 0x00, 0x03,
  0xC7, 0x00, 0x00, 0x78, 0x60, 0x00, 0x0F, 0x0E, 0x00, 0x01, 0xE0, 0xC0,
  0x00, 0x3C, 0x1C, 0x00, 0x07, 0x81, 0x80, 0x00, 0xF0, 0x38, 0x00, 0x1E,
  0x03, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x78, 0x06, 0x00, 0x0F, 0x00, 0xE0,
  0x01, 0xE0, 0x0C, 0x00, 0x3C, 0x01, 0xC0, 0x07, 0x80, 0x18, 0x00, 0xF0,
  0x03, 0x80, 0x1E, 0x00, 0x30, 0x03, 0xC0, 0x07, 0x00, 0x78, 0x00, 0x60,
  0x0F, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0xC0, 0x3C, 0x00, 0x1C, 0x07, 0x80,
  0x01, 0x80, 0xF0, 0x00, 0x38, 0x1E, 0x00, 0x03, 0x03, 0xC0, 0x00, 0x70,
  0x78, 0x00, 0x06, 0x0F, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x0C, 0x3C, 0x00,
  0x01, 0xC7, 0x80, 0x00, 0x18, 0xF0, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x33,
  0xC0, 0x00, 0x07, 0x78, 0x00, 0x00, 0x6F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1E, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x07, 0xC0, 0x7C, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x1C,
  0x01, 0xC0, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x18, 0x0E, 0x00, 0x00, 0x38,
  0x18, 0x00, 0x00, 0x30, 0x70, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x03, 0x98,
  0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x0C, 0xC0,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x37, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x76, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0x01, 0x98, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00,
  0x0C, 0xE0, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x71, 0x80, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x01, 0x87, 0x00, 0x00, 0x07, 0x06, 0x00, 0x00, 0x0C,
  0x0E, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x01, 0xC0,
  0x1C, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1F, 0x01, 0xF0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0x83, 0x00, 0x00, 0x7C, 0x60, 0x00, 0x03, 0xCC, 0x00, 0x00,
  0x39, 0x80, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0x60, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x39, 0x80, 0x00, 0x0F, 0x30, 0x00,
  0x07, 0xC7, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x07, 0xC0, 0x7C, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x1C, 0x01,
  0xC0, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x18, 0x0E, 0x00, 0x00, 0x38, 0x18,
  0x00, 0x00, 0x30, 0x70, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x00, 0x61, 0x80,
  0x00, 0x00, 0xC7, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x03, 0x98, 0x00,
  0x00, 0x03, 0x30, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x0C, 0xC0, 0x00,
  0x00, 0x19, 0x80, 0x00, 0x00, 0x37, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x76, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x01,
  0x98, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x0C,
  0xE0, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x71, 0x80, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x01, 0x87, 0x00, 0x00, 0x07, 0x06, 0x00, 0x00, 0x0C, 0x0E,
  0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x01, 0xC0, 0x1C,
  0x00, 0x07, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x7F, 0xF0, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x83,
  0x00, 0x00, 0x7C, 0x60, 0x00, 0x03, 0xCC, 0x00, 0x00, 0x39, 0x80, 0x00,
  0x03, 0xB0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00,
  0xEC, 0x00, 0x00, 0x39, 0x80, 0x00, 0x0F, 0x30, 0x00, 0x07, 0xC7, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x18, 0x01, 0xC0, 0x03, 0x00, 0x18, 0x00,
  0x60, 0x03, 0x80, 0x0C, 0x00, 0x38, 0x01, 0x80, 0x03, 0x00, 0x30, 0x00,
  0x70, 0x06, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x60, 0x18, 0x00, 0x0E, 0x03,
  0x00, 0x00, 0xE0, 0x60, 0x00, 0x1C, 0x0C, 0x00, 0x01, 0xC1, 0x80, 0x00,
  0x18, 0x30, 0x00, 0x03, 0x86, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x03, 0x18,
  0x00, 0x00, 0x73, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x0E, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0x80, 0x3F,
  0x00, 0x78, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x07, 0x03, 0x00, 0x00, 0x07,
  0x0E, 0x00, 0x00, 0x07, 0x18, 0x00, 0x00, 0x04, 0x70, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0x90, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x0E,
  0x70, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x70, 0x70, 0x00, 0x01, 0xC0,
  0x78, 0x00, 0x0F, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0x30, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x0C, 0xC0, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x71, 0x80, 0x00, 0x0C,
  0x38, 0x00, 0x03, 0x83, 0x00, 0x00, 0x60, 0x78, 0x00, 0x3C, 0x07, 0xC0,
  0x1F, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0xB0, 0x00, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0x00, 0xE3, 0x00, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x00, 0x70, 0xE0, 0x00,
  0x00, 0x38, 0x30, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x0C, 0x0E, 0x00,
  0x00, 0x0E, 0x03, 0x00, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x03, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x30, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0xC0, 0x0E,
  0x00, 0x00, 0xE0, 0x03, 0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0x30, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x06, 0x00, 0x01, 0x80, 0x03, 0x00,
  0x00, 0xE0, 0x03, 0x80, 0x00, 0x30, 0x01, 0x80, 0x00, 0x18, 0x00, 0xC0,
  0x00, 0x0E, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x70, 0x00, 0x01, 0x80, 0x30,
  0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x18, 0x0C,
  0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x01,
  0xB0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x01, 0x98,
  0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0x33,
  0x00, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x01,
  0xC6, 0x00, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x00, 0x61, 0x80, 0x0E, 0x00,
  0x30, 0xC0, 0x07, 0x00, 0x18, 0x60, 0x07, 0xC0, 0x0C, 0x30, 0x03, 0x60,
  0x06, 0x18, 0x01, 0xB0, 0x03, 0x0C, 0x00, 0xD8, 0x01, 0x86, 0x00, 0xC6,
  0x00, 0xC3, 0x80, 0x63, 0x00, 0x61, 0xC0, 0x31, 0x80, 0x70, 0x60, 0x38,
  0xE0, 0x30, 0x30, 0x18, 0x30, 0x18, 0x18, 0x0C, 0x18, 0x0C, 0x0C, 0x06,
  0x0C, 0x06, 0x06, 0x07, 0x03, 0x03, 0x03, 0x03, 0x01, 0x81, 0x81, 0x81,
  0x80, 0xC0, 0xC0, 0xC0, 0xC0, 0x70, 0x60, 0x60, 0xC0, 0x18, 0x30, 0x38,
  0x60, 0x0C, 0x18, 0x1C, 0x30, 0x06, 0x1C, 0x06, 0x38, 0x03, 0x8C, 0x03,
  0x18, 0x00, 0xC6, 0x01, 0x8C, 0x00, 0x63, 0x00, 0xC6, 0x00, 0x31, 0x80,
  0x66, 0x00, 0x0C, 0xC0, 0x33, 0x00, 0x06, 0x60, 0x19, 0x80, 0x03, 0x30,
  0x0D, 0xC0, 0x01, 0xD8, 0x06, 0xC0, 0x00, 0x6C, 0x03, 0xE0, 0x00, 0x36,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xB8, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00,
  0x01, 0x81, 0xC0, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x01, 0xC0, 0x1C, 0x00,
  0x00, 0xC0, 0x0E, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0x60, 0x00, 0x70, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x30, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00,
  0x30, 0x18, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x03, 0x70, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x03, 0x8E, 0x00,
  0x00, 0x01, 0x83, 0x80, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x01, 0xC0, 0x70,
  0x00, 0x00, 0xC0, 0x1C, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0xE0, 0x03,
  0x80, 0x00, 0x60, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x30, 0x00, 0x07, 0x00, 0x38, 0x00, 0x03, 0x80, 0x38, 0x00,
  0x00, 0xE0, 0x18, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x1C, 0x1C, 0x00,
  0x00, 0x07, 0x0C, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x00, 0x19,
  0xC0, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00,
  0x38, 0x38, 0x00, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x01, 0x80, 0x70, 0x00,
  0x00, 0x70, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x03, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x30, 0x00, 0x03, 0x80, 0x0E,
  0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0x70,
  0x1C, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00,
  0x0E, 0x38, 0x00, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x00, 0x1D, 0xC0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x00, 0xC6, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00,
  0x18, 0x0C, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x03,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x18, 0x00, 0x30, 0x00, 0x70,
  0x00, 0x70, 0x00, 0xC0, 0x00, 0x60, 0x03, 0x80, 0x00, 0xE0, 0x0E, 0x00,
  0x00, 0xC0, 0x18, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x01, 0xC0, 0xC0, 0x00,
  0x01, 0x83, 0x80, 0x00, 0x03, 0x86, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00,
  0x03, 0x70, 0x00, 0x00, 0x07, 0x40, 0x00, 0x00, 0x04, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x40, 0x70, 0x1C, 0x06, 0x03, 0x80, 0xE0,
  0x30, 0x0C, 0x07, 0x01, 0x80, 0x60, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0xF8, 0x0F, 0x80, 0x07, 0x80, 0x07, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0xC0, 0x00, 0x18, 0x06, 0x00, 0x00, 0x70, 0x08, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFE, 0x01, 0xF0, 0x00, 0x38, 0x0E, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x03,
  0x81, 0x80, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x38, 0x30, 0x00, 0x00, 0xE0,
  0xC0, 0x00, 0x03, 0x83, 0x00, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x38, 0x30,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x07, 0x81, 0x80, 0x00, 0x3E, 0x07, 0x00,
  0x01, 0xB8, 0x0E, 0x00, 0x0C, 0xE0, 0x1E, 0x01, 0xE1, 0xFC, 0x3F, 0xFF,
  0x07, 0xF0, 0x1F, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x07, 0xF8, 0x03, 0x0F, 0xFF, 0x80, 0xC7, 0x80,
  0xF8, 0x33, 0x00, 0x0F, 0x0D, 0x80, 0x01, 0xE3, 0xC0, 0x00, 0x18, 0xE0,
  0x00, 0x07, 0x38, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1B, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0xCE, 0x00,
  0x00, 0x73, 0xC0, 0x00, 0x18, 0xD8, 0x00, 0x0E, 0x33, 0x00, 0x0F, 0x0C,
  0x78, 0x0F, 0x83, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x3C, 0x07, 0xC0, 0x3C, 0x00, 0x38, 0x1C,
  0x00, 0x07, 0x06, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x06,
  0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x10, 0xC0, 0x00, 0x03, 0x38, 0x00, 0x01, 0x86, 0x00, 0x00, 0xE1,
  0xC0, 0x00, 0x70, 0x3C, 0x00, 0x38, 0x07, 0xC0, 0x3C, 0x00, 0x7F, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x07, 0xF8, 0x0C, 0x07, 0xFF, 0xC3, 0x07, 0xC0, 0x78, 0xC3,
  0xC0, 0x03, 0x31, 0xC0, 0x00, 0x6C, 0x60, 0x00, 0x0F, 0x38, 0x00, 0x01,
  0xCC, 0x00, 0x00, 0x77, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x03, 0x60, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x36, 0x00, 0x00, 0x0D, 0x80,
  0x00, 0x03, 0x70, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x73, 0x80, 0x00, 0x1C,
  0x60, 0x00, 0x0F, 0x1C, 0x00, 0x06, 0xC3, 0xC0, 0x03, 0x30, 0x7C, 0x07,
  0x8C, 0x07, 0xFF, 0xC3, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xFF, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0xF0, 0x00, 0xE0, 0x1C, 0x00,
  0x07, 0x01, 0x80, 0x00, 0x38, 0x30, 0x00, 0x01, 0x87, 0x00, 0x00, 0x1C,
  0x60, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x06, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x06, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x47, 0x00, 0x00, 0x0E, 0x30, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x18, 0x1C, 0x00, 0x03, 0x80, 0xF0, 0x00, 0xF0,
  0x07, 0xC0, 0x3E, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x40, 0x00, 0x0F,
  0xF1, 0x00, 0x01, 0xFF, 0xF4, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x70, 0x01,
  0xE0, 0x03, 0x80, 0x01, 0xC0, 0x1C, 0x00, 0x07, 0x00, 0x60, 0x00, 0x0E,
  0x01, 0x80, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x60, 0x38, 0x00, 0x01, 0x80,
  0xE0, 0x00, 0x06, 0x03, 0x80, 0x00, 0x18, 0x0E, 0x00, 0x00, 0x60, 0x38,
  0x00, 0x01, 0x80, 0xE0, 0x00, 0x06, 0x01, 0x80, 0x00, 0x38, 0x06, 0x00,
  0x00, 0xC0, 0x0C, 0x00, 0x07, 0x00, 0x38, 0x00, 0x18, 0x00, 0x70, 0x01,
  0xC0, 0x00, 0x70, 0x1E, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xF0, 0x1E, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x01, 0xC6, 0x00, 0x00,
  0x03, 0xB8, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x1B,
  0x80, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x38, 0x1E,
  0x00, 0x07, 0xC0, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x7F, 0x00, 0xC3, 0xFF, 0xE0, 0xC7,
  0x01, 0xF0, 0xCC, 0x00, 0x38, 0xD8, 0x00, 0x1C, 0xF0, 0x00, 0x0C, 0xE0,
  0x00, 0x0E, 0xE0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x33, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x80, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xCC,
  0x00, 0x00, 0x70, 0xC0, 0x00, 0x0E, 0x0C, 0x00, 0x01, 0xC0, 0xC0, 0x00,
  0x38, 0x0C, 0x00, 0x07, 0x00, 0xC0, 0x00, 0xE0, 0x0C, 0x00, 0x1C, 0x00,
  0xC0, 0x07, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0xC0, 0x1C, 0x00, 0x0C, 0x03,
  0x80, 0x00, 0xC0, 0x70, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0xC1, 0xF0, 0x00,
  0x0C, 0x3B, 0x80, 0x00, 0xCE, 0x1C, 0x00, 0x0D, 0xC1, 0xC0, 0x00, 0xF8,
  0x0E, 0x00, 0x0F, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x1C,
  0x00, 0xC0, 0x00, 0xC0, 0x0C, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x70, 0x0C,
  0x00, 0x03, 0x80, 0xC0, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x0E, 0x0C, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x1C,
  0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE1, 0xF0, 0x07, 0xE1, 0xCF, 0xF8, 0x3F, 0xE3, 0xB8, 0x38, 0xE0,
  0xE7, 0xC0, 0x33, 0x00, 0xEF, 0x00, 0x34, 0x00, 0xDC, 0x00, 0x70, 0x01,
  0xB8, 0x00, 0xE0, 0x03, 0x70, 0x01, 0xC0, 0x07, 0xE0, 0x03, 0x80, 0x0F,
  0xC0, 0x07, 0x00, 0x1F, 0x80, 0x0E, 0x00, 0x3F, 0x00, 0x1C, 0x00, 0x7E,
  0x00, 0x38, 0x00, 0xFC, 0x00, 0x70, 0x01, 0xF8, 0x00, 0xE0, 0x03, 0xF0,
  0x01, 0xC0, 0x07, 0xE0, 0x03, 0x80, 0x0F, 0xC0, 0x07, 0x00, 0x1F, 0x80,
  0x0E, 0x00, 0x3F, 0x00, 0x1C, 0x00, 0x7E, 0x00, 0x38, 0x00, 0xFC, 0x00,
  0x70, 0x01, 0xF8, 0x00, 0xE0, 0x03, 0xF0, 0x01, 0xC0, 0x07, 0xE0, 0x03,
  0x80, 0x0F, 0xC0, 0x07, 0x00, 0x1F, 0x80, 0x0E, 0x00, 0x3F, 0x00, 0x1C,
  0x00, 0x7E, 0x00, 0x38, 0x00, 0xFC, 0x00, 0x70, 0x01, 0xF8, 0x00, 0xE0,
  0x03, 0xF0, 0x01, 0xC0, 0x07, 0xE0, 0x03, 0x80, 0x0F, 0xC0, 0x07, 0x00,
  0x1C, 0xC0, 0x7F, 0x00, 0xC3, 0xFF, 0xE0, 0xC7, 0x01, 0xF0, 0xCC, 0x00,
  0x38, 0xD8, 0x00, 0x1C, 0xF0, 0x00, 0x0C, 0xE0, 0x00, 0x0E, 0xE0, 0x00,
  0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0xF8, 0x0F, 0x80, 0x0E, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0x38, 0x0E, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x03, 0x07, 0x00, 0x00, 0x1C,
  0x30, 0x00, 0x00, 0x63, 0x80, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x1C, 0xC0,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x19, 0x80, 0x00,
  0x00, 0xDC, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x66, 0x00, 0x00, 0x03, 0x30,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x06, 0x70, 0x00,
  0x00, 0x73, 0x80, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x18, 0x70, 0x00, 0x01,
  0xC1, 0x80, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x0E, 0x00,
  0xE0, 0x00, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0xC0, 0x7F, 0x80, 0x30, 0xFF, 0xF8, 0x0C, 0x78, 0x0F, 0x83,
  0x30, 0x00, 0xF0, 0xD8, 0x00, 0x1E, 0x3C, 0x00, 0x01, 0x8E, 0x00, 0x00,
  0x73, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x1B, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xB0,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x0C, 0xE0, 0x00, 0x07,
  0x3C, 0x00, 0x01, 0x8D, 0x80, 0x00, 0xE3, 0x30, 0x00, 0xF0, 0xC7, 0x80,
  0xF8, 0x30, 0xFF, 0xF8, 0x0C, 0x07, 0xF0, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0xC0, 0x7F, 0xFC, 0x30, 0x7C, 0x07, 0x8C, 0x3C, 0x00, 0x33,
  0x1C, 0x00, 0x06, 0xC6, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x1C, 0xC0, 0x00,
  0x07, 0x70, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x36, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0x60, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x37,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x07, 0x38, 0x00, 0x01, 0xC6, 0x00, 0x00,
  0xF1, 0xC0, 0x00, 0x6C, 0x3C, 0x00, 0x33, 0x07, 0xC0, 0x78, 0xC0, 0x7F,
  0xFC, 0x30, 0x07, 0xF8, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFC, 0x00, 0x71, 0xC0, 0x00, 0x00, 0xE6, 0x00, 0x00,
  0x01, 0xD8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xFF, 0x80, 0x0F, 0x80, 0x3E, 0x01, 0xE0, 0x00, 0x78, 0x38, 0x00,
  0x03, 0xC3, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x87, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x74, 0x00, 0x00, 0x06, 0xE0, 0x00,
  0x00, 0x6F, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x38,
  0x0F, 0xC0, 0x1F, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x07, 0x70,
  0x00, 0x07, 0x30, 0x00, 0x0F, 0x38, 0x00, 0x1B, 0x1C, 0x00, 0x33, 0x0F,
  0x80, 0xE3, 0x07, 0xFF, 0xC3, 0x00, 0xFF, 0x00, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0D, 0x80, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x67, 0x00, 0x00,
  0x1C, 0x60, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x1C, 0x18,
  0x00, 0x03, 0x03, 0x00, 0x00, 0x60, 0x70, 0x00, 0x1C, 0x06, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x60, 0x0C, 0x00, 0x18, 0x01, 0x80, 0x03, 0x00, 0x38,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0E, 0x00, 0xE0,
  0x00, 0xC0, 0x18, 0x00, 0x18, 0x03, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x30,
  0x18, 0x00, 0x06, 0x03, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x0C, 0x18, 0x00,
  0x01, 0xC3, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x03, 0x18, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x6C, 0x00, 0x1C, 0x00, 0x19,
  0x80, 0x06, 0xC0, 0x03, 0x30, 0x00, 0xD8, 0x00, 0x66, 0x00, 0x1B, 0x00,
  0x0C, 0xC0, 0x03, 0x60, 0x01, 0x9C, 0x00, 0xC6, 0x00, 0x71, 0x80, 0x18,
  0xC0, 0x0C, 0x30, 0x03, 0x18, 0x01, 0x86, 0x00, 0x63, 0x00, 0x30, 0xC0,
  0x18, 0x30, 0x06, 0x18, 0x03, 0x06, 0x00, 0xC1, 0x80, 0x60, 0xC0, 0x30,
  0x30, 0x0C, 0x18, 0x06, 0x06, 0x01, 0x01, 0x80, 0xC0, 0xC0, 0x60, 0x30,
  0x18, 0x18, 0x0C, 0x06, 0x03, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x20,
  0x0C, 0x18, 0x06, 0x0C, 0x01, 0x83, 0x00, 0xC1, 0x80, 0x30, 0x60, 0x18,
  0x30, 0x06, 0x0C, 0x03, 0x04, 0x00, 0x41, 0x80, 0x31, 0x80, 0x0C, 0x20,
  0x06, 0x30, 0x01, 0x8C, 0x00, 0xC6, 0x00, 0x31, 0x80, 0x18, 0xC0, 0x02,
  0x30, 0x03, 0x30, 0x00, 0x66, 0x00, 0x66, 0x00, 0x0C, 0xC0, 0x06, 0xC0,
  0x01, 0xB0, 0x00, 0xD8, 0x00, 0x16, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x00, 0x71,
  0x80, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x38, 0x38, 0x00, 0x03, 0x80, 0xE0,
  0x00, 0x38, 0x03, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x01, 0xC0, 0x1C, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x38, 0x0E, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x03, 0x86, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00,
  0x77, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x03, 0x8E, 0x00,
  0x00, 0x18, 0x30, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x1C, 0x07, 0x00, 0x01,
  0xC0, 0x1C, 0x00, 0x0C, 0x00, 0x60, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x0E, 0x00, 0xE0, 0x00, 0x38, 0x06, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x07,
  0x07, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x77, 0x00, 0x00, 0x03, 0xC0,
  0xE0, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x0C, 0xE0,
  0x00, 0x00, 0xE3, 0x00, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x70, 0x60, 0x00,
  0x03, 0x03, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x0C,
  0x03, 0x80, 0x00, 0xE0, 0x0C, 0x00, 0x06, 0x00, 0x60, 0x00, 0x30, 0x03,
  0x80, 0x03, 0x80, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x01, 0xC0, 0x01, 0x80,
  0x0C, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x30, 0x06, 0x00, 0x01, 0x80, 0x30,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0x30, 0x18, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0x30, 0x60, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x06,
  0x30, 0x00, 0x00, 0x39, 0x80, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x06, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0xC0, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0xF8, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x06, 0x1F, 0xE0, 0x00, 0x0C, 0x70, 0xF0, 0x00, 0x19,
  0xC0, 0x70, 0x00, 0x33, 0x00, 0x70, 0x00, 0xCE, 0x00, 0x60, 0x01, 0x98,
  0x00, 0x60, 0x07, 0x30, 0x00, 0xE0, 0x0C, 0xC0, 0x00, 0xE0, 0x39, 0x80,
  0x00, 0xF0, 0xE3, 0x00, 0x00, 0x7F, 0x86, 0x00, 0x00, 0x7C, 0x00,
};

const GFXglyph IBMPlexMono_ExtraLight65pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 39, 0, -1 },
  { 1, 5, 45, 39, 17, -45 },
  { 30, 11, 17, 39, 14, -48 },
  { 54, 37, 45, 39, 1, -45 },
  { 263, 31, 61, 39, 4, -53 },
  { 500, 35, 47, 39, 2, -46 },
  { 706, 34, 47, 39, 2, -46 },
  { 906, 3, 17, 39, 18, -48 },
  { 913, 16, 58, 39, 15, -49 },
  { 1029, 16, 58, 39, 8, -49 },
  { 1145, 33, 32, 39, 3, -36 },
  { 1277, 31, 32, 39, 4, -36 },
  { 1401, 7, 17, 39, 15, -6 },
  { 1416, 17, 2, 39, 11, -21 },
  { 1421, 5, 5, 39, 17, -5 },
  { 1425, 25, 58, 39, 7, -49 },
  { 1607, 31, 47, 39, 4, -46 },
  { 1790, 31, 45, 39, 5, -45 },
  { 1965, 29, 46, 39, 5, -46 },
  { 2132, 28, 47, 39, 4, -46 },
  { 2297, 33, 45, 39, 3, -45 },
  { 2483, 28, 46, 39, 5, -45 },
  { 2644, 29, 46, 39, 5, -45 },
  { 2811, 29, 45, 39, 5, -45 },
  { 2975, 31, 47, 39, 4, -46 },
  { 3158, 28, 46, 39, 6, -46 },
  { 3319, 5, 34, 39, 17, -34 },
  { 3341, 7, 45, 39, 15, -34 },
  { 3381, 27, 35, 39, 6, -37 },
  { 3500, 31, 14, 39, 4, -27 },
  { 3555, 27, 35, 39, 6, -37 },
  { 3674, 27, 46, 39, 6, -46 },
  { 3830, 27, 53, 39, 6, -46 },
  { 4009, 33, 45, 39, 3, -45 },
  { 4195, 28, 45, 39, 6, -45 },
  { 4353, 29, 47, 39, 5, -46 },
  { 4524, 28, 45, 39, 7, -45 },
  { 4682, 26, 45, 39, 7, -45 },
  { 4829, 27, 45, 39, 7, -45 },
  { 4981, 28, 47, 39, 5, -46 },
  { 5146, 27, 45, 39, 6, -45 },
  { 5298, 27, 45, 39, 6, -45 },
  { 5450, 24, 46, 39, 6, -45 },
  { 5588, 29, 45, 39, 7, -45 },
  { 5752, 25, 45, 39, 9, -45 },
  { 5893, 29, 45, 39, 5, -45 },
  { 6057, 27, 45, 39, 6, -45 },
  { 6209, 31, 47, 39, 4, -46 },
  { 6392, 27, 45, 39, 7, -45 },
  { 6544, 31, 56, 39, 4, -46 },
  { 6761, 27, 45, 39, 7, -45 },
  { 6913, 31, 47, 39, 4, -46 },
  { 7096, 35, 45, 39, 2, -45 },
  { 7293, 27, 46, 39, 6, -45 },
  { 7449, 33, 45, 39, 3, -45 },
  { 7635, 33, 45, 39, 3, -45 },
  { 7821, 33, 45, 39, 3, -45 },
  { 8007, 35, 45, 39, 2, -45 },
  { 8204, 33, 45, 39, 3, -45 },
  { 8390, 16, 58, 39, 17, -49 },
  { 8506, 25, 58, 39, 7, -49 },
  { 8688, 16, 58, 39, 6, -49 },
  { 8804, 31, 25, 39, 4, -45 },
  { 8901, 31, 2, 39, 4, 8 },
  { 8909, 9, 11, 39, 13, -50 },
  { 8922, 30, 35, 39, 5, -34 },
  { 9054, 26, 49, 39, 8, -48 },
  { 9214, 26, 35, 39, 7, -34 },
  { 9328, 26, 49, 39, 5, -48 },
  { 9488, 28, 35, 39, 6, -34 },
  { 9611, 30, 48, 39, 5, -48 },
  { 9791, 30, 51, 39, 6, -37 },
  { 9983, 24, 48, 39, 8, -48 },
  { 10127, 28, 48, 39, 7, -48 },
  { 10295, 23, 61, 39, 6, -48 },
  { 10471, 28, 48, 39, 9, -48 },
  { 10639, 27, 48, 39, 6, -48 },
  { 10801, 31, 34, 39, 4, -34 },
  { 10933, 24, 34, 39, 8, -34 },
  { 11035, 29, 35, 39, 5, -34 },
  { 11162, 26, 47, 39, 8, -34 },
  { 11315, 26, 47, 39, 5, -34 },
  { 11468, 31, 34, 39, 5, -34 },
  { 11600, 28, 35, 39, 6, -34 },
  { 11723, 32, 45, 39, 2, -45 },
  { 11903, 24, 35, 39, 7, -34 },
  { 12008, 27, 34, 39, 6, -34 },
  { 12123, 35, 34, 39, 2, -34 },
  { 12272, 29, 34, 39, 5, -34 },
  { 12396, 29, 47, 39, 5, -34 },
  { 12567, 27, 34, 39, 6, -34 },
  { 12682, 25, 58, 39, 7, -49 },
  { 12864, 3, 58, 39, 18, -49 },
  { 12886, 25, 58, 39, 7, -49 },
  { 13068, 31, 12, 39, 4, -26 },
};

const GFXfont IBMPlexMono_ExtraLight65pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLight65pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLight65pt7bGlyphs,
  0x20, 0x7E, 85
};

#endif // _IBMPLEXMONO_EXTRALIGHT65PT7B_H_
