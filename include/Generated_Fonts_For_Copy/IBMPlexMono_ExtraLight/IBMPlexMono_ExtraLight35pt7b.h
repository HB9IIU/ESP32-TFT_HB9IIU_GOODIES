#ifndef _IBMPLEXMONO_EXTRALIGHT35PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHT35PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLight.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLight35pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x40, 0x01, 0xFF, 0xC7, 0x8F,
  0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC6, 0x00, 0x82, 0x00, 0x10, 0x40, 0x06,
  0x08, 0x00, 0xC1, 0x00, 0x10, 0x60, 0x02, 0x08, 0x00, 0x41, 0x00, 0x08,
  0x20, 0x7F, 0x07, 0xE0, 0x41, 0x80, 0x08, 0x20, 0x01, 0x04, 0x00, 0x20,
  0x80, 0x04, 0x10, 0x01, 0x82, 0x07, 0xE0, 0xFE, 0x04, 0x10, 0x00, 0x82,
  0x00, 0x10, 0x40, 0x06, 0x08, 0x00, 0x81, 0x00, 0x10, 0x60, 0x02, 0x08,
  0x00, 0x41, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x7F, 0x00, 0xC4, 0x60, 0x82, 0x0C, 0xC1, 0x02, 0x40, 0x80, 0x20, 0x40,
  0x10, 0x20, 0x08, 0x10, 0x06, 0x08, 0x01, 0x84, 0x00, 0x72, 0x00, 0x0F,
  0xC0, 0x00, 0xBC, 0x00, 0x43, 0x00, 0x20, 0xC0, 0x10, 0x20, 0x08, 0x18,
  0x04, 0x0C, 0x02, 0x07, 0x01, 0x02, 0xC0, 0x81, 0x30, 0x41, 0x06, 0x23,
  0x00, 0xFE, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x1E,
  0x00, 0x2C, 0x30, 0x09, 0x02, 0x03, 0x40, 0x20, 0x48, 0x04, 0x11, 0x00,
  0x82, 0x20, 0x10, 0x84, 0x02, 0x10, 0x40, 0x84, 0x0C, 0x31, 0x80, 0x78,
  0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x1E, 0x01, 0x8C, 0x30, 0x21,
  0x02, 0x08, 0x40, 0x21, 0x08, 0x04, 0x41, 0x00, 0x88, 0x20, 0x12, 0x04,
  0x02, 0xC0, 0x40, 0x90, 0x0C, 0x34, 0x00, 0x78, 0x03, 0xE0, 0x03, 0x0C,
  0x01, 0x80, 0x80, 0x40, 0x20, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x38, 0x00, 0x11,
  0x03, 0xC8, 0x20, 0x84, 0x0C, 0x21, 0x01, 0x88, 0xC0, 0x32, 0x30, 0x06,
  0x8C, 0x00, 0xC1, 0x00, 0x10, 0x40, 0x0A, 0x18, 0x04, 0x43, 0x83, 0x08,
  0x3F, 0x03, 0xFF, 0x80, 0x01, 0x81, 0x01, 0x01, 0x01, 0x00, 0x80, 0x80,
  0x40, 0x40, 0x20, 0x10, 0x18, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x0C, 0x02, 0x01, 0x00, 0x80, 0x20, 0x10, 0x04, 0x02, 0x00,
  0x80, 0x20, 0x18, 0x03, 0xC0, 0x10, 0x04, 0x01, 0x00, 0x40, 0x20, 0x08,
  0x04, 0x01, 0x00, 0x80, 0x40, 0x30, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x18, 0x08, 0x04, 0x02, 0x02, 0x01, 0x01, 0x00, 0x80,
  0x80, 0x80, 0xC1, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x03, 0x02, 0x06, 0xF1, 0x1E, 0x0F, 0xF8, 0x00,
  0xE0, 0x00, 0x50, 0x00, 0x6C, 0x00, 0x63, 0x00, 0x20, 0x80, 0x20, 0x20,
  0x30, 0x18, 0x30, 0x06, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0xFF, 0xFF,
  0x80, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x36, 0x66, 0x44, 0xC8, 0x80, 0xFF,
  0x80, 0xFF, 0x80, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x00, 0x03, 0xE0, 0x06, 0x0C, 0x04,
  0x01, 0x04, 0x00, 0x42, 0x00, 0x22, 0x00, 0x09, 0x00, 0x04, 0x80, 0x02,
  0x40, 0x01, 0x60, 0x00, 0xF0, 0x00, 0x78, 0x38, 0x3C, 0x1C, 0x1E, 0x00,
  0x0F, 0x00, 0x06, 0x80, 0x02, 0x40, 0x01, 0x20, 0x00, 0x90, 0x00, 0x44,
  0x00, 0x42, 0x00, 0x20, 0x80, 0x20, 0x30, 0x60, 0x07, 0xC0, 0x03, 0x80,
  0x06, 0x80, 0x0C, 0x80, 0x18, 0x80, 0x30, 0x80, 0x60, 0x80, 0x80, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0xFF, 0xFF, 0x0F, 0xC0,
  0x60, 0x61, 0x80, 0x62, 0x00, 0x6C, 0x00, 0x50, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x7F, 0xFF, 0x07, 0xE0, 0x30, 0x30, 0xC0,
  0x33, 0x00, 0x20, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x04,
  0x00, 0x18, 0x00, 0xC0, 0x3E, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x1C, 0x00, 0x6C, 0x01,
  0x8E, 0x06, 0x07, 0xF0, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0A, 0x00, 0x0D,
  0x00, 0x04, 0x80, 0x04, 0x40, 0x06, 0x20, 0x02, 0x10, 0x02, 0x08, 0x02,
  0x04, 0x01, 0x02, 0x01, 0x01, 0x01, 0x00, 0x81, 0x80, 0x40, 0x80, 0x20,
  0x80, 0x10, 0xC0, 0x08, 0x40, 0x04, 0x3F, 0xFF, 0xE0, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x3F, 0xFC, 0x40, 0x00, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x1F, 0x82, 0xC1, 0xC6, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80,
  0x03, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x3C, 0x00, 0x4C, 0x01,
  0x0C, 0x0C, 0x07, 0xF0, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x00,
  0x80, 0x03, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0x8F, 0xC1, 0x60,
  0xE7, 0x00, 0x6C, 0x00, 0x58, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0E, 0x00, 0x34, 0x00, 0x44, 0x01, 0x06, 0x0C, 0x07,
  0xF0, 0xFF, 0xFF, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x28, 0x00, 0xD0, 0x01,
  0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00,
  0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x08,
  0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x07, 0xF0,
  0x0E, 0x0E, 0x0C, 0x01, 0x84, 0x00, 0x46, 0x00, 0x33, 0x00, 0x19, 0x80,
  0x0C, 0xC0, 0x06, 0x20, 0x02, 0x18, 0x03, 0x07, 0x07, 0x00, 0x7C, 0x01,
  0xC1, 0xC1, 0x00, 0x11, 0x80, 0x0C, 0x80, 0x02, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x68, 0x00, 0x26, 0x00, 0x31, 0x00, 0x10, 0x60, 0x30, 0x0F,
  0xE0, 0x07, 0xE0, 0x30, 0x60, 0x80, 0x22, 0x00, 0x24, 0x00, 0x70, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x07, 0x00, 0x1A, 0x00, 0x52,
  0x00, 0xE7, 0x06, 0x83, 0xF1, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00,
  0xC0, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x07, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x77, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x36, 0x66, 0x44, 0xC8, 0x80, 0x00, 0x02, 0x00, 0x1C, 0x00,
  0x60, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x01,
  0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x08, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x80, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x1C, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0xC0, 0x06, 0x00, 0x30, 0x01, 0xC0, 0x02, 0x00, 0x00, 0x07, 0xE0,
  0x30, 0x70, 0x80, 0x22, 0x00, 0x24, 0x00, 0x58, 0x00, 0x80, 0x01, 0x80,
  0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x60, 0x1F, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x01, 0xC0, 0x01, 0x80, 0x07, 0xC0, 0x30, 0x60, 0xC0,
  0x21, 0x00, 0x64, 0x00, 0x48, 0x00, 0x90, 0x01, 0x60, 0xFA, 0x83, 0x0F,
  0x04, 0x0E, 0x10, 0x1C, 0x20, 0x38, 0x40, 0x70, 0x80, 0xE1, 0x01, 0xC2,
  0x03, 0x84, 0x07, 0x08, 0x0E, 0x18, 0x1C, 0x10, 0x7C, 0x1F, 0x68, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x3F, 0xC0,
  0x01, 0xC0, 0x00, 0xA0, 0x00, 0x50, 0x00, 0x6C, 0x00, 0x22, 0x00, 0x11,
  0x00, 0x18, 0xC0, 0x08, 0x20, 0x04, 0x10, 0x06, 0x0C, 0x02, 0x02, 0x01,
  0x01, 0x01, 0x80, 0xC0, 0x80, 0x20, 0x40, 0x10, 0x7F, 0xFC, 0x20, 0x02,
  0x10, 0x01, 0x18, 0x00, 0xC8, 0x00, 0x24, 0x00, 0x16, 0x00, 0x0E, 0x00,
  0x03, 0x00, 0x01, 0xFF, 0xE1, 0x80, 0x33, 0x00, 0x26, 0x00, 0x6C, 0x00,
  0x58, 0x00, 0xB0, 0x01, 0x60, 0x02, 0xC0, 0x0D, 0x80, 0x13, 0x00, 0x47,
  0xFF, 0x0C, 0x01, 0x98, 0x00, 0xB0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xB0, 0x06, 0x7F, 0xF8,
  0x07, 0xE0, 0x38, 0x30, 0xC0, 0x33, 0x00, 0x34, 0x00, 0x28, 0x00, 0x30,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x16, 0x00, 0x66, 0x01, 0x87, 0x06, 0x03, 0xF0, 0xFF, 0x81, 0x00,
  0xC2, 0x00, 0x44, 0x00, 0xC8, 0x00, 0x90, 0x01, 0xA0, 0x01, 0x40, 0x02,
  0x80, 0x05, 0x00, 0x0A, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x02, 0x80, 0x05, 0x00, 0x0A, 0x00, 0x34, 0x00, 0x48, 0x01,
  0x90, 0x02, 0x20, 0x18, 0x7F, 0xC0, 0xFF, 0xFE, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x3F, 0xFF, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x3F, 0xFF,
  0xFF, 0xFE, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x3F, 0xFE, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x03, 0xF0, 0x0C, 0x18, 0x10, 0x04,
  0x30, 0x02, 0x20, 0x03, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x7F, 0x40, 0x01,
  0x40, 0x01, 0x40, 0x01, 0x40, 0x01, 0x60, 0x01, 0x20, 0x03, 0x30, 0x03,
  0x10, 0x05, 0x0C, 0x09, 0x03, 0xF1, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xFF, 0xFE, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x7F, 0xFF,
  0x3F, 0xF8, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x03, 0x80, 0x14, 0x01, 0xB0, 0x08,
  0xC1, 0x81, 0xF8, 0x80, 0x07, 0x00, 0x1A, 0x00, 0x64, 0x00, 0x88, 0x02,
  0x10, 0x08, 0x20, 0x20, 0x40, 0xC0, 0x83, 0x01, 0x0C, 0x02, 0x30, 0x04,
  0xD0, 0x0B, 0x30, 0x14, 0x20, 0x30, 0x20, 0x40, 0x60, 0x80, 0x41, 0x00,
  0x42, 0x00, 0xC4, 0x00, 0x88, 0x00, 0x90, 0x01, 0xA0, 0x01, 0x40, 0x01,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x2D,
  0x00, 0x5B, 0x01, 0x32, 0x02, 0x66, 0x08, 0xC4, 0x11, 0x8C, 0x63, 0x08,
  0x86, 0x1B, 0x0C, 0x14, 0x18, 0x38, 0x30, 0x20, 0x60, 0x40, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x06, 0x80, 0x0C, 0x80, 0x19, 0x00,
  0x31, 0x00, 0x62, 0x00, 0xC2, 0x01, 0x84, 0x03, 0x04, 0x06, 0x08, 0x0C,
  0x08, 0x18, 0x10, 0x30, 0x10, 0x60, 0x20, 0xC0, 0x21, 0x80, 0x43, 0x00,
  0x46, 0x00, 0x8C, 0x00, 0x98, 0x01, 0x30, 0x01, 0x60, 0x03, 0xC0, 0x03,
  0x03, 0xE0, 0x06, 0x0C, 0x04, 0x01, 0x04, 0x00, 0x42, 0x00, 0x22, 0x00,
  0x09, 0x00, 0x04, 0x80, 0x02, 0x40, 0x01, 0x60, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x06, 0x80, 0x02, 0x40, 0x01,
  0x20, 0x00, 0x90, 0x00, 0x44, 0x00, 0x42, 0x00, 0x20, 0x80, 0x20, 0x30,
  0x60, 0x07, 0xC0, 0xFF, 0xE1, 0x00, 0x32, 0x00, 0x34, 0x00, 0x28, 0x00,
  0x50, 0x00, 0xA0, 0x01, 0xC0, 0x02, 0x80, 0x05, 0x00, 0x0A, 0x00, 0x24,
  0x00, 0xCF, 0xFE, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x03, 0xE0, 0x06, 0x0C, 0x04, 0x01, 0x04, 0x00, 0x42, 0x00, 0x22, 0x00,
  0x09, 0x00, 0x04, 0x80, 0x02, 0x40, 0x01, 0x60, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x06, 0x80, 0x02, 0x40, 0x01,
  0x20, 0x00, 0x90, 0x00, 0x44, 0x00, 0x42, 0x00, 0x20, 0x80, 0x20, 0x30,
  0x60, 0x0F, 0xC0, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x0F, 0xE0, 0xFF, 0xE1, 0x00, 0x32, 0x00, 0x34, 0x00, 0x28, 0x00, 0x50,
  0x00, 0xA0, 0x01, 0xC0, 0x02, 0x80, 0x05, 0x00, 0x0A, 0x00, 0x24, 0x00,
  0xCF, 0xFE, 0x10, 0x60, 0x20, 0x40, 0x40, 0x40, 0x80, 0xC1, 0x00, 0x82,
  0x00, 0x84, 0x01, 0x88, 0x01, 0x10, 0x03, 0x20, 0x03, 0x40, 0x02, 0x07,
  0xF0, 0x0C, 0x06, 0x08, 0x00, 0xCC, 0x00, 0x24, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0xC0, 0x00, 0x70, 0x00, 0x2C, 0x00, 0x13, 0x00, 0x10, 0x60, 0x30,
  0x0F, 0xE0, 0xFF, 0xFF, 0xE0, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0D, 0x00, 0x12, 0x00,
  0x24, 0x00, 0x44, 0x01, 0x0C, 0x06, 0x07, 0xF0, 0x80, 0x00, 0xE0, 0x00,
  0xD0, 0x00, 0x48, 0x00, 0x26, 0x00, 0x31, 0x00, 0x10, 0x80, 0x08, 0x60,
  0x0C, 0x10, 0x04, 0x08, 0x02, 0x06, 0x03, 0x01, 0x01, 0x00, 0x80, 0x80,
  0x60, 0x40, 0x30, 0x40, 0x08, 0x20, 0x04, 0x10, 0x03, 0x18, 0x00, 0x88,
  0x00, 0x44, 0x00, 0x36, 0x00, 0x0A, 0x00, 0x05, 0x00, 0x03, 0x80, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x0F,
  0x00, 0x06, 0x81, 0x02, 0x41, 0xC1, 0x20, 0xA0, 0x90, 0x50, 0x48, 0x6C,
  0x24, 0x22, 0x12, 0x11, 0x09, 0x08, 0x84, 0x8C, 0x62, 0x64, 0x13, 0x32,
  0x09, 0x8B, 0x06, 0x85, 0x01, 0x42, 0x80, 0xA1, 0x40, 0x50, 0xE0, 0x38,
  0x60, 0x0C, 0xC0, 0x01, 0x90, 0x00, 0x42, 0x00, 0x30, 0xC0, 0x18, 0x10,
  0x04, 0x02, 0x02, 0x00, 0xC1, 0x80, 0x10, 0x40, 0x02, 0x20, 0x00, 0xD8,
  0x00, 0x14, 0x00, 0x02, 0x00, 0x01, 0xC0, 0x00, 0x58, 0x00, 0x22, 0x00,
  0x18, 0xC0, 0x04, 0x18, 0x02, 0x02, 0x01, 0x80, 0xC0, 0x40, 0x18, 0x20,
  0x02, 0x18, 0x00, 0xC4, 0x00, 0x1A, 0x00, 0x03, 0xC0, 0x00, 0x68, 0x00,
  0x09, 0x80, 0x03, 0x18, 0x00, 0xC1, 0x00, 0x10, 0x30, 0x06, 0x02, 0x00,
  0x80, 0x20, 0x20, 0x06, 0x0C, 0x00, 0x41, 0x00, 0x0C, 0x60, 0x00, 0xD8,
  0x00, 0x0A, 0x00, 0x01, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x02, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x80, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x40, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x10, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x04, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0xFF, 0x80, 0x04, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x02, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x20, 0x01,
  0xFF, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x03, 0xFF,
  0x00, 0x80, 0x00, 0xA0, 0x00, 0xD8, 0x00, 0x44, 0x00, 0x43, 0x00, 0x20,
  0x80, 0x20, 0x20, 0x30, 0x18, 0x10, 0x04, 0x18, 0x03, 0x08, 0x00, 0x88,
  0x00, 0x2C, 0x00, 0x18, 0xFF, 0xFF, 0x80, 0x82, 0x18, 0x41, 0x04, 0x1F,
  0xC0, 0x30, 0x60, 0x40, 0x10, 0x80, 0x18, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x08, 0x1F, 0xF8, 0x60, 0x08, 0xC0, 0x08, 0x80, 0x08, 0x80,
  0x08, 0x80, 0x08, 0x80, 0x28, 0xC0, 0x28, 0x60, 0x48, 0x1F, 0x8F, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x8F, 0xC2, 0x41, 0xCA, 0x01, 0xB0, 0x02, 0x80, 0x0E, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x3C, 0x00, 0xA8, 0x06, 0x90, 0x32, 0x3F, 0x00, 0x0F, 0xC0, 0xE0,
  0xC6, 0x01, 0x90, 0x02, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x03, 0x00, 0x24, 0x00, 0xD8,
  0x06, 0x38, 0x30, 0x3F, 0x00, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x0F, 0xC4, 0xE0, 0x96, 0x01,
  0x50, 0x03, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x07, 0x00, 0x14, 0x00, 0xD8, 0x05, 0x30,
  0x24, 0x3F, 0x10, 0x07, 0xC0, 0x30, 0x60, 0x80, 0x23, 0x00, 0x24, 0x00,
  0x58, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x0C, 0x00, 0x08, 0x00, 0xD8, 0x01, 0x10, 0x06, 0x18, 0x38, 0x0F,
  0xC0, 0x01, 0xFF, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0xFF, 0xFF, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0x07, 0xD0, 0x18, 0x30, 0x30,
  0x08, 0x20, 0x08, 0x60, 0x0C, 0x60, 0x04, 0x60, 0x04, 0x20, 0x0C, 0x20,
  0x08, 0x30, 0x08, 0x18, 0x30, 0x0F, 0xC0, 0x30, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x1F, 0xFC, 0x20, 0x06, 0x40, 0x03, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0xC0, 0x02, 0x70, 0x0C, 0x1F, 0xF0, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x8F, 0xC4,
  0x83, 0x28, 0x05, 0x80, 0x3C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x40, 0x03, 0x80, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x01, 0xFF, 0xFC, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x7F, 0xF0, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x0D, 0x00, 0x62, 0x01, 0x84, 0x06, 0x08, 0x18, 0x10,
  0x60, 0x21, 0x00, 0x46, 0x00, 0xB6, 0x01, 0xC6, 0x03, 0x06, 0x04, 0x04,
  0x08, 0x04, 0x10, 0x04, 0x20, 0x0C, 0x40, 0x0C, 0x80, 0x0D, 0x00, 0x0C,
  0xFF, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x01, 0xFF,
  0xFC, 0xDE, 0x1E, 0x70, 0x91, 0xB0, 0x30, 0x58, 0x10, 0x3C, 0x08, 0x1E,
  0x04, 0x0F, 0x02, 0x07, 0x81, 0x03, 0xC0, 0x81, 0xE0, 0x40, 0xF0, 0x20,
  0x78, 0x10, 0x3C, 0x08, 0x1E, 0x04, 0x0F, 0x02, 0x07, 0x81, 0x03, 0xC0,
  0x81, 0xE0, 0x40, 0xC0, 0x8F, 0xC4, 0x83, 0x28, 0x05, 0x80, 0x3C, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x07, 0xC0,
  0x30, 0x60, 0x80, 0x22, 0x00, 0x24, 0x00, 0x58, 0x00, 0xE0, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x68, 0x00,
  0x90, 0x01, 0x10, 0x04, 0x18, 0x30, 0x0F, 0xC0, 0x8F, 0xC2, 0x41, 0xCA,
  0x01, 0xB0, 0x02, 0x80, 0x0E, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x3C, 0x00, 0xA8, 0x06,
  0x90, 0x32, 0x3F, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x00, 0x0F, 0xC4, 0xE0, 0x96, 0x01, 0x50, 0x03, 0xC0,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x07, 0x00, 0x14, 0x00, 0xD8, 0x05, 0x30, 0x24, 0x3F, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0xFE, 0x3F, 0x81, 0x20, 0x00, 0xA0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x7F, 0xFF, 0x00, 0x0F, 0xE0, 0x60, 0x31, 0x80, 0x12, 0x00, 0x34, 0x00,
  0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0F, 0xC0, 0x00, 0xF0, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x60, 0x00, 0xB0, 0x02, 0x38, 0x18, 0x1F,
  0xE0, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x03, 0xFF, 0xFE, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x03, 0xFF, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x0F, 0x00, 0x68, 0x05, 0x30, 0x48, 0xFC, 0x40, 0x80, 0x02,
  0x80, 0x09, 0x00, 0x13, 0x00, 0x62, 0x00, 0x84, 0x01, 0x0C, 0x06, 0x08,
  0x08, 0x10, 0x10, 0x10, 0x40, 0x20, 0x80, 0x61, 0x00, 0x44, 0x00, 0x88,
  0x01, 0xB0, 0x01, 0x40, 0x02, 0x80, 0x02, 0x00, 0x80, 0x40, 0x28, 0x14,
  0x09, 0x02, 0x81, 0x20, 0x50, 0x24, 0x0A, 0x04, 0x82, 0x20, 0x98, 0x44,
  0x31, 0x08, 0x84, 0x21, 0x10, 0x84, 0x41, 0x10, 0x88, 0x22, 0x11, 0x04,
  0x41, 0x20, 0x90, 0x28, 0x0A, 0x05, 0x01, 0x40, 0xA0, 0x28, 0x14, 0x05,
  0x03, 0x00, 0x60, 0xC0, 0x06, 0xC0, 0x18, 0x80, 0x20, 0x80, 0x81, 0x83,
  0x01, 0x8C, 0x01, 0x10, 0x01, 0x40, 0x03, 0x80, 0x07, 0x00, 0x0A, 0x00,
  0x22, 0x00, 0x82, 0x03, 0x06, 0x04, 0x04, 0x10, 0x04, 0x40, 0x0D, 0x80,
  0x0C, 0x80, 0x03, 0x80, 0x0D, 0x00, 0x12, 0x00, 0x22, 0x00, 0x84, 0x01,
  0x0C, 0x06, 0x08, 0x08, 0x10, 0x10, 0x10, 0x40, 0x20, 0x80, 0x63, 0x00,
  0x44, 0x00, 0x88, 0x00, 0xA0, 0x01, 0x40, 0x03, 0x80, 0x02, 0x00, 0x0C,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0xF8, 0x00,
  0x7F, 0xFC, 0x00, 0x18, 0x00, 0x20, 0x00, 0x80, 0x03, 0x00, 0x0C, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x06, 0x00, 0x18, 0x00, 0x20, 0x00, 0x80,
  0x03, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x40, 0x01, 0xFF, 0xFC, 0x07, 0xF8,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x40, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x0C, 0x1F, 0x80,
  0x07, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x80, 0x0C, 0x00,
  0x40, 0x06, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x18, 0x00, 0x3F, 0x07, 0x00, 0x60, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x1F, 0xE0, 0x1C, 0x00,
  0x91, 0x80, 0x50, 0x60, 0x48, 0x18, 0x28, 0x06, 0x24, 0x00, 0xE0,
};

const GFXglyph IBMPlexMono_ExtraLight35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 21, 0, -1 },
  { 1, 3, 24, 21, 9, -24 },
  { 10, 7, 9, 21, 7, -26 },
  { 18, 19, 24, 21, 1, -24 },
  { 75, 17, 32, 21, 2, -28 },
  { 143, 19, 24, 21, 1, -24 },
  { 200, 18, 24, 21, 1, -24 },
  { 254, 1, 9, 21, 10, -26 },
  { 256, 9, 32, 21, 8, -27 },
  { 292, 9, 32, 21, 4, -27 },
  { 328, 17, 17, 21, 2, -19 },
  { 365, 17, 17, 21, 2, -19 },
  { 402, 4, 9, 21, 8, -3 },
  { 407, 9, 1, 21, 6, -11 },
  { 409, 3, 3, 21, 9, -3 },
  { 411, 13, 32, 21, 4, -27 },
  { 463, 17, 24, 21, 2, -24 },
  { 514, 16, 24, 21, 3, -24 },
  { 562, 15, 24, 21, 3, -24 },
  { 607, 15, 24, 21, 2, -24 },
  { 652, 17, 24, 21, 2, -24 },
  { 703, 15, 24, 21, 3, -24 },
  { 748, 15, 24, 21, 3, -24 },
  { 793, 15, 24, 21, 3, -24 },
  { 838, 17, 24, 21, 2, -24 },
  { 889, 15, 24, 21, 3, -24 },
  { 934, 3, 19, 21, 9, -19 },
  { 942, 4, 25, 21, 8, -19 },
  { 955, 15, 19, 21, 3, -20 },
  { 991, 17, 7, 21, 2, -14 },
  { 1006, 15, 19, 21, 3, -20 },
  { 1042, 15, 24, 21, 3, -24 },
  { 1087, 15, 28, 21, 3, -24 },
  { 1140, 17, 24, 21, 2, -24 },
  { 1191, 15, 24, 21, 3, -24 },
  { 1236, 15, 24, 21, 3, -24 },
  { 1281, 15, 24, 21, 4, -24 },
  { 1326, 14, 24, 21, 4, -24 },
  { 1368, 14, 24, 21, 4, -24 },
  { 1410, 16, 24, 21, 2, -24 },
  { 1458, 15, 24, 21, 3, -24 },
  { 1503, 15, 24, 21, 3, -24 },
  { 1548, 13, 24, 21, 3, -24 },
  { 1587, 15, 24, 21, 4, -24 },
  { 1632, 14, 24, 21, 5, -24 },
  { 1674, 15, 24, 21, 3, -24 },
  { 1719, 15, 24, 21, 3, -24 },
  { 1764, 17, 24, 21, 2, -24 },
  { 1815, 15, 24, 21, 4, -24 },
  { 1860, 17, 29, 21, 2, -24 },
  { 1922, 15, 24, 21, 4, -24 },
  { 1967, 17, 24, 21, 2, -24 },
  { 2018, 19, 24, 21, 1, -24 },
  { 2075, 15, 24, 21, 3, -24 },
  { 2120, 17, 24, 21, 2, -24 },
  { 2171, 17, 24, 21, 2, -24 },
  { 2222, 18, 24, 21, 2, -24 },
  { 2276, 19, 24, 21, 1, -24 },
  { 2333, 17, 24, 21, 2, -24 },
  { 2384, 9, 32, 21, 9, -27 },
  { 2420, 13, 32, 21, 4, -27 },
  { 2472, 9, 32, 21, 3, -27 },
  { 2508, 17, 13, 21, 2, -24 },
  { 2536, 17, 1, 21, 2, 4 },
  { 2539, 5, 6, 21, 7, -27 },
  { 2543, 16, 18, 21, 3, -18 },
  { 2579, 14, 26, 21, 4, -26 },
  { 2625, 14, 18, 21, 4, -18 },
  { 2657, 14, 26, 21, 3, -26 },
  { 2703, 15, 18, 21, 3, -18 },
  { 2737, 16, 26, 21, 3, -26 },
  { 2789, 16, 26, 21, 3, -19 },
  { 2841, 13, 26, 21, 4, -26 },
  { 2884, 15, 26, 21, 4, -26 },
  { 2933, 13, 33, 21, 3, -26 },
  { 2987, 15, 26, 21, 5, -26 },
  { 3036, 15, 26, 21, 3, -26 },
  { 3085, 17, 18, 21, 2, -18 },
  { 3124, 13, 18, 21, 4, -18 },
  { 3154, 15, 18, 21, 3, -18 },
  { 3188, 14, 25, 21, 4, -18 },
  { 3232, 14, 25, 21, 3, -18 },
  { 3276, 17, 18, 21, 3, -18 },
  { 3315, 15, 18, 21, 3, -18 },
  { 3349, 17, 24, 21, 1, -24 },
  { 3400, 13, 18, 21, 4, -18 },
  { 3430, 15, 18, 21, 3, -18 },
  { 3464, 19, 18, 21, 1, -18 },
  { 3507, 15, 18, 21, 3, -18 },
  { 3541, 15, 25, 21, 3, -18 },
  { 3588, 15, 18, 21, 3, -18 },
  { 3622, 13, 32, 21, 4, -27 },
  { 3674, 1, 32, 21, 10, -27 },
  { 3678, 13, 32, 21, 4, -27 },
  { 3730, 17, 6, 21, 2, -14 },
};

const GFXfont IBMPlexMono_ExtraLight35pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLight35pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLight35pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _IBMPLEXMONO_EXTRALIGHT35PT7B_H_
