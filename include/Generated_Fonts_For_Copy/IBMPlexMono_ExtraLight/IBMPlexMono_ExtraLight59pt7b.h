#ifndef _IBMPLEXMONO_EXTRALIGHT59PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHT59PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLight.ttf
// Size: 59pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLight59pt7bBitmaps[] PROGMEM = {
  0x00, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31,
  0x8C, 0x63, 0x18, 0x84, 0x21, 0x08, 0x42, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x7F, 0xFF, 0x70, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0C, 0x00, 0x03,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00,
  0xE0, 0x18, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00,
  0x18, 0x06, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x60, 0x00, 0x01, 0x80, 0x20, 0x00,
  0x00, 0xC0, 0x30, 0x01, 0xFF, 0xE0, 0x1F, 0xFC, 0xFF, 0xF0, 0x0F, 0xFE,
  0x00, 0x30, 0x06, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x0C, 0x03, 0x00,
  0x00, 0x06, 0x01, 0x80, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x60, 0x18,
  0x00, 0x00, 0x30, 0x0C, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0x3F, 0xF8, 0x03,
  0xFF, 0x80, 0x0C, 0x01, 0x80, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x60, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x00, 0xC0,
  0x18, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x18,
  0x06, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x06,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x60, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xFF, 0xE0, 0x07, 0x86, 0x3E, 0x03, 0xC0, 0xC0, 0xF0, 0xE0, 0x18,
  0x07, 0x18, 0x03, 0x00, 0x77, 0x00, 0x60, 0x04, 0xC0, 0x0C, 0x00, 0x18,
  0x01, 0x80, 0x03, 0x00, 0x30, 0x00, 0x60, 0x06, 0x00, 0x0C, 0x00, 0xC0,
  0x01, 0x80, 0x18, 0x00, 0x30, 0x03, 0x00, 0x07, 0x00, 0x60, 0x00, 0x60,
  0x0C, 0x00, 0x0E, 0x01, 0x80, 0x00, 0xE0, 0x30, 0x00, 0x0F, 0x06, 0x00,
  0x00, 0xFE, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x67, 0xE0, 0x00, 0x0C, 0x1E, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x30, 0x0E,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0xC0, 0x0C, 0x00, 0x18, 0x01, 0x80, 0x03,
  0x00, 0x30, 0x00, 0x60, 0x06, 0x00, 0x0C, 0x00, 0xC0, 0x01, 0x80, 0x18,
  0x00, 0x30, 0x03, 0x00, 0x06, 0x00, 0x78, 0x00, 0xC0, 0x0F, 0x80, 0x18,
  0x03, 0xB8, 0x03, 0x00, 0x63, 0x80, 0x60, 0x18, 0x3C, 0x0C, 0x0E, 0x03,
  0xE1, 0x87, 0x80, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0x3C, 0x1C, 0x00, 0x06, 0x70, 0x0E, 0x00, 0x0C, 0x60, 0x06,
  0x00, 0x0C, 0xE0, 0x03, 0x00, 0x18, 0xC0, 0x03, 0x00, 0x18, 0xC0, 0x03,
  0x00, 0x30, 0xC0, 0x03, 0x00, 0x30, 0xC0, 0x01, 0x00, 0x60, 0xC0, 0x01,
  0x00, 0xC0, 0xC0, 0x03, 0x00, 0xC0, 0xC0, 0x03, 0x01, 0x80, 0xC0, 0x03,
  0x01, 0x80, 0xC0, 0x03, 0x03, 0x00, 0x60, 0x06, 0x02, 0x00, 0x70, 0x0E,
  0x06, 0x00, 0x3C, 0x1C, 0x0C, 0x00, 0x1F, 0xF8, 0x0C, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x30, 0x3F, 0xF0, 0x00, 0x60,
  0x78, 0x38, 0x00, 0x40, 0xE0, 0x1C, 0x00, 0xC0, 0xC0, 0x0E, 0x01, 0x80,
  0xC0, 0x06, 0x01, 0x81, 0x80, 0x06, 0x03, 0x01, 0x80, 0x06, 0x03, 0x01,
  0x80, 0x03, 0x06, 0x01, 0x80, 0x03, 0x0C, 0x01, 0x80, 0x03, 0x0C, 0x01,
  0x80, 0x03, 0x18, 0x01, 0x80, 0x06, 0x18, 0x01, 0x80, 0x06, 0x30, 0x00,
  0xC0, 0x06, 0x30, 0x00, 0xC0, 0x0E, 0x60, 0x00, 0xE0, 0x1C, 0xC0, 0x00,
  0x78, 0x38, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1E, 0x07, 0x00, 0x00, 0xE0, 0x0E,
  0x00, 0x03, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x60, 0x00, 0x40,
  0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1C, 0xE0, 0x03, 0xF0, 0xE1, 0xC0, 0x0F,
  0xC6, 0x03, 0x00, 0x30, 0x38, 0x06, 0x01, 0x80, 0xC0, 0x0C, 0x06, 0x06,
  0x00, 0x38, 0x18, 0x18, 0x00, 0x70, 0x60, 0x60, 0x00, 0xE1, 0x83, 0x80,
  0x01, 0xC6, 0x0C, 0x00, 0x03, 0x18, 0x30, 0x00, 0x06, 0x60, 0xC0, 0x00,
  0x0F, 0x03, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x70, 0x18, 0x00, 0x01,
  0xE0, 0x60, 0x00, 0x0D, 0xC1, 0xC0, 0x00, 0x23, 0x83, 0x80, 0x01, 0x86,
  0x07, 0x00, 0x1C, 0x0C, 0x0F, 0x01, 0xE0, 0x18, 0x1F, 0xFE, 0x00, 0x70,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1C, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x0C, 0x00,
  0x30, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x1C, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x10, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0,
  0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01, 0x80,
  0x0E, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xBE, 0x00, 0xC0, 0x1F, 0x3F,
  0x03, 0x07, 0xF0, 0x1F, 0x8C, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x36, 0x00, 0x00, 0x01, 0xCC,
  0x00, 0x00, 0x06, 0x38, 0x00, 0x00, 0x30, 0x60, 0x00, 0x01, 0xC0, 0xC0,
  0x00, 0x0E, 0x01, 0x80, 0x00, 0x30, 0x07, 0x00, 0x01, 0x80, 0x0C, 0x00,
  0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x01, 0x80, 0x00, 0xE0, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x1E, 0x3C, 0x70, 0xE3, 0xC7, 0x0E, 0x1C,
  0x30, 0xE1, 0x83, 0x06, 0x08, 0x30, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x77,
  0xFF, 0xF7, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0x01, 0xE0, 0x03, 0x80,
  0x0F, 0x00, 0xE0, 0x00, 0x60, 0x38, 0x00, 0x06, 0x06, 0x00, 0x00, 0xE1,
  0x80, 0x00, 0x0C, 0x30, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x19, 0x80, 0x00,
  0x03, 0x30, 0x00, 0x00, 0x66, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0x80,
  0x1E, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x07, 0x18, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x38, 0x38, 0x00, 0x06, 0x03, 0x80, 0x01, 0x80,
  0x38, 0x00, 0xF0, 0x03, 0xC0, 0x78, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x76, 0x00,
  0x00, 0x0E, 0x60, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x38, 0x60, 0x00, 0x07,
  0x06, 0x00, 0x01, 0xE0, 0x60, 0x00, 0x3C, 0x06, 0x00, 0x07, 0x80, 0x60,
  0x00, 0xF0, 0x06, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x80, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0xF8, 0x0F, 0x00,
  0x70, 0x00, 0xE0, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0x86, 0x00, 0x00,
  0x63, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x07, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFF,
  0xF8, 0x01, 0xE0, 0x3E, 0x01, 0xC0, 0x03, 0x81, 0x80, 0x00, 0xE1, 0xC0,
  0x00, 0x31, 0xC0, 0x00, 0x1C, 0x40, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x68, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x38, 0x78, 0x00, 0x38,
  0x0F, 0x00, 0xF8, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x0D,
  0x80, 0x00, 0x00, 0x66, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x0C, 0x60,
  0x00, 0x00, 0x61, 0x80, 0x00, 0x03, 0x06, 0x00, 0x00, 0x0C, 0x18, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x03, 0x01, 0x80, 0x00, 0x0C, 0x06, 0x00, 0x00,
  0x60, 0x18, 0x00, 0x03, 0x00, 0x60, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x60,
  0x06, 0x00, 0x03, 0x00, 0x18, 0x00, 0x18, 0x00, 0x60, 0x00, 0x60, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x18, 0x00, 0x60, 0x00, 0x60,
  0x03, 0x00, 0x01, 0x80, 0x18, 0x00, 0x06, 0x00, 0x60, 0x00, 0x18, 0x03,
  0x00, 0x00, 0x60, 0x18, 0x00, 0x01, 0x80, 0x60, 0x00, 0x06, 0x03, 0x00,
  0x00, 0x18, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x1F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0x86, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x7F,
  0x80, 0x18, 0xFF, 0xF8, 0x0D, 0xE0, 0x3E, 0x05, 0x80, 0x03, 0x83, 0x80,
  0x00, 0xE3, 0x80, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xD0, 0x00, 0x00, 0xD8, 0x00, 0x00,
  0xE6, 0x00, 0x00, 0x63, 0x80, 0x00, 0x70, 0xF0, 0x00, 0x70, 0x1E, 0x01,
  0xF0, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x7F, 0x80, 0x18, 0x7F, 0xFC, 0x06, 0x78, 0x0F, 0x81, 0xB8, 0x00,
  0x70, 0x58, 0x00, 0x0E, 0x34, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x33, 0x80,
  0x00, 0x0E, 0xE0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x1B,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1B, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x01, 0x98, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x31, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x06, 0x00, 0x03, 0x81,
  0xE0, 0x01, 0xC0, 0x1E, 0x03, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0x60,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x19, 0x80, 0x00, 0x03, 0x30, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x07, 0x18, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xFF, 0x00, 0x1F, 0x00, 0xF0, 0x07, 0x00, 0x07, 0x81, 0xC0, 0x00,
  0x70, 0x70, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x61, 0x80, 0x00, 0x0E, 0x70,
  0x00, 0x00, 0xCE, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x03, 0x38, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x1C, 0x1C, 0x00, 0x07, 0x01, 0xC0, 0x01, 0xC0, 0x0F, 0x00, 0xF0,
  0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0x80, 0x78, 0x03, 0x80,
  0x03, 0xC0, 0xC0, 0x00, 0x1C, 0x30, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x0C, 0x60, 0x00, 0x03, 0x8E, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x78, 0x07,
  0xC0, 0x3E, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0xF8, 0x00, 0x78, 0x0F, 0x80, 0x38, 0x00, 0x70, 0x1C,
  0x00, 0x0E, 0x0E, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x31, 0x80, 0x00, 0x0E,
  0x60, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x76, 0x00, 0x00, 0x39,
  0xC0, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x87, 0x00, 0x03, 0x61, 0xE0, 0x01,
  0x98, 0x3E, 0x01, 0xC6, 0x03, 0xFF, 0xE3, 0x00, 0x3F, 0xC0, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x77, 0xFF, 0xF7, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1D, 0xFF, 0xFD, 0xC0, 0x1C,
  0x7C, 0xF9, 0xF1, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0xF1,
  0xC3, 0x8F, 0x1C, 0x38, 0x70, 0xC3, 0x86, 0x0C, 0x18, 0x20, 0xC0, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x0F, 0x00, 0xF0, 0x1C, 0x00,
  0x38, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x0C, 0x60, 0x00, 0x06, 0xC0, 0x00,
  0x06, 0xC0, 0x00, 0x06, 0x40, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xE0, 0x00, 0x7F, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0xF0, 0x01, 0xF0, 0x3C, 0x01, 0xC0, 0x07, 0x00, 0xC0, 0x00, 0xC0, 0xC0,
  0x00, 0x70, 0x60, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x18,
  0x00, 0x01, 0x98, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x66, 0x00, 0x7E, 0x13,
  0x00, 0x7F, 0xC9, 0x80, 0xF0, 0x67, 0x80, 0x60, 0x0B, 0xC0, 0x60, 0x03,
  0xE0, 0x30, 0x01, 0xF0, 0x18, 0x00, 0xF8, 0x18, 0x00, 0x3C, 0x0C, 0x00,
  0x1E, 0x06, 0x00, 0x0F, 0x03, 0x00, 0x07, 0x81, 0x80, 0x03, 0xC0, 0xC0,
  0x01, 0xE0, 0x60, 0x00, 0xF0, 0x30, 0x00, 0x78, 0x18, 0x00, 0x3C, 0x0C,
  0x00, 0x1E, 0x06, 0x00, 0x0F, 0x01, 0x80, 0x0F, 0x80, 0xC0, 0x07, 0xC0,
  0x70, 0x05, 0xA0, 0x1C, 0x06, 0xD8, 0x07, 0xDE, 0x6C, 0x01, 0xFE, 0x36,
  0x00, 0x10, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x7F,
  0xFC, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0x03, 0x60, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x73, 0x00, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0x06, 0x38, 0x00, 0x00, 0x38, 0x60, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x03, 0x07, 0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0x60,
  0x30, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x30, 0x06,
  0x00, 0x00, 0xC0, 0x1C, 0x00, 0x03, 0x00, 0x30, 0x00, 0x18, 0x00, 0xC0,
  0x00, 0x60, 0x03, 0x80, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x70, 0x00, 0xC0, 0x00, 0xC0, 0x06, 0x00, 0x03, 0x00, 0x18,
  0x00, 0x0E, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x0C, 0x00,
  0x01, 0xC0, 0x30, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x0C, 0x06, 0x00, 0x00,
  0x38, 0x18, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x01, 0x83, 0x00, 0x00, 0x07,
  0x0C, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0xC6,
  0x00, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x1C, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x30, 0x00, 0x3C, 0x18, 0x00, 0x07, 0x0C,
  0x00, 0x01, 0xC6, 0x00, 0x00, 0x63, 0x00, 0x00, 0x39, 0x80, 0x00, 0x0C,
  0xC0, 0x00, 0x06, 0x60, 0x00, 0x03, 0x30, 0x00, 0x01, 0x98, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x66, 0x00, 0x00, 0x73, 0x00, 0x00, 0x31, 0x80, 0x00,
  0x18, 0xC0, 0x00, 0x1C, 0x60, 0x00, 0x1C, 0x30, 0x00, 0x38, 0x1F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFE, 0x06, 0x00, 0x03, 0xC3, 0x00, 0x00, 0x71, 0x80,
  0x00, 0x0C, 0xC0, 0x00, 0x07, 0x60, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xD8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xB0, 0x00, 0x00,
  0xD8, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x66, 0x00, 0x00, 0xE3, 0x00, 0x01,
  0xE1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0xFC, 0x00, 0x3C, 0x03, 0xC0, 0x1C, 0x00, 0x38, 0x0E, 0x00, 0x07,
  0x07, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x06, 0x70, 0x00,
  0x00, 0xD8, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x0C, 0xC0, 0x00, 0x06, 0x38, 0x00, 0x01, 0x87, 0x00, 0x00, 0xC0,
  0xE0, 0x00, 0x70, 0x1C, 0x00, 0x38, 0x03, 0xC0, 0x3C, 0x00, 0x7F, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x30, 0x00,
  0x7C, 0x18, 0x00, 0x0F, 0x0C, 0x00, 0x01, 0x86, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x39, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x07, 0x60, 0x00, 0x01, 0xB0,
  0x00, 0x00, 0xD8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x07, 0x60,
  0x00, 0x03, 0x30, 0x00, 0x03, 0x98, 0x00, 0x01, 0x8C, 0x00, 0x01, 0xC6,
  0x00, 0x03, 0xC3, 0x00, 0x07, 0x81, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE6, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x3E, 0x03, 0xC0, 0x1C,
  0x00, 0x38, 0x0E, 0x00, 0x07, 0x03, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x18,
  0xE0, 0x00, 0x07, 0x30, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0x60, 0x00, 0x00, 0xD8,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x03, 0x70, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x33, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x07, 0x18, 0x00,
  0x01, 0xC7, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x6C, 0x1C, 0x00, 0x33, 0x03,
  0xE0, 0x38, 0xC0, 0x3F, 0xFC, 0x30, 0x03, 0xFC, 0x00, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x1B, 0x80,
  0x00, 0x33, 0x00, 0x00, 0xE7, 0x00, 0x01, 0x87, 0x00, 0x07, 0x07, 0x00,
  0x1C, 0x07, 0x80, 0xF0, 0x07, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x33, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0xE1, 0x80, 0x00, 0x38, 0x30, 0x00, 0x0E, 0x06, 0x00, 0x03,
  0x80, 0xC0, 0x00, 0xE0, 0x18, 0x00, 0x38, 0x03, 0x00, 0x06, 0x00, 0x60,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x1C, 0x00, 0x30, 0x07, 0x00,
  0x06, 0x01, 0xC0, 0x00, 0xC0, 0x70, 0x00, 0x18, 0x1C, 0x00, 0x03, 0x07,
  0xC0, 0x00, 0x60, 0xDC, 0x00, 0x0C, 0x31, 0x80, 0x01, 0x8C, 0x38, 0x00,
  0x33, 0x03, 0x80, 0x06, 0xE0, 0x30, 0x00, 0xF8, 0x07, 0x00, 0x1E, 0x00,
  0x70, 0x03, 0x80, 0x06, 0x00, 0x60, 0x00, 0xE0, 0x0C, 0x00, 0x0E, 0x01,
  0x80, 0x00, 0xC0, 0x30, 0x00, 0x1C, 0x06, 0x00, 0x01, 0xC0, 0xC0, 0x00,
  0x18, 0x18, 0x00, 0x03, 0x83, 0x00, 0x00, 0x30, 0x60, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x71, 0x80, 0x00, 0x06, 0x30, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x0E, 0xC0, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x1B, 0xD8, 0x00, 0x06, 0xF6, 0x00, 0x03, 0x3D, 0xC0,
  0x00, 0xCF, 0x30, 0x00, 0x63, 0xCE, 0x00, 0x18, 0xF1, 0x80, 0x06, 0x3C,
  0x60, 0x03, 0x0F, 0x0C, 0x00, 0xC3, 0xC3, 0x00, 0x60, 0xF0, 0x60, 0x18,
  0x3C, 0x18, 0x0C, 0x0F, 0x03, 0x03, 0x03, 0xC0, 0xC1, 0x80, 0xF0, 0x38,
  0x60, 0x3C, 0x06, 0x18, 0x0F, 0x01, 0x8C, 0x03, 0xC0, 0x33, 0x00, 0xF0,
  0x0D, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0xC0, 0x0C, 0x00,
  0xF0, 0x02, 0x00, 0x3C, 0x00, 0x80, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xD8, 0x00, 0x03, 0xD8, 0x00, 0x03, 0xCC,
  0x00, 0x03, 0xCC, 0x00, 0x03, 0xC6, 0x00, 0x03, 0xC6, 0x00, 0x03, 0xC3,
  0x00, 0x03, 0xC3, 0x00, 0x03, 0xC1, 0x80, 0x03, 0xC1, 0x80, 0x03, 0xC0,
  0xC0, 0x03, 0xC0, 0xC0, 0x03, 0xC0, 0x60, 0x03, 0xC0, 0x60, 0x03, 0xC0,
  0x30, 0x03, 0xC0, 0x30, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03, 0xC0,
  0x0C, 0x03, 0xC0, 0x0C, 0x03, 0xC0, 0x06, 0x03, 0xC0, 0x06, 0x03, 0xC0,
  0x03, 0x03, 0xC0, 0x03, 0x03, 0xC0, 0x01, 0x83, 0xC0, 0x01, 0x83, 0xC0,
  0x00, 0xC3, 0xC0, 0x00, 0xC3, 0xC0, 0x00, 0x63, 0xC0, 0x00, 0x63, 0xC0,
  0x00, 0x33, 0xC0, 0x00, 0x33, 0xC0, 0x00, 0x1B, 0xC0, 0x00, 0x1B, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xFE, 0x00, 0x0F, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0xE0, 0x00,
  0x60, 0x38, 0x00, 0x06, 0x06, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x0C, 0x30,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0x19, 0x80, 0x00, 0x03, 0x30, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xD8, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0xCE,
  0x00, 0x00, 0x18, 0xC0, 0x00, 0x07, 0x18, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x38, 0x38, 0x00, 0x06, 0x03, 0x80, 0x01, 0x80, 0x38, 0x00, 0xF0, 0x03,
  0xC0, 0x78, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFC, 0x30, 0x00, 0x0F, 0x18, 0x00, 0x01, 0xCC, 0x00,
  0x00, 0x76, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0x60, 0x00, 0x01, 0xB0, 0x00, 0x01, 0xD8, 0x00, 0x01,
  0xCC, 0x00, 0x03, 0xC7, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x81, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xFE, 0x00, 0x0F, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0xE0, 0x00, 0x60,
  0x38, 0x00, 0x06, 0x06, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x0C, 0x30, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0x19, 0x80, 0x00, 0x03, 0x30, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xD8, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0xCE, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x07, 0x18, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x38,
  0x38, 0x00, 0x06, 0x03, 0x80, 0x01, 0x80, 0x38, 0x00, 0xF0, 0x03, 0xC0,
  0x7C, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x30, 0x00, 0x0F, 0x18, 0x00, 0x01,
  0xCC, 0x00, 0x00, 0x76, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xB0, 0x00, 0x01, 0xD8,
  0x00, 0x01, 0xCC, 0x00, 0x03, 0xC7, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x01,
  0x80, 0x38, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0xC0,
  0x18, 0x00, 0x60, 0x0C, 0x00, 0x18, 0x06, 0x00, 0x0E, 0x03, 0x00, 0x03,
  0x01, 0x80, 0x01, 0xC0, 0xC0, 0x00, 0x70, 0x60, 0x00, 0x18, 0x30, 0x00,
  0x0E, 0x18, 0x00, 0x03, 0x8C, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x73, 0x00,
  0x00, 0x1D, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x7F, 0xFF, 0x80, 0x3E, 0x00, 0xF8, 0x0F, 0x00, 0x03, 0xC3, 0x80,
  0x00, 0x3C, 0x60, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0C, 0xE0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x38,
  0x0F, 0x80, 0x3E, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xE0, 0x00, 0x06, 0x60,
  0x00, 0x0E, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x1F,
  0x00, 0xF0, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x67, 0x00,
  0x00, 0x03, 0x18, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x01, 0x87, 0x00, 0x00,
  0x0C, 0x18, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x06, 0x07, 0x00, 0x00, 0x30,
  0x18, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x18, 0x07, 0x00, 0x00, 0xC0, 0x18,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x60, 0x07, 0x00, 0x03, 0x00, 0x18, 0x00,
  0x18, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60,
  0x00, 0xC0, 0x07, 0x00, 0x06, 0x00, 0x30, 0x00, 0x18, 0x01, 0x80, 0x00,
  0xC0, 0x1C, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x18, 0x06, 0x00, 0x00, 0xC0,
  0x70, 0x00, 0x06, 0x03, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0xC1, 0xC0,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0x38, 0x60, 0x00, 0x00, 0xC7, 0x00, 0x00,
  0x06, 0x30, 0x00, 0x00, 0x39, 0x80, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x34, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x0D, 0x80,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x13, 0x00, 0x00,
  0x01, 0x98, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x66, 0x00, 0x70, 0x03,
  0x30, 0x03, 0x80, 0x19, 0x80, 0x1E, 0x00, 0xC6, 0x01, 0xB0, 0x06, 0x30,
  0x0D, 0x80, 0x31, 0x80, 0x66, 0x01, 0x8C, 0x03, 0x30, 0x0C, 0x60, 0x31,
  0x80, 0x43, 0x01, 0x8C, 0x06, 0x18, 0x0C, 0x30, 0x30, 0xC0, 0x41, 0x81,
  0x86, 0x06, 0x0C, 0x0C, 0x30, 0x30, 0x20, 0x61, 0x81, 0x81, 0x83, 0x06,
  0x18, 0x0C, 0x18, 0x30, 0xC0, 0x60, 0xC1, 0x86, 0x01, 0x86, 0x0C, 0x30,
  0x0C, 0x30, 0x63, 0x00, 0x61, 0x03, 0x18, 0x03, 0x18, 0x18, 0xC0, 0x0C,
  0xC0, 0xCC, 0x00, 0x66, 0x06, 0x60, 0x03, 0x30, 0x33, 0x00, 0x0D, 0x81,
  0x98, 0x00, 0x6C, 0x07, 0x80, 0x03, 0x60, 0x3C, 0x00, 0x1B, 0x01, 0xE0,
  0x00, 0x78, 0x0E, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x00, 0x19, 0xC0, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00,
  0xC0, 0x30, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x18, 0x01, 0xC0, 0x00, 0xC0,
  0x03, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x1C, 0x00, 0xC0, 0x00,
  0x30, 0x07, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x03,
  0x07, 0x00, 0x00, 0x0E, 0x18, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00, 0x37,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x07, 0x30, 0x00,
  0x00, 0x18, 0x60, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x07, 0x03, 0x00, 0x00,
  0x18, 0x0E, 0x00, 0x00, 0xC0, 0x1C, 0x00, 0x07, 0x00, 0x30, 0x00, 0x18,
  0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x07, 0x00, 0x03, 0x00, 0x18, 0x00,
  0x0E, 0x00, 0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00,
  0xE0, 0xC0, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x0E,
  0xC0, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x01,
  0x8E, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00,
  0x60, 0x03, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x1C, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x18,
  0x0E, 0x00, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x00,
  0xC7, 0x00, 0x00, 0x00, 0x73, 0x00, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0xC0, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1B, 0x00,
  0x00, 0x01, 0x98, 0x00, 0x00, 0x31, 0x80, 0x00, 0x06, 0x0C, 0x00, 0x00,
  0x60, 0xE0, 0x00, 0x0C, 0x06, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x18, 0x03,
  0x00, 0x03, 0x80, 0x18, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x0C, 0x00,
  0x60, 0x00, 0x60, 0x0C, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x30, 0x18, 0x00,
  0x03, 0x83, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x0C,
  0xE0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x40, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE0, 0x60, 0x30, 0x38, 0x18,
  0x0C, 0x06, 0x06, 0x03, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x0F,
  0x80, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x18, 0x00, 0x1C, 0x03, 0x00, 0x00,
  0xC0, 0x70, 0x00, 0x0C, 0x02, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x1F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFE, 0x01, 0xF0, 0x00, 0x60, 0x38, 0x00, 0x06, 0x07, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x06,
  0x0E, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x0E, 0x06, 0x00, 0x00, 0xE0, 0x60,
  0x00, 0x16, 0x07, 0x00, 0x01, 0x60, 0x38, 0x00, 0x66, 0x01, 0xE0, 0x1C,
  0x7F, 0x0F, 0xFF, 0x83, 0xF0, 0x1F, 0xE0, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0xFE, 0x00, 0xC3, 0xFF, 0xC0, 0xC7, 0x01, 0xE0, 0xCC, 0x00, 0x70, 0xD0,
  0x00, 0x38, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x0C, 0xC0, 0x00, 0x0E, 0xC0,
  0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0,
  0x00, 0x0E, 0xE0, 0x00, 0x0C, 0xE0, 0x00, 0x1C, 0xD0, 0x00, 0x38, 0xCC,
  0x00, 0x70, 0xC7, 0x01, 0xE0, 0xC3, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x01, 0xFF, 0xE0, 0x07, 0x80, 0xF0, 0x0E, 0x00, 0x38, 0x1C,
  0x00, 0x0C, 0x38, 0x00, 0x06, 0x30, 0x00, 0x06, 0x70, 0x00, 0x04, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70,
  0x00, 0x02, 0x30, 0x00, 0x07, 0x38, 0x00, 0x06, 0x1C, 0x00, 0x0C, 0x0E,
  0x00, 0x1C, 0x07, 0x80, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x7F, 0x03, 0x01, 0xFF, 0xE3, 0x07, 0xC0, 0xF3, 0x0E,
  0x00, 0x1B, 0x1C, 0x00, 0x0F, 0x18, 0x00, 0x07, 0x38, 0x00, 0x03, 0x30,
  0x00, 0x03, 0x70, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60,
  0x00, 0x03, 0x60, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0x60,
  0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x70,
  0x00, 0x03, 0x30, 0x00, 0x03, 0x38, 0x00, 0x03, 0x18, 0x00, 0x07, 0x1C,
  0x00, 0x0F, 0x0E, 0x00, 0x1B, 0x07, 0xC0, 0x73, 0x01, 0xFF, 0xE3, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xF0, 0x01, 0xE0, 0x3E, 0x01,
  0xC0, 0x03, 0x81, 0xC0, 0x00, 0xC1, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x1C,
  0xE0, 0x00, 0x06, 0x60, 0x00, 0x03, 0x30, 0x00, 0x00, 0xD8, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x02, 0x70, 0x00, 0x03, 0x98, 0x00, 0x01, 0x8E,
  0x00, 0x01, 0xC3, 0x80, 0x01, 0xC0, 0xE0, 0x01, 0xC0, 0x3E, 0x03, 0xC0,
  0x07, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF,
  0xFC, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x03, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x07, 0xF9,
  0x80, 0x01, 0xFF, 0xF8, 0x00, 0x78, 0x0F, 0x80, 0x06, 0x00, 0x38, 0x00,
  0xC0, 0x01, 0xC0, 0x1C, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x60, 0x18, 0x00,
  0x06, 0x03, 0x80, 0x00, 0x60, 0x38, 0x00, 0x06, 0x03, 0x80, 0x00, 0x70,
  0x38, 0x00, 0x06, 0x03, 0x80, 0x00, 0x60, 0x18, 0x00, 0x06, 0x01, 0x80,
  0x00, 0x60, 0x1C, 0x00, 0x0C, 0x00, 0xC0, 0x01, 0xC0, 0x06, 0x00, 0x38,
  0x00, 0x38, 0x0F, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x01, 0xC0, 0x00, 0x78, 0x30, 0x00,
  0x00, 0xC6, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x6E, 0x00,
  0x00, 0x0E, 0x60, 0x00, 0x00, 0xC7, 0x80, 0x00, 0x38, 0x3E, 0x00, 0x1F,
  0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x03, 0xF8, 0x0C, 0x3F,
  0xFC, 0x31, 0xC0, 0xF8, 0xC8, 0x00, 0x73, 0x40, 0x00, 0xCE, 0x00, 0x03,
  0xB8, 0x00, 0x06, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x00, 0x1C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x3D, 0x80, 0x00,
  0x38, 0xC0, 0x00, 0x38, 0x60, 0x00, 0x38, 0x30, 0x00, 0x38, 0x18, 0x00,
  0x30, 0x0C, 0x00, 0x30, 0x06, 0x00, 0x70, 0x03, 0x00, 0x70, 0x01, 0x80,
  0x70, 0x00, 0xC0, 0x70, 0x00, 0x60, 0x70, 0x00, 0x30, 0x78, 0x00, 0x18,
  0xEE, 0x00, 0x0C, 0xE3, 0x80, 0x06, 0xE0, 0xC0, 0x03, 0xE0, 0x30, 0x01,
  0xC0, 0x1C, 0x00, 0xC0, 0x07, 0x00, 0x60, 0x01, 0xC0, 0x30, 0x00, 0x60,
  0x18, 0x00, 0x18, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x03, 0x83, 0x00, 0x00,
  0xE1, 0x80, 0x00, 0x38, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x03, 0x30, 0x00,
  0x00, 0xD8, 0x00, 0x00, 0x70, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03,
  0xE0, 0x3F, 0x19, 0xFE, 0x0F, 0xF3, 0x70, 0xE3, 0x07, 0x68, 0x0E, 0xC0,
  0x7E, 0x00, 0xD0, 0x07, 0xC0, 0x1C, 0x00, 0xF0, 0x01, 0x80, 0x1E, 0x00,
  0x30, 0x03, 0xC0, 0x06, 0x00, 0x78, 0x00, 0xC0, 0x0F, 0x00, 0x18, 0x01,
  0xE0, 0x03, 0x00, 0x3C, 0x00, 0x60, 0x07, 0x80, 0x0C, 0x00, 0xF0, 0x01,
  0x80, 0x1E, 0x00, 0x30, 0x03, 0xC0, 0x06, 0x00, 0x78, 0x00, 0xC0, 0x0F,
  0x00, 0x18, 0x01, 0xE0, 0x03, 0x00, 0x3C, 0x00, 0x60, 0x07, 0x80, 0x0C,
  0x00, 0xF0, 0x01, 0x80, 0x1E, 0x00, 0x30, 0x03, 0xC0, 0x06, 0x00, 0x78,
  0x00, 0xC0, 0x0F, 0x00, 0x18, 0x01, 0xE0, 0x03, 0x00, 0x3C, 0x00, 0x60,
  0x07, 0x80, 0x0C, 0x00, 0xF0, 0x01, 0x80, 0x18, 0x00, 0xFE, 0x03, 0x0F,
  0xFF, 0x0C, 0x70, 0x3E, 0x32, 0x00, 0x1C, 0xD0, 0x00, 0x33, 0x80, 0x00,
  0xEE, 0x00, 0x01, 0xB0, 0x00, 0x06, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xC0, 0x00, 0x7F,
  0x80, 0x01, 0xFF, 0xF0, 0x01, 0xE0, 0x3C, 0x01, 0xC0, 0x07, 0x81, 0xC0,
  0x00, 0xC1, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x06, 0x60,
  0x00, 0x03, 0x30, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x06, 0xC0, 0x00,
  0x06, 0x70, 0x00, 0x03, 0x18, 0x00, 0x03, 0x8E, 0x00, 0x01, 0x83, 0x80,
  0x01, 0x80, 0xE0, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x0F, 0xFF, 0x80, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0xC3, 0xFF, 0xC0, 0xC7, 0x01, 0xE0, 0xCC,
  0x00, 0x70, 0xD0, 0x00, 0x38, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x0C, 0xC0,
  0x00, 0x0E, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0,
  0x00, 0x06, 0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x0C, 0xE0, 0x00, 0x1C, 0xD0,
  0x00, 0x38, 0xCC, 0x00, 0x70, 0xC7, 0x01, 0xE0, 0xC3, 0xFF, 0xC0, 0xC0,
  0xFF, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x01, 0xFF, 0xE3, 0x07, 0xC0, 0xF3, 0x0E, 0x00, 0x1B, 0x1C,
  0x00, 0x0F, 0x18, 0x00, 0x07, 0x38, 0x00, 0x03, 0x30, 0x00, 0x03, 0x70,
  0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60,
  0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x70, 0x00, 0x03, 0x30,
  0x00, 0x03, 0x38, 0x00, 0x03, 0x18, 0x00, 0x07, 0x1C, 0x00, 0x0F, 0x0E,
  0x00, 0x1B, 0x07, 0xC0, 0x73, 0x01, 0xFF, 0xE3, 0x00, 0x7F, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0x0F, 0xFF, 0x00, 0x31, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x00, 0x34,
  0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00,
  0xF0, 0x07, 0xC0, 0x70, 0x00, 0x78, 0x38, 0x00, 0x07, 0x0C, 0x00, 0x00,
  0xE3, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x66, 0x00, 0x00, 0x19, 0xE0, 0x00, 0x0C,
  0x1C, 0x00, 0x0F, 0x03, 0xE0, 0x0F, 0x80, 0x3F, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x07, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1B,
  0x00, 0x01, 0xDC, 0x00, 0x1E, 0x70, 0x01, 0xB1, 0xE0, 0x39, 0x87, 0xFF,
  0x8C, 0x0F, 0xF0, 0x00, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0xCE, 0x00, 0x00, 0x63, 0x00, 0x00, 0x31, 0x80, 0x00, 0x30, 0x60,
  0x00, 0x18, 0x30, 0x00, 0x1C, 0x18, 0x00, 0x0C, 0x06, 0x00, 0x06, 0x03,
  0x00, 0x06, 0x01, 0x80, 0x03, 0x00, 0x60, 0x01, 0x80, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0xC0, 0x06, 0x00, 0xC0, 0x03, 0x00, 0x60, 0x00, 0xC0, 0x30,
  0x00, 0x60, 0x30, 0x00, 0x30, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x06, 0x0C,
  0x00, 0x01, 0x86, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x63, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x0D, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0D, 0x00, 0x0F,
  0x00, 0x1B, 0x00, 0x16, 0x00, 0x36, 0x00, 0x6C, 0x00, 0x4C, 0x00, 0xC8,
  0x01, 0x98, 0x01, 0x98, 0x03, 0x30, 0x06, 0x30, 0x06, 0x30, 0x0C, 0x60,
  0x0C, 0x60, 0x18, 0x40, 0x18, 0xC0, 0x30, 0xC0, 0x21, 0x80, 0xC1, 0x80,
  0xC3, 0x01, 0x83, 0x01, 0x82, 0x03, 0x02, 0x03, 0x06, 0x06, 0x06, 0x06,
  0x0C, 0x18, 0x0C, 0x08, 0x18, 0x30, 0x18, 0x30, 0x30, 0x60, 0x10, 0x60,
  0x20, 0x80, 0x30, 0xC0, 0x63, 0x00, 0x61, 0x80, 0xC6, 0x00, 0xC3, 0x01,
  0x8C, 0x00, 0xC4, 0x03, 0x10, 0x01, 0x98, 0x06, 0x60, 0x03, 0x30, 0x04,
  0xC0, 0x06, 0x60, 0x0D, 0x80, 0x06, 0xC0, 0x1A, 0x00, 0x0D, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x38, 0x00, 0xE0,
  0x00, 0x01, 0x9C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x60, 0x60, 0x00, 0x38,
  0x0C, 0x00, 0x0C, 0x03, 0x80, 0x06, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x01,
  0xC0, 0x01, 0x80, 0xE0, 0x00, 0x70, 0x30, 0x00, 0x0E, 0x18, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0x37, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x36, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x06, 0x38,
  0x00, 0x03, 0x07, 0x00, 0x01, 0x80, 0xC0, 0x00, 0xE0, 0x18, 0x00, 0x30,
  0x07, 0x00, 0x18, 0x00, 0xE0, 0x0C, 0x00, 0x18, 0x07, 0x00, 0x03, 0x03,
  0x80, 0x00, 0xE0, 0xC0, 0x00, 0x1C, 0x60, 0x00, 0x03, 0x38, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x03, 0x18,
  0x00, 0x00, 0xC3, 0x80, 0x00, 0x18, 0x30, 0x00, 0x03, 0x06, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x18, 0x0C, 0x00, 0x06, 0x01, 0xC0, 0x00, 0xC0, 0x18,
  0x00, 0x38, 0x03, 0x00, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x00, 0xE0, 0x06, 0x00, 0x0C, 0x01, 0x80, 0x01, 0x80, 0x30, 0x00, 0x18,
  0x06, 0x00, 0x03, 0x01, 0x80, 0x00, 0x30, 0x30, 0x00, 0x06, 0x0C, 0x00,
  0x00, 0xE1, 0x80, 0x00, 0x0C, 0x70, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x03, 0x60, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x78, 0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xF0, 0x03,
  0xFF, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0,
  0x1E, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x18, 0x7F, 0x80, 0x00, 0xC7, 0x0E, 0x00, 0x06, 0x30, 0x38,
  0x00, 0x23, 0x00, 0xE0, 0x03, 0x18, 0x03, 0x80, 0x19, 0x80, 0x0E, 0x01,
  0x8C, 0x00, 0x38, 0x1C, 0x60, 0x00, 0xF1, 0xC2, 0x00, 0x03, 0xFC, 0x30,
  0x00, 0x07, 0xC0,
};

const GFXglyph IBMPlexMono_ExtraLight59pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 35, 0, -1 },
  { 1, 5, 41, 35, 15, -41 },
  { 27, 10, 15, 35, 13, -44 },
  { 46, 33, 41, 35, 1, -41 },
  { 216, 27, 55, 35, 4, -48 },
  { 402, 32, 43, 35, 2, -42 },
  { 574, 30, 43, 35, 2, -42 },
  { 736, 2, 15, 35, 17, -44 },
  { 740, 14, 53, 35, 14, -45 },
  { 833, 14, 53, 35, 8, -45 },
  { 926, 30, 29, 35, 3, -32 },
  { 1035, 28, 28, 35, 4, -32 },
  { 1133, 7, 15, 35, 13, -5 },
  { 1147, 16, 2, 35, 10, -19 },
  { 1151, 5, 5, 35, 15, -5 },
  { 1155, 23, 53, 35, 6, -45 },
  { 1308, 27, 43, 35, 4, -42 },
  { 1454, 28, 41, 35, 5, -41 },
  { 1598, 26, 42, 35, 5, -42 },
  { 1735, 25, 43, 35, 4, -42 },
  { 1870, 30, 41, 35, 3, -41 },
  { 2024, 25, 42, 35, 5, -41 },
  { 2156, 26, 42, 35, 5, -41 },
  { 2293, 27, 41, 35, 4, -41 },
  { 2432, 27, 43, 35, 4, -42 },
  { 2578, 26, 42, 35, 5, -42 },
  { 2715, 5, 31, 35, 15, -31 },
  { 2735, 7, 41, 35, 13, -31 },
  { 2771, 25, 32, 35, 5, -34 },
  { 2871, 28, 12, 35, 4, -24 },
  { 2913, 25, 32, 35, 5, -34 },
  { 3013, 24, 42, 35, 6, -42 },
  { 3139, 25, 48, 35, 5, -42 },
  { 3289, 30, 41, 35, 3, -41 },
  { 3443, 25, 41, 35, 6, -41 },
  { 3572, 26, 43, 35, 5, -42 },
  { 3712, 25, 41, 35, 6, -41 },
  { 3841, 24, 41, 35, 6, -41 },
  { 3964, 25, 41, 35, 6, -41 },
  { 4093, 26, 43, 35, 4, -42 },
  { 4233, 24, 41, 35, 6, -41 },
  { 4356, 25, 41, 35, 5, -41 },
  { 4485, 23, 42, 35, 5, -41 },
  { 4606, 27, 41, 35, 6, -41 },
  { 4745, 23, 41, 35, 8, -41 },
  { 4863, 26, 41, 35, 5, -41 },
  { 4997, 24, 41, 35, 6, -41 },
  { 5120, 27, 43, 35, 4, -42 },
  { 5266, 25, 41, 35, 6, -41 },
  { 5395, 27, 51, 35, 4, -42 },
  { 5568, 25, 41, 35, 6, -41 },
  { 5697, 27, 43, 35, 4, -42 },
  { 5843, 31, 41, 35, 2, -41 },
  { 6002, 24, 42, 35, 6, -41 },
  { 6128, 29, 41, 35, 3, -41 },
  { 6277, 29, 41, 35, 3, -41 },
  { 6426, 30, 41, 35, 3, -41 },
  { 6580, 33, 41, 35, 1, -41 },
  { 6750, 30, 41, 35, 3, -41 },
  { 6904, 15, 53, 35, 15, -45 },
  { 7004, 23, 53, 35, 6, -45 },
  { 7157, 14, 53, 35, 6, -45 },
  { 7250, 28, 23, 35, 4, -41 },
  { 7331, 28, 2, 35, 4, 7 },
  { 7338, 8, 10, 35, 12, -45 },
  { 7348, 28, 32, 35, 4, -31 },
  { 7460, 24, 45, 35, 7, -44 },
  { 7595, 24, 32, 35, 6, -31 },
  { 7691, 24, 45, 35, 4, -44 },
  { 7826, 25, 32, 35, 5, -31 },
  { 7926, 27, 44, 35, 5, -44 },
  { 8075, 28, 47, 35, 5, -34 },
  { 8240, 22, 44, 35, 7, -44 },
  { 8361, 25, 44, 35, 7, -44 },
  { 8499, 20, 56, 35, 6, -44 },
  { 8639, 25, 44, 35, 8, -44 },
  { 8777, 25, 44, 35, 5, -44 },
  { 8915, 27, 31, 35, 4, -31 },
  { 9020, 22, 31, 35, 7, -31 },
  { 9106, 25, 32, 35, 5, -31 },
  { 9206, 24, 43, 35, 7, -31 },
  { 9335, 24, 43, 35, 4, -31 },
  { 9464, 28, 30, 35, 5, -30 },
  { 9569, 26, 32, 35, 5, -31 },
  { 9673, 29, 41, 35, 2, -41 },
  { 9822, 21, 31, 35, 7, -30 },
  { 9904, 25, 30, 35, 5, -30 },
  { 9998, 31, 30, 35, 2, -30 },
  { 10115, 26, 30, 35, 5, -30 },
  { 10213, 27, 42, 35, 4, -30 },
  { 10355, 24, 30, 35, 6, -30 },
  { 10445, 22, 53, 35, 7, -45 },
  { 10591, 2, 53, 35, 17, -45 },
  { 10605, 22, 53, 35, 7, -45 },
  { 10751, 29, 11, 35, 3, -23 },
};

const GFXfont IBMPlexMono_ExtraLight59pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLight59pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLight59pt7bGlyphs,
  0x20, 0x7E, 77
};

#endif // _IBMPLEXMONO_EXTRALIGHT59PT7B_H_
