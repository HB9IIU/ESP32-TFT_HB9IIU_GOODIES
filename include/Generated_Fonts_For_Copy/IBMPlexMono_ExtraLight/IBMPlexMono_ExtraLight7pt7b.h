#ifndef _IBMPLEXMONO_EXTRALIGHT7PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHT7PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLight.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLight7pt7bBitmaps[] PROGMEM = {
  0x00, 0xF8, 0xF0, 0x66, 0xFB, 0xA0, 0x4E, 0xD6, 0x5D, 0x60, 0xDE, 0x0F,
  0xF0, 0xE8, 0x5A, 0xF0, 0xC0, 0xFC, 0xA5, 0xA0, 0x4D, 0x2E, 0x44, 0xF4,
  0xC0, 0xC0, 0x80, 0x6A, 0x49, 0x00, 0xE9, 0xD9, 0xE0, 0x92, 0x4E, 0xC9,
  0x4E, 0xE5, 0x9E, 0x26, 0xAA, 0x70, 0xD3, 0x1C, 0xD3, 0x5C, 0xE9, 0x48,
  0xE9, 0x69, 0xE0, 0xD6, 0xA8, 0x90, 0x98, 0x72, 0x30, 0xFF, 0x89, 0xC0,
  0xCD, 0x48, 0xDA, 0xDD, 0x80, 0x46, 0xAE, 0x90, 0xDB, 0x5C, 0xD6, 0x4E,
  0xD6, 0xDC, 0xF3, 0xCE, 0xF3, 0x48, 0xE9, 0x8B, 0xF0, 0xB7, 0xDA, 0xF2,
  0x4E, 0xD5, 0xC0, 0xBA, 0x6A, 0x92, 0x4E, 0xB7, 0xDA, 0xB6, 0xFA, 0xE9,
  0x99, 0xE0, 0xD7, 0x48, 0xE9, 0x99, 0xA6, 0xD7, 0x6E, 0xE9, 0x61, 0xF0,
  0xF4, 0x44, 0x40, 0xB6, 0xDC, 0x9A, 0xA6, 0x40, 0x99, 0xB5, 0xA0, 0x96,
  0x46, 0x90, 0x9A, 0x64, 0x40, 0xF2, 0x48, 0xF0, 0xEA, 0xB0, 0x92, 0x44,
  0xC0, 0xFC, 0x4A, 0x90, 0xF0, 0x80, 0xCB, 0x70, 0x9A, 0xDC, 0xD6, 0x70,
  0x7F, 0xC0, 0xD7, 0x70, 0xFE, 0x4E, 0xFB, 0x4E, 0xBF, 0xC0, 0x52, 0x4E,
  0x35, 0x70, 0x97, 0x6A, 0x92, 0x4E, 0xFD, 0xDD, 0xFF, 0xD6, 0xE0, 0xD6,
  0xE8, 0xFF, 0x40, 0xBA, 0x70, 0xD5, 0x70, 0x4F, 0x44, 0x70, 0xFF, 0xBB,
  0x40, 0xDB, 0x5A, 0xBA, 0x70, 0xBB, 0x48, 0xCA, 0x70, 0xE7, 0xB0, 0xFC,
  0xAB, 0xA0, 0xD2,
};

const GFXglyph IBMPlexMono_ExtraLight7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 1, 5, 4, 2, -5 },
  { 2, 2, 2, 4, 1, -5 },
  { 3, 4, 5, 4, 0, -5 },
  { 6, 4, 7, 4, 0, -6 },
  { 10, 4, 5, 4, 0, -5 },
  { 13, 4, 5, 4, 0, -5 },
  { 16, 1, 2, 4, 2, -5 },
  { 17, 1, 6, 4, 2, -5 },
  { 18, 2, 6, 4, 1, -5 },
  { 20, 4, 4, 4, 0, -4 },
  { 22, 4, 4, 4, 0, -4 },
  { 24, 1, 2, 4, 1, -1 },
  { 25, 2, 1, 4, 1, -3 },
  { 26, 1, 1, 4, 2, -1 },
  { 27, 3, 6, 4, 1, -5 },
  { 30, 4, 5, 4, 0, -5 },
  { 33, 3, 5, 4, 1, -5 },
  { 35, 3, 5, 4, 1, -5 },
  { 37, 3, 5, 4, 0, -5 },
  { 39, 4, 5, 4, 0, -5 },
  { 42, 3, 5, 4, 1, -5 },
  { 44, 3, 5, 4, 1, -5 },
  { 46, 3, 5, 4, 1, -5 },
  { 48, 4, 5, 4, 0, -5 },
  { 51, 3, 5, 4, 1, -5 },
  { 53, 1, 4, 4, 2, -4 },
  { 54, 1, 5, 4, 1, -4 },
  { 55, 3, 4, 4, 1, -4 },
  { 57, 4, 2, 4, 0, -3 },
  { 58, 3, 4, 4, 1, -4 },
  { 60, 3, 5, 4, 1, -5 },
  { 62, 3, 6, 4, 1, -5 },
  { 65, 4, 5, 4, 0, -5 },
  { 68, 3, 5, 4, 1, -5 },
  { 70, 3, 5, 4, 1, -5 },
  { 72, 3, 5, 4, 1, -5 },
  { 74, 3, 5, 4, 1, -5 },
  { 76, 3, 5, 4, 1, -5 },
  { 78, 4, 5, 4, 0, -5 },
  { 81, 3, 5, 4, 1, -5 },
  { 83, 3, 5, 4, 1, -5 },
  { 85, 2, 5, 4, 1, -5 },
  { 87, 3, 5, 4, 1, -5 },
  { 89, 3, 5, 4, 1, -5 },
  { 91, 3, 5, 4, 1, -5 },
  { 93, 3, 5, 4, 1, -5 },
  { 95, 4, 5, 4, 0, -5 },
  { 98, 3, 5, 4, 1, -5 },
  { 100, 4, 6, 4, 0, -5 },
  { 103, 3, 5, 4, 1, -5 },
  { 105, 4, 5, 4, 0, -5 },
  { 108, 4, 5, 4, 0, -5 },
  { 111, 3, 5, 4, 1, -5 },
  { 113, 4, 5, 4, 0, -5 },
  { 116, 4, 5, 4, 0, -5 },
  { 119, 4, 5, 4, 0, -5 },
  { 122, 4, 5, 4, 0, -5 },
  { 125, 4, 5, 4, 0, -5 },
  { 128, 2, 6, 4, 2, -5 },
  { 130, 3, 6, 4, 1, -5 },
  { 133, 1, 6, 4, 1, -5 },
  { 134, 4, 3, 4, 0, -5 },
  { 136, 4, 1, 4, 0, 0 },
  { 137, 1, 1, 4, 1, -5 },
  { 138, 3, 4, 4, 1, -4 },
  { 140, 3, 5, 4, 1, -5 },
  { 142, 3, 4, 4, 1, -4 },
  { 144, 2, 5, 4, 1, -5 },
  { 146, 3, 4, 4, 1, -4 },
  { 148, 3, 5, 4, 1, -5 },
  { 150, 3, 5, 4, 1, -4 },
  { 152, 2, 5, 4, 1, -5 },
  { 154, 3, 5, 4, 1, -5 },
  { 156, 2, 6, 4, 1, -5 },
  { 158, 3, 5, 4, 1, -5 },
  { 160, 3, 5, 4, 1, -5 },
  { 162, 4, 4, 4, 0, -4 },
  { 164, 2, 4, 4, 1, -4 },
  { 165, 3, 4, 4, 1, -4 },
  { 167, 3, 5, 4, 1, -4 },
  { 169, 2, 5, 4, 1, -4 },
  { 171, 3, 4, 4, 1, -4 },
  { 173, 3, 4, 4, 1, -4 },
  { 175, 4, 5, 4, 0, -5 },
  { 178, 2, 4, 4, 1, -4 },
  { 179, 3, 4, 4, 1, -4 },
  { 181, 4, 4, 4, 0, -4 },
  { 183, 3, 4, 4, 1, -4 },
  { 185, 3, 5, 4, 1, -4 },
  { 187, 3, 4, 4, 1, -4 },
  { 189, 2, 6, 4, 1, -5 },
  { 191, 1, 6, 4, 2, -5 },
  { 192, 2, 6, 4, 1, -5 },
  { 194, 4, 2, 4, 0, -3 },
};

const GFXfont IBMPlexMono_ExtraLight7pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLight7pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLight7pt7bGlyphs,
  0x20, 0x7E, 9
};

#endif // _IBMPLEXMONO_EXTRALIGHT7PT7B_H_
