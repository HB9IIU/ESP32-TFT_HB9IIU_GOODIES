#ifndef _IBMPLEXMONO_EXTRALIGHT6PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHT6PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLight.ttf
// Size: 6pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLight6pt7bBitmaps[] PROGMEM = {
  0x00, 0xE0, 0x80, 0x76, 0xE0, 0x5F, 0x3E, 0x80, 0xFB, 0xF0, 0xF3, 0xF0,
  0x80, 0x6A, 0xB0, 0xFC, 0x5E, 0x80, 0x5D, 0x00, 0xC0, 0xC0, 0x00, 0x5A,
  0xA0, 0xF6, 0xF0, 0xC9, 0x30, 0xE5, 0x70, 0xE5, 0xF0, 0x3E, 0xB0, 0xF8,
  0xF0, 0x5A, 0xF0, 0xE9, 0x20, 0xF7, 0xF0, 0xF6, 0x00, 0x30, 0xE4, 0xE0,
  0x98, 0xDA, 0xFE, 0xC0, 0x55, 0xD0, 0xFF, 0xF2, 0x70, 0xFF, 0xEF, 0xEE,
  0xF2, 0xF0, 0xFF, 0xEB, 0xD7, 0xEB, 0xAB, 0xBF, 0xD0, 0xFF, 0xF6, 0xF0,
  0xFA, 0xF6, 0xD6, 0xFB, 0xF1, 0xF0, 0xE9, 0x20, 0xFF, 0xB7, 0x20, 0xBF,
  0xD0, 0xAB, 0x50, 0xB9, 0x20, 0xEA, 0x70, 0xFC, 0xAA, 0x90, 0xFC, 0xD4,
  0xE0, 0x80, 0xEF, 0x80, 0xBF, 0xEC, 0x3E, 0xF0, 0xEC, 0x7D, 0x30, 0xFB,
  0xBF, 0x2B, 0x75, 0xC0, 0xBB, 0xAB, 0xFF, 0x80, 0xFC, 0xF7, 0x80, 0xFE,
  0xF6, 0xB0, 0xEB, 0x80, 0xDC, 0x5D, 0x30, 0xFC, 0xE8, 0xFE, 0x80, 0xAA,
  0x80, 0xB9, 0x20, 0xEC, 0x6A, 0xB0, 0xFC, 0xAB, 0xA0, 0xE0,
};

const GFXglyph IBMPlexMono_ExtraLight6pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 1, 4, 4, 1, -4 },
  { 2, 1, 1, 4, 1, -4 },
  { 3, 3, 4, 4, 0, -4 },
  { 5, 3, 6, 4, 0, -5 },
  { 8, 3, 4, 4, 0, -4 },
  { 10, 3, 4, 4, 0, -4 },
  { 12, 1, 1, 4, 1, -4 },
  { 13, 2, 6, 4, 1, -5 },
  { 15, 1, 6, 4, 1, -5 },
  { 16, 3, 3, 4, 0, -3 },
  { 18, 3, 3, 4, 0, -3 },
  { 20, 1, 2, 4, 1, -1 },
  { 21, 2, 1, 4, 1, -2 },
  { 22, 1, 1, 4, 1, -1 },
  { 23, 2, 6, 4, 1, -5 },
  { 25, 3, 4, 4, 0, -4 },
  { 27, 3, 4, 4, 0, -4 },
  { 29, 3, 4, 4, 0, -4 },
  { 31, 3, 4, 4, 0, -4 },
  { 33, 3, 4, 4, 0, -4 },
  { 35, 3, 4, 4, 0, -4 },
  { 37, 3, 4, 4, 0, -4 },
  { 39, 3, 4, 4, 0, -4 },
  { 41, 3, 4, 4, 0, -4 },
  { 43, 2, 4, 4, 1, -4 },
  { 44, 1, 3, 4, 1, -3 },
  { 45, 1, 4, 4, 1, -3 },
  { 46, 2, 3, 4, 1, -3 },
  { 47, 3, 1, 4, 0, -2 },
  { 48, 2, 3, 4, 1, -3 },
  { 49, 2, 4, 4, 1, -4 },
  { 50, 2, 5, 4, 1, -4 },
  { 52, 3, 4, 4, 0, -4 },
  { 54, 2, 4, 4, 1, -4 },
  { 55, 3, 4, 4, 0, -4 },
  { 57, 2, 4, 4, 1, -4 },
  { 58, 2, 4, 4, 1, -4 },
  { 59, 2, 4, 4, 1, -4 },
  { 60, 3, 4, 4, 0, -4 },
  { 62, 2, 4, 4, 1, -4 },
  { 63, 2, 4, 4, 1, -4 },
  { 64, 2, 4, 4, 1, -4 },
  { 65, 2, 4, 4, 1, -4 },
  { 66, 2, 4, 4, 1, -4 },
  { 67, 3, 4, 4, 0, -4 },
  { 69, 2, 4, 4, 1, -4 },
  { 70, 3, 4, 4, 0, -4 },
  { 72, 2, 4, 4, 1, -4 },
  { 73, 3, 5, 4, 0, -4 },
  { 75, 2, 4, 4, 1, -4 },
  { 76, 3, 4, 4, 0, -4 },
  { 78, 3, 4, 4, 0, -4 },
  { 80, 2, 4, 4, 1, -4 },
  { 81, 3, 4, 4, 0, -4 },
  { 83, 3, 4, 4, 0, -4 },
  { 85, 3, 4, 4, 0, -4 },
  { 87, 3, 4, 4, 0, -4 },
  { 89, 3, 4, 4, 0, -4 },
  { 91, 1, 6, 4, 2, -5 },
  { 92, 2, 6, 4, 1, -5 },
  { 94, 1, 6, 4, 1, -5 },
  { 95, 3, 2, 4, 0, -4 },
  { 96, 3, 1, 4, 0, 0 },
  { 97, 1, 1, 4, 1, -5 },
  { 98, 3, 3, 4, 0, -3 },
  { 100, 2, 4, 4, 1, -4 },
  { 101, 2, 3, 4, 1, -3 },
  { 102, 3, 4, 4, 0, -4 },
  { 104, 2, 3, 4, 1, -3 },
  { 105, 3, 4, 4, 0, -4 },
  { 107, 2, 4, 4, 1, -3 },
  { 108, 2, 4, 4, 1, -4 },
  { 109, 2, 4, 4, 1, -4 },
  { 110, 2, 5, 4, 1, -4 },
  { 112, 2, 4, 4, 1, -4 },
  { 113, 2, 4, 4, 1, -4 },
  { 114, 3, 3, 4, 0, -3 },
  { 116, 2, 3, 4, 1, -3 },
  { 117, 3, 3, 4, 0, -3 },
  { 119, 2, 4, 4, 1, -3 },
  { 120, 3, 4, 4, 0, -3 },
  { 122, 3, 3, 4, 0, -3 },
  { 124, 2, 3, 4, 1, -3 },
  { 125, 3, 4, 4, 0, -4 },
  { 127, 2, 3, 4, 1, -3 },
  { 128, 2, 3, 4, 1, -3 },
  { 129, 3, 3, 4, 0, -3 },
  { 131, 3, 3, 4, 0, -3 },
  { 133, 3, 4, 4, 0, -3 },
  { 135, 2, 3, 4, 1, -3 },
  { 136, 2, 6, 4, 1, -5 },
  { 138, 1, 6, 4, 1, -5 },
  { 139, 2, 6, 4, 1, -5 },
  { 141, 3, 1, 4, 0, -2 },
};

const GFXfont IBMPlexMono_ExtraLight6pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLight6pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLight6pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _IBMPLEXMONO_EXTRALIGHT6PT7B_H_
