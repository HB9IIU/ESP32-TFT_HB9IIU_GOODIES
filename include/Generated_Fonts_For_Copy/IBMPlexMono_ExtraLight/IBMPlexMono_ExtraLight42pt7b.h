#ifndef _IBMPLEXMONO_EXTRALIGHT42PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHT42PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLight.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLight42pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x00, 0x03, 0xFE,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x08, 0x00, 0x20,
  0x60, 0x00, 0xC0, 0x80, 0x01, 0x81, 0x00, 0x03, 0x02, 0x00, 0x04, 0x0C,
  0x00, 0x08, 0x18, 0x00, 0x10, 0x30, 0x00, 0x60, 0x40, 0x00, 0xC0, 0x80,
  0x01, 0x81, 0x01, 0xFE, 0x07, 0xF8, 0x04, 0x0C, 0x00, 0x08, 0x10, 0x00,
  0x30, 0x20, 0x00, 0x60, 0x40, 0x00, 0x81, 0x80, 0x01, 0x03, 0x00, 0x02,
  0x06, 0x03, 0xFC, 0x0F, 0xF0, 0x18, 0x10, 0x00, 0x30, 0x20, 0x00, 0x40,
  0xC0, 0x00, 0x81, 0x80, 0x01, 0x02, 0x00, 0x06, 0x04, 0x00, 0x0C, 0x08,
  0x00, 0x10, 0x30, 0x00, 0x20, 0x60, 0x00, 0x40, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x3F, 0xC0, 0x38, 0xCE,
  0x0C, 0x18, 0x33, 0x03, 0x03, 0x40, 0x60, 0x58, 0x0C, 0x03, 0x01, 0x80,
  0x60, 0x30, 0x0C, 0x06, 0x00, 0x80, 0xC0, 0x18, 0x18, 0x01, 0x83, 0x00,
  0x18, 0x60, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x31, 0x80, 0x06, 0x0C,
  0x00, 0xC0, 0x80, 0x18, 0x18, 0x03, 0x01, 0x00, 0x60, 0x20, 0x0C, 0x04,
  0x01, 0x80, 0x80, 0x30, 0x1C, 0x06, 0x07, 0xC0, 0xC0, 0x9C, 0x18, 0x20,
  0xE3, 0x18, 0x07, 0xFC, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x0F, 0x80, 0x06, 0x61, 0x80, 0x09, 0x80, 0x80, 0x32, 0x01,
  0x80, 0x44, 0x01, 0x01, 0x98, 0x02, 0x02, 0x30, 0x04, 0x08, 0x60, 0x08,
  0x30, 0xC0, 0x10, 0x40, 0x80, 0x21, 0x81, 0x00, 0xC2, 0x03, 0x01, 0x08,
  0x03, 0x0C, 0x30, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x01, 0x86, 0x18, 0x02, 0x18, 0x18, 0x0C, 0x20, 0x10, 0x10, 0xC0, 0x30,
  0x41, 0x00, 0x61, 0x82, 0x00, 0x42, 0x04, 0x00, 0x8C, 0x08, 0x03, 0x10,
  0x18, 0x06, 0x60, 0x10, 0x08, 0x80, 0x30, 0x32, 0x00, 0x30, 0xCC, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x30, 0x60, 0x02, 0x01, 0x80, 0x30, 0x06,
  0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x07, 0x00, 0x00, 0x64, 0x03, 0xE6, 0x10, 0x18, 0x60, 0xC0, 0xC6, 0x03,
  0x04, 0x30, 0x0C, 0x21, 0x00, 0x31, 0x08, 0x00, 0xC8, 0x40, 0x03, 0x42,
  0x00, 0x0E, 0x10, 0x00, 0x60, 0xC0, 0x02, 0x82, 0x00, 0x36, 0x18, 0x03,
  0x18, 0x70, 0x30, 0x60, 0xFE, 0x01, 0x80, 0xFF, 0xE0, 0x00, 0xC0, 0xC0,
  0x20, 0x10, 0x08, 0x06, 0x01, 0x00, 0xC0, 0x20, 0x18, 0x04, 0x01, 0x00,
  0xC0, 0x30, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0xC0, 0x30, 0x04, 0x01, 0x00, 0x60, 0x08, 0x03, 0x00,
  0x40, 0x18, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00, 0x30, 0xE0, 0x06, 0x00,
  0x60, 0x04, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x08, 0x01, 0x00, 0x30, 0x02,
  0x00, 0x40, 0x0C, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x18, 0x02, 0x00, 0x40,
  0x18, 0x02, 0x00, 0x40, 0x10, 0x06, 0x00, 0x80, 0x20, 0x0C, 0x03, 0x01,
  0xC0, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x10, 0x04, 0x01, 0xF8,
  0x20, 0x78, 0xF9, 0x1E, 0x00, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0x05, 0x00,
  0x00, 0x64, 0x00, 0x06, 0x30, 0x00, 0x20, 0xC0, 0x03, 0x02, 0x00, 0x30,
  0x18, 0x03, 0x00, 0x60, 0x10, 0x01, 0x81, 0x80, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0xFF,
  0xFF, 0xF0, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x19, 0xCC, 0x63, 0x11, 0x8C, 0x42, 0x30, 0xFF, 0xE0,
  0xFF, 0x80, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00,
  0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00,
  0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08,
  0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01,
  0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x00, 0x03,
  0xF8, 0x01, 0xC1, 0xC0, 0x60, 0x0C, 0x18, 0x00, 0xC2, 0x00, 0x0C, 0xC0,
  0x01, 0x90, 0x00, 0x12, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x81, 0xC0, 0x70, 0x38, 0x0E, 0x07,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00,
  0x06, 0x80, 0x00, 0xD0, 0x00, 0x13, 0x00, 0x06, 0x20, 0x00, 0xC6, 0x00,
  0x30, 0x60, 0x0C, 0x07, 0x03, 0x00, 0x3F, 0x80, 0x00, 0xF0, 0x00, 0x1B,
  0x00, 0x03, 0x30, 0x00, 0x63, 0x00, 0x0C, 0x30, 0x01, 0x83, 0x00, 0x60,
  0x30, 0x0C, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xF8, 0x03,
  0x81, 0xC0, 0xC0, 0x0C, 0x18, 0x00, 0xC6, 0x00, 0x18, 0x80, 0x01, 0x30,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x70, 0x00, 0x0F, 0xFF, 0xFE, 0x07, 0xF8, 0x07, 0x03, 0x83, 0x00,
  0x31, 0x80, 0x04, 0x40, 0x01, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x01,
  0xFC, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02,
  0x80, 0x01, 0xB0, 0x00, 0x66, 0x00, 0x30, 0xE0, 0x38, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x40, 0x00, 0x1A, 0x00, 0x01,
  0x90, 0x00, 0x08, 0x80, 0x00, 0xC4, 0x00, 0x0C, 0x20, 0x00, 0x41, 0x00,
  0x06, 0x08, 0x00, 0x60, 0x40, 0x02, 0x02, 0x00, 0x30, 0x10, 0x03, 0x00,
  0x80, 0x10, 0x04, 0x01, 0x80, 0x20, 0x18, 0x01, 0x00, 0x80, 0x08, 0x0C,
  0x00, 0x40, 0xC0, 0x02, 0x04, 0x00, 0x10, 0x60, 0x00, 0x83, 0xFF, 0xFF,
  0xE0, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x10, 0x00, 0x1F, 0xFF, 0x82, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x1F, 0x80,
  0x4C, 0x0C, 0x0E, 0x00, 0x41, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x06, 0x40, 0x00, 0xDC, 0x00, 0x30, 0xC0, 0x0C, 0x0E, 0x03, 0x00,
  0x7F, 0x80, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02,
  0x00, 0x00, 0xC0, 0x00, 0x10, 0xFC, 0x06, 0xE0, 0x60, 0xB0, 0x06, 0x14,
  0x00, 0x63, 0x00, 0x06, 0x60, 0x00, 0x58, 0x00, 0x0B, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x06, 0x80, 0x00, 0xD0, 0x00, 0x13, 0x00, 0x02, 0x20,
  0x00, 0xC6, 0x00, 0x30, 0x60, 0x0C, 0x07, 0x07, 0x00, 0x3F, 0x80, 0xFF,
  0xFF, 0xF8, 0x00, 0x0F, 0x00, 0x03, 0x60, 0x00, 0x6C, 0x00, 0x09, 0x80,
  0x03, 0x30, 0x00, 0x46, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60,
  0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x03, 0xF8, 0x01, 0x80,
  0xE0, 0xC0, 0x06, 0x10, 0x00, 0x46, 0x00, 0x0C, 0xC0, 0x00, 0x90, 0x00,
  0x12, 0x00, 0x02, 0x60, 0x00, 0x4C, 0x00, 0x18, 0x80, 0x02, 0x08, 0x00,
  0xC0, 0xC0, 0x60, 0x07, 0xF0, 0x03, 0x01, 0xC1, 0x80, 0x0C, 0x60, 0x00,
  0xC8, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x03, 0x40, 0x00, 0x6C, 0x00, 0x18, 0xC0, 0x06,
  0x0E, 0x03, 0x80, 0x3F, 0x80, 0x07, 0xF0, 0x07, 0x03, 0x03, 0x00, 0x61,
  0x80, 0x04, 0x40, 0x01, 0xB0, 0x00, 0x28, 0x00, 0x0A, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x76, 0x00, 0x18, 0xC0, 0x0A, 0x1C, 0x0C, 0x81, 0xFC, 0x60, 0x00, 0x10,
  0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x39, 0xCE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x73, 0x18, 0xC4, 0x63,
  0x10, 0x8C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00, 0x70, 0x00, 0x30,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0C,
  0x00, 0x0E, 0x00, 0x02, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x04, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x60, 0x00,
  0x70, 0x00, 0x30, 0x00, 0x08, 0x00, 0x00, 0x07, 0xF0, 0x0E, 0x06, 0x0C,
  0x00, 0x8C, 0x00, 0x64, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x60, 0x00,
  0xE0, 0x07, 0xC0, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x03, 0xF0, 0x06,
  0x0E, 0x04, 0x01, 0x84, 0x00, 0x46, 0x00, 0x12, 0x00, 0x09, 0x00, 0x07,
  0x80, 0x01, 0xC0, 0x78, 0xC0, 0xC3, 0x60, 0xC0, 0xB0, 0x40, 0x38, 0x20,
  0x0C, 0x30, 0x06, 0x18, 0x03, 0x0C, 0x01, 0x86, 0x00, 0xC3, 0x00, 0x61,
  0x80, 0x30, 0xC0, 0x18, 0x20, 0x0C, 0x10, 0x0E, 0x0C, 0x07, 0x03, 0x05,
  0x80, 0xFC, 0xE0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x14, 0x00, 0x01, 0xB0, 0x00, 0x0C, 0x80, 0x00,
  0x44, 0x00, 0x06, 0x30, 0x00, 0x30, 0x80, 0x01, 0x04, 0x00, 0x18, 0x30,
  0x00, 0xC0, 0x80, 0x04, 0x04, 0x00, 0x60, 0x30, 0x03, 0x00, 0x80, 0x10,
  0x04, 0x01, 0x80, 0x30, 0x0C, 0x00, 0x80, 0x40, 0x04, 0x07, 0xFF, 0xF0,
  0x30, 0x00, 0x81, 0x00, 0x04, 0x18, 0x00, 0x30, 0xC0, 0x00, 0x84, 0x00,
  0x04, 0x60, 0x00, 0x33, 0x00, 0x00, 0x90, 0x00, 0x05, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0x80, 0xFF, 0xF8, 0x30, 0x03, 0x0C, 0x00, 0x63, 0x00, 0x0C,
  0xC0, 0x01, 0x30, 0x00, 0x4C, 0x00, 0x1B, 0x00, 0x06, 0xC0, 0x01, 0xB0,
  0x00, 0x6C, 0x00, 0x13, 0x00, 0x0C, 0xC0, 0x06, 0x30, 0x03, 0x0F, 0xFF,
  0x83, 0x00, 0x18, 0xC0, 0x01, 0x30, 0x00, 0x6C, 0x00, 0x0B, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xB0,
  0x00, 0x6C, 0x00, 0x13, 0x00, 0x18, 0xFF, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0xE0, 0xE0, 0x30, 0x06, 0x0C, 0x00, 0x63, 0x00, 0x04, 0x40, 0x00, 0xD8,
  0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x01, 0x00, 0x03, 0x30, 0x00, 0x43, 0x00, 0x18, 0x30,
  0x06, 0x03, 0x83, 0x80, 0x1F, 0xC0, 0xFF, 0xF0, 0x30, 0x07, 0x0C, 0x00,
  0x63, 0x00, 0x0C, 0xC0, 0x01, 0x30, 0x00, 0x6C, 0x00, 0x0B, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0B, 0x00, 0x06,
  0xC0, 0x01, 0x30, 0x00, 0xCC, 0x00, 0x63, 0x00, 0x70, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0F, 0xFF, 0xFB, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0F, 0xFF, 0xFB, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0xC0, 0xC0, 0x60, 0x04, 0x08, 0x00, 0x42, 0x00, 0x0C,
  0xC0, 0x00, 0x98, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x3F, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x06, 0x80, 0x00, 0xD8, 0x00, 0x1B, 0x00, 0x03, 0x20, 0x00, 0xE6,
  0x00, 0x1C, 0x60, 0x05, 0x87, 0x03, 0x30, 0x3F, 0x86, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0xFF,
  0xFF, 0x80, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x0F, 0xFF,
  0xF8, 0x3F, 0xFF, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x80,
  0x02, 0xC0, 0x06, 0xC0, 0x04, 0x60, 0x0C, 0x38, 0x38, 0x0F, 0xE0, 0xC0,
  0x00, 0x78, 0x00, 0x1B, 0x00, 0x06, 0x60, 0x01, 0x8C, 0x00, 0x61, 0x80,
  0x18, 0x30, 0x06, 0x06, 0x00, 0x80, 0xC0, 0x30, 0x18, 0x0C, 0x03, 0x03,
  0x00, 0x60, 0xC0, 0x0C, 0x30, 0x01, 0x8F, 0x00, 0x33, 0x30, 0x06, 0xC2,
  0x00, 0xD0, 0x60, 0x1C, 0x06, 0x03, 0x80, 0x40, 0x60, 0x0C, 0x0C, 0x00,
  0xC1, 0x80, 0x08, 0x30, 0x01, 0x86, 0x00, 0x18, 0xC0, 0x01, 0x18, 0x00,
  0x33, 0x00, 0x03, 0x60, 0x00, 0x6C, 0x00, 0x06, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0,
  0x03, 0xE8, 0x00, 0xFD, 0x80, 0x17, 0xB0, 0x06, 0xF2, 0x00, 0x9E, 0x60,
  0x33, 0xC4, 0x04, 0x78, 0xC1, 0x8F, 0x08, 0x21, 0xE1, 0x84, 0x3C, 0x11,
  0x87, 0x83, 0x20, 0xF0, 0x2C, 0x1E, 0x05, 0x03, 0xC0, 0xE0, 0x78, 0x08,
  0x0F, 0x01, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x06, 0xC0, 0x00, 0xF0, 0x00, 0x68, 0x00, 0x36, 0x00, 0x19,
  0x00, 0x0C, 0xC0, 0x06, 0x20, 0x03, 0x18, 0x01, 0x84, 0x00, 0xC3, 0x00,
  0x60, 0x80, 0x30, 0x60, 0x18, 0x10, 0x0C, 0x0C, 0x06, 0x02, 0x03, 0x01,
  0x81, 0x80, 0x40, 0xC0, 0x30, 0x60, 0x08, 0x30, 0x06, 0x18, 0x01, 0x0C,
  0x00, 0xC6, 0x00, 0x23, 0x00, 0x19, 0x80, 0x04, 0xC0, 0x03, 0x60, 0x00,
  0xB0, 0x00, 0x78, 0x00, 0x18, 0x03, 0xF8, 0x01, 0xC1, 0xC0, 0x60, 0x0C,
  0x18, 0x00, 0xC2, 0x00, 0x0C, 0xC0, 0x01, 0x90, 0x00, 0x12, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x06, 0x80, 0x00, 0xD0, 0x00, 0x13,
  0x00, 0x06, 0x20, 0x00, 0xC6, 0x00, 0x30, 0x60, 0x0C, 0x07, 0x03, 0x00,
  0x3F, 0x80, 0xFF, 0xFC, 0x30, 0x01, 0xCC, 0x00, 0x1B, 0x00, 0x02, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xB0, 0x00, 0x6C, 0x00, 0x73,
  0xFF, 0xF0, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x01, 0xC1,
  0xC0, 0x60, 0x0C, 0x18, 0x00, 0xC2, 0x00, 0x0C, 0xC0, 0x01, 0x90, 0x00,
  0x12, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x06, 0x80, 0x00,
  0xD0, 0x00, 0x13, 0x00, 0x06, 0x20, 0x00, 0x86, 0x00, 0x30, 0x60, 0x0C,
  0x07, 0x03, 0x00, 0x3F, 0x80, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x0F, 0xF0, 0xFF, 0xFC, 0x30, 0x01, 0xCC, 0x00, 0x1B,
  0x00, 0x02, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xB0, 0x00,
  0x6C, 0x00, 0x73, 0xFF, 0xF0, 0xC0, 0xC0, 0x30, 0x18, 0x0C, 0x02, 0x03,
  0x00, 0xC0, 0xC0, 0x18, 0x30, 0x02, 0x0C, 0x00, 0xC3, 0x00, 0x18, 0xC0,
  0x02, 0x30, 0x00, 0xCC, 0x00, 0x1B, 0x00, 0x06, 0xC0, 0x00, 0xC0, 0x03,
  0xFC, 0x03, 0x80, 0xE0, 0xC0, 0x07, 0x30, 0x00, 0x34, 0x00, 0x05, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00,
  0x19, 0xC0, 0x06, 0x0E, 0x03, 0x80, 0x7F, 0xC0, 0xFF, 0xFF, 0xFC, 0x00,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x20, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x06, 0x80, 0x03, 0x40, 0x01, 0x30, 0x01, 0x8C,
  0x00, 0x83, 0x01, 0x80, 0x7F, 0x80, 0xC0, 0x00, 0x1A, 0x00, 0x00, 0xD8,
  0x00, 0x04, 0xC0, 0x00, 0x62, 0x00, 0x03, 0x18, 0x00, 0x10, 0xC0, 0x01,
  0x82, 0x00, 0x0C, 0x18, 0x00, 0x40, 0xC0, 0x06, 0x02, 0x00, 0x30, 0x10,
  0x01, 0x00, 0xC0, 0x18, 0x02, 0x00, 0xC0, 0x10, 0x04, 0x00, 0xC0, 0x60,
  0x06, 0x03, 0x00, 0x10, 0x10, 0x00, 0xC0, 0x80, 0x06, 0x0C, 0x00, 0x10,
  0x40, 0x00, 0xC2, 0x00, 0x06, 0x30, 0x00, 0x11, 0x00, 0x00, 0xC8, 0x00,
  0x06, 0xC0, 0x00, 0x14, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x06, 0x80, 0x00, 0x34, 0x00, 0x01,
  0xA0, 0x00, 0x09, 0x00, 0x00, 0x48, 0x00, 0x02, 0x40, 0x00, 0x12, 0x01,
  0x80, 0x98, 0x1C, 0x04, 0xC0, 0xA0, 0x26, 0x05, 0x83, 0x30, 0x6C, 0x18,
  0x83, 0x20, 0xC4, 0x11, 0x06, 0x20, 0x8C, 0x21, 0x0C, 0x21, 0x08, 0x41,
  0x08, 0x42, 0x0C, 0x43, 0x30, 0x62, 0x19, 0x81, 0x10, 0xC8, 0x08, 0x86,
  0x40, 0x6C, 0x36, 0x01, 0x60, 0xA0, 0x0B, 0x05, 0x00, 0x78, 0x38, 0x03,
  0x81, 0x80, 0x0C, 0x00, 0xC0, 0x00, 0x1B, 0x00, 0x01, 0x8C, 0x00, 0x08,
  0x20, 0x00, 0xC1, 0x80, 0x0C, 0x06, 0x00, 0x40, 0x10, 0x06, 0x00, 0xC0,
  0x60, 0x03, 0x02, 0x00, 0x08, 0x30, 0x00, 0x63, 0x00, 0x01, 0x90, 0x00,
  0x05, 0x80, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xD8,
  0x00, 0x04, 0x60, 0x00, 0x61, 0x00, 0x06, 0x0C, 0x00, 0x20, 0x30, 0x03,
  0x00, 0x80, 0x30, 0x06, 0x01, 0x00, 0x18, 0x18, 0x00, 0x41, 0x80, 0x03,
  0x18, 0x00, 0x0C, 0xC0, 0x00, 0x2C, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x06,
  0xC0, 0x00, 0x18, 0x80, 0x00, 0x31, 0x80, 0x00, 0xC1, 0x80, 0x03, 0x01,
  0x00, 0x06, 0x03, 0x00, 0x18, 0x03, 0x00, 0x20, 0x02, 0x00, 0xC0, 0x06,
  0x03, 0x00, 0x06, 0x04, 0x00, 0x04, 0x18, 0x00, 0x0C, 0x60, 0x00, 0x0C,
  0x80, 0x00, 0x1B, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0xFF, 0xE0, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x3F, 0xF0, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x04, 0x00, 0x03,
  0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x08, 0x00, 0x06, 0x00,
  0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x10, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x08, 0x00, 0x06,
  0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x10, 0x00, 0x0C, 0xFF,
  0xC0, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x7F, 0xF0, 0x00,
  0xE0, 0x00, 0x0A, 0x00, 0x01, 0xB0, 0x00, 0x11, 0x00, 0x03, 0x18, 0x00,
  0x20, 0xC0, 0x06, 0x04, 0x00, 0xC0, 0x60, 0x08, 0x02, 0x01, 0x80, 0x30,
  0x10, 0x01, 0x83, 0x00, 0x08, 0x60, 0x00, 0xC4, 0x00, 0x04, 0xC0, 0x00,
  0x68, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0xC1, 0x82, 0x04, 0x18, 0x20, 0x40,
  0x07, 0xF0, 0x01, 0x81, 0xC0, 0x30, 0x06, 0x06, 0x00, 0x20, 0x40, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00,
  0x10, 0x0F, 0xFF, 0x03, 0x80, 0x10, 0x60, 0x01, 0x04, 0x00, 0x10, 0xC0,
  0x01, 0x0C, 0x00, 0x10, 0xC0, 0x03, 0x0C, 0x00, 0x30, 0x40, 0x05, 0x06,
  0x00, 0x50, 0x38, 0x11, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x43, 0xF0, 0x26, 0x06, 0x14, 0x00, 0x8C, 0x00, 0x26, 0x00,
  0x1A, 0x00, 0x05, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xB0, 0x00, 0xD8, 0x00, 0x4A, 0x00, 0x44, 0xC0, 0xC2, 0x1F,
  0xC0, 0x03, 0xF8, 0x07, 0x07, 0x06, 0x00, 0xC6, 0x00, 0x22, 0x00, 0x1B,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x60,
  0x00, 0x10, 0x00, 0x4C, 0x00, 0x63, 0x00, 0x60, 0xE0, 0xE0, 0x1F, 0xC0,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x81, 0xF8, 0x43, 0x03, 0x23,
  0x00, 0x53, 0x00, 0x1B, 0x00, 0x0D, 0x00, 0x02, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0x40, 0x00, 0xA0, 0x00, 0x58, 0x00, 0x66, 0x00, 0x31,
  0x80, 0x28, 0x60, 0x64, 0x0F, 0xC2, 0x07, 0xF0, 0x03, 0x03, 0x03, 0x00,
  0x61, 0x80, 0x0C, 0x40, 0x01, 0x30, 0x00, 0x6C, 0x00, 0x0A, 0x00, 0x02,
  0x80, 0x00, 0xE0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x90, 0x00, 0x62, 0x00,
  0x10, 0xC0, 0x08, 0x0C, 0x0C, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x0F, 0xFF, 0xFF, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x07, 0xE0, 0x7E, 0x80, 0x30, 0x30, 0x08, 0x03, 0x03,
  0x00, 0x20, 0x40, 0x06, 0x18, 0x00, 0x43, 0x00, 0x08, 0x60, 0x01, 0x0C,
  0x00, 0x20, 0x80, 0x0C, 0x18, 0x01, 0x01, 0x00, 0x60, 0x18, 0x18, 0x01,
  0xFC, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0xFF, 0xF0, 0x60, 0x03, 0x10, 0x00, 0x16, 0x00, 0x03, 0x80,
  0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x24, 0x00, 0x0C, 0x60,
  0x06, 0x03, 0xFF, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC7, 0xE0,
  0xD8, 0x18, 0xE0, 0x0C, 0xC0, 0x06, 0xC0, 0x02, 0xC0, 0x02, 0xC0, 0x02,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x00, 0xC0, 0x00, 0x78, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x03, 0xFF, 0xFF, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x3F, 0xFC, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x3B, 0x00, 0x0C, 0x60,
  0x03, 0x0C, 0x00, 0xC1, 0x80, 0x30, 0x30, 0x18, 0x06, 0x06, 0x00, 0xC1,
  0x80, 0x18, 0x60, 0x03, 0x1E, 0x00, 0x66, 0x60, 0x0D, 0x8C, 0x01, 0xE0,
  0xC0, 0x30, 0x0C, 0x06, 0x00, 0xC0, 0xC0, 0x0C, 0x18, 0x01, 0x83, 0x00,
  0x18, 0x60, 0x01, 0x8C, 0x00, 0x19, 0x80, 0x01, 0xB0, 0x00, 0x38, 0xFF,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x0F, 0xFF, 0xFC, 0x9F, 0x07, 0x96,
  0x33, 0x1B, 0x03, 0x81, 0xE0, 0x30, 0x18, 0x04, 0x03, 0x00, 0x80, 0x60,
  0x10, 0x0C, 0x02, 0x01, 0x80, 0x40, 0x30, 0x08, 0x06, 0x01, 0x00, 0xC0,
  0x20, 0x18, 0x04, 0x03, 0x00, 0x80, 0x60, 0x10, 0x0C, 0x02, 0x01, 0x80,
  0x40, 0x30, 0x08, 0x06, 0x01, 0x00, 0xC0, 0x20, 0x18, 0x04, 0x03, 0x00,
  0x80, 0x40, 0xC7, 0xE0, 0xD8, 0x18, 0xE0, 0x0C, 0xC0, 0x06, 0xC0, 0x02,
  0xC0, 0x02, 0xC0, 0x02, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x07, 0xF0,
  0x07, 0x07, 0x03, 0x00, 0x61, 0x80, 0x0C, 0x40, 0x01, 0x30, 0x00, 0x6C,
  0x00, 0x0A, 0x00, 0x02, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0B, 0x00, 0x02, 0xC0, 0x01,
  0x90, 0x00, 0x46, 0x00, 0x30, 0xC0, 0x18, 0x1C, 0x1C, 0x01, 0xFC, 0x00,
  0x87, 0xE0, 0x4C, 0x0C, 0x28, 0x01, 0x18, 0x00, 0x4C, 0x00, 0x34, 0x00,
  0x0A, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0x60, 0x01, 0xB0, 0x00, 0x94, 0x00, 0x89, 0x81, 0x84, 0x3F, 0x82, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x00, 0x03, 0xF0, 0x86, 0x06, 0x46, 0x00, 0xA6, 0x00,
  0x36, 0x00, 0x1A, 0x00, 0x05, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x02,
  0x80, 0x01, 0x40, 0x00, 0xB0, 0x00, 0xCC, 0x00, 0x63, 0x00, 0x50, 0xC0,
  0xC8, 0x1F, 0x84, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0xFF, 0x87, 0xF0, 0x09,
  0x80, 0x00, 0xA0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x0F, 0xFF, 0xFC, 0x07, 0xF0, 0x06, 0x03, 0x82, 0x00, 0x31, 0x80, 0x06,
  0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0E,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x03, 0x80, 0x00, 0x20, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x09, 0x80, 0x04,
  0x1C, 0x06, 0x01, 0xFE, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x0F, 0xFF,
  0xFF, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0xFF, 0xF0, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x80, 0x0D, 0x00, 0x1B, 0x00, 0x53, 0x03, 0x21, 0xFC, 0x40,
  0x80, 0x00, 0xF0, 0x00, 0x24, 0x00, 0x19, 0x00, 0x04, 0x60, 0x03, 0x08,
  0x00, 0xC2, 0x00, 0x20, 0xC0, 0x18, 0x10, 0x04, 0x06, 0x01, 0x01, 0x80,
  0xC0, 0x20, 0x20, 0x0C, 0x08, 0x01, 0x06, 0x00, 0x41, 0x00, 0x18, 0x40,
  0x02, 0x30, 0x00, 0x88, 0x00, 0x36, 0x00, 0x05, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x80, 0x30, 0x0E, 0x01, 0xC0, 0x28, 0x05, 0x00, 0xA0, 0x14,
  0x02, 0xC0, 0x58, 0x0B, 0x03, 0x20, 0x64, 0x08, 0x81, 0x90, 0x22, 0x04,
  0x40, 0x8C, 0x11, 0x86, 0x10, 0x46, 0x10, 0x41, 0x08, 0x41, 0x0C, 0x21,
  0x06, 0x20, 0x8C, 0x08, 0x82, 0x20, 0x22, 0x0C, 0x80, 0x88, 0x32, 0x03,
  0x20, 0x58, 0x05, 0x81, 0x40, 0x14, 0x05, 0x00, 0x50, 0x14, 0x01, 0x40,
  0x70, 0x03, 0x00, 0x60, 0x00, 0x64, 0x00, 0x10, 0xC0, 0x06, 0x0C, 0x01,
  0x80, 0xC0, 0x20, 0x08, 0x0C, 0x01, 0x83, 0x00, 0x18, 0xC0, 0x01, 0x90,
  0x00, 0x16, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0B, 0x00, 0x03, 0x20,
  0x00, 0xC6, 0x00, 0x30, 0x60, 0x04, 0x06, 0x01, 0x80, 0x40, 0x60, 0x0C,
  0x18, 0x00, 0xC2, 0x00, 0x0D, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0x68, 0x00,
  0x09, 0x80, 0x03, 0x10, 0x00, 0x63, 0x00, 0x08, 0x60, 0x03, 0x04, 0x00,
  0x40, 0xC0, 0x18, 0x08, 0x03, 0x01, 0x80, 0x40, 0x10, 0x18, 0x02, 0x02,
  0x00, 0x60, 0xC0, 0x04, 0x10, 0x00, 0xC2, 0x00, 0x08, 0xC0, 0x01, 0x90,
  0x00, 0x36, 0x00, 0x02, 0x80, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x80,
  0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x01, 0x80, 0x00, 0x20, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x10, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x07, 0xFF, 0xFC, 0x03, 0xFE, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x03, 0x00,
  0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x40, 0x03, 0x03, 0xF8, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x7F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x40,
  0x01, 0x80, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0xF8,
  0x1C, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x1F, 0xF0, 0x00,
  0x0F, 0x00, 0x18, 0x8C, 0x00, 0xC8, 0x10, 0x04, 0xC0, 0x40, 0x24, 0x01,
  0x02, 0x20, 0x06, 0x33, 0x00, 0x1E, 0x00,
};

const GFXglyph IBMPlexMono_ExtraLight42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 3, 29, 25, 11, -29 },
  { 12, 7, 11, 25, 9, -31 },
  { 22, 23, 29, 25, 1, -29 },
  { 106, 19, 37, 25, 3, -33 },
  { 194, 23, 29, 25, 1, -29 },
  { 278, 21, 29, 25, 2, -29 },
  { 355, 1, 11, 25, 12, -31 },
  { 357, 10, 38, 25, 10, -32 },
  { 405, 11, 38, 25, 5, -32 },
  { 458, 21, 21, 25, 2, -23 },
  { 514, 20, 21, 25, 3, -23 },
  { 567, 5, 11, 25, 9, -4 },
  { 574, 11, 1, 25, 7, -13 },
  { 576, 3, 3, 25, 11, -3 },
  { 578, 17, 38, 25, 4, -32 },
  { 659, 19, 29, 25, 3, -29 },
  { 728, 20, 29, 25, 3, -29 },
  { 801, 19, 29, 25, 3, -29 },
  { 870, 18, 29, 25, 3, -29 },
  { 936, 21, 29, 25, 2, -29 },
  { 1013, 19, 29, 25, 3, -29 },
  { 1082, 19, 29, 25, 3, -29 },
  { 1151, 19, 29, 25, 3, -29 },
  { 1220, 19, 29, 25, 3, -29 },
  { 1289, 18, 29, 25, 4, -29 },
  { 1355, 3, 22, 25, 11, -22 },
  { 1364, 5, 29, 25, 9, -22 },
  { 1383, 18, 23, 25, 4, -24 },
  { 1435, 20, 8, 25, 3, -17 },
  { 1455, 18, 23, 25, 4, -24 },
  { 1507, 17, 29, 25, 4, -29 },
  { 1569, 17, 34, 25, 4, -29 },
  { 1642, 21, 29, 25, 2, -29 },
  { 1719, 18, 29, 25, 4, -29 },
  { 1785, 19, 29, 25, 3, -29 },
  { 1854, 18, 29, 25, 4, -29 },
  { 1920, 18, 29, 25, 4, -29 },
  { 1986, 18, 29, 25, 4, -29 },
  { 2052, 19, 29, 25, 3, -29 },
  { 2121, 17, 29, 25, 4, -29 },
  { 2183, 17, 29, 25, 4, -29 },
  { 2245, 16, 29, 25, 4, -29 },
  { 2303, 19, 29, 25, 4, -29 },
  { 2372, 16, 29, 25, 6, -29 },
  { 2430, 19, 29, 25, 3, -29 },
  { 2499, 17, 29, 25, 4, -29 },
  { 2561, 19, 29, 25, 3, -29 },
  { 2630, 18, 29, 25, 4, -29 },
  { 2696, 19, 34, 25, 3, -29 },
  { 2777, 18, 29, 25, 4, -29 },
  { 2843, 19, 29, 25, 3, -29 },
  { 2912, 22, 29, 25, 2, -29 },
  { 2992, 17, 29, 25, 4, -29 },
  { 3054, 21, 29, 25, 2, -29 },
  { 3131, 21, 29, 25, 2, -29 },
  { 3208, 21, 29, 25, 2, -29 },
  { 3285, 23, 29, 25, 1, -29 },
  { 3369, 21, 29, 25, 2, -29 },
  { 3446, 10, 38, 25, 11, -32 },
  { 3494, 17, 38, 25, 4, -32 },
  { 3575, 10, 38, 25, 4, -32 },
  { 3623, 20, 16, 25, 3, -29 },
  { 3663, 20, 1, 25, 3, 5 },
  { 3666, 6, 7, 25, 8, -32 },
  { 3672, 20, 22, 25, 3, -22 },
  { 3727, 17, 31, 25, 5, -31 },
  { 3793, 17, 22, 25, 4, -22 },
  { 3840, 17, 31, 25, 3, -31 },
  { 3906, 18, 22, 25, 4, -22 },
  { 3956, 20, 31, 25, 3, -31 },
  { 4034, 19, 31, 25, 4, -23 },
  { 4108, 16, 31, 25, 5, -31 },
  { 4170, 18, 32, 25, 5, -32 },
  { 4242, 15, 40, 25, 4, -32 },
  { 4317, 19, 31, 25, 5, -31 },
  { 4391, 18, 31, 25, 4, -31 },
  { 4461, 19, 22, 25, 3, -22 },
  { 4514, 16, 22, 25, 5, -22 },
  { 4558, 18, 22, 25, 4, -22 },
  { 4608, 17, 30, 25, 5, -22 },
  { 4672, 17, 30, 25, 3, -22 },
  { 4736, 20, 22, 25, 3, -22 },
  { 4791, 18, 22, 25, 4, -22 },
  { 4841, 20, 29, 25, 2, -29 },
  { 4914, 15, 22, 25, 5, -22 },
  { 4956, 18, 22, 25, 4, -22 },
  { 5006, 22, 22, 25, 2, -22 },
  { 5067, 19, 22, 25, 3, -22 },
  { 5120, 19, 30, 25, 3, -22 },
  { 5192, 17, 22, 25, 4, -22 },
  { 5239, 15, 38, 25, 5, -32 },
  { 5311, 1, 38, 25, 12, -32 },
  { 5316, 15, 38, 25, 5, -32 },
  { 5388, 21, 7, 25, 2, -16 },
};

const GFXfont IBMPlexMono_ExtraLight42pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLight42pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLight42pt7bGlyphs,
  0x20, 0x7E, 55
};

#endif // _IBMPLEXMONO_EXTRALIGHT42PT7B_H_
