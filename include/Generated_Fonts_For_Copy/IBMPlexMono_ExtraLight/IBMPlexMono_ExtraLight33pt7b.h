#ifndef _IBMPLEXMONO_EXTRALIGHT33PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHT33PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLight.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLight33pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB6, 0xDB, 0x69, 0x24, 0x92, 0x00, 0x07, 0xD8, 0x86, 0x18,
  0x61, 0x86, 0x18, 0x61, 0x01, 0x84, 0x00, 0x41, 0x00, 0x10, 0x40, 0x04,
  0x10, 0x01, 0x04, 0x00, 0xC3, 0x00, 0x20, 0x80, 0x08, 0x20, 0x7E, 0x0F,
  0xC0, 0x82, 0x00, 0x21, 0x80, 0x18, 0x40, 0x04, 0x10, 0x01, 0x04, 0x0F,
  0xC1, 0xF8, 0x10, 0x40, 0x0C, 0x30, 0x02, 0x08, 0x00, 0x82, 0x00, 0x20,
  0x80, 0x08, 0x20, 0x02, 0x08, 0x01, 0x84, 0x00, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x0F, 0xF0, 0x18, 0x9C, 0x20, 0x86, 0x40, 0x82, 0x40, 0x80,
  0x40, 0x80, 0x40, 0x80, 0x40, 0x80, 0x60, 0x80, 0x30, 0x80, 0x1E, 0x80,
  0x03, 0xF0, 0x00, 0x9C, 0x00, 0x86, 0x00, 0x82, 0x00, 0x82, 0x00, 0x83,
  0x00, 0x83, 0x00, 0x82, 0xC0, 0x82, 0x60, 0x86, 0x38, 0x9C, 0x0F, 0xF0,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x1E, 0x00, 0x58, 0x40, 0x24, 0x08,
  0x12, 0x02, 0x04, 0x80, 0x82, 0x20, 0x20, 0x88, 0x08, 0x42, 0x02, 0x30,
  0x40, 0x88, 0x18, 0x44, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x01,
  0x88, 0x60, 0x44, 0x08, 0x21, 0x03, 0x08, 0xC0, 0x44, 0x30, 0x13, 0x0C,
  0x04, 0x81, 0x03, 0x40, 0x40, 0x90, 0x08, 0x68, 0x01, 0xE0, 0x07, 0xC0,
  0x06, 0x18, 0x04, 0x06, 0x02, 0x02, 0x01, 0x00, 0x01, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x03, 0x40, 0xF2,
  0x10, 0x42, 0x0C, 0x21, 0x03, 0x11, 0x80, 0xC8, 0x80, 0x34, 0x60, 0x0E,
  0x30, 0x02, 0x08, 0x02, 0x86, 0x01, 0x21, 0x83, 0x08, 0x3E, 0x06, 0xFF,
  0xFF, 0x03, 0x04, 0x08, 0x10, 0x30, 0x20, 0x40, 0x40, 0x40, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x40, 0x40,
  0x40, 0x20, 0x30, 0x10, 0x08, 0x04, 0x03, 0xC0, 0x20, 0x10, 0x08, 0x08,
  0x04, 0x04, 0x02, 0x02, 0x02, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x02, 0x02, 0x02, 0x04, 0x04, 0x08, 0x08, 0x10, 0x20,
  0xC0, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0xE1, 0x07, 0x3D, 0x3C, 0x07, 0xC0, 0x01, 0x80, 0x02, 0x40, 0x06,
  0x60, 0x0C, 0x20, 0x08, 0x10, 0x10, 0x18, 0x30, 0x0C, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0xFF, 0xFF, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x33, 0x26, 0x64, 0x4C, 0xFF,
  0x80, 0x7D, 0x80, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x80,
  0x04, 0x00, 0x60, 0x00, 0x07, 0xE0, 0x18, 0x30, 0x30, 0x08, 0x20, 0x04,
  0x40, 0x06, 0x40, 0x02, 0x40, 0x02, 0xC0, 0x02, 0xC0, 0x02, 0xC0, 0x03,
  0xC0, 0x03, 0xC1, 0x83, 0xC1, 0x83, 0xC0, 0x03, 0xC0, 0x02, 0xC0, 0x02,
  0x40, 0x02, 0x40, 0x02, 0x40, 0x06, 0x20, 0x04, 0x30, 0x08, 0x18, 0x30,
  0x07, 0xE0, 0x03, 0x00, 0x0E, 0x00, 0x24, 0x01, 0x88, 0x06, 0x10, 0x18,
  0x20, 0x20, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x3F, 0xFF, 0x80, 0x0F, 0xC0,
  0xC1, 0x86, 0x01, 0x30, 0x06, 0x80, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x08, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x0F, 0xFF, 0xC0, 0x0F, 0xC0, 0x60, 0xC2, 0x00, 0x90, 0x03, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x18, 0x00, 0xC0, 0xFC, 0x00, 0x1C,
  0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x70, 0x03, 0x60, 0x08, 0xC0, 0xC0, 0xFC, 0x00, 0x00, 0x08, 0x00, 0x0C,
  0x00, 0x0A, 0x00, 0x05, 0x00, 0x04, 0x80, 0x04, 0x40, 0x06, 0x20, 0x02,
  0x10, 0x02, 0x08, 0x03, 0x04, 0x01, 0x02, 0x01, 0x01, 0x01, 0x80, 0x80,
  0x80, 0x40, 0x80, 0x20, 0xC0, 0x10, 0x40, 0x08, 0x7F, 0xFF, 0xC0, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x7F, 0xF9, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x3F, 0x05, 0x03, 0x18, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0xE0, 0x02, 0xC0, 0x10, 0xC1, 0x81,
  0xFC, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x40,
  0x02, 0x00, 0x18, 0x00, 0x40, 0x01, 0x3F, 0x0B, 0x03, 0x38, 0x06, 0xC0,
  0x0A, 0x00, 0x38, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xD0,
  0x02, 0x60, 0x18, 0xC0, 0xC0, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0x00,
  0x16, 0x00, 0x2C, 0x00, 0xD8, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30,
  0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00,
  0xC0, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80,
  0x03, 0x00, 0x00, 0x07, 0xE0, 0x18, 0x18, 0x20, 0x0C, 0x60, 0x04, 0x40,
  0x06, 0x40, 0x02, 0x40, 0x06, 0x60, 0x04, 0x20, 0x0C, 0x18, 0x18, 0x07,
  0xE0, 0x18, 0x18, 0x20, 0x04, 0x40, 0x02, 0x40, 0x02, 0xC0, 0x02, 0xC0,
  0x03, 0xC0, 0x02, 0xC0, 0x02, 0x40, 0x02, 0x20, 0x04, 0x18, 0x18, 0x07,
  0xE0, 0x0F, 0xC0, 0xC0, 0xC6, 0x01, 0x90, 0x02, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x14, 0x00, 0xD8, 0x05, 0x30, 0x2C,
  0x3F, 0x20, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x80, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x08, 0x00, 0xC0, 0x00, 0x7D, 0x80, 0x00, 0x00, 0x00, 0x03,
  0xEC, 0x37, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x32, 0x66, 0x44,
  0xC0, 0x00, 0x04, 0x00, 0x70, 0x03, 0x00, 0x30, 0x03, 0x00, 0x18, 0x01,
  0x80, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x10, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x30, 0x03, 0x00, 0x18, 0x01, 0x80, 0x18, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x02, 0x00, 0x00, 0x0F, 0xC0, 0xC0, 0xC6, 0x01,
  0x90, 0x02, 0xC0, 0x08, 0x00, 0x20, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00,
  0xC0, 0x0E, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x60, 0x00,
  0x0F, 0xC0, 0x61, 0x82, 0x01, 0x18, 0x06, 0x40, 0x09, 0x00, 0x28, 0x00,
  0xA0, 0x7A, 0x82, 0x1E, 0x10, 0x38, 0x40, 0xE3, 0x03, 0x88, 0x0E, 0x20,
  0x38, 0x80, 0xE2, 0x03, 0x84, 0x0E, 0x10, 0x38, 0x61, 0xE0, 0xFB, 0x80,
  0x01, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x60, 0x00, 0x7F, 0x00,
  0x01, 0x80, 0x01, 0x80, 0x02, 0xC0, 0x02, 0x40, 0x02, 0x40, 0x04, 0x60,
  0x04, 0x20, 0x04, 0x20, 0x08, 0x20, 0x08, 0x10, 0x08, 0x10, 0x10, 0x10,
  0x10, 0x08, 0x10, 0x08, 0x3F, 0xF8, 0x20, 0x04, 0x20, 0x04, 0x40, 0x04,
  0x40, 0x02, 0x40, 0x02, 0xC0, 0x02, 0x80, 0x01, 0x80, 0x01, 0xFF, 0xC2,
  0x00, 0xC8, 0x01, 0x20, 0x02, 0x80, 0x0A, 0x00, 0x28, 0x00, 0xA0, 0x02,
  0x80, 0x0A, 0x00, 0x48, 0x03, 0x3F, 0xF0, 0x80, 0x32, 0x00, 0x28, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0A, 0x00,
  0x6F, 0xFE, 0x00, 0x07, 0xE0, 0x60, 0xC2, 0x00, 0x98, 0x03, 0x40, 0x07,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00,
  0x50, 0x03, 0x20, 0x08, 0x60, 0xC0, 0x7C, 0x00, 0xFF, 0xC1, 0x80, 0xC3,
  0x00, 0x46, 0x00, 0x4C, 0x00, 0x98, 0x00, 0xB0, 0x01, 0x60, 0x02, 0xC0,
  0x05, 0x80, 0x0B, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0x60, 0x02, 0xC0, 0x05, 0x80, 0x0B, 0x00, 0x26, 0x00, 0x4C, 0x01, 0x18,
  0x0C, 0x3F, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x3F,
  0xFF, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x3F, 0xFE, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x00, 0x07, 0xE0, 0x18, 0x30, 0x40, 0x31, 0x00, 0x26, 0x00, 0x68,
  0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x0F, 0xF8, 0x00, 0x70, 0x00, 0xA0, 0x01, 0x40, 0x02, 0x80, 0x05,
  0x80, 0x19, 0x00, 0x33, 0x00, 0xA3, 0x82, 0x41, 0xF8, 0x80, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x40, 0xFF, 0xFC, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x0F, 0xFF, 0xC0, 0x3F, 0xF0, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x80,
  0x1C, 0x01, 0x40, 0x23, 0x04, 0x1F, 0x80, 0xC0, 0x07, 0x80, 0x1B, 0x00,
  0x66, 0x00, 0x8C, 0x02, 0x18, 0x08, 0x30, 0x20, 0x60, 0xC0, 0xC3, 0x01,
  0x8C, 0x03, 0x38, 0x06, 0x58, 0x0D, 0x10, 0x1C, 0x10, 0x30, 0x30, 0x60,
  0x20, 0xC0, 0x21, 0x80, 0x63, 0x00, 0x46, 0x00, 0x4C, 0x00, 0xD8, 0x00,
  0xB0, 0x00, 0x80, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0xFF, 0xF0, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xE8, 0x05, 0xA0, 0x16, 0x40,
  0x99, 0x02, 0x66, 0x11, 0x88, 0x46, 0x23, 0x18, 0x48, 0x61, 0x21, 0x83,
  0x06, 0x0C, 0x18, 0x20, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0xC0, 0x07, 0x80, 0x1A, 0x00,
  0x6C, 0x01, 0x90, 0x06, 0x60, 0x18, 0x80, 0x63, 0x01, 0x84, 0x06, 0x18,
  0x18, 0x20, 0x60, 0xC1, 0x81, 0x06, 0x06, 0x18, 0x08, 0x60, 0x31, 0x80,
  0x46, 0x01, 0x98, 0x02, 0x60, 0x0D, 0x80, 0x16, 0x00, 0x78, 0x00, 0xC0,
  0x07, 0xE0, 0x18, 0x30, 0x30, 0x08, 0x20, 0x04, 0x40, 0x06, 0x40, 0x02,
  0x40, 0x02, 0xC0, 0x02, 0xC0, 0x02, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x02, 0xC0, 0x02, 0x40, 0x02, 0x40, 0x02,
  0x40, 0x06, 0x20, 0x04, 0x30, 0x08, 0x18, 0x30, 0x07, 0xE0, 0xFF, 0xE3,
  0x00, 0x6C, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x06, 0xFF, 0xE3, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x00, 0x07, 0xE0, 0x18, 0x30, 0x30, 0x08, 0x20, 0x04, 0x40,
  0x06, 0x40, 0x02, 0x40, 0x02, 0xC0, 0x02, 0xC0, 0x02, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x02, 0xC0, 0x02, 0x40,
  0x02, 0x40, 0x02, 0x40, 0x06, 0x20, 0x04, 0x30, 0x08, 0x18, 0x30, 0x07,
  0xE0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x00, 0xFC, 0xFF, 0xE3, 0x00,
  0x6C, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0xB0, 0x06, 0xFF, 0xE3, 0x04, 0x0C, 0x18, 0x30,
  0x30, 0xC0, 0x43, 0x01, 0x8C, 0x02, 0x30, 0x04, 0xC0, 0x1B, 0x00, 0x2C,
  0x00, 0x40, 0x0F, 0xF0, 0x38, 0x18, 0x60, 0x06, 0x40, 0x02, 0x40, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1E, 0x00,
  0x03, 0xF0, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x03, 0x80, 0x02, 0xC0, 0x02, 0x60, 0x04, 0x38, 0x18, 0x0F, 0xF0,
  0xFF, 0xFF, 0xC0, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x24,
  0x00, 0x90, 0x02, 0x60, 0x18, 0xC0, 0xC1, 0xFC, 0x00, 0x80, 0x01, 0x80,
  0x03, 0xC0, 0x02, 0x40, 0x02, 0x40, 0x06, 0x60, 0x04, 0x20, 0x04, 0x20,
  0x0C, 0x30, 0x08, 0x10, 0x08, 0x10, 0x08, 0x18, 0x10, 0x08, 0x10, 0x08,
  0x10, 0x0C, 0x20, 0x04, 0x20, 0x04, 0x20, 0x06, 0x60, 0x02, 0x40, 0x02,
  0x40, 0x02, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x02, 0xC1, 0x82, 0x41,
  0x82, 0x43, 0x82, 0x42, 0x42, 0x42, 0x42, 0x42, 0x42, 0x44, 0x42, 0x44,
  0x22, 0x44, 0x22, 0x4C, 0x26, 0x48, 0x34, 0x68, 0x14, 0x28, 0x14, 0x30,
  0x14, 0x30, 0x0C, 0x30, 0x0C, 0x60, 0x01, 0x90, 0x00, 0x8C, 0x00, 0x82,
  0x00, 0xC0, 0x80, 0x40, 0x60, 0x40, 0x10, 0x60, 0x04, 0x20, 0x03, 0x20,
  0x00, 0x90, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x09, 0x00, 0x08,
  0xC0, 0x0C, 0x20, 0x04, 0x08, 0x04, 0x06, 0x06, 0x01, 0x02, 0x00, 0x42,
  0x00, 0x33, 0x00, 0x0B, 0x00, 0x02, 0xC0, 0x00, 0xD0, 0x00, 0x26, 0x00,
  0x10, 0x80, 0x0C, 0x10, 0x02, 0x06, 0x01, 0x00, 0x80, 0xC0, 0x10, 0x20,
  0x06, 0x18, 0x00, 0x84, 0x00, 0x12, 0x00, 0x07, 0x80, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0xFF, 0xFE,
  0x00, 0x02, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x10, 0x00, 0x30,
  0x00, 0x20, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x00, 0x03, 0x00,
  0x06, 0x00, 0x04, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x60, 0x00, 0x40, 0x00, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x07, 0xFC, 0xC0, 0x02, 0x00, 0x10, 0x00, 0x40,
  0x02, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x20, 0x01, 0x00, 0x04, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x00, 0x80, 0x04, 0xFF, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0xFF, 0x01, 0x80, 0x03, 0x80, 0x02, 0x40, 0x04, 0x60, 0x04, 0x20, 0x08,
  0x10, 0x18, 0x10, 0x10, 0x08, 0x20, 0x0C, 0x20, 0x04, 0x40, 0x06, 0xC0,
  0x02, 0x80, 0x03, 0xFF, 0xFF, 0x88, 0x46, 0x21, 0x0F, 0xC0, 0x30, 0x60,
  0x20, 0x10, 0x40, 0x18, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08,
  0x1F, 0xF8, 0x30, 0x08, 0x40, 0x08, 0x40, 0x08, 0xC0, 0x08, 0x40, 0x08,
  0x40, 0x28, 0x30, 0x68, 0x1F, 0x8F, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x11, 0xF0, 0xB0, 0x66, 0x01, 0xA0, 0x05,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x01, 0x60, 0x1A, 0xC1, 0x91, 0xF0, 0x07, 0xC0, 0x60,
  0xC2, 0x01, 0x98, 0x02, 0x40, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x80, 0x32, 0x00, 0x86,
  0x0C, 0x07, 0xC0, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x41, 0xF1, 0x18, 0x34, 0xC0, 0x56, 0x00, 0xD0, 0x01,
  0x40, 0x05, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x05, 0x00, 0x14, 0x00,
  0x50, 0x01, 0x60, 0x0C, 0xC0, 0x51, 0x83, 0x41, 0xF1, 0x0F, 0xC0, 0xC1,
  0x86, 0x01, 0x10, 0x02, 0xC0, 0x0A, 0x00, 0x38, 0x00, 0x60, 0x01, 0xFF,
  0xFE, 0x00, 0x08, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x36, 0x00, 0x8C,
  0x0C, 0x0F, 0xC0, 0x01, 0xFE, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x7F, 0xFF, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x7F, 0xFE,
  0x00, 0x1E, 0x1F, 0xC0, 0x61, 0x81, 0x00, 0x86, 0x01, 0x08, 0x01, 0x10,
  0x02, 0x20, 0x04, 0x40, 0x08, 0x40, 0x30, 0x80, 0x40, 0xC3, 0x01, 0xFC,
  0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x20, 0x00, 0x7F, 0xF1, 0x80, 0x14,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x70, 0x01, 0xB0, 0x0E, 0x1F, 0xE0, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0xF8, 0xB0,
  0x6C, 0x02, 0x80, 0x38, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x03,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x3F, 0xFF, 0x00, 0x70, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x7F, 0xE0, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x06, 0x80, 0x31, 0x00, 0xC2, 0x03,
  0x04, 0x0C, 0x08, 0x30, 0x10, 0x80, 0x23, 0x80, 0x49, 0x80, 0xE1, 0x81,
  0x81, 0x02, 0x01, 0x04, 0x03, 0x08, 0x03, 0x10, 0x03, 0x20, 0x02, 0x40,
  0x03, 0xFF, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x3F, 0xFF, 0x9E, 0x3C, 0xA3, 0x46, 0xC1,
  0x82, 0x81, 0x83, 0x81, 0x03, 0x81, 0x03, 0x81, 0x03, 0x81, 0x03, 0x81,
  0x03, 0x81, 0x03, 0x81, 0x03, 0x81, 0x03, 0x81, 0x03, 0x81, 0x03, 0x81,
  0x03, 0x81, 0x03, 0x81, 0x03, 0x8F, 0x8B, 0x06, 0xC0, 0x28, 0x03, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x0F, 0xC0, 0xC1, 0x86, 0x01,
  0x10, 0x02, 0xC0, 0x0A, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0xC0, 0x09, 0x00, 0x26, 0x01, 0x0C, 0x1C, 0x0F,
  0xC0, 0x8F, 0x85, 0x83, 0x30, 0x0D, 0x00, 0x28, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0B,
  0x00, 0xD6, 0x0C, 0x8F, 0x84, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x07, 0xC4, 0x60, 0xD3, 0x01, 0x58, 0x03, 0x40,
  0x05, 0x00, 0x14, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x14, 0x00, 0x50,
  0x01, 0x40, 0x05, 0x80, 0x33, 0x01, 0x46, 0x0D, 0x07, 0xC4, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0xFC, 0x7E,
  0x09, 0x00, 0x14, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0xFF, 0xFC, 0x0F, 0xC0, 0xC0, 0xC4, 0x00, 0x90,
  0x01, 0x40, 0x01, 0x00, 0x06, 0x00, 0x0F, 0x00, 0x07, 0xE0, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x1C, 0x00, 0xCC, 0x06, 0x0F, 0xE0,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00,
  0xFF, 0xFF, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0xFF, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x03, 0xC0, 0x56, 0x0D, 0x1F, 0x10,
  0x80, 0x07, 0x00, 0x24, 0x00, 0x90, 0x02, 0x20, 0x10, 0x80, 0x42, 0x03,
  0x04, 0x08, 0x10, 0x20, 0x61, 0x00, 0x84, 0x02, 0x10, 0x0C, 0x80, 0x12,
  0x00, 0x58, 0x00, 0xC0, 0x03, 0x00, 0x80, 0xC0, 0xF0, 0x30, 0x24, 0x0C,
  0x09, 0x04, 0x82, 0x41, 0x20, 0x90, 0x48, 0x24, 0x12, 0x10, 0x88, 0x44,
  0x22, 0x11, 0x08, 0x84, 0x42, 0x21, 0x10, 0x90, 0x24, 0x24, 0x0A, 0x05,
  0x02, 0x81, 0x40, 0xA0, 0x60, 0x18, 0x18, 0x06, 0x00, 0xC0, 0x0D, 0x00,
  0x62, 0x01, 0x0C, 0x08, 0x18, 0x60, 0x23, 0x00, 0x48, 0x01, 0xC0, 0x03,
  0x00, 0x1C, 0x00, 0x48, 0x02, 0x10, 0x10, 0x60, 0xC0, 0x82, 0x01, 0x10,
  0x02, 0x80, 0x0C, 0x80, 0x06, 0x00, 0x34, 0x00, 0x90, 0x02, 0x60, 0x10,
  0x80, 0x42, 0x03, 0x04, 0x08, 0x10, 0x20, 0x61, 0x00, 0x84, 0x02, 0x30,
  0x04, 0x80, 0x12, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20,
  0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0x80, 0x3E, 0x00, 0x7F, 0xF8, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x60, 0x03, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x18, 0x00, 0xC0, 0x02, 0x00, 0x10, 0x00, 0x80, 0x06, 0x00, 0x10,
  0x00, 0xFF, 0xFC, 0x07, 0xF0, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x20,
  0xFC, 0x00, 0x60, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFE, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x60, 0x04, 0x00, 0x80, 0x18, 0x01, 0x00, 0x08, 0x00,
  0xC0, 0x03, 0xF0, 0x60, 0x08, 0x01, 0x80, 0x10, 0x00, 0x80, 0x0C, 0x00,
  0x40, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x0F,
  0xE0, 0x1C, 0x01, 0x62, 0x01, 0x41, 0x02, 0x80, 0x82, 0x80, 0x44, 0x80,
  0x38,
};

const GFXglyph IBMPlexMono_ExtraLight33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 20, 0, -1 },
  { 1, 3, 23, 20, 8, -23 },
  { 10, 6, 8, 20, 7, -24 },
  { 16, 18, 23, 20, 1, -23 },
  { 68, 16, 29, 20, 2, -26 },
  { 126, 18, 23, 20, 1, -23 },
  { 178, 17, 23, 20, 1, -23 },
  { 227, 2, 8, 20, 9, -24 },
  { 229, 8, 30, 20, 8, -25 },
  { 259, 8, 30, 20, 4, -25 },
  { 289, 16, 16, 20, 2, -18 },
  { 321, 16, 17, 20, 2, -19 },
  { 355, 4, 8, 20, 7, -3 },
  { 359, 9, 1, 20, 5, -11 },
  { 361, 3, 3, 20, 8, -3 },
  { 363, 13, 30, 20, 3, -25 },
  { 412, 16, 23, 20, 2, -23 },
  { 458, 15, 23, 20, 3, -23 },
  { 502, 14, 23, 20, 3, -23 },
  { 543, 14, 23, 20, 2, -23 },
  { 584, 17, 23, 20, 1, -23 },
  { 633, 14, 23, 20, 3, -23 },
  { 674, 14, 23, 20, 3, -23 },
  { 715, 15, 23, 20, 2, -23 },
  { 759, 16, 23, 20, 2, -23 },
  { 805, 14, 23, 20, 3, -23 },
  { 846, 3, 18, 20, 8, -18 },
  { 853, 4, 23, 20, 7, -18 },
  { 865, 14, 18, 20, 3, -19 },
  { 897, 16, 7, 20, 2, -14 },
  { 911, 14, 18, 20, 3, -19 },
  { 943, 14, 23, 20, 3, -23 },
  { 984, 14, 27, 20, 3, -23 },
  { 1032, 16, 23, 20, 2, -23 },
  { 1078, 14, 23, 20, 3, -23 },
  { 1119, 14, 23, 20, 3, -23 },
  { 1160, 15, 23, 20, 3, -23 },
  { 1204, 14, 23, 20, 3, -23 },
  { 1245, 14, 23, 20, 3, -23 },
  { 1286, 15, 23, 20, 2, -23 },
  { 1330, 14, 23, 20, 3, -23 },
  { 1371, 14, 23, 20, 3, -23 },
  { 1412, 12, 23, 20, 3, -23 },
  { 1447, 15, 23, 20, 3, -23 },
  { 1491, 12, 23, 20, 5, -23 },
  { 1526, 14, 23, 20, 3, -23 },
  { 1567, 14, 23, 20, 3, -23 },
  { 1608, 16, 23, 20, 2, -23 },
  { 1654, 14, 23, 20, 3, -23 },
  { 1695, 16, 27, 20, 2, -23 },
  { 1749, 14, 23, 20, 3, -23 },
  { 1790, 16, 23, 20, 2, -23 },
  { 1836, 18, 23, 20, 1, -23 },
  { 1888, 14, 23, 20, 3, -23 },
  { 1929, 16, 23, 20, 2, -23 },
  { 1975, 16, 23, 20, 2, -23 },
  { 2021, 17, 23, 20, 1, -23 },
  { 2070, 18, 23, 20, 1, -23 },
  { 2122, 16, 23, 20, 2, -23 },
  { 2168, 9, 30, 20, 8, -25 },
  { 2202, 13, 30, 20, 3, -25 },
  { 2251, 8, 30, 20, 3, -25 },
  { 2281, 16, 13, 20, 2, -23 },
  { 2307, 16, 1, 20, 2, 4 },
  { 2309, 4, 6, 20, 7, -26 },
  { 2312, 16, 17, 20, 2, -17 },
  { 2346, 13, 24, 20, 4, -24 },
  { 2385, 14, 17, 20, 3, -17 },
  { 2415, 14, 24, 20, 2, -24 },
  { 2457, 14, 17, 20, 3, -17 },
  { 2487, 15, 24, 20, 3, -24 },
  { 2532, 15, 25, 20, 3, -18 },
  { 2579, 12, 24, 20, 4, -24 },
  { 2615, 14, 24, 20, 4, -24 },
  { 2657, 12, 31, 20, 3, -24 },
  { 2704, 15, 24, 20, 4, -24 },
  { 2749, 14, 24, 20, 3, -24 },
  { 2791, 16, 17, 20, 2, -17 },
  { 2825, 12, 17, 20, 4, -17 },
  { 2851, 14, 17, 20, 3, -17 },
  { 2881, 13, 24, 20, 4, -17 },
  { 2920, 14, 24, 20, 2, -17 },
  { 2962, 15, 17, 20, 3, -17 },
  { 2994, 14, 17, 20, 3, -17 },
  { 3024, 16, 23, 20, 1, -23 },
  { 3070, 12, 17, 20, 4, -17 },
  { 3096, 14, 17, 20, 3, -17 },
  { 3126, 18, 17, 20, 1, -17 },
  { 3165, 14, 17, 20, 3, -17 },
  { 3195, 14, 24, 20, 3, -17 },
  { 3237, 14, 17, 20, 3, -17 },
  { 3267, 12, 30, 20, 4, -25 },
  { 3312, 1, 30, 20, 9, -25 },
  { 3316, 12, 30, 20, 4, -25 },
  { 3361, 16, 6, 20, 2, -13 },
};

const GFXfont IBMPlexMono_ExtraLight33pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLight33pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLight33pt7bGlyphs,
  0x20, 0x7E, 43
};

#endif // _IBMPLEXMONO_EXTRALIGHT33PT7B_H_
