#ifndef _IBMPLEXMONO_EXTRALIGHT23PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHT23PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLight.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLight23pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0xA8, 0x0F, 0x99, 0x99, 0x99, 0x02, 0x20, 0x22, 0x01,
  0x10, 0x08, 0x80, 0x44, 0x3E, 0x3C, 0x11, 0x01, 0x10, 0x08, 0x80, 0x44,
  0x3E, 0x3E, 0x11, 0x01, 0x08, 0x08, 0x80, 0x44, 0x02, 0x20, 0x04, 0x00,
  0x80, 0x7E, 0x12, 0x24, 0x42, 0x88, 0x11, 0x02, 0x20, 0x24, 0x03, 0xC0,
  0x17, 0x02, 0x10, 0x42, 0x08, 0x41, 0x0E, 0x21, 0x24, 0x43, 0xF0, 0x10,
  0x02, 0x00, 0x78, 0x18, 0x42, 0x84, 0x28, 0x44, 0x84, 0x48, 0x48, 0x85,
  0x07, 0x80, 0x01, 0xE1, 0x23, 0x12, 0x12, 0x41, 0x44, 0x14, 0x21, 0x82,
  0x38, 0x1E, 0x1E, 0x02, 0x10, 0x40, 0x84, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x03, 0x07, 0x48, 0x48, 0x44, 0x82, 0x48, 0x18, 0x80, 0x88, 0x14, 0x41,
  0x43, 0xE3, 0xFC, 0x0C, 0x42, 0x08, 0x41, 0x08, 0x20, 0x82, 0x08, 0x20,
  0x82, 0x04, 0x10, 0x20, 0x81, 0x03, 0x81, 0x02, 0x04, 0x10, 0x20, 0x82,
  0x08, 0x10, 0x42, 0x08, 0x20, 0x84, 0x10, 0x84, 0x20, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0xC4, 0x33, 0xDC, 0x06, 0x00, 0xA0, 0x09, 0x01, 0x08,
  0x20, 0x40, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x41, 0xFF, 0xC1, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x00, 0x69, 0x29, 0x00, 0xFC, 0xF0, 0x00,
  0x80, 0x40, 0x40, 0x20, 0x10, 0x10, 0x08, 0x08, 0x04, 0x04, 0x02, 0x01,
  0x01, 0x00, 0x80, 0x80, 0x40, 0x20, 0x20, 0x10, 0x10, 0x00, 0x1E, 0x18,
  0x64, 0x0A, 0x01, 0x80, 0x60, 0x18, 0x06, 0x31, 0x8C, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x50, 0x26, 0x18, 0x78, 0x0C, 0x02, 0x80, 0x90, 0x22, 0x08,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x07, 0xFF, 0x1E, 0x18, 0x48, 0x0A, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x04, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x0C, 0x03, 0xFF,
  0x1F, 0x08, 0x24, 0x04, 0x01, 0x00, 0x40, 0x10, 0x08, 0x7C, 0x01, 0x80,
  0x10, 0x04, 0x01, 0x00, 0x70, 0x12, 0x08, 0x7C, 0x00, 0x80, 0x18, 0x02,
  0x80, 0x48, 0x04, 0x80, 0x88, 0x10, 0x82, 0x08, 0x20, 0x84, 0x08, 0x80,
  0x8F, 0xFF, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x7F, 0x90, 0x04, 0x01,
  0x00, 0x40, 0x20, 0x09, 0xE1, 0x86, 0x80, 0x80, 0x10, 0x04, 0x01, 0x00,
  0x60, 0x24, 0x18, 0xF8, 0x06, 0x02, 0x01, 0x00, 0x80, 0x60, 0x10, 0x09,
  0xE2, 0x86, 0xC0, 0xA0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x26, 0x18, 0xF8,
  0xFF, 0xE0, 0x18, 0x0A, 0x02, 0x81, 0x00, 0x40, 0x20, 0x08, 0x04, 0x01,
  0x00, 0x40, 0x20, 0x08, 0x04, 0x01, 0x00, 0x80, 0x3E, 0x18, 0x68, 0x0A,
  0x01, 0x80, 0x60, 0x18, 0x09, 0x86, 0x1E, 0x18, 0x68, 0x06, 0x01, 0x80,
  0x60, 0x1C, 0x08, 0xFC, 0x1E, 0x18, 0x64, 0x0A, 0x01, 0x80, 0x60, 0x18,
  0x07, 0x03, 0x61, 0x4F, 0xA0, 0x08, 0x04, 0x01, 0x00, 0x80, 0x40, 0x60,
  0xF0, 0x00, 0x0F, 0x6C, 0x00, 0x00, 0x01, 0xA4, 0xA4, 0x00, 0x40, 0x60,
  0x20, 0x30, 0x10, 0x18, 0x08, 0x01, 0x00, 0x30, 0x03, 0x00, 0x20, 0x06,
  0x00, 0x40, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x80,
  0x10, 0x03, 0x00, 0x30, 0x02, 0x00, 0x60, 0x04, 0x06, 0x02, 0x03, 0x01,
  0x01, 0x80, 0x80, 0x00, 0x1E, 0x18, 0x64, 0x0A, 0x02, 0x00, 0xC0, 0x20,
  0x10, 0x18, 0x08, 0x02, 0x00, 0x80, 0x00, 0x00, 0x00, 0x01, 0x80, 0x60,
  0x1E, 0x08, 0x44, 0x0A, 0x02, 0x80, 0xA1, 0xE8, 0x8E, 0x41, 0x90, 0x64,
  0x19, 0x06, 0x41, 0x88, 0xE3, 0xD8, 0x01, 0x00, 0x20, 0x07, 0xE0, 0x06,
  0x00, 0x60, 0x0A, 0x00, 0x90, 0x09, 0x01, 0x10, 0x10, 0x81, 0x08, 0x20,
  0x82, 0x04, 0x3F, 0xC4, 0x04, 0x40, 0x24, 0x02, 0x80, 0x28, 0x01, 0xFF,
  0x20, 0x68, 0x0A, 0x02, 0x80, 0xA0, 0x28, 0x13, 0xF8, 0x81, 0xA0, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x0B, 0xFC, 0x1F, 0x08, 0x24, 0x06, 0x01,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x50,
  0x12, 0x08, 0x7C, 0xFE, 0x20, 0x68, 0x0A, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x28, 0x1B, 0xF8, 0xFF,
  0xE0, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x03, 0xFF, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x03, 0xFF, 0xFF, 0xE0, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x03, 0xFE, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x1E, 0x18, 0x44, 0x0A, 0x01, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x87, 0xE0, 0x18, 0x06, 0x01, 0x80, 0x50, 0x36, 0x14, 0x79, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x07, 0xFF, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0xFF, 0xC2, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x83, 0xFF, 0x3F, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x18, 0x0C, 0x09, 0x0C, 0x7C, 0x80, 0x70, 0x12,
  0x04, 0x40, 0x88, 0x21, 0x08, 0x22, 0x04, 0xC0, 0xA4, 0x18, 0x82, 0x08,
  0x40, 0x88, 0x11, 0x01, 0x20, 0x14, 0x03, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0xFF, 0x80, 0x70, 0x3C, 0x16, 0x85, 0xA1, 0x64, 0x99, 0x26, 0x51, 0x8C,
  0x62, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0xC0, 0x70, 0x1A,
  0x06, 0x81, 0x90, 0x64, 0x18, 0x86, 0x21, 0x84, 0x61, 0x18, 0x26, 0x09,
  0x81, 0x60, 0x58, 0x0E, 0x03, 0x1E, 0x18, 0x64, 0x0A, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x50, 0x26, 0x18,
  0x78, 0xFF, 0x20, 0x28, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x02, 0xFF,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x1E, 0x18, 0x64,
  0x0A, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x50, 0x26, 0x18, 0x78, 0x08, 0x02, 0x00, 0x78, 0xFF, 0x20, 0x28,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x02, 0xFF, 0x21, 0x08, 0x22, 0x08,
  0x81, 0x20, 0x28, 0x0A, 0x01, 0x1F, 0x84, 0x09, 0x00, 0xA0, 0x04, 0x00,
  0x80, 0x08, 0x00, 0xF0, 0x01, 0xC0, 0x0C, 0x00, 0x80, 0x10, 0x03, 0x80,
  0x48, 0x10, 0xFC, 0xFF, 0xF0, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x90, 0x26, 0x18, 0xFC, 0x80,
  0x34, 0x02, 0x40, 0x24, 0x02, 0x40, 0x42, 0x04, 0x20, 0x42, 0x08, 0x10,
  0x81, 0x08, 0x11, 0x00, 0x90, 0x09, 0x00, 0xA0, 0x06, 0x00, 0x60, 0x80,
  0x18, 0x02, 0x80, 0x28, 0x02, 0x80, 0x28, 0x62, 0x46, 0x24, 0xA2, 0x4A,
  0x24, 0x92, 0x49, 0x25, 0x12, 0x50, 0xC5, 0x0C, 0x60, 0xC2, 0x04, 0xC0,
  0x34, 0x02, 0x20, 0x41, 0x08, 0x10, 0x80, 0x90, 0x0A, 0x00, 0x60, 0x06,
  0x00, 0x90, 0x09, 0x01, 0x08, 0x20, 0x42, 0x04, 0x40, 0x28, 0x03, 0x80,
  0x14, 0x02, 0x40, 0x22, 0x04, 0x10, 0x81, 0x08, 0x09, 0x00, 0x60, 0x06,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x7F,
  0xE0, 0x02, 0x00, 0x40, 0x08, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x04,
  0x00, 0x80, 0x10, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x0F, 0xFF, 0xFE,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x3F, 0x80, 0x20, 0x10, 0x04, 0x02, 0x01, 0x00, 0x40, 0x20, 0x08,
  0x04, 0x02, 0x00, 0x80, 0x40, 0x10, 0x08, 0x02, 0x01, 0x00, 0x80, 0x20,
  0x10, 0xFC, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10,
  0x41, 0x04, 0x10, 0x7F, 0x06, 0x01, 0x40, 0x24, 0x08, 0x81, 0x08, 0x40,
  0x90, 0x12, 0x01, 0x80, 0x20, 0xFF, 0xE0, 0x91, 0x10, 0x3E, 0x30, 0x40,
  0x10, 0x04, 0x01, 0x1F, 0xCC, 0x12, 0x04, 0x81, 0x20, 0xCC, 0x31, 0xF3,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x05, 0xF3, 0x0D, 0x02, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x05, 0x86, 0xBE, 0x00, 0x1E, 0x08, 0x64, 0x09,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x40, 0x10, 0x32, 0x18, 0x78, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x09, 0xF5, 0x87, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x02, 0xC3, 0x3E, 0x80, 0x1E, 0x18, 0x64, 0x0A, 0x01,
  0x80, 0x7F, 0xF8, 0x02, 0x00, 0x80, 0x10, 0x16, 0x18, 0x7C, 0x07, 0xC2,
  0x00, 0x80, 0x20, 0x08, 0x3F, 0xF0, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0xFF, 0xC0, 0x00, 0xE3, 0xE0, 0x84,
  0x20, 0x44, 0x08, 0x81, 0x10, 0x21, 0x08, 0x1E, 0x0C, 0x01, 0x00, 0x20,
  0x03, 0xF9, 0x80, 0xA0, 0x0C, 0x02, 0xC0, 0x47, 0xF0, 0x80, 0x80, 0x80,
  0x80, 0x80, 0xBC, 0xC3, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x08, 0x04, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x7F, 0xC0, 0x01,
  0x01, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0xFF, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x28, 0x12, 0x08, 0x8C, 0x24, 0x0A, 0x83,
  0x10, 0x84, 0x20, 0x88, 0x12, 0x02, 0x80, 0x40, 0xF8, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0xFF, 0xC0, 0xF3, 0xA3, 0x18, 0x86, 0x21, 0x88,
  0x62, 0x18, 0x86, 0x21, 0x88, 0x62, 0x18, 0x86, 0x21, 0xBC, 0xC3, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x1E, 0x18, 0x64,
  0x0A, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x50, 0x26, 0x18, 0x78,
  0xBE, 0x61, 0xA0, 0x50, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0xB0,
  0xD7, 0xC8, 0x04, 0x02, 0x01, 0x00, 0x80, 0x00, 0x3E, 0xB0, 0xE0, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x58, 0x67, 0xD0, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0xFB, 0xE1, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x7F, 0xE0, 0x3F, 0x10, 0x68,
  0x0E, 0x00, 0x40, 0x0F, 0x00, 0x38, 0x01, 0x00, 0x60, 0x14, 0x08, 0xFC,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x0F, 0xFE, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x7F, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0xC3, 0x7D, 0x80, 0x60,
  0x24, 0x09, 0x02, 0x41, 0x08, 0x42, 0x20, 0x48, 0x12, 0x05, 0x00, 0xC0,
  0x30, 0x86, 0x18, 0x61, 0x8A, 0x18, 0xA2, 0x89, 0x24, 0x92, 0x51, 0x25,
  0x12, 0x50, 0xC5, 0x0C, 0x60, 0xC2, 0x04, 0x80, 0xD0, 0x22, 0x10, 0x48,
  0x14, 0x03, 0x00, 0xC0, 0x48, 0x22, 0x08, 0x44, 0x0A, 0x01, 0x80, 0x60,
  0x24, 0x09, 0x02, 0x41, 0x08, 0x42, 0x20, 0x48, 0x12, 0x05, 0x00, 0xC0,
  0x20, 0x08, 0x02, 0x01, 0x00, 0x40, 0xE0, 0x00, 0xFF, 0x80, 0x20, 0x10,
  0x08, 0x04, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x04, 0x03, 0xFF, 0x1F,
  0x10, 0x10, 0x10, 0x10, 0x08, 0x08, 0x04, 0x08, 0xF0, 0x18, 0x04, 0x04,
  0x08, 0x10, 0x10, 0x10, 0x10, 0x10, 0x1F, 0xFF, 0xFF, 0xF0, 0xF8, 0x08,
  0x08, 0x08, 0x08, 0x10, 0x20, 0x20, 0x30, 0x0F, 0x18, 0x20, 0x20, 0x20,
  0x10, 0x08, 0x08, 0x08, 0x08, 0xF8, 0x38, 0x29, 0x85, 0x10, 0xC1, 0x18,
  0x1C,
};

const GFXglyph IBMPlexMono_ExtraLight23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 2, 16, 14, 6, -16 },
  { 5, 4, 6, 14, 5, -17 },
  { 8, 13, 16, 14, 0, -16 },
  { 34, 11, 20, 14, 1, -18 },
  { 62, 12, 16, 14, 1, -16 },
  { 86, 12, 16, 14, 1, -16 },
  { 110, 1, 6, 14, 6, -17 },
  { 111, 6, 20, 14, 5, -17 },
  { 126, 6, 20, 14, 3, -17 },
  { 141, 12, 11, 14, 1, -13 },
  { 158, 11, 11, 14, 1, -13 },
  { 174, 3, 6, 14, 5, -2 },
  { 177, 6, 1, 14, 4, -8 },
  { 178, 2, 2, 14, 6, -2 },
  { 179, 9, 20, 14, 2, -17 },
  { 202, 10, 16, 14, 2, -16 },
  { 222, 11, 16, 14, 2, -16 },
  { 244, 10, 16, 14, 2, -16 },
  { 264, 10, 16, 14, 1, -16 },
  { 284, 12, 16, 14, 1, -16 },
  { 308, 10, 16, 14, 2, -16 },
  { 328, 10, 16, 14, 2, -16 },
  { 348, 10, 16, 14, 2, -16 },
  { 368, 10, 16, 14, 2, -16 },
  { 388, 10, 16, 14, 2, -16 },
  { 408, 2, 12, 14, 6, -12 },
  { 411, 3, 16, 14, 5, -12 },
  { 417, 10, 13, 14, 2, -14 },
  { 434, 11, 6, 14, 1, -10 },
  { 443, 10, 13, 14, 2, -14 },
  { 460, 10, 16, 14, 2, -16 },
  { 480, 10, 18, 14, 2, -16 },
  { 503, 12, 16, 14, 1, -16 },
  { 527, 10, 16, 14, 2, -16 },
  { 547, 10, 16, 14, 2, -16 },
  { 567, 10, 16, 14, 2, -16 },
  { 587, 10, 16, 14, 2, -16 },
  { 607, 10, 16, 14, 2, -16 },
  { 627, 10, 16, 14, 2, -16 },
  { 647, 10, 16, 14, 2, -16 },
  { 667, 10, 16, 14, 2, -16 },
  { 687, 9, 16, 14, 2, -16 },
  { 705, 11, 16, 14, 2, -16 },
  { 727, 9, 16, 14, 3, -16 },
  { 745, 10, 16, 14, 2, -16 },
  { 765, 10, 16, 14, 2, -16 },
  { 785, 10, 16, 14, 2, -16 },
  { 805, 10, 16, 14, 2, -16 },
  { 825, 10, 19, 14, 2, -16 },
  { 849, 10, 16, 14, 2, -16 },
  { 869, 11, 16, 14, 1, -16 },
  { 891, 12, 16, 14, 1, -16 },
  { 915, 10, 16, 14, 2, -16 },
  { 935, 12, 16, 14, 1, -16 },
  { 959, 12, 16, 14, 1, -16 },
  { 983, 12, 16, 14, 1, -16 },
  { 1007, 12, 16, 14, 1, -16 },
  { 1031, 12, 16, 14, 1, -16 },
  { 1055, 6, 20, 14, 6, -17 },
  { 1070, 9, 20, 14, 2, -17 },
  { 1093, 6, 20, 14, 2, -17 },
  { 1108, 11, 9, 14, 1, -16 },
  { 1121, 11, 1, 14, 1, 3 },
  { 1123, 3, 4, 14, 5, -18 },
  { 1125, 10, 12, 14, 2, -12 },
  { 1140, 9, 17, 14, 3, -17 },
  { 1160, 10, 12, 14, 2, -12 },
  { 1175, 9, 17, 14, 2, -17 },
  { 1195, 10, 12, 14, 2, -12 },
  { 1210, 10, 17, 14, 2, -17 },
  { 1232, 11, 18, 14, 2, -13 },
  { 1257, 8, 17, 14, 3, -17 },
  { 1274, 9, 18, 14, 3, -18 },
  { 1295, 8, 23, 14, 2, -18 },
  { 1318, 10, 17, 14, 3, -17 },
  { 1340, 10, 17, 14, 2, -17 },
  { 1362, 10, 12, 14, 2, -12 },
  { 1377, 8, 12, 14, 3, -12 },
  { 1389, 10, 12, 14, 2, -12 },
  { 1404, 9, 17, 14, 3, -12 },
  { 1424, 9, 17, 14, 2, -12 },
  { 1444, 11, 12, 14, 2, -12 },
  { 1461, 10, 12, 14, 2, -12 },
  { 1476, 11, 16, 14, 1, -16 },
  { 1498, 8, 12, 14, 3, -12 },
  { 1510, 10, 12, 14, 2, -12 },
  { 1525, 12, 12, 14, 1, -12 },
  { 1543, 10, 12, 14, 2, -12 },
  { 1558, 10, 17, 14, 2, -12 },
  { 1580, 10, 12, 14, 2, -12 },
  { 1595, 8, 20, 14, 3, -17 },
  { 1615, 1, 20, 14, 6, -17 },
  { 1618, 8, 20, 14, 3, -17 },
  { 1638, 11, 5, 14, 1, -9 },
};

const GFXfont IBMPlexMono_ExtraLight23pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLight23pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLight23pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _IBMPLEXMONO_EXTRALIGHT23PT7B_H_
