#ifndef _IBMPLEXMONO_EXTRALIGHT26PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHT26PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLight.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLight26pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0xAA, 0x00, 0xF0, 0x99, 0x99, 0x99, 0x90, 0x06, 0x20,
  0x10, 0x80, 0x42, 0x01, 0x08, 0x04, 0x40, 0x11, 0x0F, 0x87, 0xC2, 0x10,
  0x08, 0x40, 0x22, 0x00, 0x88, 0x3E, 0x3E, 0x10, 0x80, 0x42, 0x01, 0x08,
  0x04, 0x40, 0x11, 0x00, 0x84, 0x00, 0x04, 0x00, 0x40, 0x04, 0x01, 0xF8,
  0x64, 0x4C, 0x42, 0x84, 0x18, 0x40, 0x84, 0x0C, 0x40, 0x64, 0x01, 0xE0,
  0x05, 0xC0, 0x42, 0x04, 0x10, 0x41, 0x04, 0x18, 0x41, 0x84, 0x26, 0x46,
  0x1F, 0x80, 0x40, 0x04, 0x00, 0x40, 0x38, 0x05, 0x10, 0x28, 0x21, 0x20,
  0x84, 0x82, 0x22, 0x08, 0x88, 0x24, 0x11, 0x10, 0x38, 0x00, 0x03, 0xC0,
  0x90, 0x84, 0x41, 0x12, 0x04, 0x88, 0x12, 0x20, 0x50, 0x41, 0x81, 0x0A,
  0x03, 0xC0, 0x0F, 0x00, 0x84, 0x08, 0x10, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x02, 0x00, 0x18, 0x3B, 0x21, 0x10, 0x89, 0x06, 0x48, 0x1A, 0x40,
  0x72, 0x01, 0x18, 0x14, 0x61, 0x90, 0xF0, 0x40, 0xFE, 0x04, 0x21, 0x08,
  0x21, 0x04, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x81, 0x04, 0x08,
  0x20, 0x40, 0x81, 0xC0, 0x40, 0x40, 0x80, 0x81, 0x01, 0x02, 0x04, 0x08,
  0x08, 0x10, 0x20, 0x41, 0x02, 0x04, 0x08, 0x20, 0x41, 0x02, 0x08, 0x60,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x08, 0x20, 0xB9, 0x1C, 0x3F, 0x00,
  0x60, 0x05, 0x80, 0x44, 0x02, 0x10, 0x20, 0x42, 0x02, 0x00, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0xFF, 0xF0, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x69, 0x69, 0x00, 0xFE, 0xF0, 0x00,
  0x40, 0x20, 0x08, 0x02, 0x01, 0x00, 0x40, 0x20, 0x08, 0x02, 0x01, 0x00,
  0x40, 0x20, 0x08, 0x02, 0x01, 0x00, 0x40, 0x20, 0x08, 0x02, 0x01, 0x00,
  0x40, 0x20, 0x08, 0x02, 0x00, 0x1F, 0x02, 0x0C, 0x40, 0x64, 0x02, 0x80,
  0x28, 0x01, 0x80, 0x18, 0x01, 0x86, 0x18, 0x61, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x02, 0x40, 0x24, 0x06, 0x30, 0xC1, 0xF0, 0x06, 0x00, 0xA0, 0x12,
  0x02, 0x20, 0xC2, 0x08, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x0F, 0xFF, 0x1F,
  0x02, 0x0C, 0x40, 0x48, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x04, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x0F, 0xFF, 0x1F, 0x0C, 0x11, 0x01, 0x40, 0x20, 0x02, 0x00, 0x80, 0x10,
  0x04, 0x1F, 0x00, 0x30, 0x01, 0x00, 0x10, 0x02, 0x00, 0x60, 0x0C, 0x02,
  0x60, 0xC3, 0xE0, 0x00, 0x40, 0x06, 0x00, 0x50, 0x02, 0x80, 0x24, 0x02,
  0x20, 0x11, 0x01, 0x08, 0x10, 0x41, 0x02, 0x08, 0x10, 0x80, 0x88, 0x04,
  0x7F, 0xFC, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x7F, 0xE8, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0xFC, 0x60, 0xC8, 0x0C, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x60, 0x0E, 0x03, 0x60, 0xC3, 0xE0, 0x03, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x40, 0x10, 0x02, 0x7C, 0x70, 0xD8, 0x0E,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0A, 0x03, 0x20, 0xC3, 0xE0, 0xFF,
  0xF0, 0x06, 0x00, 0xC0, 0x28, 0x04, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00,
  0x20, 0x08, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00,
  0x1F, 0x86, 0x0C, 0x40, 0x28, 0x02, 0x80, 0x28, 0x02, 0x40, 0x22, 0x0C,
  0x1F, 0x07, 0x0C, 0xC0, 0x28, 0x01, 0x80, 0x18, 0x01, 0x80, 0x1C, 0x02,
  0x60, 0x41, 0xF8, 0x1F, 0x03, 0x0C, 0x40, 0x24, 0x02, 0x80, 0x28, 0x01,
  0x80, 0x3C, 0x02, 0x40, 0x23, 0x0E, 0x1F, 0x20, 0x04, 0x00, 0x40, 0x08,
  0x01, 0x80, 0x30, 0x06, 0x01, 0x80, 0xF0, 0x00, 0x00, 0xF0, 0x6C, 0x00,
  0x00, 0x00, 0x06, 0x96, 0x90, 0x00, 0x20, 0x08, 0x06, 0x03, 0x00, 0x80,
  0x60, 0x30, 0x06, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00,
  0x40, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x0C,
  0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x01, 0x00, 0xC0, 0x60,
  0x10, 0x0C, 0x06, 0x01, 0x00, 0x00, 0x1F, 0x84, 0x19, 0x01, 0xA0, 0x18,
  0x02, 0x00, 0x40, 0x08, 0x02, 0x01, 0x80, 0xC0, 0x10, 0x02, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x1F, 0x06, 0x18, 0x81, 0x20,
  0x14, 0x03, 0x07, 0x61, 0x1C, 0x41, 0x88, 0x31, 0x06, 0x20, 0xC4, 0x18,
  0x83, 0x10, 0x63, 0x1C, 0x3D, 0x40, 0x08, 0x00, 0x80, 0x18, 0x00, 0xFC,
  0x03, 0x00, 0x18, 0x01, 0x40, 0x09, 0x00, 0x48, 0x04, 0x40, 0x21, 0x01,
  0x08, 0x10, 0x40, 0x81, 0x04, 0x08, 0x7F, 0xC2, 0x01, 0x10, 0x09, 0x00,
  0x48, 0x01, 0x40, 0x0C, 0x00, 0x40, 0xFF, 0x88, 0x0C, 0x80, 0x68, 0x02,
  0x80, 0x28, 0x02, 0x80, 0x48, 0x0C, 0xFF, 0x88, 0x04, 0x80, 0x28, 0x02,
  0x80, 0x18, 0x01, 0x80, 0x28, 0x02, 0x80, 0x4F, 0xF8, 0x0F, 0x83, 0x04,
  0x60, 0x24, 0x02, 0x40, 0x18, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x36, 0x02, 0x30, 0x40, 0xF8,
  0xFE, 0x10, 0x32, 0x02, 0x40, 0x28, 0x05, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xA0, 0x14, 0x04, 0x81, 0x9F,
  0xC0, 0xFF, 0xE0, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0xFF,
  0xE0, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x3F, 0xF0,
  0xFF, 0xF0, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0xFF,
  0xD0, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x00, 0x0F, 0x06, 0x19, 0x01, 0xA0, 0x18, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x0F, 0xC0, 0x18, 0x03, 0x00, 0x50, 0x0A, 0x01, 0x30,
  0xE3, 0xE4, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0xFF, 0xF0, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x04, 0xFF, 0xE0, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x1F, 0xFC, 0x3F, 0xC0, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x18, 0x05, 0x03,
  0x61, 0x87, 0xC0, 0x80, 0x30, 0x0A, 0x02, 0x40, 0x88, 0x21, 0x08, 0x23,
  0x04, 0xC0, 0x98, 0x14, 0x83, 0x10, 0x41, 0x08, 0x11, 0x02, 0x20, 0x24,
  0x02, 0x80, 0x50, 0x04, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x3F, 0xF0, 0xC0, 0x3C, 0x05, 0xA0, 0x5A, 0x09, 0xA0, 0x99, 0x09,
  0x91, 0x18, 0x91, 0x8A, 0x18, 0x61, 0x84, 0x18, 0x41, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0xC0, 0x34, 0x06, 0x80, 0xC8, 0x19,
  0x03, 0x10, 0x62, 0x0C, 0x21, 0x84, 0x30, 0x46, 0x08, 0xC0, 0x98, 0x13,
  0x01, 0x60, 0x2C, 0x03, 0x80, 0x70, 0x04, 0x1F, 0x02, 0x0C, 0x40, 0x64,
  0x02, 0x80, 0x28, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x02, 0x40, 0x24, 0x06, 0x30, 0xC1, 0xF0, 0xFF, 0x10,
  0x1A, 0x01, 0x40, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x02, 0x80, 0xDF, 0xF2,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x00, 0x1F,
  0x02, 0x0C, 0x40, 0x64, 0x02, 0x80, 0x28, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x02, 0x40, 0x24, 0x06, 0x30,
  0xC1, 0xF0, 0x04, 0x00, 0x40, 0x04, 0x00, 0x3C, 0xFF, 0x10, 0x1A, 0x01,
  0x40, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x02, 0x80, 0xDF, 0xE2, 0x10, 0x43,
  0x08, 0x21, 0x02, 0x20, 0x44, 0x04, 0x80, 0x50, 0x0C, 0x1F, 0x86, 0x04,
  0xC0, 0x28, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x3E, 0x00, 0x1C,
  0x00, 0x20, 0x03, 0x00, 0x10, 0x01, 0x80, 0x18, 0x02, 0x60, 0x61, 0xF8,
  0xFF, 0xFC, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x02, 0x80, 0x50, 0x0A, 0x03, 0x20, 0xC3, 0xF0, 0xC0, 0x0A, 0x00,
  0x50, 0x06, 0x80, 0x22, 0x01, 0x10, 0x08, 0x80, 0x82, 0x04, 0x10, 0x20,
  0x82, 0x02, 0x10, 0x10, 0x80, 0x88, 0x02, 0x40, 0x12, 0x00, 0xA0, 0x03,
  0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x80, 0x14, 0x00, 0xA1,
  0x85, 0x0C, 0x28, 0xA1, 0x45, 0x12, 0x24, 0x91, 0x24, 0x91, 0x24, 0x89,
  0x24, 0x28, 0xA1, 0x46, 0x0A, 0x30, 0x31, 0x81, 0x80, 0xC0, 0x0B, 0x00,
  0x88, 0x04, 0x20, 0x41, 0x04, 0x04, 0x20, 0x12, 0x00, 0xA0, 0x03, 0x00,
  0x18, 0x01, 0x60, 0x19, 0x00, 0x84, 0x08, 0x30, 0xC0, 0x84, 0x02, 0x40,
  0x16, 0x00, 0x40, 0x80, 0x05, 0x00, 0x24, 0x01, 0x08, 0x04, 0x20, 0x20,
  0x40, 0x80, 0x84, 0x02, 0x20, 0x04, 0x80, 0x14, 0x00, 0x30, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x7F,
  0xF8, 0x00, 0x80, 0x04, 0x00, 0x40, 0x04, 0x00, 0x60, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x40, 0x07, 0xFF, 0xC0, 0xFE, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x3F, 0x80,
  0x20, 0x08, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0x80, 0x10, 0x04, 0x00,
  0x80, 0x20, 0x08, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0x80, 0x10, 0x04,
  0x00, 0x80, 0x20, 0x08, 0x01, 0xFC, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x7F, 0x06,
  0x00, 0xA0, 0x09, 0x01, 0x10, 0x10, 0x82, 0x04, 0x40, 0x44, 0x02, 0x80,
  0x28, 0x01, 0xFF, 0xF0, 0xC4, 0x21, 0x3F, 0x06, 0x18, 0x80, 0x80, 0x04,
  0x00, 0x40, 0x04, 0x3F, 0xC4, 0x04, 0x80, 0x48, 0x04, 0x80, 0xC4, 0x14,
  0x3E, 0x70, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x27, 0xC5,
  0x0C, 0x80, 0x50, 0x0A, 0x01, 0x40, 0x18, 0x03, 0x00, 0x60, 0x14, 0x02,
  0x80, 0x54, 0x32, 0x7C, 0x00, 0x1F, 0x18, 0x64, 0x06, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x14, 0x05, 0x82, 0x1F, 0x00, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x47, 0xC9, 0x05, 0x40, 0x70, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x40, 0x6C, 0x14, 0x7C,
  0x80, 0x1F, 0x06, 0x19, 0x01, 0x20, 0x18, 0x03, 0x00, 0x7F, 0xFC, 0x00,
  0x80, 0x08, 0x01, 0x00, 0x98, 0x21, 0xF8, 0x07, 0xF0, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0xFF, 0xF0, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0xFF, 0xE0,
  0x00, 0x71, 0xF8, 0x30, 0x82, 0x04, 0x40, 0x44, 0x02, 0x40, 0x42, 0x04,
  0x10, 0xC1, 0xF0, 0x60, 0x04, 0x00, 0x20, 0x03, 0xFE, 0x40, 0x18, 0x01,
  0x80, 0x14, 0x03, 0x3F, 0xC0, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x09, 0xF2, 0x86, 0xC0, 0xA0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x04, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x83, 0xFF, 0x80, 0x00, 0xC0, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x09, 0xFE, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x68, 0x08, 0x81, 0x08, 0x20, 0x8C, 0x09, 0x80, 0xA4, 0x0C, 0x20, 0x81,
  0x08, 0x08, 0x80, 0xC8, 0x04, 0x80, 0x30, 0xFC, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x83, 0xFF, 0x80, 0xB8, 0xEC,
  0x72, 0x84, 0x18, 0x41, 0x84, 0x18, 0x41, 0x84, 0x18, 0x41, 0x84, 0x18,
  0x41, 0x84, 0x18, 0x41, 0x84, 0x10, 0x9F, 0x28, 0x6C, 0x0A, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x40, 0x1F,
  0x04, 0x19, 0x01, 0xA0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x28,
  0x05, 0x01, 0x90, 0x61, 0xF0, 0x9F, 0x14, 0x32, 0x01, 0x40, 0x28, 0x05,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x50, 0x0A, 0x01, 0x50, 0xC9, 0xF1, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x00, 0x1F, 0x24, 0x15, 0x01, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x05, 0x01, 0xB0, 0x51, 0xF2,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0xF8, 0xF0, 0xB0, 0x0C, 0x00,
  0x40, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0xFF, 0xE0, 0x1F, 0x82, 0x04, 0x40, 0x24, 0x00, 0x40, 0x03, 0x00,
  0x0F, 0xC0, 0x06, 0x00, 0x20, 0x03, 0x80, 0x26, 0x06, 0x1F, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x7F, 0xFC, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x3F, 0xC0, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x28, 0x33, 0xE8, 0x80, 0x28, 0x05, 0x01,
  0x10, 0x22, 0x04, 0x41, 0x04, 0x20, 0x84, 0x11, 0x01, 0x20, 0x28, 0x03,
  0x00, 0x60, 0x83, 0x06, 0x0C, 0x28, 0x50, 0xA1, 0x42, 0x44, 0x89, 0x12,
  0x24, 0x89, 0x12, 0x24, 0x48, 0x50, 0xA1, 0x43, 0x05, 0x0C, 0x14, 0x30,
  0x20, 0xC0, 0x2C, 0x08, 0x82, 0x08, 0x40, 0x90, 0x0C, 0x01, 0x00, 0x50,
  0x09, 0x02, 0x10, 0x83, 0x20, 0x2C, 0x02, 0x80, 0x34, 0x02, 0x40, 0x24,
  0x04, 0x20, 0x42, 0x08, 0x10, 0x81, 0x10, 0x09, 0x00, 0x90, 0x0A, 0x00,
  0x60, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x0F, 0x00, 0xFF, 0xC0,
  0x20, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x30, 0x08, 0x04, 0x02,
  0x00, 0xFF, 0xC0, 0x0F, 0xC2, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0xC0,
  0x10, 0x02, 0x00, 0x80, 0x43, 0xE0, 0x0C, 0x00, 0x80, 0x20, 0x10, 0x04,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFC, 0x01, 0x00, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x40, 0x10, 0x04,
  0x01, 0x80, 0x1F, 0x0C, 0x04, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x43, 0xF0, 0x38, 0x09, 0x30, 0x50, 0x82, 0x83,
  0x28, 0x0E, 0x00,
};

const GFXglyph IBMPlexMono_ExtraLight26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 2, 18, 16, 7, -18 },
  { 6, 4, 7, 16, 6, -19 },
  { 10, 14, 18, 16, 1, -18 },
  { 42, 12, 24, 16, 2, -21 },
  { 78, 14, 18, 16, 1, -18 },
  { 110, 13, 18, 16, 1, -18 },
  { 140, 1, 7, 16, 7, -19 },
  { 141, 6, 24, 16, 6, -20 },
  { 159, 7, 24, 16, 3, -20 },
  { 180, 13, 13, 16, 1, -14 },
  { 202, 12, 13, 16, 2, -14 },
  { 222, 3, 6, 16, 6, -2 },
  { 225, 7, 1, 16, 4, -8 },
  { 226, 2, 2, 16, 7, -2 },
  { 227, 10, 24, 16, 3, -20 },
  { 257, 12, 18, 16, 2, -18 },
  { 284, 12, 18, 16, 2, -18 },
  { 311, 12, 18, 16, 2, -18 },
  { 338, 11, 18, 16, 2, -18 },
  { 363, 13, 18, 16, 1, -18 },
  { 393, 11, 18, 16, 2, -18 },
  { 418, 11, 18, 16, 2, -18 },
  { 443, 11, 18, 16, 2, -18 },
  { 468, 12, 18, 16, 2, -18 },
  { 495, 12, 18, 16, 2, -18 },
  { 522, 2, 14, 16, 7, -14 },
  { 526, 3, 18, 16, 6, -14 },
  { 533, 11, 14, 16, 2, -15 },
  { 553, 12, 6, 16, 2, -11 },
  { 562, 11, 14, 16, 2, -15 },
  { 582, 11, 18, 16, 2, -18 },
  { 607, 11, 21, 16, 2, -18 },
  { 636, 13, 18, 16, 1, -18 },
  { 666, 12, 18, 16, 2, -18 },
  { 693, 12, 18, 16, 2, -18 },
  { 720, 11, 18, 16, 3, -18 },
  { 745, 10, 18, 16, 3, -18 },
  { 768, 11, 18, 16, 3, -18 },
  { 793, 11, 18, 16, 2, -18 },
  { 818, 11, 18, 16, 2, -18 },
  { 843, 11, 18, 16, 2, -18 },
  { 868, 10, 18, 16, 2, -18 },
  { 891, 11, 18, 16, 3, -18 },
  { 916, 10, 18, 16, 4, -18 },
  { 939, 12, 18, 16, 2, -18 },
  { 966, 11, 18, 16, 2, -18 },
  { 991, 12, 18, 16, 2, -18 },
  { 1018, 11, 18, 16, 3, -18 },
  { 1043, 12, 22, 16, 2, -18 },
  { 1076, 11, 18, 16, 3, -18 },
  { 1101, 12, 18, 16, 2, -18 },
  { 1128, 14, 18, 16, 1, -18 },
  { 1160, 11, 18, 16, 2, -18 },
  { 1185, 13, 18, 16, 1, -18 },
  { 1215, 13, 18, 16, 1, -18 },
  { 1245, 13, 18, 16, 1, -18 },
  { 1275, 14, 18, 16, 1, -18 },
  { 1307, 13, 18, 16, 1, -18 },
  { 1337, 6, 24, 16, 7, -20 },
  { 1355, 10, 24, 16, 3, -20 },
  { 1385, 6, 24, 16, 3, -20 },
  { 1403, 12, 10, 16, 2, -18 },
  { 1418, 12, 1, 16, 2, 3 },
  { 1420, 4, 4, 16, 5, -19 },
  { 1422, 12, 13, 16, 2, -13 },
  { 1442, 11, 19, 16, 3, -19 },
  { 1469, 10, 13, 16, 3, -13 },
  { 1486, 11, 19, 16, 2, -19 },
  { 1513, 11, 13, 16, 2, -13 },
  { 1531, 12, 19, 16, 2, -19 },
  { 1560, 12, 19, 16, 2, -14 },
  { 1589, 10, 19, 16, 3, -19 },
  { 1613, 11, 19, 16, 3, -19 },
  { 1640, 10, 24, 16, 2, -19 },
  { 1670, 12, 19, 16, 3, -19 },
  { 1699, 11, 19, 16, 2, -19 },
  { 1726, 12, 13, 16, 2, -13 },
  { 1746, 10, 13, 16, 3, -13 },
  { 1763, 11, 13, 16, 2, -13 },
  { 1781, 11, 18, 16, 3, -13 },
  { 1806, 11, 18, 16, 2, -13 },
  { 1831, 12, 13, 16, 2, -13 },
  { 1851, 12, 13, 16, 2, -13 },
  { 1871, 13, 18, 16, 1, -18 },
  { 1901, 9, 13, 16, 3, -13 },
  { 1916, 11, 13, 16, 2, -13 },
  { 1934, 14, 13, 16, 1, -13 },
  { 1957, 11, 13, 16, 2, -13 },
  { 1975, 12, 18, 16, 2, -13 },
  { 2002, 10, 13, 16, 3, -13 },
  { 2019, 10, 24, 16, 3, -20 },
  { 2049, 1, 24, 16, 7, -20 },
  { 2052, 10, 24, 16, 3, -20 },
  { 2082, 13, 5, 16, 1, -10 },
};

const GFXfont IBMPlexMono_ExtraLight26pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLight26pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLight26pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _IBMPLEXMONO_EXTRALIGHT26PT7B_H_
