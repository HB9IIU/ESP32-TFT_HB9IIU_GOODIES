#ifndef _IBMPLEXMONO_EXTRALIGHT14PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHT14PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLight.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLight14pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0x40, 0xFF, 0x16, 0x14, 0x14, 0x67, 0x24, 0x24, 0xE7, 0x28,
  0x28, 0x48, 0x11, 0xE9, 0x64, 0x91, 0xC1, 0xC5, 0x16, 0x57, 0x84, 0x71,
  0x92, 0x92, 0x94, 0x70, 0x06, 0x29, 0x51, 0x49, 0x86, 0x71, 0x12, 0x04,
  0x04, 0x74, 0xA6, 0x44, 0x8D, 0xEC, 0xF0, 0x34, 0x48, 0x88, 0x88, 0x88,
  0x44, 0x30, 0x89, 0x12, 0x49, 0x25, 0x28, 0x20, 0x42, 0x8B, 0xE3, 0x09,
  0x21, 0x00, 0x20, 0x40, 0x87, 0xF2, 0x04, 0x08, 0x00, 0x68, 0xF0, 0x80,
  0x04, 0x20, 0x82, 0x10, 0x42, 0x08, 0x21, 0x04, 0x20, 0x80, 0x79, 0x18,
  0x61, 0x86, 0x58, 0x61, 0x45, 0xE0, 0x10, 0x61, 0x44, 0x81, 0x02, 0x04,
  0x08, 0x11, 0xFC, 0x3B, 0x18, 0x41, 0x04, 0x21, 0x08, 0xC3, 0xF0, 0x3B,
  0x10, 0x42, 0x30, 0x30, 0x41, 0x85, 0xE0, 0x08, 0x30, 0xA1, 0x44, 0x91,
  0x22, 0x7F, 0x08, 0x10, 0x7E, 0x08, 0x2E, 0xC4, 0x10, 0x41, 0x85, 0xE0,
  0x18, 0x84, 0x20, 0xBB, 0x18, 0x61, 0x85, 0xE0, 0xFE, 0x18, 0x82, 0x10,
  0x41, 0x08, 0x21, 0x00, 0x7A, 0x18, 0x61, 0x7B, 0x38, 0x61, 0x85, 0xE0,
  0x7A, 0x18, 0x61, 0x8D, 0xF0, 0x42, 0x10, 0x80, 0x82, 0x40, 0x06, 0x80,
  0x04, 0x23, 0x30, 0x81, 0x81, 0x81, 0xFE, 0x03, 0xF8, 0x81, 0x81, 0x03,
  0x04, 0x62, 0x30, 0x39, 0x18, 0x41, 0x08, 0xC2, 0x00, 0x00, 0xC0, 0x39,
  0x18, 0x67, 0xA6, 0x9A, 0x69, 0x9E, 0x04, 0x0F, 0x10, 0x60, 0xC2, 0x44,
  0x89, 0x1F, 0x42, 0x85, 0x04, 0xFA, 0x18, 0x61, 0xFA, 0x18, 0x61, 0x87,
  0xE0, 0x39, 0x18, 0x60, 0x82, 0x08, 0x21, 0x44, 0xE0, 0xFA, 0x18, 0x61,
  0x86, 0x18, 0x61, 0x87, 0xE0, 0xFE, 0x08, 0x20, 0xFE, 0x08, 0x20, 0x83,
  0xF0, 0xFE, 0x08, 0x20, 0xFE, 0x08, 0x20, 0x82, 0x00, 0x39, 0x18, 0x60,
  0x82, 0x78, 0x61, 0x44, 0xF0, 0x86, 0x18, 0x61, 0xFE, 0x18, 0x61, 0x86,
  0x10, 0xFC, 0x82, 0x08, 0x20, 0x82, 0x08, 0x23, 0xF0, 0x7C, 0x10, 0x41,
  0x04, 0x10, 0x61, 0x89, 0xE0, 0x87, 0x12, 0x24, 0x8A, 0x1A, 0x22, 0x44,
  0x85, 0x0C, 0x84, 0x21, 0x08, 0x42, 0x10, 0x87, 0xC0, 0x86, 0x1C, 0xF3,
  0xB6, 0x5A, 0x61, 0x86, 0x10, 0x87, 0x1C, 0x69, 0xA6, 0x59, 0x63, 0x8E,
  0x10, 0x79, 0x18, 0x61, 0x86, 0x18, 0x61, 0x45, 0xE0, 0xFA, 0x18, 0x61,
  0x87, 0xE8, 0x20, 0x82, 0x00, 0x79, 0x18, 0x61, 0x86, 0x18, 0x61, 0x45,
  0xE2, 0x07, 0xFA, 0x18, 0x61, 0x87, 0xE9, 0x22, 0x8A, 0x10, 0x7A, 0x18,
  0x20, 0x70, 0x30, 0x41, 0x85, 0xE0, 0xFE, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x85, 0xE0, 0x83,
  0x0A, 0x14, 0x24, 0x89, 0x12, 0x18, 0x30, 0x20, 0x83, 0x06, 0x14, 0xAB,
  0x56, 0xB5, 0x66, 0x44, 0x88, 0x87, 0x09, 0x21, 0x81, 0x02, 0x1A, 0x24,
  0x85, 0x0C, 0x81, 0x42, 0x24, 0x24, 0x18, 0x10, 0x10, 0x10, 0x10, 0x10,
  0xFC, 0x08, 0x20, 0x41, 0x04, 0x10, 0x40, 0x81, 0xFC, 0xF2, 0x49, 0x24,
  0x92, 0x4E, 0x82, 0x04, 0x10, 0x20, 0x82, 0x04, 0x10, 0x20, 0x82, 0x04,
  0xF1, 0x11, 0x11, 0x11, 0x11, 0x11, 0xF0, 0x10, 0x61, 0x24, 0x28, 0x60,
  0xFE, 0xB0, 0x79, 0x10, 0x23, 0xC8, 0x91, 0x1D, 0x80, 0x84, 0x21, 0xE8,
  0xC6, 0x31, 0x8F, 0x80, 0x39, 0x18, 0x20, 0x81, 0x13, 0x80, 0x04, 0x10,
  0x5D, 0x8E, 0x18, 0x61, 0x85, 0xF0, 0x7A, 0x18, 0x7F, 0x82, 0x07, 0xC0,
  0x1E, 0x40, 0x87, 0xF2, 0x04, 0x08, 0x10, 0x21, 0xF8, 0x06, 0x71, 0x14,
  0x24, 0x47, 0x30, 0x3E, 0x83, 0x05, 0xF0, 0x84, 0x21, 0xE8, 0xC6, 0x31,
  0x8C, 0x40, 0x20, 0x00, 0x38, 0x20, 0x82, 0x08, 0x23, 0xF0, 0x08, 0x01,
  0xF0, 0x84, 0x21, 0x08, 0x42, 0x17, 0x80, 0x82, 0x08, 0x23, 0x92, 0x8E,
  0x24, 0x8A, 0x30, 0xE0, 0x82, 0x08, 0x20, 0x82, 0x08, 0x23, 0xF0, 0xEE,
  0x5A, 0x69, 0xA6, 0x9A, 0x40, 0xF4, 0x63, 0x18, 0xC6, 0x20, 0x7A, 0x18,
  0x61, 0x86, 0x17, 0x80, 0xF4, 0x63, 0x18, 0xC7, 0xD0, 0x84, 0x00, 0x76,
  0x38, 0x61, 0x86, 0x17, 0xC1, 0x04, 0x10, 0xEE, 0x20, 0x81, 0x02, 0x04,
  0x3F, 0x00, 0x7A, 0x18, 0x1F, 0x06, 0x17, 0x80, 0x20, 0x82, 0x3F, 0x20,
  0x82, 0x08, 0x20, 0xF0, 0x8C, 0x63, 0x18, 0xC7, 0xE0, 0x86, 0x14, 0x92,
  0x50, 0xC1, 0x00, 0x89, 0x89, 0x9A, 0x6A, 0x66, 0x66, 0x22, 0x85, 0x23,
  0x04, 0x31, 0x28, 0x40, 0x86, 0x14, 0x92, 0x50, 0xC1, 0x08, 0x23, 0x00,
  0x7C, 0x21, 0x08, 0x42, 0x0F, 0xC0, 0x3A, 0x10, 0x82, 0x13, 0x04, 0x22,
  0x10, 0x83, 0x80, 0xFF, 0xF8, 0xE1, 0x08, 0x84, 0x20, 0xEC, 0x42, 0x08,
  0x4E, 0x00, 0x63, 0x2A, 0x30,
};

const GFXglyph IBMPlexMono_ExtraLight14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 1, 10, 8, 4, -10 },
  { 3, 2, 4, 8, 3, -10 },
  { 4, 8, 10, 8, 0, -10 },
  { 14, 6, 12, 8, 1, -11 },
  { 23, 8, 10, 8, 0, -10 },
  { 33, 7, 10, 8, 1, -10 },
  { 42, 1, 4, 8, 4, -10 },
  { 43, 4, 13, 8, 3, -11 },
  { 50, 3, 13, 8, 2, -11 },
  { 55, 7, 7, 8, 1, -8 },
  { 62, 7, 7, 8, 1, -8 },
  { 69, 2, 3, 8, 3, -1 },
  { 70, 4, 1, 8, 2, -5 },
  { 71, 1, 1, 8, 4, -1 },
  { 72, 6, 13, 8, 1, -11 },
  { 82, 6, 10, 8, 1, -10 },
  { 90, 7, 10, 8, 1, -10 },
  { 99, 6, 10, 8, 1, -10 },
  { 107, 6, 10, 8, 1, -10 },
  { 115, 7, 10, 8, 1, -10 },
  { 124, 6, 10, 8, 1, -10 },
  { 132, 6, 10, 8, 1, -10 },
  { 140, 6, 10, 8, 1, -10 },
  { 148, 6, 10, 8, 1, -10 },
  { 156, 6, 10, 8, 1, -10 },
  { 164, 1, 7, 8, 4, -7 },
  { 165, 2, 9, 8, 3, -7 },
  { 168, 6, 8, 8, 1, -8 },
  { 174, 7, 3, 8, 1, -6 },
  { 177, 6, 8, 8, 1, -8 },
  { 183, 6, 10, 8, 1, -10 },
  { 191, 6, 12, 8, 1, -10 },
  { 200, 7, 10, 8, 1, -10 },
  { 209, 6, 10, 8, 1, -10 },
  { 217, 6, 10, 8, 1, -10 },
  { 225, 6, 10, 8, 1, -10 },
  { 233, 6, 10, 8, 1, -10 },
  { 241, 6, 10, 8, 1, -10 },
  { 249, 6, 10, 8, 1, -10 },
  { 257, 6, 10, 8, 1, -10 },
  { 265, 6, 10, 8, 1, -10 },
  { 273, 6, 10, 8, 1, -10 },
  { 281, 7, 10, 8, 1, -10 },
  { 290, 5, 10, 8, 2, -10 },
  { 297, 6, 10, 8, 1, -10 },
  { 305, 6, 10, 8, 1, -10 },
  { 313, 6, 10, 8, 1, -10 },
  { 321, 6, 10, 8, 1, -10 },
  { 329, 6, 12, 8, 1, -10 },
  { 338, 6, 10, 8, 1, -10 },
  { 346, 6, 10, 8, 1, -10 },
  { 354, 7, 10, 8, 1, -10 },
  { 363, 6, 10, 8, 1, -10 },
  { 371, 7, 10, 8, 1, -10 },
  { 380, 7, 10, 8, 1, -10 },
  { 389, 7, 10, 8, 1, -10 },
  { 398, 8, 10, 8, 0, -10 },
  { 408, 7, 10, 8, 1, -10 },
  { 417, 3, 13, 8, 4, -11 },
  { 422, 6, 13, 8, 1, -11 },
  { 432, 4, 13, 8, 1, -11 },
  { 439, 7, 5, 8, 1, -10 },
  { 444, 7, 1, 8, 1, 1 },
  { 445, 2, 2, 8, 3, -11 },
  { 446, 7, 7, 8, 1, -7 },
  { 453, 5, 10, 8, 2, -10 },
  { 460, 6, 7, 8, 1, -7 },
  { 466, 6, 10, 8, 1, -10 },
  { 474, 6, 7, 8, 1, -7 },
  { 480, 7, 10, 8, 1, -10 },
  { 489, 7, 11, 8, 1, -8 },
  { 499, 5, 10, 8, 2, -10 },
  { 506, 6, 10, 8, 2, -10 },
  { 514, 5, 13, 8, 1, -10 },
  { 523, 6, 10, 8, 2, -10 },
  { 531, 6, 10, 8, 1, -10 },
  { 539, 6, 7, 8, 1, -7 },
  { 545, 5, 7, 8, 2, -7 },
  { 550, 6, 7, 8, 1, -7 },
  { 556, 5, 10, 8, 2, -7 },
  { 563, 6, 10, 8, 1, -7 },
  { 571, 7, 7, 8, 1, -7 },
  { 578, 6, 7, 8, 1, -7 },
  { 584, 6, 10, 8, 1, -10 },
  { 592, 5, 7, 8, 2, -7 },
  { 597, 6, 7, 8, 1, -7 },
  { 603, 8, 7, 8, 0, -7 },
  { 610, 6, 7, 8, 1, -7 },
  { 616, 6, 10, 8, 1, -7 },
  { 624, 6, 7, 8, 1, -7 },
  { 630, 5, 13, 8, 2, -11 },
  { 639, 1, 13, 8, 4, -11 },
  { 641, 5, 13, 8, 2, -11 },
  { 650, 7, 3, 8, 1, -6 },
};

const GFXfont IBMPlexMono_ExtraLight14pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLight14pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLight14pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _IBMPLEXMONO_EXTRALIGHT14PT7B_H_
