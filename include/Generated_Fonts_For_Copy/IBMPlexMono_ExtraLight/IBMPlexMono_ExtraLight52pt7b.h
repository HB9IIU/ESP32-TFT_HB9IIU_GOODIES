#ifndef _IBMPLEXMONO_EXTRALIGHT52PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHT52PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLight.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLight52pt7bBitmaps[] PROGMEM = {
  0x00, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x21,
  0x08, 0x42, 0x10, 0x84, 0x21, 0x00, 0x00, 0x00, 0x00, 0x77, 0xFE, 0xE0,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x18, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x60, 0x30, 0x00, 0x03,
  0x01, 0x80, 0x00, 0x10, 0x0C, 0x00, 0x00, 0x80, 0x60, 0x00, 0x0C, 0x02,
  0x00, 0x00, 0x60, 0x30, 0x00, 0x03, 0x01, 0x80, 0x00, 0x18, 0x0C, 0x00,
  0x00, 0x80, 0x60, 0x00, 0x0C, 0x02, 0x00, 0x00, 0x60, 0x10, 0x03, 0xFF,
  0x01, 0xFF, 0x9F, 0xF8, 0x0F, 0xFC, 0x00, 0xC0, 0x60, 0x00, 0x04, 0x03,
  0x00, 0x00, 0x60, 0x10, 0x00, 0x03, 0x01, 0x80, 0x00, 0x18, 0x0C, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x04, 0x03, 0x00, 0x00, 0x60, 0x10, 0x03, 0xFF,
  0x00, 0xFF, 0x9F, 0xF8, 0x0F, 0xFC, 0x00, 0xC0, 0x60, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x20, 0x18, 0x00, 0x03, 0x00, 0x80, 0x00, 0x18, 0x0C, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x06, 0x03, 0x00, 0x00, 0x20, 0x18, 0x00, 0x01,
  0x00, 0xC0, 0x00, 0x18, 0x04, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFF, 0xC0,
  0x1F, 0x18, 0xF0, 0x1C, 0x0C, 0x1C, 0x1C, 0x06, 0x03, 0x0C, 0x03, 0x00,
  0xC6, 0x01, 0x80, 0x46, 0x00, 0xC0, 0x03, 0x00, 0x60, 0x01, 0x80, 0x30,
  0x00, 0xC0, 0x18, 0x00, 0x60, 0x0C, 0x00, 0x18, 0x06, 0x00, 0x0C, 0x03,
  0x00, 0x07, 0x01, 0x80, 0x01, 0xC0, 0xC0, 0x00, 0x78, 0x60, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x06, 0x3E, 0x00,
  0x03, 0x03, 0x80, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0x30, 0x00, 0x60, 0x18,
  0x00, 0x30, 0x04, 0x00, 0x18, 0x03, 0x00, 0x0C, 0x01, 0x80, 0x06, 0x00,
  0xC0, 0x03, 0x00, 0x60, 0x01, 0x80, 0x6C, 0x00, 0xC0, 0x33, 0x00, 0x60,
  0x18, 0xE0, 0x30, 0x18, 0x38, 0x18, 0x38, 0x0F, 0x8C, 0x78, 0x01, 0xFF,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0xCF, 0x0E, 0x00, 0x0C, 0x60, 0x18, 0x00, 0x46, 0x00,
  0x60, 0x06, 0x30, 0x03, 0x00, 0x61, 0x00, 0x18, 0x03, 0x08, 0x00, 0x40,
  0x30, 0x40, 0x02, 0x01, 0x82, 0x00, 0x10, 0x18, 0x10, 0x00, 0x80, 0x80,
  0x80, 0x0C, 0x0C, 0x06, 0x00, 0x60, 0xC0, 0x30, 0x03, 0x06, 0x00, 0xC0,
  0x30, 0x60, 0x07, 0x87, 0x02, 0x00, 0x1F, 0xF0, 0x30, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x30, 0x3F, 0xE0, 0x01, 0x03, 0x83, 0x80, 0x18, 0x30, 0x0C, 0x00,
  0x81, 0x80, 0x30, 0x0C, 0x18, 0x01, 0x80, 0xC0, 0xC0, 0x04, 0x06, 0x06,
  0x00, 0x30, 0x60, 0x30, 0x01, 0x82, 0x01, 0x80, 0x0C, 0x30, 0x0C, 0x00,
  0x61, 0x00, 0x60, 0x02, 0x18, 0x03, 0x00, 0x31, 0x80, 0x0C, 0x01, 0x8C,
  0x00, 0x60, 0x18, 0xC0, 0x01, 0xC1, 0xC4, 0x00, 0x07, 0xFC, 0x40, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0E, 0x07, 0x00,
  0x03, 0x00, 0x70, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0x8E, 0x38, 0x03, 0xF1, 0x83, 0x00,
  0x40, 0x60, 0x30, 0x18, 0x18, 0x03, 0x03, 0x03, 0x00, 0x70, 0x60, 0xC0,
  0x07, 0x0C, 0x18, 0x00, 0x71, 0x83, 0x00, 0x06, 0x30, 0x60, 0x00, 0x64,
  0x0C, 0x00, 0x06, 0x81, 0x80, 0x00, 0x70, 0x30, 0x00, 0x06, 0x06, 0x00,
  0x01, 0xE0, 0x60, 0x00, 0x6E, 0x0E, 0x00, 0x1C, 0xE0, 0xE0, 0x07, 0x0C,
  0x0F, 0x03, 0xC0, 0xC0, 0xFF, 0xE0, 0x0C, 0x07, 0xF0, 0x00, 0x40, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x38, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x18, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x08, 0x00,
  0x60, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xE0, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00,
  0xC0, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x60, 0x02, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00,
  0x40, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x02, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04,
  0x00, 0x0C, 0x00, 0x80, 0x1B, 0xF0, 0x10, 0x1F, 0x87, 0xC2, 0x1F, 0x80,
  0x1F, 0x5F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xD8,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x06, 0x30, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x60, 0x30, 0x00, 0x0C, 0x03, 0x00, 0x03, 0x00, 0x60, 0x00, 0xC0, 0x06,
  0x00, 0x38, 0x00, 0x60, 0x06, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x20, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x3C, 0xE3, 0x8E,
  0x71, 0xC7, 0x18, 0x61, 0x8C, 0x30, 0xC2, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x77, 0xFE, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00,
  0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08,
  0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF,
  0xE0, 0x01, 0xE0, 0x3C, 0x01, 0xC0, 0x07, 0x00, 0xC0, 0x01, 0xC0, 0xC0,
  0x00, 0x60, 0x60, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x30,
  0x00, 0x01, 0x98, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x66, 0x00, 0x00, 0x33,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x03, 0x60, 0x00, 0x01,
  0xF0, 0x0E, 0x00, 0xF8, 0x07, 0x00, 0x7C, 0x03, 0x80, 0x3E, 0x01, 0xC0,
  0x1B, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x03, 0x60, 0x00,
  0x03, 0x30, 0x00, 0x01, 0x98, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x31, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x18,
  0x00, 0x0C, 0x06, 0x00, 0x0E, 0x03, 0x80, 0x0E, 0x00, 0xF0, 0x1E, 0x00,
  0x1F, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3B, 0x00, 0x00, 0x39, 0x80, 0x00, 0x38, 0xC0, 0x00, 0x38, 0x60,
  0x00, 0x38, 0x30, 0x00, 0x78, 0x18, 0x00, 0x78, 0x0C, 0x00, 0x78, 0x06,
  0x00, 0x10, 0x03, 0x00, 0x10, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x1F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF0, 0x00,
  0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x3C, 0x07, 0x80, 0xE0, 0x03, 0x83, 0x80,
  0x03, 0x0E, 0x00, 0x07, 0x18, 0x00, 0x06, 0x30, 0x00, 0x0C, 0xC0, 0x00,
  0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xFF, 0x80, 0x1C, 0x07, 0x80, 0xE0, 0x03, 0x81, 0x80, 0x03,
  0x86, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x03,
  0xFE, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x20, 0x00, 0x06, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x30,
  0xE0, 0x01, 0xC0, 0x78, 0x0F, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x19, 0x80, 0x00, 0x02, 0x30, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x83, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x18, 0x0C, 0x00, 0x02, 0x01, 0x80, 0x00, 0xC0, 0x30, 0x00,
  0x30, 0x06, 0x00, 0x04, 0x00, 0xC0, 0x01, 0x80, 0x18, 0x00, 0x60, 0x03,
  0x00, 0x08, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0xC0, 0x01, 0x80, 0x10,
  0x00, 0x30, 0x06, 0x00, 0x06, 0x01, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x18,
  0x08, 0x00, 0x03, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x60, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x3F, 0xC0, 0x19, 0xFF, 0xE0,
  0x37, 0x01, 0xE0, 0x58, 0x00, 0xE0, 0xE0, 0x00, 0xE0, 0x80, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x90, 0x00, 0x03, 0x70, 0x00, 0x0C, 0x70, 0x00,
  0x38, 0x70, 0x00, 0xE0, 0x7C, 0x07, 0x80, 0x3F, 0xFE, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x1F, 0xC0, 0x19, 0xFF, 0xE0, 0x67,
  0x01, 0xE0, 0xD8, 0x00, 0xE1, 0xE0, 0x00, 0xE2, 0x80, 0x00, 0xEE, 0x00,
  0x00, 0xDC, 0x00, 0x01, 0xB0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x6C, 0x00, 0x01, 0x98, 0x00, 0x03, 0x18, 0x00, 0x0C, 0x38, 0x00, 0x38,
  0x38, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0x3F, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0xD8, 0x00, 0x03, 0x30, 0x00, 0x06, 0x60, 0x00, 0x18, 0xC0,
  0x00, 0x31, 0x80, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x07,
  0xFF, 0xC0, 0x0F, 0x01, 0xF0, 0x1C, 0x00, 0x78, 0x30, 0x00, 0x18, 0x70,
  0x00, 0x1C, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0x60,
  0x00, 0x0C, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0x30,
  0x00, 0x1C, 0x30, 0x00, 0x18, 0x1C, 0x00, 0x30, 0x0F, 0x01, 0xE0, 0x03,
  0xFF, 0x80, 0x03, 0xFF, 0x80, 0x0F, 0x01, 0xE0, 0x38, 0x00, 0x38, 0x30,
  0x00, 0x1C, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0,
  0x00, 0x02, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0x60, 0x00, 0x0E, 0x70,
  0x00, 0x1C, 0x38, 0x00, 0x38, 0x1F, 0x00, 0xF0, 0x07, 0xFF, 0xC0, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x3C, 0x07, 0x80, 0xE0,
  0x03, 0x83, 0x80, 0x01, 0x86, 0x00, 0x03, 0x98, 0x00, 0x03, 0x30, 0x00,
  0x06, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xD8, 0x00, 0x01, 0xB0, 0x00, 0x07,
  0x60, 0x00, 0x0E, 0x60, 0x00, 0x3C, 0xE0, 0x00, 0x58, 0xE0, 0x03, 0x60,
  0xF0, 0x1C, 0xC0, 0xFF, 0xF1, 0x80, 0x3F, 0x86, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x77, 0xFE, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0xFF, 0xDC, 0x39, 0xF7, 0xCE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xCE,
  0x38, 0xE7, 0x1C, 0x71, 0x86, 0x18, 0xC3, 0x0C, 0x20, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xFC, 0x07, 0x80,
  0xF0, 0x70, 0x01, 0xC3, 0x00, 0x07, 0x30, 0x00, 0x19, 0x80, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x1C, 0x00, 0x1F, 0x80, 0x00, 0xE0, 0x00, 0x04, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFE,
  0x00, 0x78, 0x1E, 0x03, 0x80, 0x1C, 0x1C, 0x00, 0x30, 0x60, 0x00, 0x63,
  0x00, 0x01, 0x8C, 0x00, 0x02, 0x30, 0x00, 0x0C, 0x80, 0x00, 0x36, 0x00,
  0x00, 0xD8, 0x03, 0xE3, 0x60, 0x3F, 0xED, 0x81, 0xE0, 0xB4, 0x06, 0x01,
  0xD0, 0x30, 0x03, 0x40, 0xC0, 0x0D, 0x03, 0x00, 0x3C, 0x08, 0x00, 0xF0,
  0x20, 0x03, 0xC1, 0x80, 0x0F, 0x06, 0x00, 0x3C, 0x18, 0x00, 0xF0, 0x20,
  0x03, 0xC0, 0x80, 0x0D, 0x02, 0x00, 0x34, 0x0C, 0x00, 0xD0, 0x30, 0x03,
  0x40, 0x60, 0x1D, 0x81, 0xC0, 0xF6, 0x03, 0xFE, 0xD8, 0x07, 0xF3, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x2C, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x01, 0xB0, 0x00, 0x00,
  0x23, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x20, 0xC0,
  0x00, 0x0C, 0x18, 0x00, 0x01, 0x83, 0x00, 0x00, 0x20, 0x30, 0x00, 0x0C,
  0x06, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x20, 0x0C, 0x00, 0x0C, 0x01, 0x80,
  0x01, 0x80, 0x30, 0x00, 0x30, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x0C, 0x00, 0x18, 0x01, 0x80, 0x03, 0x00,
  0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0x80, 0x00, 0xC0, 0x30, 0x00,
  0x1C, 0x0C, 0x00, 0x01, 0x81, 0x80, 0x00, 0x30, 0x30, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x61, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0x19, 0x80, 0x00, 0x03, 0x70, 0x00, 0x00, 0x30, 0xFF, 0xFE, 0x03, 0xFF,
  0xFE, 0x0C, 0x00, 0x1C, 0x30, 0x00, 0x38, 0xC0, 0x00, 0x73, 0x00, 0x00,
  0xCC, 0x00, 0x03, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x6C,
  0x00, 0x01, 0xB0, 0x00, 0x0C, 0xC0, 0x00, 0x33, 0x00, 0x00, 0xCC, 0x00,
  0x06, 0x30, 0x00, 0x38, 0xC0, 0x01, 0xC3, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC,
  0x30, 0x00, 0x38, 0xC0, 0x00, 0x33, 0x00, 0x00, 0x6C, 0x00, 0x01, 0xB0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xB0, 0x00, 0x06,
  0xC0, 0x00, 0x33, 0x00, 0x03, 0xCF, 0xFF, 0xFC, 0x3F, 0xFF, 0xC0, 0x00,
  0x7F, 0x00, 0x03, 0xFF, 0x80, 0x1E, 0x03, 0xC0, 0x70, 0x01, 0xC1, 0xC0,
  0x01, 0x83, 0x00, 0x01, 0x8C, 0x00, 0x01, 0x98, 0x00, 0x03, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x01, 0x98, 0x00, 0x03, 0x18, 0x00, 0x0C, 0x38, 0x00,
  0x30, 0x38, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0x1F, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x03, 0x00, 0x0F, 0x06, 0x00, 0x07,
  0x0C, 0x00, 0x07, 0x18, 0x00, 0x06, 0x30, 0x00, 0x06, 0x60, 0x00, 0x0C,
  0xC0, 0x00, 0x19, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x36, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0xD8, 0x00, 0x01, 0xB0, 0x00, 0x01, 0x60, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x60, 0x00, 0x06, 0xC0, 0x00,
  0x0D, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x36, 0x00, 0x00, 0xCC, 0x00, 0x01,
  0x98, 0x00, 0x03, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x38, 0xC0, 0x00, 0xE1,
  0x80, 0x07, 0x83, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xB0, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xB0, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0x80, 0x1E, 0x07, 0x80,
  0x70, 0x03, 0x81, 0x80, 0x03, 0x87, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x30,
  0x00, 0x06, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0xD8, 0x00, 0x03, 0x98, 0x00, 0x07, 0x38,
  0x00, 0x16, 0x30, 0x00, 0x2C, 0x38, 0x01, 0x98, 0x3C, 0x0F, 0x30, 0x3F,
  0xF8, 0x60, 0x1F, 0xC0, 0x00, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x06, 0x60,
  0x01, 0xCE, 0x00, 0x70, 0xF0, 0x1C, 0x07, 0xFF, 0x00, 0x3F, 0x80, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x38, 0xC0,
  0x00, 0x70, 0xC0, 0x00, 0xE0, 0xC0, 0x00, 0xC0, 0xC0, 0x01, 0x80, 0xC0,
  0x03, 0x00, 0xC0, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x18, 0x00, 0xC0,
  0x38, 0x00, 0xC0, 0x70, 0x00, 0xC0, 0xE0, 0x00, 0xC0, 0xC0, 0x00, 0xC1,
  0xE0, 0x00, 0xC3, 0x70, 0x00, 0xC6, 0x30, 0x00, 0xCC, 0x18, 0x00, 0xD8,
  0x1C, 0x00, 0xF0, 0x0C, 0x00, 0xF0, 0x06, 0x00, 0xE0, 0x07, 0x00, 0xC0,
  0x03, 0x00, 0xC0, 0x01, 0x80, 0xC0, 0x01, 0xC0, 0xC0, 0x00, 0xC0, 0xC0,
  0x00, 0x60, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x18, 0xC0,
  0x00, 0x1C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFD, 0x80, 0x03,
  0x7B, 0x00, 0x06, 0xF3, 0x00, 0x09, 0xE6, 0x00, 0x33, 0xC6, 0x00, 0x67,
  0x8C, 0x01, 0x8F, 0x08, 0x03, 0x1E, 0x18, 0x0C, 0x3C, 0x30, 0x18, 0x78,
  0x30, 0x20, 0xF0, 0x60, 0xC1, 0xE0, 0x61, 0x03, 0xC0, 0xC6, 0x07, 0x80,
  0x8C, 0x0F, 0x01, 0xB0, 0x1E, 0x01, 0x60, 0x3C, 0x03, 0x80, 0x78, 0x07,
  0x00, 0xF0, 0x04, 0x01, 0xE0, 0x08, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1D, 0x80, 0x00, 0xEC, 0x00, 0x07, 0x30, 0x00,
  0x39, 0x80, 0x01, 0xC6, 0x00, 0x0E, 0x30, 0x00, 0x70, 0xC0, 0x03, 0x86,
  0x00, 0x1C, 0x18, 0x00, 0xE0, 0xC0, 0x07, 0x03, 0x00, 0x38, 0x18, 0x01,
  0xC0, 0x60, 0x0E, 0x03, 0x00, 0x70, 0x0C, 0x03, 0x80, 0x60, 0x1C, 0x01,
  0x80, 0xE0, 0x0C, 0x07, 0x00, 0x30, 0x38, 0x01, 0x81, 0xC0, 0x06, 0x0E,
  0x00, 0x30, 0x70, 0x00, 0xC3, 0x80, 0x06, 0x1C, 0x00, 0x18, 0xE0, 0x00,
  0xC7, 0x00, 0x03, 0x38, 0x00, 0x19, 0xC0, 0x00, 0x6E, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x70, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xE0, 0x01,
  0xE0, 0x3C, 0x01, 0xC0, 0x07, 0x00, 0xC0, 0x01, 0xC0, 0xC0, 0x00, 0x60,
  0x60, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x30, 0x00, 0x01,
  0x98, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x66, 0x00, 0x00, 0x33, 0x00, 0x00,
  0x19, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x03, 0x60, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1B, 0x00,
  0x00, 0x0D, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x03, 0x60, 0x00, 0x03, 0x30,
  0x00, 0x01, 0x98, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x66, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x30, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x0C,
  0x06, 0x00, 0x0E, 0x03, 0x80, 0x0E, 0x00, 0xF0, 0x1E, 0x00, 0x1F, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC3, 0x00, 0x03,
  0xC6, 0x00, 0x01, 0xCC, 0x00, 0x01, 0x98, 0x00, 0x01, 0xB0, 0x00, 0x03,
  0x60, 0x00, 0x06, 0xC0, 0x00, 0x05, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0xD8, 0x00, 0x01, 0xB0, 0x00, 0x03, 0x60,
  0x00, 0x0C, 0xC0, 0x00, 0x39, 0x80, 0x01, 0xE3, 0xFF, 0xFF, 0x87, 0xFF,
  0xFC, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xE0, 0x3C, 0x01, 0xC0, 0x07,
  0x00, 0xC0, 0x01, 0xC0, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x18, 0x60, 0x00,
  0x0C, 0x30, 0x00, 0x06, 0x30, 0x00, 0x01, 0x98, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x33, 0x00, 0x00, 0x19, 0x80, 0x00, 0x06, 0xC0,
  0x00, 0x03, 0x60, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x06,
  0xC0, 0x00, 0x03, 0x60, 0x00, 0x03, 0x30, 0x00, 0x01, 0x98, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x66, 0x00, 0x00, 0x31, 0x80, 0x00, 0x30, 0xC0, 0x00,
  0x18, 0x70, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x06, 0x00, 0x0E, 0x03, 0x80,
  0x0E, 0x00, 0xF0, 0x1E, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xC3, 0x00, 0x03, 0xC6, 0x00, 0x01, 0xCC, 0x00, 0x01, 0x98,
  0x00, 0x01, 0xB0, 0x00, 0x03, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x05, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xD8, 0x00,
  0x01, 0xB0, 0x00, 0x03, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x39, 0x80, 0x01,
  0xE3, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x0C, 0x03, 0x00, 0x18, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x06, 0x01, 0x80, 0x0E, 0x03,
  0x00, 0x0C, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x1C, 0x18, 0x00, 0x18, 0x30,
  0x00, 0x18, 0x60, 0x00, 0x38, 0xC0, 0x00, 0x31, 0x80, 0x00, 0x33, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x60, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x03,
  0xC0, 0x1E, 0x03, 0x80, 0x03, 0x83, 0x80, 0x00, 0x61, 0x80, 0x00, 0x19,
  0xC0, 0x00, 0x08, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0D, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x06, 0x60, 0x00, 0x07,
  0x1C, 0x00, 0x03, 0x07, 0x00, 0x07, 0x01, 0xF0, 0x0F, 0x00, 0x3F, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0D, 0x80, 0x00, 0xCC, 0x00, 0x06, 0x70, 0x00, 0x71, 0xC0, 0x07, 0x07,
  0x80, 0xF0, 0x1F, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x19, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x03,
  0x18, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x18, 0x30, 0x00,
  0x06, 0x06, 0x00, 0x01, 0x81, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x0C,
  0x00, 0x0C, 0x03, 0x00, 0x06, 0x00, 0xC0, 0x01, 0x80, 0x18, 0x00, 0x60,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x03, 0x00, 0x0C, 0x01,
  0x80, 0x03, 0x00, 0x60, 0x00, 0x60, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x06,
  0x03, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x18, 0x00,
  0x01, 0x06, 0x00, 0x00, 0x63, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x02, 0x30,
  0x00, 0x00, 0xD8, 0x00, 0x00, 0x36, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x40, 0x00, 0x01, 0xA0, 0x00, 0x00,
  0xD0, 0x00, 0x00, 0x4C, 0x03, 0x80, 0x26, 0x01, 0xC0, 0x13, 0x00, 0xA0,
  0x09, 0x80, 0x58, 0x0C, 0xC0, 0x6C, 0x06, 0x60, 0x32, 0x03, 0x30, 0x11,
  0x81, 0x98, 0x18, 0xC0, 0xC4, 0x0C, 0x60, 0x62, 0x06, 0x10, 0x31, 0x06,
  0x0C, 0x10, 0xC3, 0x06, 0x08, 0x61, 0x81, 0x04, 0x30, 0x80, 0xC6, 0x18,
  0xC0, 0x63, 0x0C, 0x60, 0x31, 0x86, 0x30, 0x08, 0xC3, 0x30, 0x06, 0x61,
  0x98, 0x03, 0x30, 0x4C, 0x00, 0x98, 0x24, 0x00, 0x6C, 0x16, 0x00, 0x34,
  0x0F, 0x00, 0x1A, 0x07, 0x80, 0x07, 0x03, 0x80, 0x03, 0x80, 0x60, 0x00,
  0x00, 0xE6, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x70, 0x1C, 0x00, 0x0C, 0x01, 0x80, 0x03, 0x00, 0x18, 0x00,
  0xE0, 0x03, 0x80, 0x18, 0x00, 0x30, 0x06, 0x00, 0x03, 0x01, 0xC0, 0x00,
  0x70, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x63, 0x80, 0x00, 0x0E, 0x60,
  0x00, 0x00, 0xD8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x01, 0x98, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x18, 0x30, 0x00, 0x03, 0x03, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x30,
  0x06, 0x00, 0x06, 0x00, 0xE0, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x00, 0xC0,
  0x0C, 0x00, 0x1C, 0x03, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x18, 0x18, 0x00,
  0x03, 0x86, 0x00, 0x00, 0x31, 0x80, 0x00, 0x03, 0x70, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x18, 0x30,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x0C, 0x06, 0x00, 0x00, 0xC0, 0x38, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0x60, 0x03, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x30,
  0x00, 0x60, 0x03, 0x00, 0x01, 0x80, 0x38, 0x00, 0x0C, 0x01, 0x80, 0x00,
  0x30, 0x18, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00,
  0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0xFF, 0xFF,
  0xFF, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0D, 0x80,
  0x00, 0x04, 0x60, 0x00, 0x06, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x06,
  0x00, 0x03, 0x01, 0x80, 0x01, 0x80, 0x60, 0x01, 0x80, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0xC0, 0x06, 0x00, 0xC0, 0x01, 0x80, 0x60, 0x00, 0x60, 0x60,
  0x00, 0x30, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x30, 0x00, 0x01, 0x98,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x41, 0xC1, 0xC1, 0x81, 0x81, 0x83, 0x03, 0x02, 0x01, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x1E, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x70, 0x00, 0xE0,
  0x60, 0x00, 0x60, 0x40, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x3C, 0x00, 0x30, 0x70, 0x00, 0x30,
  0xE0, 0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x30,
  0xC0, 0x00, 0x30, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0xB0, 0x60, 0x01, 0xB0,
  0x3C, 0x07, 0x3F, 0x1F, 0xFE, 0x3F, 0x07, 0xF8, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x83, 0xF8, 0x0C, 0x7F, 0xF0, 0x67, 0x03, 0xC3, 0x60, 0x07,
  0x1E, 0x00, 0x0C, 0xE0, 0x00, 0x76, 0x00, 0x01, 0xB0, 0x00, 0x0D, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x06, 0xC0, 0x00, 0x37,
  0x00, 0x03, 0xBC, 0x00, 0x19, 0xB0, 0x03, 0x8C, 0xE0, 0x78, 0x63, 0xFF,
  0x80, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xFC, 0x03, 0xC0, 0x70,
  0x38, 0x00, 0xC1, 0x80, 0x03, 0x18, 0x00, 0x0C, 0xC0, 0x00, 0x6C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x04, 0xC0, 0x00, 0x63, 0x00, 0x06, 0x1C, 0x00, 0x60, 0x78, 0x0E,
  0x00, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x03,
  0xF8, 0x30, 0x7F, 0xF1, 0x87, 0x81, 0xCC, 0x70, 0x03, 0x67, 0x00, 0x07,
  0x70, 0x00, 0x3B, 0x00, 0x00, 0xD8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x6C, 0x00, 0x03, 0x60, 0x00, 0x1B, 0x80, 0x01, 0xCE,
  0x00, 0x0E, 0x38, 0x01, 0xB0, 0xF0, 0x39, 0x83, 0xFF, 0x8C, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x1C, 0x07, 0x80, 0x60, 0x03,
  0x81, 0x80, 0x03, 0x86, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x30, 0x00, 0x06,
  0x60, 0x00, 0x04, 0xC0, 0x00, 0x09, 0x80, 0x00, 0x1A, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x46, 0x00, 0x01, 0x8C, 0x00, 0x07, 0x0C, 0x00, 0x0C, 0x0C, 0x00,
  0x70, 0x0F, 0x03, 0xC0, 0x0F, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x7F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x18, 0x00, 0x1F, 0xCC, 0x00, 0x3F, 0xFE, 0x00, 0x38, 0x0F, 0x00, 0x38,
  0x01, 0xC0, 0x38, 0x00, 0x60, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x0C, 0x04,
  0x00, 0x06, 0x06, 0x00, 0x03, 0x03, 0x00, 0x01, 0x80, 0x80, 0x00, 0xC0,
  0x60, 0x00, 0x60, 0x30, 0x00, 0x20, 0x1C, 0x00, 0x30, 0x07, 0x00, 0x30,
  0x01, 0xC0, 0x70, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x70, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0xE0,
  0x00, 0x70, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x06, 0x60, 0x00, 0x01, 0x60,
  0x00, 0x00, 0xB0, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x66, 0x00, 0x00, 0x33,
  0x80, 0x00, 0x70, 0xF0, 0x00, 0xF0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0x80,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0xFE, 0x0C, 0x7F, 0xF1, 0x9C, 0x0F, 0x36, 0x00,
  0x77, 0x80, 0x06, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x40, 0x00, 0x38, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xBF, 0xFF, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x19, 0xFF, 0xFE, 0x7F, 0xFF, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x0E, 0xC0, 0x00, 0x63, 0x00,
  0x03, 0x0C, 0x00, 0x18, 0x30, 0x01, 0xC0, 0xC0, 0x0E, 0x03, 0x00, 0x70,
  0x0C, 0x03, 0x80, 0x30, 0x18, 0x00, 0xC0, 0xC0, 0x03, 0x06, 0x00, 0x0C,
  0x3C, 0x00, 0x33, 0xB8, 0x00, 0xDC, 0x60, 0x03, 0xC0, 0xC0, 0x0E, 0x01,
  0x80, 0x30, 0x03, 0x00, 0xC0, 0x0E, 0x03, 0x00, 0x18, 0x0C, 0x00, 0x30,
  0x30, 0x00, 0x60, 0xC0, 0x00, 0xC3, 0x00, 0x03, 0x8C, 0x00, 0x07, 0x30,
  0x00, 0x0C, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x30, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x87, 0x80, 0xF8, 0x9F, 0xE3, 0xFC, 0x90,
  0x66, 0x0E, 0xA0, 0x34, 0x06, 0xC0, 0x38, 0x06, 0xC0, 0x18, 0x03, 0x80,
  0x18, 0x03, 0x80, 0x10, 0x03, 0x80, 0x10, 0x03, 0x80, 0x10, 0x03, 0x80,
  0x10, 0x03, 0x80, 0x10, 0x03, 0x80, 0x10, 0x03, 0x80, 0x10, 0x03, 0x80,
  0x10, 0x03, 0x80, 0x10, 0x03, 0x80, 0x10, 0x03, 0x80, 0x10, 0x03, 0x80,
  0x10, 0x03, 0x80, 0x10, 0x03, 0x80, 0x10, 0x03, 0x80, 0x10, 0x03, 0x80,
  0x10, 0x03, 0x80, 0x10, 0x03, 0x80, 0x10, 0x03, 0x80, 0x10, 0x03, 0x80,
  0x10, 0x03, 0xC1, 0xFC, 0x18, 0xFF, 0xE3, 0x38, 0x1E, 0x6C, 0x00, 0xEF,
  0x00, 0x0D, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xFF,
  0x00, 0x3C, 0x07, 0x80, 0xE0, 0x03, 0x81, 0x80, 0x03, 0x86, 0x00, 0x03,
  0x0C, 0x00, 0x03, 0x30, 0x00, 0x06, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x09,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x06, 0x80, 0x00, 0x0D, 0x80,
  0x00, 0x13, 0x00, 0x00, 0x66, 0x00, 0x00, 0xC6, 0x00, 0x01, 0x8C, 0x00,
  0x06, 0x0C, 0x00, 0x1C, 0x1C, 0x00, 0x70, 0x1E, 0x03, 0xC0, 0x0F, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0xC1, 0xFC, 0x06, 0x3F, 0xF8, 0x33, 0x81, 0xE1,
  0xB0, 0x03, 0x8F, 0x00, 0x06, 0x70, 0x00, 0x3B, 0x00, 0x00, 0xD8, 0x00,
  0x06, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0x60,
  0x00, 0x1B, 0x80, 0x01, 0xDE, 0x00, 0x0C, 0xD8, 0x01, 0xC6, 0x70, 0x3C,
  0x31, 0xFF, 0xC1, 0x83, 0xF8, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x18, 0x3F, 0xF8, 0xC3,
  0xC0, 0xE6, 0x38, 0x01, 0xB3, 0x80, 0x03, 0xB8, 0x00, 0x1D, 0x80, 0x00,
  0x6C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x36, 0x00,
  0x01, 0xB0, 0x00, 0x0D, 0xC0, 0x00, 0xE7, 0x00, 0x07, 0x1C, 0x00, 0xD8,
  0x78, 0x1C, 0xC1, 0xFF, 0xC6, 0x03, 0xF8, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF1, 0xFF, 0xC0, 0x19, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x06, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x0F, 0xFF, 0x80, 0x3C, 0x07, 0xC0, 0xC0, 0x01, 0xC3, 0x00, 0x00, 0xC6,
  0x00, 0x01, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x68, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xB8, 0x00, 0x06, 0x38, 0x00, 0x1C, 0x3E, 0x01, 0xF0,
  0x1F, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF8, 0x00, 0x3B, 0x00, 0x07, 0x70, 0x03, 0x67, 0x81,
  0xCC, 0x7F, 0xF1, 0x83, 0xF8, 0x00, 0xE0, 0x00, 0x06, 0xC0, 0x00, 0x19,
  0x80, 0x00, 0x31, 0x80, 0x00, 0x43, 0x00, 0x01, 0x86, 0x00, 0x03, 0x06,
  0x00, 0x04, 0x0C, 0x00, 0x18, 0x08, 0x00, 0x30, 0x18, 0x00, 0xC0, 0x30,
  0x01, 0x80, 0x30, 0x02, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18, 0x00, 0xC0,
  0x20, 0x01, 0x80, 0xC0, 0x01, 0x01, 0x80, 0x03, 0x02, 0x00, 0x06, 0x0C,
  0x00, 0x04, 0x18, 0x00, 0x0C, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x19, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0x00, 0x28, 0x01, 0xE0, 0x05,
  0x80, 0x34, 0x01, 0xB0, 0x06, 0xC0, 0x32, 0x00, 0x98, 0x04, 0x40, 0x13,
  0x00, 0x8C, 0x06, 0x60, 0x31, 0x80, 0xC4, 0x06, 0x10, 0x18, 0x80, 0x82,
  0x02, 0x18, 0x10, 0x60, 0x43, 0x06, 0x0C, 0x18, 0x60, 0xC0, 0x83, 0x0C,
  0x10, 0x10, 0x60, 0x82, 0x03, 0x0C, 0x10, 0xC0, 0x61, 0x03, 0x18, 0x04,
  0x20, 0x62, 0x00, 0x8C, 0x0C, 0x40, 0x19, 0x80, 0x98, 0x03, 0x30, 0x13,
  0x00, 0x24, 0x03, 0x40, 0x04, 0x80, 0x68, 0x00, 0xD0, 0x0F, 0x00, 0x1E,
  0x01, 0xE0, 0x01, 0xC0, 0x18, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x0E, 0x60,
  0x00, 0x18, 0xE0, 0x00, 0x60, 0xC0, 0x01, 0x80, 0xC0, 0x06, 0x00, 0xC0,
  0x0C, 0x01, 0xC0, 0x30, 0x01, 0x80, 0xC0, 0x01, 0x83, 0x00, 0x01, 0x86,
  0x00, 0x03, 0x98, 0x00, 0x03, 0x60, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x36, 0x00, 0x00, 0xC6, 0x00, 0x03, 0x86, 0x00,
  0x06, 0x0E, 0x00, 0x18, 0x0C, 0x00, 0x60, 0x0C, 0x01, 0xC0, 0x0C, 0x03,
  0x00, 0x1C, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x18, 0xE0, 0x00, 0x1B, 0x80,
  0x00, 0x38, 0xC0, 0x00, 0x06, 0x80, 0x00, 0x0D, 0x80, 0x00, 0x33, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x86, 0x00, 0x03, 0x06, 0x00, 0x06, 0x0C, 0x00,
  0x18, 0x18, 0x00, 0x30, 0x18, 0x00, 0xC0, 0x30, 0x01, 0x80, 0x30, 0x02,
  0x00, 0x60, 0x0C, 0x00, 0x40, 0x18, 0x00, 0xC0, 0x60, 0x01, 0x80, 0xC0,
  0x01, 0x81, 0x00, 0x03, 0x06, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x30, 0x00,
  0x0C, 0x60, 0x00, 0x0D, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x80, 0x01, 0xE0, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00,
  0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00,
  0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0xFF, 0xC0, 0x3F, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xE0,
  0x1F, 0xFE, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80,
  0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00,
  0x03, 0xC0, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00,
  0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00,
  0x02, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x01, 0xFF, 0xE0, 0x3F,
  0xF8, 0x00, 0x07, 0x80, 0x00, 0x8F, 0xE0, 0x00, 0xCE, 0x3C, 0x00, 0x66,
  0x07, 0x00, 0x36, 0x01, 0x80, 0x13, 0x00, 0x60, 0x19, 0x00, 0x18, 0x19,
  0x80, 0x07, 0x1C, 0xC0, 0x01, 0xFC, 0x60, 0x00, 0x7C, 0x00,
};

const GFXglyph IBMPlexMono_ExtraLight52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 31, 0, -1 },
  { 1, 5, 36, 31, 13, -36 },
  { 24, 9, 13, 31, 11, -38 },
  { 39, 29, 36, 31, 1, -36 },
  { 170, 25, 48, 31, 3, -42 },
  { 320, 29, 38, 31, 1, -37 },
  { 458, 27, 38, 31, 2, -37 },
  { 587, 2, 13, 31, 15, -38 },
  { 591, 13, 47, 31, 12, -40 },
  { 668, 12, 47, 31, 7, -40 },
  { 739, 27, 26, 31, 2, -29 },
  { 827, 25, 26, 31, 3, -29 },
  { 909, 6, 14, 31, 12, -5 },
  { 920, 14, 2, 31, 9, -17 },
  { 924, 5, 4, 31, 13, -4 },
  { 927, 21, 47, 31, 5, -40 },
  { 1051, 25, 38, 31, 3, -37 },
  { 1170, 25, 36, 31, 4, -36 },
  { 1283, 23, 37, 31, 4, -37 },
  { 1390, 23, 38, 31, 3, -37 },
  { 1500, 27, 36, 31, 2, -36 },
  { 1622, 23, 37, 31, 4, -36 },
  { 1729, 23, 37, 31, 4, -36 },
  { 1836, 23, 36, 31, 4, -36 },
  { 1940, 24, 38, 31, 4, -37 },
  { 2054, 23, 37, 31, 4, -37 },
  { 2161, 5, 27, 31, 13, -27 },
  { 2178, 6, 36, 31, 12, -27 },
  { 2205, 23, 28, 31, 4, -30 },
  { 2286, 25, 12, 31, 3, -22 },
  { 2324, 23, 28, 31, 4, -30 },
  { 2405, 21, 37, 31, 5, -37 },
  { 2503, 22, 43, 31, 4, -37 },
  { 2622, 27, 36, 31, 2, -36 },
  { 2744, 22, 36, 31, 5, -36 },
  { 2843, 23, 38, 31, 4, -37 },
  { 2953, 23, 36, 31, 5, -36 },
  { 3057, 22, 36, 31, 5, -36 },
  { 3156, 22, 36, 31, 5, -36 },
  { 3255, 23, 38, 31, 4, -37 },
  { 3365, 21, 36, 31, 5, -36 },
  { 3460, 22, 36, 31, 5, -36 },
  { 3559, 19, 37, 31, 5, -36 },
  { 3647, 24, 36, 31, 5, -36 },
  { 3755, 21, 36, 31, 7, -36 },
  { 3850, 23, 36, 31, 4, -36 },
  { 3954, 21, 36, 31, 5, -36 },
  { 4049, 25, 38, 31, 3, -37 },
  { 4168, 23, 36, 31, 5, -36 },
  { 4272, 25, 45, 31, 3, -37 },
  { 4413, 23, 36, 31, 5, -36 },
  { 4517, 25, 38, 31, 3, -37 },
  { 4636, 27, 36, 31, 2, -36 },
  { 4758, 21, 37, 31, 5, -36 },
  { 4856, 26, 36, 31, 3, -36 },
  { 4973, 25, 36, 31, 3, -36 },
  { 5086, 27, 36, 31, 2, -36 },
  { 5208, 29, 36, 31, 1, -36 },
  { 5339, 27, 36, 31, 2, -36 },
  { 5461, 13, 47, 31, 13, -40 },
  { 5538, 21, 47, 31, 5, -40 },
  { 5662, 13, 47, 31, 5, -40 },
  { 5739, 25, 20, 31, 3, -36 },
  { 5802, 25, 2, 31, 3, 6 },
  { 5809, 7, 9, 31, 10, -40 },
  { 5817, 24, 28, 31, 4, -27 },
  { 5901, 21, 39, 31, 6, -38 },
  { 6004, 21, 28, 31, 5, -27 },
  { 6078, 21, 39, 31, 4, -38 },
  { 6181, 23, 28, 31, 4, -27 },
  { 6262, 24, 38, 31, 4, -38 },
  { 6376, 25, 41, 31, 4, -30 },
  { 6505, 19, 38, 31, 6, -38 },
  { 6596, 22, 39, 31, 6, -39 },
  { 6704, 18, 49, 31, 5, -39 },
  { 6815, 22, 38, 31, 7, -38 },
  { 6920, 22, 38, 31, 5, -38 },
  { 7025, 24, 27, 31, 4, -27 },
  { 7106, 19, 27, 31, 6, -27 },
  { 7171, 23, 28, 31, 4, -27 },
  { 7252, 21, 37, 31, 6, -27 },
  { 7350, 21, 37, 31, 4, -27 },
  { 7448, 25, 27, 31, 4, -27 },
  { 7533, 23, 28, 31, 4, -27 },
  { 7614, 25, 36, 31, 2, -36 },
  { 7727, 19, 28, 31, 6, -27 },
  { 7794, 23, 27, 31, 4, -27 },
  { 7872, 27, 27, 31, 2, -27 },
  { 7964, 23, 27, 31, 4, -27 },
  { 8042, 23, 37, 31, 4, -27 },
  { 8149, 21, 27, 31, 5, -27 },
  { 8220, 19, 47, 31, 6, -40 },
  { 8332, 1, 47, 31, 15, -40 },
  { 8338, 19, 47, 31, 6, -40 },
  { 8450, 25, 10, 31, 3, -21 },
};

const GFXfont IBMPlexMono_ExtraLight52pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLight52pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLight52pt7bGlyphs,
  0x20, 0x7E, 68
};

#endif // _IBMPLEXMONO_EXTRALIGHT52PT7B_H_
