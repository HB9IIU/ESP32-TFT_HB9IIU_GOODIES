#ifndef _IBMPLEXMONO_EXTRALIGHT70PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHT70PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLight.ttf
// Size: 70pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLight70pt7bBitmaps[] PROGMEM = {
  0x00, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0xFF, 0xFF,
  0xFF, 0x78, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x00, 0x00, 0x60, 0x07, 0x00, 0x00, 0x00,
  0x60, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x06,
  0x00, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x0E, 0x00, 0x00,
  0x00, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x0C, 0x00, 0x00, 0x01, 0xC0, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x00, 0x01,
  0x80, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x18, 0x00, 0x00, 0x03, 0x80, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x38, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x1F,
  0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00,
  0x30, 0x00, 0x00, 0x07, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x70, 0x00,
  0x00, 0x06, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0x0E,
  0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0xF8, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x1C, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x01, 0xC0, 0x00,
  0x00, 0x18, 0x01, 0x80, 0x00, 0x00, 0x38, 0x01, 0x80, 0x00, 0x00, 0x38,
  0x01, 0x80, 0x00, 0x00, 0x38, 0x01, 0x80, 0x00, 0x00, 0x30, 0x03, 0x80,
  0x00, 0x00, 0x30, 0x03, 0x80, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x00,
  0x70, 0x03, 0x00, 0x00, 0x00, 0x70, 0x03, 0x00, 0x00, 0x00, 0x60, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x07, 0x00, 0x00, 0x00, 0x60, 0x07, 0x00, 0x00,
  0x00, 0x60, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0xF8, 0x71, 0xF8, 0x01, 0xE0, 0x38, 0x1F, 0x01, 0xE0, 0x1C, 0x03, 0xC0,
  0xE0, 0x0E, 0x00, 0xF0, 0xE0, 0x07, 0x00, 0x38, 0xE0, 0x03, 0x80, 0x0E,
  0x70, 0x01, 0xC0, 0x00, 0x30, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x70, 0x00,
  0x0C, 0x00, 0x38, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x0E, 0x00,
  0x01, 0x80, 0x07, 0x00, 0x00, 0xC0, 0x03, 0x80, 0x00, 0x70, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x07, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x00, 0x1F, 0x07,
  0x00, 0x00, 0x03, 0xFB, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x77, 0xF0, 0x00, 0x00, 0x38, 0x3E, 0x00, 0x00,
  0x1C, 0x07, 0x80, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x1C, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0xE0, 0x03, 0x80,
  0x00, 0x70, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x30,
  0x00, 0x0E, 0x00, 0x18, 0x00, 0x07, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x06,
  0x00, 0x01, 0xC0, 0x03, 0x00, 0x00, 0xE0, 0x03, 0xB0, 0x00, 0x70, 0x01,
  0xFC, 0x00, 0x38, 0x01, 0xCF, 0x00, 0x1C, 0x00, 0xE3, 0xC0, 0x0E, 0x00,
  0xE0, 0xF0, 0x07, 0x00, 0xE0, 0x3E, 0x03, 0x81, 0xE0, 0x07, 0xE1, 0xC7,
  0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x31, 0xE0, 0x78, 0x00, 0x01, 0x8F, 0x00, 0x70, 0x00, 0x0E, 0x30, 0x00,
  0xC0, 0x00, 0x31, 0xC0, 0x03, 0x80, 0x01, 0xC6, 0x00, 0x06, 0x00, 0x06,
  0x18, 0x00, 0x18, 0x00, 0x30, 0xE0, 0x00, 0x70, 0x00, 0xC3, 0x80, 0x00,
  0xC0, 0x06, 0x0C, 0x00, 0x03, 0x00, 0x38, 0x30, 0x00, 0x0C, 0x00, 0xC0,
  0xC0, 0x00, 0x30, 0x07, 0x03, 0x00, 0x00, 0xC0, 0x18, 0x0E, 0x00, 0x03,
  0x00, 0xC0, 0x38, 0x00, 0x1C, 0x07, 0x00, 0x60, 0x00, 0x60, 0x18, 0x01,
  0x80, 0x01, 0x80, 0xE0, 0x07, 0x00, 0x0E, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x18, 0x00, 0x38, 0x01, 0xC0, 0x60, 0x00, 0x78, 0x1E, 0x03, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x30, 0x1E,
  0x07, 0x80, 0x01, 0x80, 0xE0, 0x0E, 0x00, 0x06, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x1C, 0x00, 0x38, 0x01, 0xC0, 0x60, 0x00, 0x60, 0x06, 0x01, 0x80,
  0x01, 0x80, 0x38, 0x0E, 0x00, 0x07, 0x00, 0xC0, 0x30, 0x00, 0x1C, 0x06,
  0x00, 0xC0, 0x00, 0x70, 0x38, 0x03, 0x00, 0x00, 0xC0, 0xC0, 0x0C, 0x00,
  0x03, 0x07, 0x00, 0x30, 0x00, 0x1C, 0x18, 0x00, 0xC0, 0x00, 0x70, 0xC0,
  0x03, 0x80, 0x01, 0xC3, 0x00, 0x06, 0x00, 0x06, 0x18, 0x00, 0x18, 0x00,
  0x18, 0xE0, 0x00, 0x70, 0x00, 0xE3, 0x00, 0x00, 0xC0, 0x03, 0x1C, 0x00,
  0x03, 0x80, 0x3C, 0x60, 0x00, 0x07, 0x81, 0xE3, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x06, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x05, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x00, 0xF3, 0x80, 0x01, 0xFC,
  0x38, 0x38, 0x00, 0x7F, 0x8E, 0x03, 0x80, 0x0E, 0x03, 0x80, 0x38, 0x01,
  0xC0, 0x60, 0x03, 0x80, 0x38, 0x1C, 0x00, 0x38, 0x06, 0x03, 0x00, 0x03,
  0x00, 0xC0, 0xE0, 0x00, 0x70, 0x18, 0x1C, 0x00, 0x07, 0x03, 0x03, 0x00,
  0x00, 0x70, 0x60, 0x60, 0x00, 0x07, 0x0C, 0x0C, 0x00, 0x00, 0x73, 0x81,
  0x80, 0x00, 0x06, 0x60, 0x30, 0x00, 0x00, 0xEC, 0x06, 0x00, 0x00, 0x0F,
  0x80, 0xC0, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00,
  0x03, 0xE0, 0x30, 0x00, 0x00, 0x4E, 0x07, 0x00, 0x00, 0x18, 0xE0, 0x70,
  0x00, 0x06, 0x0E, 0x0F, 0x00, 0x01, 0x81, 0xC0, 0xF0, 0x00, 0xE0, 0x1C,
  0x0F, 0xC0, 0x78, 0x01, 0xC0, 0x7F, 0xFC, 0x00, 0x1C, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0x80, 0x03, 0x00,
  0x07, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x80, 0x03, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60,
  0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x1C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0xE0, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03,
  0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00,
  0x07, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x60, 0x00, 0x6F, 0xC0, 0x06,
  0x00, 0x3F, 0x3F, 0x80, 0x60, 0x1F, 0xC0, 0x7F, 0x06, 0x0F, 0xE0, 0x00,
  0xFE, 0x67, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x39,
  0xC0, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00,
  0x0E, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x1C, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x1F, 0x1E, 0x1E, 0x1E, 0x3C, 0x3C, 0x3C, 0x38, 0x38, 0x78,
  0x70, 0x70, 0x70, 0x60, 0xE0, 0xE0, 0xC0, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x7B, 0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x03,
  0xC0, 0x03, 0xC0, 0x07, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x70, 0x0C,
  0x00, 0x00, 0x30, 0x1C, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x18, 0x38,
  0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0x0E, 0x70,
  0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0x60,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x0E, 0x70,
  0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x1C, 0x18,
  0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0x30, 0x0E,
  0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x01,
  0xF0, 0x0F, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF6, 0x00, 0x00,
  0x00, 0x79, 0x80, 0x00, 0x00, 0x3C, 0x60, 0x00, 0x00, 0x1C, 0x18, 0x00,
  0x00, 0x0E, 0x06, 0x00, 0x00, 0x0F, 0x01, 0x80, 0x00, 0x07, 0x80, 0x60,
  0x00, 0x03, 0xC0, 0x18, 0x00, 0x01, 0xE0, 0x06, 0x00, 0x00, 0xF0, 0x01,
  0x80, 0x00, 0x78, 0x00, 0x60, 0x00, 0x38, 0x00, 0x18, 0x00, 0x04, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x1F, 0x00, 0xFC, 0x00, 0x78, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x3C, 0x07,
  0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x3E, 0x01, 0xF0, 0x03, 0xC0, 0x01, 0xE0, 0x1E, 0x00, 0x01,
  0xC0, 0x70, 0x00, 0x03, 0x83, 0x80, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x1C,
  0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE4, 0x00, 0x00, 0x03, 0xB0,
  0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x03, 0x83, 0xC0,
  0x00, 0x1C, 0x07, 0x80, 0x01, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x37, 0x00,
  0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x00, 0x67, 0x00, 0x00, 0x00, 0x0C,
  0x70, 0x00, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x00, 0x18, 0x70, 0x00, 0x00,
  0x03, 0x07, 0x00, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x0E, 0x07, 0x00,
  0x00, 0x00, 0xC0, 0x70, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x70, 0x00, 0x00, 0x30, 0x07, 0x00, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x70, 0x00, 0x03, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x30, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x0C, 0x00, 0x00,
  0x70, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00, 0x70, 0x03, 0x00,
  0x00, 0x07, 0x00, 0x60, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x1F,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC1, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x1F, 0xF0, 0x00, 0xC3, 0xFF, 0xF8, 0x03, 0x1E, 0x01,
  0xF0, 0x0D, 0xC0, 0x00, 0xF0, 0x34, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x03,
  0x83, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x39, 0x00, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0xE0,
  0xF0, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x78, 0x01, 0xF0, 0x07, 0xC0, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x07, 0xFC, 0x00, 0x30, 0xFF,
  0xFE, 0x01, 0xC7, 0x80, 0x7C, 0x06, 0x70, 0x00, 0x7C, 0x1B, 0x80, 0x00,
  0x78, 0x6C, 0x00, 0x00, 0xE3, 0xE0, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x03,
  0xBC, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xD8, 0x00, 0x00,
  0x07, 0x60, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x03,
  0x0E, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x07, 0x00,
  0x78, 0x00, 0x78, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xDC, 0x00,
  0x00, 0x03, 0xB8, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x1C, 0xE0, 0x00,
  0x00, 0x31, 0xC0, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x01, 0xC7, 0x00, 0x00,
  0x07, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xF0, 0x0F,
  0xC0, 0x07, 0x80, 0x01, 0xE0, 0x0E, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00,
  0x38, 0x1C, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00,
  0x1C, 0x30, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00,
  0x0E, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00,
  0x0C, 0x30, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00,
  0x1C, 0x1C, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00,
  0xF0, 0x07, 0x80, 0x01, 0xE0, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0x00, 0x01,
  0xE0, 0x0E, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00,
  0x1C, 0x70, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0x60, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00,
  0x1C, 0x3C, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x78, 0x0F, 0x80, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3E, 0x01, 0xF0,
  0x01, 0xE0, 0x00, 0xE0, 0x0E, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x03, 0x83,
  0x80, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0x39, 0x80,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x1B, 0x1C, 0x00, 0x00, 0x5C, 0x78,
  0x00, 0x07, 0x70, 0xF8, 0x00, 0x39, 0x80, 0xF8, 0x07, 0x86, 0x01, 0xFF,
  0xFC, 0x38, 0x00, 0xFF, 0x80, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7B, 0xFF, 0xFF,
  0xFD, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0xFF, 0xFF, 0xFF,
  0x78, 0x1E, 0x3F, 0x3F, 0x3F, 0x3F, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x1E, 0x1E, 0x1E,
  0x3C, 0x3C, 0x3C, 0x38, 0x38, 0x78, 0x70, 0x70, 0x70, 0x60, 0xE0, 0xE0,
  0xC0, 0xC0, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x07,
  0xC0, 0x3E, 0x00, 0xF0, 0x00, 0x70, 0x1C, 0x00, 0x03, 0x83, 0x80, 0x00,
  0x1C, 0x70, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x6E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7C, 0x07, 0x80, 0x07, 0x00,
  0x0F, 0x00, 0x70, 0x00, 0x38, 0x07, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x03,
  0x83, 0x80, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x67, 0x00, 0x00, 0x03, 0xB0, 0x00,
  0x00, 0x1D, 0x80, 0x00, 0x00, 0x6C, 0x00, 0x1F, 0x83, 0x60, 0x03, 0xFF,
  0x1B, 0x00, 0x3C, 0x0C, 0xF8, 0x03, 0x80, 0x37, 0xC0, 0x38, 0x00, 0xBE,
  0x01, 0x80, 0x03, 0xF0, 0x1C, 0x00, 0x1F, 0x00, 0xC0, 0x00, 0x78, 0x06,
  0x00, 0x03, 0xC0, 0x30, 0x00, 0x1E, 0x01, 0x80, 0x00, 0xF0, 0x0C, 0x00,
  0x07, 0x80, 0xE0, 0x00, 0x3C, 0x07, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x0F,
  0x01, 0xC0, 0x00, 0x78, 0x06, 0x00, 0x03, 0xC0, 0x30, 0x00, 0x1E, 0x01,
  0x80, 0x00, 0xF0, 0x0C, 0x00, 0x07, 0x80, 0x60, 0x00, 0x3E, 0x03, 0x80,
  0x01, 0xF0, 0x0C, 0x00, 0x1F, 0x80, 0x70, 0x00, 0xEC, 0x03, 0x80, 0x0B,
  0x60, 0x0E, 0x00, 0xDB, 0x00, 0x3E, 0x7C, 0xD8, 0x00, 0x7F, 0xC6, 0xC0,
  0x00, 0x60, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0x98, 0x00,
  0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00,
  0x06, 0x06, 0x00, 0x00, 0x00, 0x60, 0x70, 0x00, 0x00, 0x0E, 0x07, 0x00,
  0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x01, 0xC0,
  0x38, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00,
  0x38, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0xC0,
  0x00, 0x07, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x03, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x1C, 0x00, 0x00, 0x03, 0x81, 0x80, 0x00, 0x00, 0x18, 0x38,
  0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0x00,
  0xC7, 0x00, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x00, 0xE6, 0x00, 0x00,
  0x00, 0x06, 0xE0, 0x00, 0x00, 0x00, 0x70, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xF0, 0x0C, 0x00, 0x01, 0xF0, 0x30, 0x00, 0x01, 0xE0, 0xC0, 0x00,
  0x03, 0x83, 0x00, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00,
  0x38, 0xC0, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x06,
  0x30, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x63, 0x00, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0xE3, 0x00,
  0x00, 0x03, 0x8C, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x70, 0xC0, 0x00,
  0x03, 0x83, 0x00, 0x00, 0x1C, 0x0C, 0x00, 0x01, 0xE0, 0x3F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFE, 0x03, 0x00, 0x00, 0x3E, 0x0C, 0x00, 0x00, 0x1C,
  0x30, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x00, 0x73, 0x00, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x1B, 0x00,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x03,
  0x30, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x07, 0x0C,
  0x00, 0x00, 0xF8, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7C, 0x07, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x03, 0x80, 0x00, 0x78, 0x07, 0x00, 0x00, 0x38, 0x06,
  0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x0E, 0x1C,
  0x00, 0x00, 0x07, 0x18, 0x00, 0x00, 0x04, 0x38, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x1C, 0x00, 0x00, 0x07, 0x1C,
  0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x1C, 0x07,
  0x00, 0x00, 0x38, 0x03, 0xC0, 0x00, 0x78, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x7C, 0x07, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x0E, 0x00, 0x07, 0xE0, 0x38, 0x00,
  0x03, 0xC0, 0xE0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x07, 0x0E, 0x00, 0x00,
  0x1C, 0x38, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x63, 0x80, 0x00, 0x01,
  0xCE, 0x00, 0x00, 0x03, 0x38, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x3B,
  0x80, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xB8, 0x00,
  0x00, 0x06, 0xE0, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x03, 0x38, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x63, 0x80, 0x00, 0x03,
  0x8E, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x03, 0x83,
  0x80, 0x00, 0x3C, 0x0E, 0x00, 0x07, 0xE0, 0x3F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF7, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE7, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x38, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x0E, 0x03, 0x80,
  0x00, 0x0E, 0x0E, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x1C, 0x70, 0x00,
  0x00, 0x18, 0xE0, 0x00, 0x00, 0x29, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x6E, 0x00,
  0x00, 0x01, 0xDC, 0x00, 0x00, 0x03, 0x98, 0x00, 0x00, 0x07, 0x38, 0x00,
  0x00, 0x0E, 0x70, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x78, 0xE0, 0x00,
  0x00, 0xB0, 0xE0, 0x00, 0x03, 0x60, 0xE0, 0x00, 0x0C, 0xC1, 0xE0, 0x00,
  0x31, 0x81, 0xE0, 0x00, 0xE3, 0x00, 0xF8, 0x0F, 0x86, 0x00, 0xFF, 0xFC,
  0x0C, 0x00, 0x3F, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x30, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x39, 0xC0,
  0x00, 0x06, 0x38, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x30, 0x78, 0x00, 0x0E,
  0x07, 0x80, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1C, 0xE0, 0x00,
  0x00, 0x38, 0xE0, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x00, 0x70, 0xE0, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x07, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0xE0, 0x00, 0x78, 0x00, 0xE0, 0x00, 0x70, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0xE0, 0x03, 0x80, 0x00, 0xE0, 0x07,
  0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0xE0, 0x3C,
  0x00, 0x00, 0xE0, 0x3C, 0x00, 0x00, 0xE0, 0x7E, 0x00, 0x00, 0xE0, 0xEE,
  0x00, 0x00, 0xE1, 0xC7, 0x00, 0x00, 0xE3, 0x87, 0x80, 0x00, 0xE7, 0x03,
  0x80, 0x00, 0xEE, 0x01, 0xC0, 0x00, 0xFC, 0x01, 0xC0, 0x00, 0xF8, 0x00,
  0xE0, 0x00, 0xF8, 0x00, 0x70, 0x00, 0xF0, 0x00, 0x70, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0xE0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x01, 0xC0, 0xE0, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x70, 0xE0, 0x00,
  0x00, 0x38, 0xE0, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x1C, 0xE0, 0x00,
  0x00, 0x0E, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xD8, 0x00, 0x00, 0x6F, 0x70,
  0x00, 0x03, 0xBC, 0xC0, 0x00, 0x0E, 0xF3, 0x00, 0x00, 0x33, 0xCE, 0x00,
  0x01, 0xCF, 0x18, 0x00, 0x06, 0x3C, 0x70, 0x00, 0x38, 0xF0, 0xC0, 0x00,
  0xC3, 0xC3, 0x80, 0x07, 0x0F, 0x06, 0x00, 0x18, 0x3C, 0x1C, 0x00, 0x60,
  0xF0, 0x70, 0x03, 0x83, 0xC0, 0xC0, 0x0C, 0x0F, 0x03, 0x80, 0x70, 0x3C,
  0x06, 0x01, 0x80, 0xF0, 0x1C, 0x0E, 0x03, 0xC0, 0x30, 0x30, 0x0F, 0x00,
  0xE0, 0xC0, 0x3C, 0x01, 0x86, 0x00, 0xF0, 0x06, 0x18, 0x03, 0xC0, 0x1C,
  0xE0, 0x0F, 0x00, 0x33, 0x00, 0x3C, 0x00, 0xFC, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0C, 0x00, 0x3C, 0x00, 0x30, 0x00,
  0xF0, 0x00, 0x80, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xD8, 0x00,
  0x00, 0x3D, 0xC0, 0x00, 0x03, 0xCC, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x03,
  0xC6, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x03, 0xC3, 0x00, 0x00, 0x3C, 0x38,
  0x00, 0x03, 0xC1, 0x80, 0x00, 0x3C, 0x1C, 0x00, 0x03, 0xC0, 0xC0, 0x00,
  0x3C, 0x0E, 0x00, 0x03, 0xC0, 0x60, 0x00, 0x3C, 0x07, 0x00, 0x03, 0xC0,
  0x30, 0x00, 0x3C, 0x03, 0x80, 0x03, 0xC0, 0x18, 0x00, 0x3C, 0x01, 0xC0,
  0x03, 0xC0, 0x0C, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0xC0, 0x06, 0x00, 0x3C,
  0x00, 0x70, 0x03, 0xC0, 0x03, 0x00, 0x3C, 0x00, 0x38, 0x03, 0xC0, 0x01,
  0x80, 0x3C, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0xC0, 0x3C, 0x00, 0x0E, 0x03,
  0xC0, 0x00, 0x60, 0x3C, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x30, 0x3C, 0x00,
  0x03, 0x83, 0xC0, 0x00, 0x18, 0x3C, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x0C,
  0x3C, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x06, 0x3C, 0x00, 0x00, 0x73, 0xC0,
  0x00, 0x03, 0x3C, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x01, 0xBC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xF0, 0x0F, 0x80,
  0x03, 0xC0, 0x03, 0xC0, 0x07, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x70,
  0x0C, 0x00, 0x00, 0x30, 0x1C, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x18,
  0x38, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0x0E,
  0x70, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0x60, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x0E,
  0x70, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x1C,
  0x18, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0x30,
  0x0E, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0xE0, 0x03, 0xC0, 0x03, 0xC0,
  0x01, 0xF0, 0x0F, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x0E, 0x00, 0x00, 0x7C, 0x38,
  0x00, 0x00, 0x78, 0xE0, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x01, 0xCE, 0x00,
  0x00, 0x03, 0xB8, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x1B, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xB8,
  0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x01, 0xCE, 0x00,
  0x00, 0x07, 0x38, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x07, 0xC3, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x01, 0xF0, 0x0F, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x00, 0x00, 0xE0,
  0x0E, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x30, 0x1C, 0x00, 0x00, 0x38,
  0x18, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0x0C,
  0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06,
  0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x0C,
  0x38, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x38,
  0x0C, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0xE0,
  0x03, 0xC0, 0x03, 0xC0, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x0E,
  0x00, 0x00, 0x7C, 0x38, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x00, 0xF3, 0x80,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x06, 0xE0, 0x00,
  0x00, 0x1B, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x3B, 0x80,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x78, 0xE0, 0x00,
  0x07, 0xC3, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0x38, 0x01, 0xC0,
  0x00, 0xE0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x60, 0x03, 0x80, 0x01, 0xC0, 0x0E,
  0x00, 0x03, 0x80, 0x38, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x1C, 0x03, 0x80,
  0x00, 0x38, 0x0E, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x01, 0xC0, 0xE0, 0x00,
  0x03, 0x83, 0x80, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00,
  0x30, 0xE0, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x07,
  0x38, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x78, 0x70, 0x00, 0x00,
  0x1C, 0x70, 0x00, 0x00, 0x06, 0x38, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x01, 0xD8, 0x00, 0x00, 0x00, 0xDE, 0x00, 0x00, 0x00, 0xE7, 0x80, 0x00,
  0x00, 0x61, 0xE0, 0x00, 0x00, 0x70, 0x78, 0x00, 0x00, 0xF0, 0x1F, 0x00,
  0x00, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x66, 0x00, 0x00, 0x06, 0x70,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x01, 0xC1, 0xC0, 0x00,
  0x38, 0x1E, 0x00, 0x07, 0x80, 0xF8, 0x01, 0xF0, 0x03, 0xFF, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0x0E,
  0x70, 0x00, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x01, 0x81, 0xC0,
  0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x00, 0x30,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x06, 0x00, 0x00,
  0x07, 0x00, 0x70, 0x00, 0x00, 0x60, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x00, 0x70, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00,
  0xC0, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x01,
  0x80, 0x18, 0x00, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x38, 0x00,
  0x00, 0x0C, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x00, 0x0E, 0x07,
  0x00, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x00, 0x03, 0x9C, 0x00, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x01, 0x98,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xD8, 0x00,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x00, 0x66, 0x00, 0x1E, 0x00, 0x19,
  0x80, 0x07, 0x80, 0x06, 0x70, 0x01, 0xE0, 0x01, 0x9C, 0x00, 0x7C, 0x00,
  0xE7, 0x00, 0x3F, 0x00, 0x39, 0xC0, 0x0C, 0xC0, 0x0E, 0x30, 0x03, 0x30,
  0x03, 0x0C, 0x01, 0xCE, 0x00, 0xC3, 0x00, 0x61, 0x80, 0x30, 0xC0, 0x18,
  0x60, 0x0C, 0x30, 0x06, 0x18, 0x03, 0x0C, 0x03, 0x87, 0x00, 0xC3, 0x00,
  0xC0, 0xC0, 0x30, 0xE0, 0x30, 0x30, 0x1C, 0x38, 0x0C, 0x0E, 0x07, 0x0E,
  0x07, 0x03, 0x81, 0xC3, 0x81, 0x80, 0x60, 0x70, 0x60, 0x60, 0x18, 0x18,
  0x18, 0x38, 0x07, 0x06, 0x06, 0x0C, 0x00, 0xC1, 0x81, 0x83, 0x00, 0x30,
  0x60, 0x60, 0xC0, 0x0C, 0x18, 0x18, 0x70, 0x03, 0x86, 0x06, 0x18, 0x00,
  0x61, 0x81, 0xC6, 0x00, 0x18, 0xE0, 0x71, 0x80, 0x07, 0x38, 0x1C, 0xE0,
  0x01, 0xCE, 0x07, 0x30, 0x00, 0x33, 0x80, 0xCC, 0x00, 0x0C, 0xC0, 0x37,
  0x00, 0x03, 0xB0, 0x0D, 0x80, 0x00, 0x6C, 0x03, 0x60, 0x00, 0x1B, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x00, 0x1C, 0x38, 0x00,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x03, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x00,
  0xC0, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x30, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x0C, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x38,
  0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x07,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x03, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x38,
  0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x30,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x03, 0x83,
  0x80, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x00,
  0x0E, 0xE0, 0x00, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x00, 0x1D, 0xC0,
  0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x00,
  0x1C, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x70, 0x00, 0x00, 0x03, 0x80, 0xE0,
  0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0x07, 0x01, 0x80, 0x00, 0x00, 0x1C,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x00, 0x61, 0xC0, 0x00,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x03,
  0x87, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00,
  0x18, 0x06, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x38, 0x00,
  0x01, 0x80, 0x0E, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x03, 0x80, 0x00,
  0x70, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x01, 0x80, 0x38, 0x00,
  0x00, 0x70, 0x0C, 0x00, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x03, 0x83, 0x80,
  0x00, 0x00, 0x70, 0xC0, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0x03, 0x98,
  0x00, 0x00, 0x00, 0x6A, 0x00, 0x00, 0x00, 0x14, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x40, 0x70, 0x1C, 0x06, 0x03, 0x80, 0xE0,
  0x30, 0x1C, 0x07, 0x01, 0x80, 0x60, 0x30, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xC0, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xF8, 0x01, 0xF0, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x0E, 0x01, 0xC0, 0x00,
  0x07, 0x01, 0xC0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x01, 0xC0, 0x60, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x38, 0x1C, 0x00,
  0x00, 0x1C, 0x0E, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x07, 0x01, 0x80,
  0x00, 0x07, 0x80, 0xC0, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x02, 0xE0, 0x1C,
  0x00, 0x03, 0x70, 0x07, 0x00, 0x07, 0x38, 0x01, 0xF0, 0x0F, 0x0F, 0xF0,
  0x7F, 0xFE, 0x03, 0xF8, 0x07, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x07, 0xF8, 0x00, 0xE0, 0xFF, 0xF8, 0x07, 0x1E, 0x03,
  0xF0, 0x39, 0xC0, 0x03, 0xC1, 0xD8, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x38,
  0x78, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x1C, 0xE0,
  0x00, 0x00, 0x67, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x1D, 0xC0, 0x00,
  0x00, 0x6E, 0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00,
  0x37, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0xCE,
  0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x07, 0x1F, 0x00,
  0x00, 0x70, 0xEC, 0x00, 0x07, 0x87, 0x38, 0x00, 0x78, 0x38, 0xF0, 0x1F,
  0x01, 0xC1, 0xFF, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xF0, 0x1F, 0x00, 0x38, 0x00, 0x38, 0x07,
  0x00, 0x01, 0xC0, 0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x07, 0x38, 0x00, 0x00, 0x43, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x02, 0x18, 0x00, 0x00, 0x31, 0xC0, 0x00,
  0x07, 0x0E, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x1C, 0x03, 0x80, 0x03, 0x80,
  0x1F, 0x01, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x03, 0xFC, 0x07, 0x00, 0xFF, 0xF8, 0x38,
  0x1F, 0x80, 0xF1, 0xC1, 0xE0, 0x01, 0xCE, 0x1E, 0x00, 0x03, 0x70, 0xE0,
  0x00, 0x0F, 0x8E, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x01, 0xE7, 0x00, 0x00,
  0x07, 0x30, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x0E,
  0xC0, 0x00, 0x00, 0x76, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x07, 0x60,
  0x00, 0x00, 0x3B, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x0E, 0x60, 0x00,
  0x00, 0x73, 0x80, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x01,
  0xE1, 0xC0, 0x00, 0x1F, 0x0F, 0x00, 0x01, 0xB8, 0x3C, 0x00, 0x39, 0xC0,
  0xFC, 0x07, 0x8E, 0x01, 0xFF, 0xF0, 0x70, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1E, 0x01, 0xF0, 0x01, 0xE0,
  0x01, 0xE0, 0x0E, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x03, 0x81, 0xC0, 0x00,
  0x06, 0x0E, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x04, 0x70, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x03, 0x07, 0x00, 0x00, 0x1C, 0x0C,
  0x00, 0x00, 0xE0, 0x3C, 0x00, 0x07, 0x00, 0x78, 0x00, 0x38, 0x00, 0x7C,
  0x07, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x03, 0xFC, 0x30, 0x00, 0x07, 0xFF, 0xD8, 0x00, 0x0F,
  0x00, 0xFC, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x0E,
  0x00, 0x01, 0xC0, 0x06, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x18, 0x03,
  0x80, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x03, 0x80,
  0x60, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x00, 0x70,
  0x0C, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x18, 0x03, 0x80, 0x00, 0x0C,
  0x00, 0xC0, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x06,
  0x00, 0x07, 0x00, 0x0E, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x1C, 0x00, 0x01, 0xF0, 0x38, 0x00, 0x00, 0x3C, 0x30,
  0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x03, 0x98, 0x00, 0x00, 0x00, 0xDC,
  0x00, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x1B,
  0x80, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x07,
  0x38, 0x00, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x07, 0x07, 0x80, 0x00, 0x0F,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0xFF, 0x00, 0xE0, 0xFF, 0xF8, 0x38, 0xF0, 0x1F, 0x0E,
  0x60, 0x01, 0xE3, 0xB0, 0x00, 0x1C, 0xE8, 0x00, 0x03, 0xBC, 0x00, 0x00,
  0xEF, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x7B, 0x80, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x1C, 0x38, 0x00,
  0x01, 0xE0, 0xE0, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x70, 0x0E, 0x00, 0x03,
  0x80, 0x38, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x78, 0x00, 0x38, 0x03, 0xC0, 0x00, 0xE0, 0x1C, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x38, 0x3F, 0x00, 0x00, 0xE1,
  0xDE, 0x00, 0x03, 0x9E, 0x38, 0x00, 0x0E, 0xE0, 0x70, 0x00, 0x3F, 0x00,
  0xE0, 0x00, 0xF8, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x0E,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x38, 0x03, 0x80, 0x00, 0x70,
  0x0E, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x07, 0x03,
  0x80, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x38, 0xE0,
  0x00, 0x00, 0x73, 0x80, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x03, 0xB8, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF8, 0x03, 0xF0, 0xC7, 0xFC, 0x0F,
  0xFC, 0xCC, 0x0E, 0x18, 0x1C, 0xD8, 0x07, 0x30, 0x0E, 0xD0, 0x03, 0x20,
  0x06, 0xE0, 0x03, 0xC0, 0x07, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x01, 0x80,
  0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80,
  0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80,
  0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80,
  0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80,
  0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80,
  0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80,
  0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80,
  0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80,
  0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80,
  0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x3F, 0xC0,
  0x38, 0x3F, 0xFE, 0x0E, 0x3C, 0x07, 0xC3, 0x98, 0x00, 0x78, 0xEC, 0x00,
  0x07, 0x3A, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x06, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3E, 0x01, 0xF0, 0x01, 0xE0, 0x01,
  0xE0, 0x0E, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x03, 0x81, 0x80, 0x00, 0x06,
  0x0E, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x00, 0xE6,
  0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x76,
  0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x38, 0xC0,
  0x00, 0x00, 0xC3, 0x80, 0x00, 0x07, 0x06, 0x00, 0x00, 0x18, 0x1C, 0x00,
  0x00, 0xE0, 0x38, 0x00, 0x07, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x07,
  0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x07, 0x07, 0xFF, 0xC0, 0x38, 0xF0, 0x1F, 0x81, 0xCE, 0x00, 0x1E, 0x0E,
  0xC0, 0x00, 0x78, 0x7C, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x07, 0x1E, 0x00,
  0x00, 0x1C, 0xE0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x03, 0x38, 0x00, 0x00,
  0x1D, 0xC0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0x1B,
  0x80, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x06,
  0xE0, 0x00, 0x00, 0x37, 0x00, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x1D, 0xC0,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x73, 0xC0, 0x00,
  0x03, 0x9E, 0x00, 0x00, 0x38, 0xF8, 0x00, 0x03, 0x87, 0x60, 0x00, 0x3C,
  0x39, 0xC0, 0x03, 0xC1, 0xC7, 0x80, 0xF8, 0x0E, 0x0F, 0xFF, 0x80, 0x70,
  0x1F, 0xE0, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFF, 0xC1, 0xC0, 0xFC, 0x07,
  0x8E, 0x0F, 0x00, 0x0E, 0x70, 0xF0, 0x00, 0x1B, 0x87, 0x00, 0x00, 0x7C,
  0x70, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x0F, 0x38, 0x00, 0x00, 0x39, 0x80,
  0x00, 0x01, 0xDC, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x76, 0x00, 0x00,
  0x03, 0xB0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x01,
  0xD8, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x73, 0x00, 0x00, 0x03, 0x9C,
  0x00, 0x00, 0x1C, 0xE0, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x0F, 0x0E, 0x00,
  0x00, 0xF8, 0x78, 0x00, 0x0D, 0xC1, 0xE0, 0x01, 0xCE, 0x07, 0xE0, 0x3C,
  0x70, 0x0F, 0xFF, 0x83, 0x80, 0x0F, 0xF0, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xC0, 0x03, 0x0E, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x34, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x7C, 0x01, 0xF8, 0x03,
  0xC0, 0x00, 0xF8, 0x1C, 0x00, 0x00, 0xF0, 0x60, 0x00, 0x01, 0xE3, 0x80,
  0x00, 0x01, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0D, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x06,
  0x78, 0x00, 0x00, 0x38, 0x70, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x0E, 0x01,
  0xF8, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xD8, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x1F,
  0x38, 0x00, 0x0D, 0xC7, 0x80, 0x06, 0x70, 0xF8, 0x0F, 0x1C, 0x1F, 0xFF,
  0x87, 0x00, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x30,
  0xE0, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x07, 0x06, 0x00, 0x00, 0x18, 0x1C,
  0x00, 0x00, 0xE0, 0x30, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x0C, 0x03, 0x80,
  0x00, 0x70, 0x06, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x06, 0x00, 0x70, 0x00,
  0x38, 0x00, 0xC0, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x06, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x60, 0x00, 0x70, 0x03, 0x80, 0x00, 0xC0, 0x0C, 0x00,
  0x03, 0x00, 0x30, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x18, 0x06, 0x00, 0x00,
  0x70, 0x38, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x03, 0x03, 0x00, 0x00, 0x0E,
  0x1C, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x61, 0x80, 0x00, 0x01, 0xCE,
  0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xE0, 0x01, 0x98, 0x00, 0x36, 0x00, 0x19, 0x80, 0x07, 0x60,
  0x01, 0x98, 0x00, 0x66, 0x00, 0x19, 0x80, 0x06, 0x60, 0x03, 0x0C, 0x00,
  0x66, 0x00, 0x30, 0xC0, 0x06, 0x70, 0x03, 0x0C, 0x00, 0xE3, 0x00, 0x30,
  0xC0, 0x0C, 0x30, 0x06, 0x06, 0x00, 0xC3, 0x00, 0x60, 0x60, 0x0C, 0x30,
  0x06, 0x06, 0x00, 0xC3, 0x80, 0x60, 0x60, 0x0C, 0x38, 0x0C, 0x03, 0x01,
  0xC1, 0x80, 0xC0, 0x30, 0x18, 0x18, 0x0C, 0x03, 0x01, 0x81, 0x80, 0xC0,
  0x30, 0x18, 0x18, 0x18, 0x01, 0x81, 0x81, 0xC1, 0x80, 0x18, 0x38, 0x0C,
  0x18, 0x01, 0x83, 0x00, 0xC1, 0x80, 0x18, 0x30, 0x0C, 0x30, 0x00, 0xC3,
  0x00, 0xC3, 0x00, 0x0C, 0x30, 0x0C, 0x30, 0x00, 0xC3, 0x00, 0xE3, 0x00,
  0x0C, 0x70, 0x06, 0x60, 0x00, 0x66, 0x00, 0x66, 0x00, 0x06, 0x60, 0x06,
  0x60, 0x00, 0x66, 0x00, 0x66, 0x00, 0x06, 0x60, 0x07, 0xC0, 0x00, 0x36,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0xE0, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0xE3, 0x80, 0x00,
  0x07, 0x07, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x07,
  0x00, 0x70, 0x00, 0x38, 0x00, 0xE0, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x07, 0x00, 0x38, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x1C, 0x0E, 0x00, 0x00,
  0x70, 0x38, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x63, 0x80,
  0x00, 0x03, 0x87, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0xE0, 0x1C, 0x00,
  0x03, 0x00, 0x70, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x07,
  0x00, 0x03, 0x80, 0x18, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x1C, 0x07, 0x00,
  0x00, 0x38, 0x38, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x01, 0xC7, 0x00, 0x00,
  0x03, 0xB8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00,
  0x06, 0x70, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00,
  0x1C, 0x18, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00,
  0x38, 0x0C, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x70, 0x06, 0x00, 0x00,
  0x60, 0x07, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0xE0, 0x03, 0x00, 0x00,
  0xC0, 0x03, 0x80, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x03,
  0x80, 0x00, 0xC0, 0x03, 0x00, 0x00, 0xE0, 0x03, 0x00, 0x00, 0xE0, 0x07,
  0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x30, 0x0C,
  0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x18, 0x18,
  0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x0E, 0x70,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF0, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xC1, 0xFE, 0x00, 0x00, 0x30, 0xE1, 0xE0,
  0x00, 0x0C, 0x70, 0x1C, 0x00, 0x06, 0x38, 0x03, 0x80, 0x01, 0x8C, 0x00,
  0x60, 0x00, 0x63, 0x00, 0x0C, 0x00, 0x31, 0x80, 0x03, 0x80, 0x0C, 0x60,
  0x00, 0x70, 0x07, 0x18, 0x00, 0x0E, 0x03, 0x8C, 0x00, 0x01, 0xE1, 0xC3,
  0x00, 0x00, 0x1F, 0xE0, 0xC0, 0x00, 0x03, 0xE0, 0x00,
};

const GFXglyph IBMPlexMono_ExtraLight70pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 42, 0, -1 },
  { 1, 6, 49, 42, 18, -49 },
  { 38, 12, 18, 42, 15, -52 },
  { 65, 40, 49, 42, 1, -49 },
  { 310, 33, 65, 42, 4, -57 },
  { 579, 38, 51, 42, 2, -50 },
  { 822, 35, 51, 42, 3, -50 },
  { 1046, 2, 18, 42, 20, -52 },
  { 1051, 17, 63, 42, 16, -53 },
  { 1185, 17, 63, 42, 9, -53 },
  { 1319, 36, 35, 42, 3, -38 },
  { 1477, 34, 34, 42, 4, -38 },
  { 1622, 8, 18, 42, 16, -6 },
  { 1640, 18, 2, 42, 12, -22 },
  { 1645, 6, 6, 42, 18, -6 },
  { 1650, 28, 63, 42, 7, -53 },
  { 1871, 32, 51, 42, 5, -50 },
  { 2075, 34, 49, 42, 5, -49 },
  { 2284, 31, 50, 42, 6, -50 },
  { 2478, 30, 51, 42, 5, -50 },
  { 2670, 36, 49, 42, 3, -49 },
  { 2891, 30, 50, 42, 6, -49 },
  { 3079, 30, 50, 42, 6, -49 },
  { 3267, 31, 49, 42, 5, -49 },
  { 3457, 32, 51, 42, 5, -50 },
  { 3661, 30, 50, 42, 6, -50 },
  { 3849, 6, 37, 42, 18, -37 },
  { 3877, 8, 49, 42, 16, -37 },
  { 3926, 30, 38, 42, 6, -40 },
  { 4069, 34, 15, 42, 4, -29 },
  { 4133, 30, 38, 42, 6, -40 },
  { 4276, 28, 50, 42, 7, -50 },
  { 4451, 29, 57, 42, 6, -50 },
  { 4658, 36, 49, 42, 3, -49 },
  { 4879, 30, 49, 42, 7, -49 },
  { 5063, 32, 51, 42, 5, -50 },
  { 5267, 30, 49, 42, 7, -49 },
  { 5451, 29, 49, 42, 7, -49 },
  { 5629, 29, 49, 42, 7, -49 },
  { 5807, 31, 51, 42, 5, -50 },
  { 6005, 28, 49, 42, 7, -49 },
  { 6177, 30, 49, 42, 6, -49 },
  { 6361, 27, 50, 42, 6, -49 },
  { 6530, 32, 49, 42, 7, -49 },
  { 6726, 27, 49, 42, 10, -49 },
  { 6892, 30, 49, 42, 6, -49 },
  { 7076, 28, 49, 42, 7, -49 },
  { 7248, 32, 51, 42, 5, -50 },
  { 7452, 30, 49, 42, 7, -49 },
  { 7636, 32, 60, 42, 5, -50 },
  { 7876, 30, 49, 42, 7, -49 },
  { 8060, 33, 51, 42, 4, -50 },
  { 8271, 36, 49, 42, 3, -49 },
  { 8492, 28, 50, 42, 7, -49 },
  { 8667, 36, 49, 42, 3, -49 },
  { 8888, 34, 49, 42, 4, -49 },
  { 9097, 36, 49, 42, 3, -49 },
  { 9318, 38, 49, 42, 2, -49 },
  { 9551, 36, 49, 42, 3, -49 },
  { 9772, 17, 63, 42, 18, -53 },
  { 9906, 28, 63, 42, 7, -53 },
  { 10127, 17, 63, 42, 7, -53 },
  { 10261, 34, 27, 42, 4, -49 },
  { 10376, 34, 2, 42, 4, 8 },
  { 10385, 9, 12, 42, 14, -54 },
  { 10399, 33, 38, 42, 5, -37 },
  { 10556, 29, 53, 42, 8, -52 },
  { 10749, 28, 38, 42, 7, -37 },
  { 10882, 29, 53, 42, 5, -52 },
  { 11075, 30, 38, 42, 6, -37 },
  { 11218, 32, 52, 42, 6, -52 },
  { 11426, 33, 55, 42, 6, -40 },
  { 11653, 26, 52, 42, 8, -52 },
  { 11822, 30, 52, 42, 8, -52 },
  { 12017, 24, 66, 42, 7, -52 },
  { 12215, 30, 52, 42, 9, -52 },
  { 12410, 30, 52, 42, 6, -52 },
  { 12605, 32, 37, 42, 5, -37 },
  { 12753, 26, 37, 42, 8, -37 },
  { 12874, 30, 38, 42, 6, -37 },
  { 13017, 29, 51, 42, 8, -37 },
  { 13202, 29, 51, 42, 5, -37 },
  { 13387, 33, 36, 42, 6, -36 },
  { 13536, 30, 38, 42, 6, -37 },
  { 13679, 34, 49, 42, 3, -49 },
  { 13888, 26, 37, 42, 8, -36 },
  { 14009, 30, 36, 42, 6, -36 },
  { 14144, 36, 36, 42, 3, -36 },
  { 14306, 30, 36, 42, 6, -36 },
  { 14441, 32, 50, 42, 5, -36 },
  { 14641, 28, 36, 42, 7, -36 },
  { 14767, 26, 63, 42, 8, -53 },
  { 14972, 2, 63, 42, 20, -53 },
  { 14988, 26, 63, 42, 8, -53 },
  { 15193, 34, 13, 42, 4, -28 },
};

const GFXfont IBMPlexMono_ExtraLight70pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLight70pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLight70pt7bGlyphs,
  0x20, 0x7E, 91
};

#endif // _IBMPLEXMONO_EXTRALIGHT70PT7B_H_
