#ifndef _IBMPLEXMONO_EXTRALIGHT60PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHT60PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLight.ttf
// Size: 60pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLight60pt7bBitmaps[] PROGMEM = {
  0x00, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xEF, 0xBF, 0x79, 0xE0, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0C, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x18,
  0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x18,
  0x03, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00,
  0x60, 0x18, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x60, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0xFF, 0xF0, 0x0F, 0xFF,
  0x00, 0x1C, 0x03, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x30,
  0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x30,
  0x06, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x0F, 0xFF, 0x00, 0xFF, 0xF3, 0xFF,
  0xC0, 0x3F, 0xFC, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x70, 0x00, 0x00, 0x60, 0x18, 0x00,
  0x00, 0x38, 0x06, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x03, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x60,
  0x0C, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xC2, 0x1F, 0x00, 0xE0,
  0x20, 0x78, 0x1C, 0x02, 0x01, 0xC3, 0x80, 0x20, 0x0E, 0x30, 0x02, 0x00,
  0x66, 0x00, 0x20, 0x00, 0x60, 0x02, 0x00, 0x06, 0x00, 0x20, 0x00, 0x60,
  0x02, 0x00, 0x06, 0x00, 0x20, 0x00, 0x60, 0x02, 0x00, 0x06, 0x00, 0x20,
  0x00, 0x70, 0x02, 0x00, 0x03, 0x00, 0x20, 0x00, 0x38, 0x02, 0x00, 0x01,
  0xC0, 0x20, 0x00, 0x0E, 0x02, 0x00, 0x00, 0x7C, 0x20, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x21, 0xF0,
  0x00, 0x02, 0x03, 0x80, 0x00, 0x20, 0x1C, 0x00, 0x02, 0x00, 0xE0, 0x00,
  0x20, 0x06, 0x00, 0x02, 0x00, 0x60, 0x00, 0x20, 0x07, 0x00, 0x02, 0x00,
  0x30, 0x00, 0x20, 0x03, 0x00, 0x02, 0x00, 0x30, 0x00, 0x20, 0x03, 0x00,
  0x02, 0x00, 0x30, 0x00, 0x20, 0x07, 0xC0, 0x02, 0x00, 0x6E, 0x00, 0x20,
  0x06, 0x70, 0x02, 0x00, 0xC3, 0x80, 0x20, 0x1C, 0x1E, 0x02, 0x07, 0x80,
  0xFC, 0x21, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0x3C, 0x1C, 0x00, 0x03, 0x30, 0x0E, 0x00, 0x06, 0x60,
  0x07, 0x00, 0x0C, 0x60, 0x03, 0x00, 0x0C, 0xC0, 0x03, 0x00, 0x18, 0xC0,
  0x01, 0x80, 0x18, 0xC0, 0x01, 0x80, 0x30, 0xC0, 0x01, 0x80, 0x30, 0xC0,
  0x01, 0x80, 0x60, 0xC0, 0x01, 0x80, 0xC0, 0xC0, 0x01, 0x80, 0xC0, 0xC0,
  0x01, 0x81, 0x80, 0xC0, 0x03, 0x01, 0x80, 0x60, 0x03, 0x03, 0x00, 0x60,
  0x07, 0x06, 0x00, 0x30, 0x0E, 0x06, 0x00, 0x3C, 0x1C, 0x0C, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x30, 0x38, 0x3C, 0x00, 0x60, 0x70, 0x0C, 0x00, 0x60, 0xE0, 0x06, 0x00,
  0xC0, 0xC0, 0x06, 0x01, 0x80, 0xC0, 0x03, 0x01, 0x81, 0x80, 0x03, 0x03,
  0x01, 0x80, 0x03, 0x03, 0x01, 0x80, 0x03, 0x06, 0x01, 0x80, 0x03, 0x0C,
  0x01, 0x80, 0x03, 0x0C, 0x01, 0x80, 0x03, 0x18, 0x01, 0x80, 0x03, 0x18,
  0x00, 0xC0, 0x03, 0x30, 0x00, 0xC0, 0x06, 0x30, 0x00, 0xE0, 0x06, 0x60,
  0x00, 0x70, 0x0C, 0xC0, 0x00, 0x38, 0x3C, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x30, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x77, 0x00, 0x1F, 0xC3, 0x86, 0x00, 0x3F, 0x8E, 0x06, 0x00, 0x60,
  0x18, 0x0E, 0x00, 0xC0, 0x60, 0x0E, 0x01, 0x80, 0xC0, 0x0E, 0x03, 0x03,
  0x00, 0x0E, 0x06, 0x06, 0x00, 0x0C, 0x0C, 0x0C, 0x00, 0x0C, 0x30, 0x38,
  0x00, 0x0C, 0x60, 0x70, 0x00, 0x1C, 0xC0, 0xE0, 0x00, 0x1D, 0x81, 0xC0,
  0x00, 0x1F, 0x03, 0x80, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x1C, 0x06, 0x00,
  0x00, 0x78, 0x0E, 0x00, 0x00, 0x98, 0x0C, 0x00, 0x03, 0x38, 0x1C, 0x00,
  0x0C, 0x38, 0x1C, 0x00, 0x70, 0x38, 0x1F, 0x03, 0xC0, 0x38, 0x1F, 0xFF,
  0x00, 0x38, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x06, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x01,
  0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x38, 0x00, 0x70, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01,
  0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06,
  0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x30,
  0x00, 0x7C, 0x00, 0xC0, 0x0F, 0x7F, 0x03, 0x01, 0xF8, 0x3F, 0x8C, 0x7F,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00,
  0x38, 0x70, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x06, 0x01, 0x80, 0x00, 0x38,
  0x07, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x30, 0x01, 0xC0, 0x00, 0xE0, 0x06, 0x00, 0x01, 0x80, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x3C,
  0x78, 0xE1, 0xC3, 0x8E, 0x1C, 0x38, 0x60, 0xC3, 0x86, 0x0C, 0x18, 0x60,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7B, 0xEF, 0xDE, 0x78, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xE0, 0x7C,
  0x00, 0x70, 0x00, 0xE0, 0x0E, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x38, 0x18,
  0x00, 0x01, 0x83, 0x80, 0x00, 0x1C, 0x30, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x0C, 0x70, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0x60,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x67, 0x00, 0x00,
  0x0E, 0x30, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x01, 0xC1,
  0x80, 0x00, 0x18, 0x1C, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x70, 0x07, 0x00,
  0x0E, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7B, 0x00, 0x00, 0x0F,
  0x30, 0x00, 0x01, 0xE3, 0x00, 0x00, 0x38, 0x30, 0x00, 0x07, 0x03, 0x00,
  0x00, 0xE0, 0x30, 0x00, 0x1C, 0x03, 0x00, 0x07, 0x80, 0x30, 0x00, 0xF0,
  0x03, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x40, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x7F, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x3E, 0x03,
  0xE0, 0x0F, 0x00, 0x1E, 0x03, 0x80, 0x00, 0xE0, 0x60, 0x00, 0x1C, 0x1C,
  0x00, 0x01, 0xC3, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x03, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xFC, 0x00,
  0x78, 0x07, 0x80, 0x38, 0x00, 0x70, 0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x01,
  0xC3, 0x00, 0x00, 0x31, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x01, 0xFF,
  0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x06, 0x40, 0x00, 0x01, 0xB8, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x38, 0x3C, 0x00, 0x1E, 0x03, 0xE0, 0x1E, 0x00, 0x7F, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x76, 0x00, 0x00,
  0x01, 0x98, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x71, 0x80, 0x00, 0x01,
  0x86, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x70, 0x60, 0x00, 0x01, 0x81,
  0x80, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x60, 0x18, 0x00, 0x01, 0x80, 0x60,
  0x00, 0x0C, 0x01, 0x80, 0x00, 0x60, 0x06, 0x00, 0x01, 0x80, 0x18, 0x00,
  0x0C, 0x00, 0x60, 0x00, 0x60, 0x01, 0x80, 0x01, 0x80, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x60, 0x00, 0x60, 0x01, 0x80, 0x01, 0x80, 0x0C, 0x00,
  0x06, 0x00, 0x60, 0x00, 0x18, 0x01, 0x80, 0x00, 0x60, 0x0C, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x06, 0x01, 0x80, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x60,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xC1, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x1F, 0xF0, 0x03, 0x1F, 0xFF, 0x00, 0xDE, 0x01, 0xE0, 0x3E,
  0x00, 0x1E, 0x0E, 0x00, 0x03, 0x83, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x19,
  0x00, 0x00, 0x0E, 0xE0, 0x00, 0x03, 0x18, 0x00, 0x01, 0xC7, 0x80, 0x00,
  0xE0, 0x70, 0x00, 0x70, 0x0F, 0x80, 0x78, 0x01, 0xFF, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x1F, 0xE0,
  0x06, 0x1F, 0xFF, 0x01, 0x9E, 0x01, 0xE0, 0x6E, 0x00, 0x1E, 0x1E, 0x00,
  0x03, 0x8D, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x01, 0xB8,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xD8, 0x00, 0x00, 0x76, 0x00, 0x00, 0x19, 0x80, 0x00, 0x06, 0x30,
  0x00, 0x03, 0x8E, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0xE0, 0x38, 0x00, 0x70,
  0x07, 0x80, 0x78, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x6E,
  0x00, 0x00, 0x0D, 0xC0, 0x00, 0x03, 0x38, 0x00, 0x00, 0x67, 0x00, 0x00,
  0x1C, 0xE0, 0x00, 0x03, 0x1C, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xFF, 0x80, 0x07, 0xC0, 0x3E, 0x00, 0xF0, 0x00, 0xF0, 0x1C, 0x00,
  0x03, 0x81, 0x80, 0x00, 0x18, 0x38, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x0C,
  0x30, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x0E, 0x30, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00,
  0xC3, 0x80, 0x00, 0x1C, 0x18, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x30, 0x07,
  0x00, 0x0E, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0x00, 0x07, 0xC0, 0x3E, 0x00, 0xE0, 0x00, 0x70, 0x1C, 0x00, 0x03, 0x83,
  0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x06, 0x60, 0x00,
  0x00, 0x6E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x06, 0x60, 0x00, 0x00, 0x67, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0x38, 0x1E, 0x00, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x03,
  0xFF, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xFC,
  0x00, 0x7C, 0x07, 0x80, 0x38, 0x00, 0x70, 0x1C, 0x00, 0x06, 0x0E, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x39, 0x80, 0x00, 0x06, 0x60, 0x00, 0x01, 0xB8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xD8, 0x00, 0x00, 0x76, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x0F, 0x38,
  0x00, 0x02, 0xC7, 0x00, 0x01, 0xB1, 0xE0, 0x01, 0xD8, 0x1E, 0x01, 0xE6,
  0x03, 0xFF, 0xE1, 0x80, 0x1F, 0xE0, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x7B, 0xEF, 0xDE, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0xFB,
  0xF7, 0x9E, 0x1E, 0x3E, 0x3F, 0x1E, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0E, 0x1E, 0x1E, 0x1C, 0x1C, 0x1C, 0x38, 0x38,
  0x38, 0x30, 0x30, 0x70, 0x60, 0x60, 0x60, 0xC0, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xE0,
  0x0F, 0x00, 0xF0, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x0E,
  0x60, 0x00, 0x06, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0xF0, 0x3E,
  0x00, 0xE0, 0x03, 0x80, 0xE0, 0x00, 0xC0, 0xE0, 0x00, 0x30, 0x60, 0x00,
  0x1C, 0x70, 0x00, 0x06, 0x30, 0x00, 0x03, 0x18, 0x00, 0x01, 0x98, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x36, 0x00, 0x00, 0x1B, 0x00, 0x1F, 0x0D, 0x80,
  0x3F, 0xE6, 0xC0, 0x38, 0x1B, 0xC0, 0x38, 0x05, 0xE0, 0x18, 0x01, 0xF0,
  0x18, 0x00, 0x78, 0x0C, 0x00, 0x3C, 0x06, 0x00, 0x1E, 0x06, 0x00, 0x0F,
  0x03, 0x00, 0x07, 0x81, 0x80, 0x03, 0xC0, 0xC0, 0x01, 0xE0, 0x60, 0x00,
  0xF0, 0x30, 0x00, 0x78, 0x18, 0x00, 0x3C, 0x0C, 0x00, 0x1E, 0x03, 0x00,
  0x0F, 0x01, 0x80, 0x07, 0x80, 0xC0, 0x03, 0xC0, 0x60, 0x03, 0xA0, 0x18,
  0x01, 0xD8, 0x0E, 0x01, 0x6C, 0x03, 0xFF, 0x36, 0x00, 0xFF, 0x1B, 0x00,
  0x04, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0x70, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x33, 0x00, 0x00,
  0x01, 0x8E, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00,
  0xE1, 0xC0, 0x00, 0x03, 0x03, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x70,
  0x38, 0x00, 0x01, 0x80, 0x60, 0x00, 0x06, 0x01, 0x80, 0x00, 0x38, 0x07,
  0x00, 0x00, 0xC0, 0x0C, 0x00, 0x03, 0x00, 0x30, 0x00, 0x1C, 0x00, 0xE0,
  0x00, 0x60, 0x01, 0x80, 0x01, 0x80, 0x06, 0x00, 0x06, 0x00, 0x1C, 0x00,
  0x30, 0x00, 0x30, 0x00, 0xC0, 0x00, 0xC0, 0x03, 0x00, 0x03, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x0C, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x0C, 0x06, 0x00, 0x00,
  0x18, 0x18, 0x00, 0x00, 0x60, 0x60, 0x00, 0x01, 0x83, 0x00, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x00, 0xE6,
  0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x30, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x30, 0x00, 0x3E,
  0x18, 0x00, 0x07, 0x0C, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x73, 0x00, 0x00,
  0x19, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x06, 0x60, 0x00, 0x03, 0x30, 0x00,
  0x01, 0xD8, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x66, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x19, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x0E, 0x30,
  0x00, 0x0E, 0x18, 0x00, 0x1E, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x83,
  0x00, 0x00, 0xF1, 0x80, 0x00, 0x1C, 0xC0, 0x00, 0x07, 0x60, 0x00, 0x01,
  0xB0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x3B, 0x00, 0x00, 0x39, 0x80, 0x00, 0x78, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x3E, 0x03,
  0xC0, 0x1C, 0x00, 0x38, 0x0E, 0x00, 0x07, 0x07, 0x00, 0x00, 0xE1, 0x80,
  0x00, 0x18, 0xE0, 0x00, 0x03, 0x30, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x38, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x38, 0x38, 0x00,
  0x1C, 0x07, 0x00, 0x0E, 0x00, 0xF8, 0x0F, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x0C, 0x00, 0x1F, 0x03,
  0x00, 0x00, 0xE0, 0xC0, 0x00, 0x1C, 0x30, 0x00, 0x03, 0x8C, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x3B, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xB0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x0E, 0xC0, 0x00,
  0x03, 0x30, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x73, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x0E, 0x30, 0x00, 0x07, 0x0C, 0x00, 0x03, 0x83, 0x00, 0x07, 0xC0,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFB, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFB, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xFF, 0x00, 0x07, 0x80, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0xE0, 0x00, 0x70,
  0x18, 0x00, 0x07, 0x07, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x06, 0x38, 0x00,
  0x00, 0xC6, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0xD8, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x6E, 0x00,
  0x00, 0x0C, 0xC0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x71, 0x80, 0x00, 0x0E,
  0x38, 0x00, 0x02, 0xC3, 0x00, 0x00, 0x58, 0x70, 0x00, 0x13, 0x07, 0x80,
  0x0E, 0x60, 0x7C, 0x07, 0x8C, 0x03, 0xFF, 0xC1, 0x80, 0x1F, 0xE0, 0x00,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x66, 0x00, 0x00, 0xCE, 0x00, 0x03,
  0x8E, 0x00, 0x0E, 0x0E, 0x00, 0x38, 0x0F, 0x01, 0xE0, 0x0F, 0xFF, 0x80,
  0x03, 0xF8, 0x00, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3B, 0x00, 0x00,
  0x0E, 0x60, 0x00, 0x03, 0x8C, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x18, 0x30,
  0x00, 0x06, 0x06, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x70, 0x18, 0x00, 0x1C,
  0x03, 0x00, 0x07, 0x00, 0x60, 0x01, 0xC0, 0x0C, 0x00, 0x70, 0x01, 0x80,
  0x1C, 0x00, 0x30, 0x03, 0x00, 0x06, 0x00, 0xC0, 0x00, 0xC0, 0x38, 0x00,
  0x18, 0x0E, 0x00, 0x03, 0x03, 0xC0, 0x00, 0x60, 0xFC, 0x00, 0x0C, 0x39,
  0x80, 0x01, 0x8E, 0x38, 0x00, 0x31, 0x83, 0x80, 0x06, 0x60, 0x30, 0x00,
  0xD8, 0x07, 0x00, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x06, 0x00, 0x70, 0x00,
  0xE0, 0x0C, 0x00, 0x0C, 0x01, 0x80, 0x00, 0xC0, 0x30, 0x00, 0x1C, 0x06,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x38, 0x18, 0x00, 0x03, 0x83, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x71, 0x80, 0x00, 0x06, 0x30,
  0x00, 0x00, 0xE6, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0xD8, 0x00, 0x00,
  0x1C, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xD8, 0x00, 0x06, 0xF6,
  0x00, 0x01, 0xBC, 0xC0, 0x00, 0xCF, 0x30, 0x00, 0x33, 0xCE, 0x00, 0x18,
  0xF1, 0x80, 0x06, 0x3C, 0x70, 0x01, 0x8F, 0x0C, 0x00, 0xC3, 0xC3, 0x00,
  0x30, 0xF0, 0x60, 0x18, 0x3C, 0x18, 0x06, 0x0F, 0x03, 0x03, 0x03, 0xC0,
  0xC0, 0xC0, 0xF0, 0x18, 0x60, 0x3C, 0x06, 0x18, 0x0F, 0x01, 0xC6, 0x03,
  0xC0, 0x33, 0x00, 0xF0, 0x0C, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x0C, 0x00, 0xF0, 0x03, 0x00, 0x3C, 0x00, 0x80, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x30,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xD8, 0x00, 0x03, 0xD8, 0x00, 0x03, 0xCC, 0x00, 0x03, 0xCC, 0x00, 0x03,
  0xC6, 0x00, 0x03, 0xC6, 0x00, 0x03, 0xC3, 0x00, 0x03, 0xC3, 0x00, 0x03,
  0xC1, 0x80, 0x03, 0xC1, 0x80, 0x03, 0xC0, 0xC0, 0x03, 0xC0, 0xC0, 0x03,
  0xC0, 0x60, 0x03, 0xC0, 0x60, 0x03, 0xC0, 0x30, 0x03, 0xC0, 0x30, 0x03,
  0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x0C, 0x03, 0xC0, 0x0C, 0x03,
  0xC0, 0x06, 0x03, 0xC0, 0x06, 0x03, 0xC0, 0x03, 0x03, 0xC0, 0x03, 0x03,
  0xC0, 0x01, 0x83, 0xC0, 0x01, 0x83, 0xC0, 0x00, 0xC3, 0xC0, 0x00, 0xC3,
  0xC0, 0x00, 0x63, 0xC0, 0x00, 0x63, 0xC0, 0x00, 0x33, 0xC0, 0x00, 0x33,
  0xC0, 0x00, 0x1B, 0xC0, 0x00, 0x1B, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xE0, 0x7C, 0x00, 0x70, 0x00, 0xE0, 0x0E, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0x38, 0x18, 0x00, 0x01, 0x83, 0x80, 0x00, 0x1C, 0x30, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0x66, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x6E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x66, 0x00, 0x00, 0x06, 0x60, 0x00,
  0x00, 0x67, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x0C,
  0x38, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x18, 0x1C, 0x00, 0x03, 0x80, 0xE0,
  0x00, 0x70, 0x07, 0x00, 0x0E, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x0C, 0x00,
  0x03, 0xC3, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x07, 0x30, 0x00, 0x00, 0xEC,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x01, 0xB0,
  0x00, 0x00, 0xEC, 0x00, 0x00, 0x73, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x3C,
  0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x70, 0x00, 0xE0, 0x0E,
  0x00, 0x07, 0x01, 0xC0, 0x00, 0x38, 0x18, 0x00, 0x01, 0x83, 0x80, 0x00,
  0x1C, 0x30, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0xE6,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x66, 0x00, 0x00, 0x06, 0xE0, 0x00,
  0x00, 0x6E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x06, 0x60, 0x00, 0x00, 0x67, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x0C, 0x38, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x18, 0x1C, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x70, 0x07, 0x00, 0x0E, 0x00, 0x3E, 0x03, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x0C, 0x00, 0x03, 0xC3, 0x00, 0x00, 0x38,
  0xC0, 0x00, 0x07, 0x30, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xEC, 0x00, 0x00,
  0x73, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x3C, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFE, 0x03, 0x00, 0x30, 0x00, 0xC0, 0x0E, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x70, 0x03, 0x00, 0x0E, 0x00, 0xC0, 0x01, 0x80, 0x30, 0x00, 0x70,
  0x0C, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x70, 0x30, 0x00,
  0x0C, 0x0C, 0x00, 0x03, 0x83, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x0C, 0x30,
  0x00, 0x03, 0x8C, 0x00, 0x00, 0x63, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x03,
  0xB0, 0x00, 0x00, 0x70, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x07,
  0xC0, 0x3F, 0x01, 0xE0, 0x00, 0x78, 0x1C, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x0E, 0x70, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x6E, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x1C,
  0x1E, 0x00, 0x07, 0x80, 0xFC, 0x03, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x60,
  0x00, 0x06, 0x60, 0x00, 0x06, 0x70, 0x00, 0x0E, 0x30, 0x00, 0x0C, 0x3C,
  0x00, 0x3C, 0x1F, 0x00, 0xF8, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x76, 0x00, 0x00, 0x01, 0x9C, 0x00,
  0x00, 0x06, 0x70, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x03, 0x0E, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x60, 0x60, 0x00, 0x01,
  0x81, 0xC0, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0xC0,
  0x38, 0x00, 0x07, 0x00, 0x60, 0x00, 0x18, 0x01, 0x80, 0x00, 0x60, 0x07,
  0x00, 0x03, 0x80, 0x0C, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x30, 0x00, 0xE0,
  0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x06, 0x00, 0x18, 0x00, 0x1C, 0x00,
  0x60, 0x00, 0x30, 0x03, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x03, 0x00, 0x30,
  0x00, 0x06, 0x01, 0xC0, 0x00, 0x18, 0x06, 0x00, 0x00, 0x60, 0x18, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0x03, 0x03, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00,
  0x38, 0x70, 0x00, 0x00, 0x61, 0x80, 0x00, 0x01, 0x86, 0x00, 0x00, 0x07,
  0x38, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xD0, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x19, 0x80,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x06, 0x60, 0x03,
  0x00, 0x19, 0x80, 0x1E, 0x00, 0x62, 0x00, 0x78, 0x01, 0x8C, 0x01, 0xE0,
  0x0C, 0x30, 0x0C, 0xC0, 0x30, 0xC0, 0x33, 0x00, 0xC3, 0x00, 0xCC, 0x03,
  0x0C, 0x03, 0x30, 0x0C, 0x30, 0x18, 0x60, 0x30, 0xC0, 0x61, 0x80, 0xC3,
  0x01, 0x86, 0x03, 0x0C, 0x06, 0x18, 0x0C, 0x30, 0x30, 0x30, 0x30, 0x60,
  0xC0, 0xC0, 0xC1, 0x83, 0x03, 0x06, 0x06, 0x18, 0x06, 0x18, 0x18, 0x60,
  0x18, 0x60, 0x61, 0x80, 0x61, 0x81, 0x86, 0x01, 0x86, 0x06, 0x30, 0x03,
  0x18, 0x18, 0xC0, 0x0C, 0x60, 0x63, 0x00, 0x31, 0x81, 0x8C, 0x00, 0xC6,
  0x06, 0x60, 0x01, 0x98, 0x0D, 0x80, 0x06, 0x40, 0x36, 0x00, 0x1B, 0x00,
  0xF0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0xF0, 0x0F, 0x00, 0x03, 0xC0, 0x3C,
  0x00, 0x0F, 0x00, 0xE0, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0xE3, 0x00,
  0x00, 0x03, 0x0E, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0xE0, 0x30, 0x00,
  0x03, 0x00, 0xE0, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x60, 0x03, 0x00, 0x03,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x30, 0x03, 0x00,
  0x00, 0xE0, 0x1C, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x0E, 0x1C, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x1C, 0xE0,
  0x00, 0x00, 0x61, 0xC0, 0x00, 0x03, 0x03, 0x00, 0x00, 0x1C, 0x0E, 0x00,
  0x00, 0x60, 0x1C, 0x00, 0x03, 0x00, 0x30, 0x00, 0x1C, 0x00, 0xE0, 0x00,
  0x60, 0x01, 0xC0, 0x03, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x60,
  0x00, 0x1C, 0x03, 0x00, 0x00, 0x30, 0x1C, 0x00, 0x00, 0xE0, 0x60, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00,
  0x1B, 0x00, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00,
  0x00, 0xE3, 0x80, 0x00, 0x00, 0x70, 0x60, 0x00, 0x00, 0x18, 0x1C, 0x00,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0x03, 0x00, 0x60, 0x00, 0x01, 0x80, 0x1C,
  0x00, 0x00, 0xE0, 0x03, 0x00, 0x00, 0x30, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x1C,
  0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0xE1,
  0xC0, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x03, 0x38, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0x98, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x18, 0x03, 0x80, 0x01,
  0x80, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x60, 0x00,
  0x60, 0x0E, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x30, 0x18, 0x00, 0x01, 0x81,
  0x80, 0x00, 0x18, 0x30, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x0E, 0x60, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x30, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE0, 0x70, 0x30, 0x18, 0x1C, 0x0C, 0x06,
  0x03, 0x03, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0x80, 0xF0,
  0x01, 0xE0, 0x03, 0x80, 0x18, 0x00, 0x1C, 0x03, 0x00, 0x00, 0xC0, 0x30,
  0x00, 0x0E, 0x02, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF,
  0xFE, 0x01, 0xF0, 0x00, 0x60, 0x38, 0x00, 0x06, 0x07, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60, 0x60, 0x00, 0x06, 0x0E, 0x00,
  0x00, 0x60, 0xE0, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60, 0x60, 0x00, 0x0E,
  0x06, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x16, 0x03, 0x80, 0x06, 0x60, 0x1E,
  0x01, 0xC7, 0xF0, 0xFF, 0xF8, 0x3F, 0x01, 0xFE, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x0F, 0xF0, 0x06, 0x1F, 0xFE, 0x03, 0x1C, 0x07, 0xC1, 0x98, 0x00, 0xF0,
  0xD8, 0x00, 0x18, 0x78, 0x00, 0x0E, 0x38, 0x00, 0x03, 0x9C, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x66, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x0D, 0x80, 0x00,
  0x06, 0xC0, 0x00, 0x03, 0x60, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x0D, 0x80,
  0x00, 0x06, 0xC0, 0x00, 0x03, 0x60, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xD8,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x67, 0x00, 0x00, 0x33, 0x80, 0x00, 0x39,
  0xE0, 0x00, 0x38, 0xD8, 0x00, 0x18, 0x66, 0x00, 0x3C, 0x31, 0xC0, 0x7C,
  0x18, 0x7F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xFF,
  0xE0, 0x07, 0xC0, 0x78, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x18, 0x00,
  0x06, 0x38, 0x00, 0x03, 0x30, 0x00, 0x02, 0x70, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x38, 0x00, 0x03, 0x18, 0x00, 0x07, 0x1C, 0x00, 0x0E, 0x0E, 0x00,
  0x1C, 0x07, 0xC0, 0x78, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x07, 0xF8, 0x18, 0x0F, 0xFF, 0x0C, 0x1F, 0x01, 0xC6, 0x1E, 0x00, 0x33,
  0x0C, 0x00, 0x0D, 0x8C, 0x00, 0x03, 0xCE, 0x00, 0x00, 0xE6, 0x00, 0x00,
  0x73, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x06, 0xC0, 0x00,
  0x03, 0x60, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x06, 0xC0,
  0x00, 0x03, 0x60, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x19, 0x80, 0x00, 0x1C, 0xE0, 0x00, 0x0E,
  0x30, 0x00, 0x0F, 0x0C, 0x00, 0x0D, 0x87, 0x80, 0x0C, 0xC1, 0xF0, 0x1C,
  0x60, 0x3F, 0xFC, 0x30, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0xF8, 0x00, 0x7C, 0x07, 0x80, 0x38, 0x00, 0x70, 0x1C, 0x00, 0x0E, 0x06,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x01,
  0x98, 0x00, 0x00, 0x66, 0x00, 0x00, 0x19, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x63, 0x00, 0x00, 0x38, 0x60,
  0x00, 0x0C, 0x1C, 0x00, 0x06, 0x03, 0x80, 0x07, 0x00, 0x7C, 0x07, 0x80,
  0x07, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x01,
  0xFF, 0xFC, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0x88, 0x00, 0x1F,
  0xFE, 0x80, 0x03, 0xC0, 0x78, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x0C,
  0x01, 0xC0, 0x00, 0x60, 0x18, 0x00, 0x06, 0x01, 0x80, 0x00, 0x70, 0x18,
  0x00, 0x03, 0x03, 0x80, 0x00, 0x30, 0x38, 0x00, 0x03, 0x03, 0x80, 0x00,
  0x30, 0x18, 0x00, 0x03, 0x01, 0x80, 0x00, 0x70, 0x18, 0x00, 0x06, 0x01,
  0xC0, 0x00, 0x60, 0x0E, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x03, 0xC0,
  0x78, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x70, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xF8, 0x06, 0x00, 0x03, 0xC1, 0x80, 0x00, 0x0E, 0x30,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x6E,
  0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x3C, 0x1E, 0x00,
  0x0F, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0xFF, 0x03, 0x0F, 0xFF, 0x0C,
  0x70, 0x1E, 0x33, 0x00, 0x1C, 0xD0, 0x00, 0x3B, 0x40, 0x00, 0x6E, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFE, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xCF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xE0, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x01, 0xCC, 0x00,
  0x00, 0xE3, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x38, 0x0C,
  0x00, 0x1C, 0x03, 0x00, 0x0E, 0x00, 0xC0, 0x07, 0x00, 0x30, 0x03, 0x80,
  0x0C, 0x01, 0xC0, 0x03, 0x00, 0xC0, 0x00, 0xC0, 0xE0, 0x00, 0x30, 0x78,
  0x00, 0x0C, 0x3F, 0x00, 0x03, 0x1C, 0xC0, 0x00, 0xCE, 0x18, 0x00, 0x36,
  0x07, 0x00, 0x0F, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x03, 0x80,
  0x30, 0x00, 0x60, 0x0C, 0x00, 0x1C, 0x03, 0x00, 0x03, 0x80, 0xC0, 0x00,
  0x70, 0x30, 0x00, 0x0E, 0x0C, 0x00, 0x01, 0x83, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x0E, 0x30, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03,
  0xE0, 0x1F, 0x0C, 0xFF, 0x87, 0xFC, 0xCC, 0x38, 0xE1, 0xED, 0x00, 0xC8,
  0x06, 0xE0, 0x0D, 0x00, 0x6E, 0x00, 0x70, 0x03, 0xC0, 0x06, 0x00, 0x3C,
  0x00, 0x60, 0x03, 0xC0, 0x06, 0x00, 0x3C, 0x00, 0x60, 0x03, 0xC0, 0x06,
  0x00, 0x3C, 0x00, 0x60, 0x03, 0xC0, 0x06, 0x00, 0x3C, 0x00, 0x60, 0x03,
  0xC0, 0x06, 0x00, 0x3C, 0x00, 0x60, 0x03, 0xC0, 0x06, 0x00, 0x3C, 0x00,
  0x60, 0x03, 0xC0, 0x06, 0x00, 0x3C, 0x00, 0x60, 0x03, 0xC0, 0x06, 0x00,
  0x3C, 0x00, 0x60, 0x03, 0xC0, 0x06, 0x00, 0x3C, 0x00, 0x60, 0x03, 0xC0,
  0x06, 0x00, 0x3C, 0x00, 0x60, 0x03, 0xC0, 0x06, 0x00, 0x3C, 0x00, 0x60,
  0x03, 0xC0, 0x06, 0x00, 0x3C, 0x00, 0x60, 0x03, 0xC0, 0x06, 0x00, 0x3C,
  0x00, 0x60, 0x03, 0x00, 0xFF, 0x03, 0x0F, 0xFF, 0x0C, 0x70, 0x1E, 0x33,
  0x00, 0x1C, 0xD0, 0x00, 0x3B, 0x40, 0x00, 0x6E, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0xF8, 0x00, 0x7C, 0x0F, 0x80, 0x38, 0x00, 0x70, 0x1C, 0x00, 0x0E, 0x06,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x01,
  0x98, 0x00, 0x00, 0x66, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x76, 0x00, 0x00, 0x19, 0x80, 0x00,
  0x06, 0x60, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x18, 0x1C, 0x00, 0x0E, 0x03, 0x80, 0x07, 0x00, 0x78, 0x07, 0x80,
  0x07, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x61, 0xFF,
  0xE0, 0x31, 0xC0, 0x7C, 0x19, 0x80, 0x0F, 0x0D, 0x80, 0x01, 0x87, 0x80,
  0x00, 0xE3, 0x80, 0x00, 0x39, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x06, 0x60,
  0x00, 0x01, 0xB0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x06, 0xC0, 0x00,
  0x06, 0x70, 0x00, 0x03, 0x38, 0x00, 0x03, 0x9E, 0x00, 0x03, 0x8D, 0x80,
  0x01, 0x86, 0x60, 0x03, 0xC3, 0x1C, 0x07, 0xC1, 0x87, 0xFF, 0x80, 0xC0,
  0xFF, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xF0, 0xC1, 0xF0, 0x1C, 0x61, 0xE0,
  0x03, 0x30, 0xC0, 0x00, 0xD8, 0xC0, 0x00, 0x3C, 0xE0, 0x00, 0x0E, 0x60,
  0x00, 0x07, 0x30, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xD8, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x36, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x0D, 0x80, 0x00,
  0x06, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x01, 0x98, 0x00, 0x01, 0xCE, 0x00,
  0x00, 0xE3, 0x00, 0x00, 0xF0, 0xC0, 0x00, 0xD8, 0x78, 0x00, 0xCC, 0x1F,
  0x01, 0xC6, 0x03, 0xFF, 0xC3, 0x00, 0x7F, 0x81, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0x0F, 0xFF, 0x00, 0x31, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x03, 0x40, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x0F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0xFC, 0x00, 0xF8, 0x07, 0xC0, 0x70, 0x00, 0x38, 0x18, 0x00, 0x07,
  0x0C, 0x00, 0x00, 0x63, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0D,
  0xC0, 0x00, 0x06, 0x38, 0x00, 0x03, 0x87, 0x80, 0x01, 0xC0, 0xFC, 0x03,
  0xE0, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x76, 0x00, 0x03, 0xDC, 0x00, 0x0B, 0x38, 0x00,
  0xEC, 0x78, 0x0F, 0x30, 0xFF, 0xF0, 0xC0, 0xFF, 0x00, 0xE0, 0x00, 0x00,
  0xD8, 0x00, 0x00, 0x66, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x0E, 0x30, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x60, 0x60, 0x00, 0x18, 0x18,
  0x00, 0x06, 0x03, 0x00, 0x03, 0x00, 0xC0, 0x00, 0xC0, 0x38, 0x00, 0x30,
  0x06, 0x00, 0x18, 0x01, 0x80, 0x06, 0x00, 0x30, 0x03, 0x00, 0x0C, 0x00,
  0xC0, 0x03, 0x00, 0x30, 0x00, 0x60, 0x18, 0x00, 0x18, 0x06, 0x00, 0x06,
  0x01, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x06, 0x18, 0x00,
  0x01, 0x86, 0x00, 0x00, 0x61, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x03, 0x30,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x60, 0x03,
  0xC0, 0x02, 0x60, 0x03, 0x40, 0x06, 0x60, 0x02, 0x40, 0x06, 0x60, 0x06,
  0x60, 0x06, 0x60, 0x06, 0x60, 0x06, 0x20, 0x06, 0x20, 0x06, 0x30, 0x04,
  0x20, 0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x30, 0x0C,
  0x30, 0x0C, 0x30, 0x08, 0x10, 0x0C, 0x10, 0x18, 0x18, 0x08, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x10, 0x08, 0x18, 0x18, 0x30,
  0x0C, 0x18, 0x18, 0x30, 0x0C, 0x18, 0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x20,
  0x04, 0x30, 0x0C, 0x60, 0x06, 0x30, 0x0C, 0x60, 0x06, 0x30, 0x0C, 0x60,
  0x06, 0x30, 0x04, 0x40, 0x02, 0x20, 0x06, 0xC0, 0x03, 0x60, 0x06, 0xC0,
  0x03, 0x60, 0x06, 0xC0, 0x03, 0x60, 0x06, 0x80, 0x01, 0x60, 0x07, 0x80,
  0x01, 0xE0, 0x03, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0x01, 0xDC, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x30, 0x60, 0x00, 0x18, 0x0C, 0x00, 0x0C, 0x03, 0x80,
  0x07, 0x00, 0x70, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x01, 0x80, 0x60, 0x00,
  0x70, 0x38, 0x00, 0x0E, 0x0C, 0x00, 0x01, 0x86, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0D, 0xC0, 0x00, 0x07, 0x38, 0x00, 0x01, 0x86, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x38, 0x07, 0x00, 0x0C, 0x00, 0xC0,
  0x06, 0x00, 0x18, 0x03, 0x80, 0x07, 0x01, 0xC0, 0x00, 0xE0, 0x60, 0x00,
  0x18, 0x30, 0x00, 0x03, 0x1C, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x1C, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x19, 0x80, 0x00, 0x06,
  0x70, 0x00, 0x03, 0x8C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x18, 0x18, 0x00, 0x06, 0x07, 0x00, 0x03, 0x80, 0xC0, 0x00, 0xC0, 0x30,
  0x00, 0x30, 0x06, 0x00, 0x18, 0x01, 0x80, 0x06, 0x00, 0x30, 0x03, 0x00,
  0x0C, 0x00, 0xC0, 0x03, 0x80, 0x30, 0x00, 0x60, 0x18, 0x00, 0x18, 0x06,
  0x00, 0x03, 0x03, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x06,
  0x18, 0x00, 0x01, 0x86, 0x00, 0x00, 0x33, 0x00, 0x00, 0x0C, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x01, 0xE0, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xF8, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x40, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x78, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0xFF, 0xF8,
  0x03, 0xFF, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x0C, 0x3F, 0xC0, 0x00, 0x21,
  0xC3, 0x80, 0x01, 0x86, 0x03, 0x80, 0x06, 0x30, 0x06, 0x00, 0x18, 0xC0,
  0x0C, 0x00, 0xC6, 0x00, 0x18, 0x03, 0x18, 0x00, 0x70, 0x18, 0x60, 0x00,
  0xF0, 0xE1, 0x00, 0x00, 0xFF, 0x0C, 0x00, 0x01, 0xF0, 0x00,
};

const GFXglyph IBMPlexMono_ExtraLight60pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 36, 0, -1 },
  { 1, 6, 42, 36, 15, -42 },
  { 33, 10, 15, 36, 13, -44 },
  { 52, 34, 42, 36, 1, -42 },
  { 231, 28, 56, 36, 4, -49 },
  { 427, 32, 44, 36, 2, -43 },
  { 603, 31, 44, 36, 2, -43 },
  { 774, 2, 15, 36, 17, -44 },
  { 778, 14, 54, 36, 14, -46 },
  { 873, 14, 54, 36, 8, -46 },
  { 968, 30, 30, 36, 3, -33 },
  { 1081, 28, 30, 36, 4, -33 },
  { 1186, 7, 16, 36, 13, -6 },
  { 1200, 16, 2, 36, 10, -19 },
  { 1204, 6, 5, 36, 15, -5 },
  { 1208, 24, 54, 36, 6, -46 },
  { 1370, 28, 44, 36, 4, -43 },
  { 1524, 28, 42, 36, 5, -42 },
  { 1671, 27, 43, 36, 5, -43 },
  { 1817, 26, 44, 36, 4, -43 },
  { 1960, 30, 42, 36, 3, -42 },
  { 2118, 26, 43, 36, 5, -42 },
  { 2258, 26, 43, 36, 5, -42 },
  { 2398, 27, 42, 36, 4, -42 },
  { 2540, 28, 44, 36, 4, -43 },
  { 2694, 26, 43, 36, 5, -43 },
  { 2834, 6, 32, 36, 15, -32 },
  { 2858, 8, 42, 36, 13, -32 },
  { 2900, 26, 33, 36, 5, -35 },
  { 3008, 28, 13, 36, 4, -25 },
  { 3054, 26, 33, 36, 5, -35 },
  { 3162, 24, 43, 36, 6, -43 },
  { 3291, 25, 49, 36, 5, -43 },
  { 3445, 30, 42, 36, 3, -42 },
  { 3603, 25, 42, 36, 6, -42 },
  { 3735, 26, 44, 36, 5, -43 },
  { 3878, 26, 42, 36, 6, -42 },
  { 4015, 25, 42, 36, 6, -42 },
  { 4147, 25, 42, 36, 6, -42 },
  { 4279, 27, 44, 36, 4, -43 },
  { 4428, 24, 42, 36, 6, -42 },
  { 4554, 26, 42, 36, 5, -42 },
  { 4691, 23, 43, 36, 5, -42 },
  { 4815, 27, 42, 36, 6, -42 },
  { 4957, 24, 42, 36, 8, -42 },
  { 5083, 26, 42, 36, 5, -42 },
  { 5220, 24, 42, 36, 6, -42 },
  { 5346, 28, 44, 36, 4, -43 },
  { 5500, 26, 42, 36, 6, -42 },
  { 5637, 28, 52, 36, 4, -43 },
  { 5819, 26, 42, 36, 6, -42 },
  { 5956, 28, 44, 36, 4, -43 },
  { 6110, 32, 42, 36, 2, -42 },
  { 6278, 24, 43, 36, 6, -42 },
  { 6407, 30, 42, 36, 3, -42 },
  { 6565, 30, 42, 36, 3, -42 },
  { 6723, 30, 42, 36, 3, -42 },
  { 6881, 34, 42, 36, 1, -42 },
  { 7060, 30, 42, 36, 3, -42 },
  { 7218, 15, 54, 36, 15, -46 },
  { 7320, 24, 54, 36, 6, -46 },
  { 7482, 15, 54, 36, 6, -46 },
  { 7584, 28, 23, 36, 4, -42 },
  { 7665, 28, 2, 36, 4, 7 },
  { 7672, 8, 10, 36, 12, -46 },
  { 7682, 28, 33, 36, 4, -32 },
  { 7798, 25, 45, 36, 7, -44 },
  { 7939, 24, 33, 36, 6, -32 },
  { 8038, 25, 45, 36, 4, -44 },
  { 8179, 26, 33, 36, 5, -32 },
  { 8287, 27, 44, 36, 5, -44 },
  { 8436, 28, 47, 36, 5, -34 },
  { 8601, 22, 44, 36, 7, -44 },
  { 8722, 25, 45, 36, 7, -45 },
  { 8863, 21, 57, 36, 6, -45 },
  { 9013, 26, 44, 36, 8, -44 },
  { 9156, 26, 44, 36, 5, -44 },
  { 9299, 28, 32, 36, 4, -32 },
  { 9411, 22, 32, 36, 7, -32 },
  { 9499, 26, 33, 36, 5, -32 },
  { 9607, 25, 44, 36, 7, -32 },
  { 9745, 25, 44, 36, 4, -32 },
  { 9883, 28, 31, 36, 5, -31 },
  { 9992, 26, 33, 36, 5, -32 },
  { 10100, 29, 42, 36, 2, -42 },
  { 10253, 22, 32, 36, 7, -31 },
  { 10341, 26, 31, 36, 5, -31 },
  { 10442, 32, 31, 36, 2, -31 },
  { 10566, 26, 31, 36, 5, -31 },
  { 10667, 26, 43, 36, 5, -31 },
  { 10807, 24, 31, 36, 6, -31 },
  { 10900, 22, 54, 36, 7, -46 },
  { 11049, 2, 54, 36, 17, -46 },
  { 11063, 22, 54, 36, 7, -46 },
  { 11212, 30, 11, 36, 3, -24 },
};

const GFXfont IBMPlexMono_ExtraLight60pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLight60pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLight60pt7bGlyphs,
  0x20, 0x7E, 78
};

#endif // _IBMPLEXMONO_EXTRALIGHT60PT7B_H_
