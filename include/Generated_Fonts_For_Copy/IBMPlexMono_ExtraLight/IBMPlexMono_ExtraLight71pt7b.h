#ifndef _IBMPLEXMONO_EXTRALIGHT71PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHT71PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLight.ttf
// Size: 71pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLight71pt7bBitmaps[] PROGMEM = {
  0x00, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3,
  0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x04, 0x10, 0x41, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7B, 0xFF,
  0xFF, 0xFD, 0xE0, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x00, 0x60, 0x07, 0x00,
  0x00, 0x00, 0x60, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x00, 0x00,
  0xE0, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x0E,
  0x00, 0x00, 0x00, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x18, 0x00, 0x1F, 0xFF,
  0x80, 0x1F, 0xFF, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x30, 0x00, 0x00,
  0x07, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0xFC, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x01,
  0xC0, 0x00, 0x00, 0x18, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x01, 0x80, 0x00,
  0x00, 0x38, 0x01, 0x80, 0x00, 0x00, 0x38, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x03, 0x80, 0x00, 0x00, 0x30, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x03, 0x00, 0x00, 0x00, 0x70, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x03, 0x00, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x00, 0x60, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7C, 0x18,
  0xFE, 0x00, 0x3C, 0x06, 0x03, 0xC0, 0x3C, 0x01, 0x80, 0x78, 0x0E, 0x00,
  0x60, 0x07, 0x07, 0x00, 0x18, 0x00, 0xE1, 0x80, 0x06, 0x00, 0x10, 0xE0,
  0x01, 0x80, 0x00, 0x38, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x03, 0x80, 0x06, 0x00, 0x00, 0xE0, 0x01, 0x80,
  0x00, 0x38, 0x00, 0x60, 0x00, 0x07, 0x00, 0x18, 0x00, 0x01, 0xE0, 0x06,
  0x00, 0x00, 0x3C, 0x01, 0x80, 0x00, 0x07, 0x80, 0x60, 0x00, 0x00, 0xFC,
  0x18, 0x00, 0x00, 0x0F, 0xF6, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x19, 0xFC, 0x00, 0x00, 0x06, 0x07, 0x80,
  0x00, 0x01, 0x80, 0x70, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x18, 0x01,
  0xC0, 0x00, 0x06, 0x00, 0x38, 0x00, 0x01, 0x80, 0x0E, 0x00, 0x00, 0x60,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x70, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x01,
  0x80, 0x07, 0x00, 0x00, 0x60, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x70, 0x00,
  0x06, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x07, 0x00, 0x00, 0x60, 0x01, 0x98,
  0x00, 0x18, 0x00, 0xEF, 0x00, 0x06, 0x00, 0x38, 0xE0, 0x01, 0x80, 0x1C,
  0x3C, 0x00, 0x60, 0x0F, 0x07, 0xC0, 0x18, 0x07, 0x80, 0x7C, 0x06, 0x03,
  0xC0, 0x0F, 0xE1, 0x87, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0E, 0x0F, 0xFE, 0x00, 0x00, 0x18, 0x78, 0x1E, 0x00, 0x00, 0x60, 0xE0,
  0x0E, 0x00, 0x01, 0xC3, 0x80, 0x0E, 0x00, 0x03, 0x0E, 0x00, 0x0C, 0x00,
  0x0E, 0x18, 0x00, 0x18, 0x00, 0x18, 0x30, 0x00, 0x38, 0x00, 0x60, 0xE0,
  0x00, 0x30, 0x01, 0xC1, 0xC0, 0x00, 0x60, 0x03, 0x03, 0x80, 0x00, 0xC0,
  0x0E, 0x07, 0x00, 0x01, 0x80, 0x18, 0x0E, 0x00, 0x03, 0x00, 0x70, 0x1C,
  0x00, 0x06, 0x00, 0xC0, 0x38, 0x00, 0x0C, 0x03, 0x00, 0x70, 0x00, 0x18,
  0x0E, 0x00, 0x60, 0x00, 0x70, 0x18, 0x00, 0xC0, 0x00, 0xC0, 0x70, 0x01,
  0xC0, 0x01, 0x80, 0xC0, 0x01, 0xC0, 0x07, 0x03, 0x00, 0x01, 0xC0, 0x1C,
  0x06, 0x00, 0x03, 0xC0, 0xF0, 0x10, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xC0, 0x78, 0x3C, 0x00, 0x07,
  0x01, 0xC0, 0x1C, 0x00, 0x0C, 0x07, 0x00, 0x1C, 0x00, 0x30, 0x0C, 0x00,
  0x18, 0x00, 0xE0, 0x38, 0x00, 0x38, 0x01, 0x80, 0x60, 0x00, 0x30, 0x07,
  0x00, 0xC0, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x00, 0xC0, 0x30, 0x07, 0x00,
  0x01, 0x80, 0x60, 0x0E, 0x00, 0x03, 0x01, 0x80, 0x1C, 0x00, 0x06, 0x07,
  0x00, 0x38, 0x00, 0x0C, 0x0C, 0x00, 0x70, 0x00, 0x18, 0x38, 0x00, 0x60,
  0x00, 0x30, 0x60, 0x00, 0xC0, 0x00, 0x61, 0x80, 0x01, 0xC0, 0x01, 0xC7,
  0x00, 0x01, 0x80, 0x03, 0x0C, 0x00, 0x03, 0x80, 0x0E, 0x38, 0x00, 0x03,
  0x80, 0x38, 0x60, 0x00, 0x03, 0xC1, 0xE1, 0x80, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x01,
  0x80, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x04, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x00, 0x78, 0xE0,
  0x00, 0xFF, 0x0E, 0x06, 0x00, 0x0F, 0xF1, 0xC0, 0x70, 0x00, 0xC0, 0x38,
  0x03, 0x80, 0x0C, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x70, 0x00, 0xE0, 0x0C,
  0x07, 0x00, 0x07, 0x01, 0xC0, 0xE0, 0x00, 0x38, 0x1C, 0x0E, 0x00, 0x01,
  0x81, 0xC0, 0xE0, 0x00, 0x1C, 0x18, 0x0C, 0x00, 0x00, 0xE1, 0x80, 0xC0,
  0x00, 0x07, 0x18, 0x0C, 0x00, 0x00, 0x39, 0x80, 0xC0, 0x00, 0x01, 0xF8,
  0x0C, 0x00, 0x00, 0x0F, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00,
  0x07, 0x80, 0xE0, 0x00, 0x00, 0x78, 0x06, 0x00, 0x00, 0x0D, 0xC0, 0x70,
  0x00, 0x01, 0x8E, 0x03, 0x80, 0x00, 0x38, 0x70, 0x3C, 0x00, 0x07, 0x03,
  0x81, 0xE0, 0x00, 0xE0, 0x1C, 0x07, 0xC0, 0x78, 0x00, 0xE0, 0x3F, 0xFF,
  0x00, 0x07, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00,
  0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07,
  0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0F, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00,
  0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18,
  0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E,
  0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01,
  0xC0, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x40, 0x00, 0x70, 0x00, 0x37, 0x80, 0x07, 0x00, 0x1F, 0xFF, 0x00, 0x70,
  0x0F, 0xF0, 0xFF, 0x07, 0x07, 0xF8, 0x01, 0xFE, 0x73, 0xF8, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x03, 0x8C,
  0x00, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x38, 0x00, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x03, 0x80, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x1F, 0x1E,
  0x1E, 0x1E, 0x1C, 0x3C, 0x3C, 0x38, 0x38, 0x38, 0x70, 0x70, 0x70, 0x60,
  0x60, 0xE0, 0xC0, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x7B, 0xFF, 0xFF,
  0xFD, 0xE0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x78,
  0x00, 0x38, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x03, 0x80, 0x38,
  0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x1C, 0x1C,
  0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x00, 0xC7,
  0x00, 0x00, 0x00, 0x63, 0x80, 0x00, 0x00, 0x39, 0x80, 0x00, 0x00, 0x1D,
  0xC0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0x01,
  0xB8, 0x00, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x03, 0x80,
  0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8,
  0x00, 0xFC, 0x00, 0x38, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0x70, 0x00, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x00, 0xE6, 0x00, 0x00, 0x00, 0x73, 0x00, 0x00, 0x00, 0x39, 0xC0,
  0x00, 0x00, 0x18, 0xE0, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x0E, 0x1C,
  0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x03, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x03, 0x80,
  0x07, 0x80, 0x03, 0x80, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x07, 0x9C, 0x00, 0x00, 0x07, 0x8E,
  0x00, 0x00, 0x07, 0x87, 0x00, 0x00, 0x07, 0x83, 0x80, 0x00, 0x07, 0x81,
  0xC0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x0F, 0x00,
  0x38, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x01, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x78, 0x00, 0x3C, 0x01,
  0xE0, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x38, 0x38,
  0x00, 0x00, 0x38, 0x60, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0x63, 0x80,
  0x00, 0x00, 0xE2, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3E, 0x01, 0xF0, 0x01, 0xC0, 0x00,
  0xF0, 0x0E, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x03, 0x83, 0x80, 0x00, 0x07,
  0x0C, 0x00, 0x00, 0x0C, 0x50, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x74,
  0x00, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x71, 0xC0,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x3B, 0x00, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x00, 0x73,
  0x00, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00,
  0x1C, 0x30, 0x00, 0x00, 0x03, 0x83, 0x00, 0x00, 0x00, 0x30, 0x30, 0x00,
  0x00, 0x07, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x00, 0x38, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x30, 0x00, 0x00, 0x70, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x03, 0x80, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x30, 0x00, 0x07, 0x00, 0x03, 0x00, 0x00, 0xE0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00,
  0x38, 0x00, 0x03, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x70, 0x00, 0x03,
  0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x1C, 0x00,
  0x00, 0x30, 0x03, 0x80, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x30, 0x07,
  0x00, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0xE1, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x1F,
  0xF0, 0x00, 0xC3, 0xFF, 0xF8, 0x03, 0x1E, 0x01, 0xF8, 0x0C, 0xC0, 0x00,
  0xF0, 0x36, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x64, 0x00, 0x00, 0x03,
  0xB8, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x03, 0x83,
  0xC0, 0x00, 0x1C, 0x07, 0xC0, 0x00, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x01, 0xFF, 0x00, 0x06, 0x0F, 0xFF, 0xC0, 0x1C, 0x78, 0x07, 0xE0,
  0x31, 0xC0, 0x01, 0xE0, 0x66, 0x00, 0x01, 0xE0, 0xD8, 0x00, 0x00, 0xE3,
  0xE0, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x01, 0x9C,
  0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x06, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0x70, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x1C, 0xC0, 0x00,
  0x00, 0x39, 0xC0, 0x00, 0x00, 0x61, 0x80, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x07, 0x03, 0x80, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x78, 0x03, 0xC0, 0x01,
  0xE0, 0x03, 0xE0, 0x1F, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00,
  0x1C, 0xE0, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x00,
  0x38, 0xE0, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0xF0, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x70, 0x00,
  0x00, 0x70, 0x70, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x0E, 0x18, 0x00,
  0x00, 0x07, 0x0C, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x01, 0xC7, 0x00,
  0x00, 0x00, 0xE1, 0x80, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x00, 0x38, 0x60,
  0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x0E, 0x07,
  0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x07, 0x00,
  0x1C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x1E, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0x3C,
  0x01, 0xC0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00,
  0x71, 0xC0, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00,
  0x07, 0x70, 0x00, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0x70, 0x00,
  0x00, 0x03, 0x9C, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x00, 0xE0, 0x0F,
  0x00, 0x01, 0xE0, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x0F, 0xC0, 0x7E, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x1C, 0x70,
  0x00, 0x00, 0x18, 0xE0, 0x00, 0x00, 0x39, 0x80, 0x00, 0x00, 0x37, 0x00,
  0x00, 0x00, 0x6E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x01, 0xEE, 0x00, 0x00, 0x03, 0xCC, 0x00, 0x00, 0x07, 0x9C, 0x00, 0x00,
  0x1F, 0x1C, 0x00, 0x00, 0x6C, 0x1C, 0x00, 0x01, 0x98, 0x1E, 0x00, 0x0E,
  0x70, 0x1F, 0x00, 0x78, 0xE0, 0x0F, 0xFF, 0xC1, 0x80, 0x03, 0xFE, 0x07,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7B, 0xFF, 0xFF, 0xFD, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7B, 0xFF, 0xFF, 0xFD, 0xE0, 0x1E,
  0x3F, 0x3F, 0x3F, 0x3F, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x1F, 0x1E, 0x1E, 0x1E, 0x1C,
  0x3C, 0x3C, 0x38, 0x38, 0x38, 0x70, 0x70, 0x70, 0x60, 0x60, 0xE0, 0xC0,
  0xC0, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x0F, 0x01,
  0xC0, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x03, 0x8E, 0x00,
  0x00, 0x0E, 0xE0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0xE0,
  0x00, 0xE0, 0x07, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x03, 0x80, 0xC0, 0x00,
  0x06, 0x07, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00,
  0xC3, 0x80, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x19,
  0xC0, 0x00, 0x00, 0x67, 0x00, 0x00, 0x01, 0x98, 0x00, 0x3F, 0x86, 0x60,
  0x03, 0xFF, 0x19, 0x80, 0x1E, 0x07, 0x76, 0x00, 0xE0, 0x05, 0xF8, 0x03,
  0x00, 0x0F, 0xE0, 0x1C, 0x00, 0x3F, 0x80, 0x60, 0x00, 0x7E, 0x03, 0x80,
  0x01, 0xF8, 0x0C, 0x00, 0x07, 0xE0, 0x30, 0x00, 0x1F, 0x80, 0xC0, 0x00,
  0x7E, 0x03, 0x00, 0x01, 0xF8, 0x0C, 0x00, 0x07, 0xE0, 0x30, 0x00, 0x1F,
  0x80, 0xC0, 0x00, 0x7E, 0x03, 0x00, 0x01, 0xF8, 0x0C, 0x00, 0x07, 0xE0,
  0x30, 0x00, 0x1F, 0x80, 0xC0, 0x00, 0x7E, 0x03, 0x00, 0x01, 0xF8, 0x0E,
  0x00, 0x07, 0xE0, 0x38, 0x00, 0x1F, 0x80, 0x60, 0x00, 0x7E, 0x01, 0xC0,
  0x03, 0xD8, 0x03, 0x80, 0x1F, 0x60, 0x0F, 0x00, 0xDD, 0x80, 0x1F, 0x1E,
  0x76, 0x00, 0x1F, 0xF1, 0xD8, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00,
  0x00, 0x19, 0xC0, 0x00, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x00, 0x38, 0xE0,
  0x00, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x60, 0x00, 0x00, 0x07,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x70, 0x00, 0x00, 0x06, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x30, 0x00, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x38,
  0x00, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x18,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x0C, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00,
  0x03, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x60, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x00, 0x60, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x18, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x00,
  0xC0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x70, 0x00, 0x00, 0x70, 0x06, 0x00, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x00,
  0x38, 0x1C, 0x00, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x00, 0x1C, 0x18, 0x00,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x00, 0xC3,
  0x80, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00,
  0x06, 0x70, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x0C, 0x00, 0x01, 0xF0, 0x30, 0x00, 0x01,
  0xE0, 0xC0, 0x00, 0x03, 0xC3, 0x00, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x0E,
  0x30, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x00, 0x63, 0x00, 0x00, 0x01, 0xCC,
  0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00, 0x73, 0x00,
  0x00, 0x01, 0xCC, 0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0x1C, 0xC0, 0x00,
  0x00, 0x73, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00,
  0x38, 0xC0, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x78,
  0x30, 0x00, 0x07, 0x80, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x0C,
  0x00, 0x00, 0x78, 0x30, 0x00, 0x00, 0x78, 0xC0, 0x00, 0x00, 0xE3, 0x00,
  0x00, 0x01, 0xCC, 0x00, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x0E, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x73, 0x00,
  0x00, 0x03, 0x8C, 0x00, 0x00, 0x1E, 0x30, 0x00, 0x01, 0xF0, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x7C, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x03, 0xC0,
  0x00, 0x38, 0x07, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x0C, 0x0E, 0x00,
  0x00, 0x0E, 0x0C, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x07, 0x18, 0x00,
  0x00, 0x02, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x02, 0x1C, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0x0C, 0x07, 0x80, 0x00, 0x1C, 0x03, 0xC0,
  0x00, 0x38, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xF0, 0x03, 0x80, 0x00, 0xF8, 0x07, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x00,
  0x38, 0x1C, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00,
  0x30, 0xE0, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0x63, 0x80, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x03,
  0xB8, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x0D,
  0xC0, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x00, 0x37, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x06, 0xE0, 0x00,
  0x00, 0x0D, 0xC0, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x03, 0x38, 0x00, 0x00,
  0x0E, 0x70, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x01, 0x87, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x1C,
  0x1C, 0x00, 0x00, 0x70, 0x38, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x1F, 0x00,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xEE, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xCE, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xF8, 0x07, 0xC0,
  0x01, 0xE0, 0x01, 0xE0, 0x03, 0x80, 0x00, 0x70, 0x07, 0x00, 0x00, 0x38,
  0x0E, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x0C,
  0x38, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x07,
  0x70, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x07,
  0x30, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x0F, 0x38, 0x00, 0x00, 0x0F,
  0x1C, 0x00, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0x1F, 0x0E, 0x00, 0x00, 0x17,
  0x07, 0x00, 0x00, 0x37, 0x03, 0x80, 0x00, 0x67, 0x01, 0xE0, 0x01, 0xC7,
  0x00, 0xF8, 0x07, 0x87, 0x00, 0x3F, 0xFE, 0x07, 0x00, 0x0F, 0xF8, 0x00,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0x38,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x18, 0x70, 0x00, 0x07, 0x07, 0x00, 0x01,
  0xC0, 0x70, 0x00, 0x70, 0x07, 0xC0, 0x7C, 0x00, 0x7F, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0E, 0xE0,
  0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x03, 0xC0, 0xE0,
  0x00, 0x03, 0x80, 0xE0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0xE0, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x70, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0xE0,
  0x03, 0x80, 0x00, 0xE0, 0x07, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0xE0,
  0x1C, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x00, 0xE0, 0x7E, 0x00, 0x00, 0xE0,
  0xEE, 0x00, 0x00, 0xE0, 0xE7, 0x00, 0x00, 0xE1, 0xC7, 0x80, 0x00, 0xE3,
  0x83, 0x80, 0x00, 0xE7, 0x01, 0xC0, 0x00, 0xEE, 0x01, 0xC0, 0x00, 0xFC,
  0x00, 0xE0, 0x00, 0xF8, 0x00, 0x70, 0x00, 0xF0, 0x00, 0x70, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0xE0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0xE0, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x01, 0xC0, 0xE0,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x1C, 0xE0,
  0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFD, 0x80, 0x00,
  0x07, 0xFB, 0x80, 0x00, 0x0F, 0xF3, 0x00, 0x00, 0x1B, 0xE7, 0x00, 0x00,
  0x77, 0xC6, 0x00, 0x00, 0xCF, 0x8C, 0x00, 0x03, 0x9F, 0x1C, 0x00, 0x06,
  0x3E, 0x18, 0x00, 0x1C, 0x7C, 0x38, 0x00, 0x30, 0xF8, 0x30, 0x00, 0xE1,
  0xF0, 0x70, 0x01, 0xC3, 0xE0, 0x60, 0x03, 0x07, 0xC0, 0xE0, 0x0E, 0x0F,
  0x81, 0xC0, 0x18, 0x1F, 0x01, 0x80, 0x70, 0x3E, 0x03, 0x80, 0xC0, 0x7C,
  0x03, 0x03, 0x80, 0xF8, 0x07, 0x06, 0x01, 0xF0, 0x06, 0x0C, 0x03, 0xE0,
  0x0E, 0x30, 0x07, 0xC0, 0x0C, 0x60, 0x0F, 0x80, 0x1D, 0xC0, 0x1F, 0x00,
  0x3B, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00,
  0x70, 0x01, 0xF0, 0x00, 0xC0, 0x03, 0xE0, 0x00, 0x80, 0x07, 0xC0, 0x02,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3D, 0xC0,
  0x00, 0x01, 0xEE, 0x00, 0x00, 0x0F, 0x38, 0x00, 0x00, 0x79, 0xC0, 0x00,
  0x03, 0xC7, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x07,
  0x87, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x0F, 0x03,
  0x80, 0x00, 0x78, 0x1C, 0x00, 0x03, 0xC0, 0x60, 0x00, 0x1E, 0x03, 0x80,
  0x00, 0xF0, 0x0C, 0x00, 0x07, 0x80, 0x70, 0x00, 0x3C, 0x01, 0x80, 0x01,
  0xE0, 0x0E, 0x00, 0x0F, 0x00, 0x30, 0x00, 0x78, 0x01, 0xC0, 0x03, 0xC0,
  0x06, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x00, 0xC0, 0x07, 0x80, 0x07,
  0x00, 0x3C, 0x00, 0x18, 0x01, 0xE0, 0x00, 0xE0, 0x0F, 0x00, 0x03, 0x00,
  0x78, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x60, 0x1E, 0x00, 0x03, 0x80, 0xF0,
  0x00, 0x0C, 0x07, 0x80, 0x00, 0x70, 0x3C, 0x00, 0x01, 0x81, 0xE0, 0x00,
  0x0E, 0x0F, 0x00, 0x00, 0x30, 0x78, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x06,
  0x1E, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x00, 0xC7, 0x80, 0x00, 0x07, 0x3C,
  0x00, 0x00, 0x19, 0xE0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x03, 0x78, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x78,
  0x00, 0x38, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x03, 0x80, 0x38,
  0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x1C, 0x1C,
  0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x00, 0xC7,
  0x00, 0x00, 0x00, 0x63, 0x80, 0x00, 0x00, 0x39, 0x80, 0x00, 0x00, 0x1D,
  0xC0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0x01,
  0xB8, 0x00, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0x70, 0x00, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x00, 0xE6, 0x00, 0x00, 0x00, 0x73, 0x00, 0x00, 0x00, 0x39, 0xC0,
  0x00, 0x00, 0x18, 0xE0, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x0E, 0x1C,
  0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x03, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x03, 0x80,
  0x07, 0x80, 0x03, 0x80, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0x03, 0x80, 0x00, 0x1F, 0x07, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x07,
  0x1C, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x0E,
  0xE0, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x00, 0x37,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0D, 0xC0,
  0x00, 0x00, 0x1B, 0x80, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x01, 0x9C, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x1C, 0x70, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x07, 0xC1, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xF0, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x38, 0x00,
  0x78, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0xE0,
  0x38, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x00,
  0x63, 0x80, 0x00, 0x00, 0x39, 0x80, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00,
  0x0E, 0xE0, 0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0x01, 0xB8, 0x00, 0x00,
  0x00, 0xDC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0x70,
  0x00, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x00, 0xE6,
  0x00, 0x00, 0x00, 0x73, 0x00, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x18,
  0xE0, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x06,
  0x06, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x70, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x03, 0x80, 0x07, 0x80, 0x03,
  0x80, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x03, 0x80,
  0x00, 0x1F, 0x07, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x07, 0x1C, 0x00,
  0x00, 0x07, 0x38, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x0E, 0xE0, 0x00,
  0x00, 0x1D, 0xC0, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x00, 0x37, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x00,
  0x1B, 0x80, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x01,
  0x9C, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x07, 0xC1, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x07,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x70, 0x01, 0xC0,
  0x00, 0xE0, 0x03, 0x80, 0x00, 0xE0, 0x07, 0x00, 0x00, 0xE0, 0x0E, 0x00,
  0x01, 0xC0, 0x1C, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x03, 0x80, 0x70, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x07, 0x03, 0x80, 0x00,
  0x07, 0x07, 0x00, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00,
  0x0E, 0x38, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00,
  0x1D, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x0F, 0x00,
  0x00, 0x1E, 0x03, 0x80, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x00, 0x78, 0xE0,
  0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0x90,
  0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x00, 0x0E,
  0x38, 0x00, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x03, 0x81, 0xF0, 0x00, 0x01,
  0xC0, 0x1E, 0x00, 0x01, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x06, 0xE0,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x03, 0x98, 0x00, 0x00, 0x1C, 0xE0, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x60, 0x70, 0x00, 0x07,
  0x01, 0xC0, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00,
  0x1C, 0xE0, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x00, 0xE1, 0xC0, 0x00,
  0x00, 0x1C, 0x38, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x70,
  0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0xE0,
  0x1C, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x03, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x07, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x1C, 0x00,
  0x00, 0x60, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x03, 0x80, 0x07,
  0x00, 0x00, 0x60, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x60, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x00,
  0x38, 0x03, 0x80, 0x00, 0x07, 0x00, 0x60, 0x00, 0x00, 0x60, 0x1C, 0x00,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x00, 0x18, 0x1C,
  0x00, 0x00, 0x03, 0x03, 0x80, 0x00, 0x00, 0x70, 0x60, 0x00, 0x00, 0x0E,
  0x0C, 0x00, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x00,
  0x03, 0x8C, 0x00, 0x00, 0x00, 0x33, 0x80, 0x00, 0x00, 0x07, 0x70, 0x00,
  0x00, 0x00, 0xEC, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x00,
  0x37, 0x00, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0x00, 0x19, 0x80, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x00, 0xE6, 0x00,
  0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00, 0x03, 0x98, 0x00, 0x00, 0x00, 0x73,
  0x80, 0x07, 0x00, 0x0C, 0x70, 0x01, 0xE0, 0x01, 0x8E, 0x00, 0x3E, 0x00,
  0x31, 0xC0, 0x07, 0xC0, 0x06, 0x18, 0x00, 0xD8, 0x00, 0xC3, 0x00, 0x3B,
  0x00, 0x18, 0x60, 0x06, 0x70, 0x03, 0x0C, 0x00, 0xC6, 0x00, 0xE1, 0x80,
  0x38, 0xC0, 0x1C, 0x30, 0x06, 0x1C, 0x03, 0x86, 0x00, 0xC3, 0x80, 0x70,
  0xE0, 0x18, 0x30, 0x0C, 0x1C, 0x07, 0x06, 0x01, 0x83, 0x80, 0xC0, 0xE0,
  0x30, 0x70, 0x18, 0x0C, 0x06, 0x06, 0x07, 0x01, 0x80, 0xC0, 0xC0, 0xE0,
  0x30, 0x18, 0x18, 0x18, 0x07, 0x03, 0x03, 0x03, 0x00, 0x60, 0xE0, 0x60,
  0xE0, 0x0C, 0x1C, 0x0C, 0x18, 0x01, 0xC3, 0x81, 0x83, 0x00, 0x38, 0x70,
  0x38, 0x60, 0x03, 0x0C, 0x07, 0x1C, 0x00, 0x61, 0x80, 0xE3, 0x00, 0x0E,
  0x30, 0x1C, 0x60, 0x00, 0xC6, 0x01, 0x9C, 0x00, 0x18, 0xC0, 0x33, 0x80,
  0x03, 0x98, 0x06, 0x60, 0x00, 0x73, 0x00, 0xCC, 0x00, 0x06, 0xE0, 0x1B,
  0x80, 0x00, 0xDC, 0x03, 0x60, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x03, 0xF0,
  0x0F, 0x80, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x70, 0x00, 0x00,
  0x00, 0x71, 0xC0, 0x00, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x38,
  0x00, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x60, 0x00, 0x07, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x03, 0x00, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0x00, 0x70, 0x18, 0x00, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00,
  0x01, 0x87, 0x00, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x70,
  0x00, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x70, 0x00, 0x00, 0x60, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x07, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x00, 0x39, 0xC0,
  0x00, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00,
  0x07, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x00, 0x38, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x00, 0x30, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x01, 0x80, 0x00, 0x00, 0x70,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x38, 0x00,
  0x00, 0x00, 0xC0, 0xE0, 0x00, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x00, 0x01,
  0xC7, 0x00, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x00, 0x03, 0xB8, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00, 0x07, 0x18, 0x00, 0x00,
  0x01, 0x87, 0x00, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x30, 0x38, 0x00,
  0x00, 0x1C, 0x07, 0x00, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x06, 0x00, 0x00, 0x60, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x03, 0x80,
  0x00, 0x30, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x38,
  0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x01, 0x81,
  0x80, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x03,
  0x9C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0C, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x60, 0x38, 0x07, 0x00, 0xE0, 0x18,
  0x07, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x01, 0xE0, 0x00,
  0xE0, 0x01, 0xC0, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xF8, 0x01, 0xF8, 0x00, 0x0C, 0x01, 0xE0, 0x00, 0x06, 0x01,
  0xC0, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x00, 0xC0,
  0x60, 0x00, 0x00, 0x60, 0x70, 0x00, 0x00, 0x30, 0x38, 0x00, 0x00, 0x18,
  0x1C, 0x00, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x06, 0x07, 0x00, 0x00, 0x07,
  0x01, 0x80, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x02, 0xC0, 0x70, 0x00, 0x03,
  0x60, 0x1C, 0x00, 0x03, 0x30, 0x07, 0x00, 0x03, 0x18, 0x01, 0xF0, 0x0F,
  0x0F, 0xF0, 0x7F, 0xFF, 0x03, 0xF8, 0x07, 0xFC, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x3F, 0xE0, 0x07,
  0x07, 0xFF, 0xC0, 0x38, 0xF0, 0x0F, 0x81, 0xCE, 0x00, 0x1E, 0x0E, 0xC0,
  0x00, 0x38, 0x7C, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x03, 0x9E, 0x00, 0x00,
  0x1C, 0xE0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x0D,
  0xC0, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0D, 0xC0, 0x00,
  0x00, 0x6E, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x03,
  0x9E, 0x00, 0x00, 0x1C, 0xF8, 0x00, 0x01, 0xC7, 0x60, 0x00, 0x1C, 0x39,
  0xC0, 0x03, 0xC1, 0xC7, 0x80, 0x7C, 0x0E, 0x0F, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7C, 0x03,
  0xC0, 0x07, 0x00, 0x07, 0x80, 0x70, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x70,
  0x70, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x06, 0x38, 0x00, 0x00, 0x21, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x08, 0x60, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x0E, 0x0E, 0x00,
  0x00, 0x70, 0x38, 0x00, 0x07, 0x00, 0xE0, 0x00, 0xF0, 0x03, 0xE0, 0x1F,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x1F, 0xE0, 0x18, 0x07, 0xFF,
  0xE0, 0xC0, 0x7C, 0x07, 0x86, 0x0F, 0x00, 0x06, 0x30, 0xF0, 0x00, 0x19,
  0x87, 0x00, 0x00, 0x6C, 0x70, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x07, 0x38,
  0x00, 0x00, 0x39, 0x80, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x06, 0xE0, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00,
  0x1B, 0x00, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x33,
  0x00, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0xE3, 0x80,
  0x00, 0x0F, 0x0E, 0x00, 0x00, 0xD8, 0x78, 0x00, 0x0C, 0xC1, 0xE0, 0x00,
  0xC6, 0x03, 0xE0, 0x3C, 0x30, 0x0F, 0xFF, 0xC1, 0x80, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0x80, 0x7C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x1C, 0x07,
  0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x38, 0x60,
  0x00, 0x00, 0x31, 0xC0, 0x00, 0x00, 0x73, 0x00, 0x00, 0x00, 0xE6, 0x00,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x03, 0x70, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x87, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x06,
  0x0E, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x01, 0xC0,
  0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x03, 0xFE, 0x30, 0x00, 0x07, 0xFF, 0xD8, 0x00, 0x0F, 0x80, 0xFC,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00,
  0xE0, 0x07, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00,
  0x0E, 0x01, 0xC0, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x70, 0x00,
  0x00, 0xC0, 0x38, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x00, 0x30, 0x0E, 0x00,
  0x00, 0x38, 0x07, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x0C, 0x00, 0xE0,
  0x00, 0x06, 0x00, 0x70, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x1C, 0x00, 0x01, 0xF0, 0x38, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00,
  0x07, 0x38, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x07, 0x38, 0x00,
  0x00, 0x03, 0x9E, 0x00, 0x00, 0x03, 0x87, 0x80, 0x00, 0x07, 0x80, 0xF8,
  0x00, 0x1F, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x7F, 0xC0, 0x30, 0x7F, 0xFC, 0x0C, 0x78, 0x07,
  0x83, 0x30, 0x00, 0x78, 0xD8, 0x00, 0x0E, 0x34, 0x00, 0x01, 0xCE, 0x00,
  0x00, 0x33, 0x80, 0x00, 0x0E, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x3F, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x79, 0xC0,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x07, 0x07, 0x00, 0x00, 0x1C, 0x0E, 0x00,
  0x00, 0x70, 0x1C, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x07, 0x00, 0x70, 0x00,
  0x3C, 0x00, 0xE0, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x0E,
  0x00, 0x07, 0x00, 0x38, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x1C, 0x03, 0x80,
  0x00, 0x38, 0x0E, 0x00, 0x00, 0x70, 0x7E, 0x00, 0x00, 0xE1, 0xFE, 0x00,
  0x01, 0xC7, 0x1C, 0x00, 0x03, 0x9C, 0x1C, 0x00, 0x07, 0x70, 0x1C, 0x00,
  0x0F, 0xC0, 0x1C, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x38, 0x03,
  0x80, 0x00, 0x78, 0x07, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x70, 0x1C,
  0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0xE0, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xC1, 0xF8, 0x03, 0xF0, 0x63, 0xFF, 0x07, 0xFE, 0x33, 0x83,
  0xC7, 0x07, 0x99, 0x00, 0xE6, 0x00, 0xED, 0x00, 0x3A, 0x00, 0x77, 0x00,
  0x0E, 0x00, 0x1B, 0x80, 0x07, 0x00, 0x0F, 0x80, 0x03, 0x80, 0x07, 0xC0,
  0x01, 0xC0, 0x03, 0xE0, 0x00, 0xE0, 0x01, 0xF0, 0x00, 0x70, 0x00, 0xF8,
  0x00, 0x38, 0x00, 0x7C, 0x00, 0x1C, 0x00, 0x3E, 0x00, 0x0E, 0x00, 0x1F,
  0x00, 0x07, 0x00, 0x0F, 0x80, 0x03, 0x80, 0x07, 0xC0, 0x01, 0xC0, 0x03,
  0xE0, 0x00, 0xE0, 0x01, 0xF0, 0x00, 0x70, 0x00, 0xF8, 0x00, 0x38, 0x00,
  0x7C, 0x00, 0x1C, 0x00, 0x3E, 0x00, 0x0E, 0x00, 0x1F, 0x00, 0x07, 0x00,
  0x0F, 0x80, 0x03, 0x80, 0x07, 0xC0, 0x01, 0xC0, 0x03, 0xE0, 0x00, 0xE0,
  0x01, 0xF0, 0x00, 0x70, 0x00, 0xF8, 0x00, 0x38, 0x00, 0x7C, 0x00, 0x1C,
  0x00, 0x3E, 0x00, 0x0E, 0x00, 0x1F, 0x00, 0x07, 0x00, 0x0F, 0x80, 0x03,
  0x80, 0x07, 0xC0, 0x01, 0xC0, 0x03, 0xE0, 0x00, 0xE0, 0x01, 0xF0, 0x00,
  0x70, 0x00, 0xF8, 0x00, 0x38, 0x00, 0x7C, 0x00, 0x1C, 0x00, 0x38, 0xC0,
  0x7F, 0xC0, 0x30, 0x7F, 0xFC, 0x0C, 0x78, 0x07, 0x83, 0x30, 0x00, 0x78,
  0xD8, 0x00, 0x0E, 0x34, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x33, 0x80, 0x00,
  0x0E, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0x80, 0x7C, 0x00,
  0x3C, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x1C, 0x07,
  0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x38, 0xE0,
  0x00, 0x00, 0x31, 0xC0, 0x00, 0x00, 0x73, 0x00, 0x00, 0x00, 0xE6, 0x00,
  0x00, 0x00, 0xDC, 0x00, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x03, 0x70, 0x00,
  0x00, 0x06, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00,
  0x0C, 0xC0, 0x00, 0x00, 0x39, 0x80, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x0C,
  0x0E, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x03, 0x80,
  0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xE0, 0x3F, 0xE0, 0x07, 0x07, 0xFF, 0xC0, 0x38,
  0xF0, 0x0F, 0x81, 0xCE, 0x00, 0x1E, 0x0E, 0xC0, 0x00, 0x38, 0x7C, 0x00,
  0x00, 0xE3, 0xC0, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00,
  0x77, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x00, 0x6E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x00, 0x6E, 0x00, 0x00,
  0x07, 0x70, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x1C,
  0xF8, 0x00, 0x01, 0xC7, 0x60, 0x00, 0x1C, 0x39, 0xC0, 0x03, 0xC1, 0xC7,
  0x80, 0x7C, 0x0E, 0x0F, 0xFF, 0x80, 0x70, 0x1F, 0xF0, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x18, 0x07, 0xFF, 0xE0, 0xC0, 0x7C, 0x07, 0x86, 0x0F, 0x00, 0x06, 0x30,
  0xF0, 0x00, 0x19, 0x87, 0x00, 0x00, 0x6C, 0x70, 0x00, 0x01, 0xE7, 0x00,
  0x00, 0x07, 0x38, 0x00, 0x00, 0x39, 0x80, 0x00, 0x00, 0xDC, 0x00, 0x00,
  0x06, 0xE0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x0D,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x03,
  0x60, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x06, 0xE0,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x1C, 0xE0, 0x00,
  0x00, 0xE3, 0x80, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0xD8, 0x78, 0x00, 0x0C,
  0xC1, 0xE0, 0x00, 0xC6, 0x03, 0xE0, 0x3C, 0x30, 0x0F, 0xFF, 0xC1, 0x80,
  0x0F, 0xF0, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x00,
  0xC3, 0xC0, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00,
  0x03, 0x20, 0x00, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x00, 0x34, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x1F, 0x80, 0x3E, 0x00, 0x78, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x07, 0x03,
  0x80, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0x38, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x18,
  0x38, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x03, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x76, 0x00, 0x00, 0x1D, 0xC0, 0x00,
  0x0F, 0x38, 0x00, 0x02, 0xCE, 0x00, 0x01, 0xB1, 0xE0, 0x01, 0xCC, 0x3E,
  0x01, 0xE3, 0x03, 0xFF, 0xE0, 0xC0, 0x3F, 0xE0, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0xC0, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x03, 0x87, 0x00, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x0C,
  0x0C, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0xC0,
  0x30, 0x00, 0x03, 0x80, 0x70, 0x00, 0x06, 0x00, 0x60, 0x00, 0x1C, 0x00,
  0xE0, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x60, 0x01, 0x80, 0x01, 0xC0, 0x03,
  0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x18, 0x01, 0xC0, 0x00, 0x38,
  0x03, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x70, 0x18, 0x00, 0x00, 0xE0,
  0x30, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x07, 0x18, 0x00, 0x00, 0x06, 0x30,
  0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x70,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x36, 0x00, 0x0F, 0x80,
  0x01, 0xB0, 0x00, 0x6E, 0x00, 0x0D, 0x80, 0x03, 0x30, 0x00, 0xEC, 0x00,
  0x19, 0x80, 0x06, 0x70, 0x00, 0xCC, 0x00, 0x31, 0x80, 0x06, 0x60, 0x01,
  0x8C, 0x00, 0x73, 0x00, 0x1C, 0x60, 0x03, 0x1C, 0x00, 0xC3, 0x00, 0x18,
  0x60, 0x06, 0x0C, 0x00, 0xC3, 0x00, 0x30, 0x60, 0x06, 0x18, 0x03, 0x83,
  0x00, 0x70, 0xC0, 0x18, 0x18, 0x03, 0x07, 0x00, 0xC0, 0x60, 0x18, 0x38,
  0x06, 0x03, 0x00, 0xC0, 0xC0, 0x70, 0x18, 0x06, 0x06, 0x03, 0x00, 0xC0,
  0x30, 0x30, 0x18, 0x03, 0x03, 0x81, 0x80, 0xC0, 0x18, 0x18, 0x0E, 0x0E,
  0x00, 0xC0, 0xC0, 0x30, 0x60, 0x06, 0x06, 0x01, 0x83, 0x00, 0x18, 0x30,
  0x0C, 0x18, 0x00, 0xC1, 0x80, 0x60, 0xC0, 0x06, 0x1C, 0x03, 0x0C, 0x00,
  0x30, 0xC0, 0x1C, 0x60, 0x00, 0xC6, 0x00, 0x63, 0x00, 0x06, 0x30, 0x03,
  0x18, 0x00, 0x31, 0x80, 0x19, 0x80, 0x01, 0x8C, 0x00, 0xCC, 0x00, 0x06,
  0xC0, 0x07, 0x60, 0x00, 0x36, 0x00, 0x1B, 0x00, 0x01, 0xB0, 0x00, 0xF0,
  0x00, 0x0D, 0x80, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0xE0, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x18,
  0x01, 0xC0, 0x00, 0x70, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x03, 0x80, 0x0C, 0x00, 0x03, 0x80, 0x38, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x07, 0x03, 0x80, 0x00, 0x07, 0x06, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00,
  0x07, 0x70, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0x9C, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x70,
  0x38, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x03, 0x80, 0x38, 0x00, 0x0E, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x70, 0x01, 0xC0, 0x00,
  0x70, 0x07, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x01,
  0xE0, 0xE0, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00,
  0x06, 0x30, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00,
  0x1C, 0x1C, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00,
  0x38, 0x0E, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00,
  0x60, 0x03, 0x00, 0x00, 0x60, 0x03, 0x80, 0x00, 0xE0, 0x03, 0x80, 0x00,
  0xC0, 0x01, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x00, 0xC0, 0x03,
  0x80, 0x00, 0xE0, 0x03, 0x80, 0x00, 0xE0, 0x03, 0x00, 0x00, 0x60, 0x07,
  0x00, 0x00, 0x70, 0x06, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x38, 0x0E,
  0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x1C, 0x18,
  0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x06, 0x30,
  0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80,
  0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0,
  0x03, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xE0, 0xFF, 0x80, 0x00, 0x18, 0x38, 0x78, 0x00, 0x03, 0x0E, 0x03, 0x80,
  0x00, 0x61, 0x80, 0x38, 0x00, 0x1C, 0x60, 0x03, 0x80, 0x03, 0x0C, 0x00,
  0x38, 0x00, 0x63, 0x00, 0x03, 0x80, 0x1C, 0x60, 0x00, 0x38, 0x03, 0x0C,
  0x00, 0x03, 0x80, 0xC3, 0x80, 0x00, 0x38, 0x78, 0x60, 0x00, 0x03, 0xFE,
  0x0C, 0x00, 0x00, 0x1F, 0x00,
};

const GFXglyph IBMPlexMono_ExtraLight71pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 43, 0, -1 },
  { 1, 6, 50, 43, 18, -50 },
  { 39, 13, 18, 43, 15, -53 },
  { 69, 40, 50, 43, 1, -50 },
  { 319, 34, 65, 43, 4, -57 },
  { 596, 39, 51, 43, 2, -50 },
  { 845, 36, 51, 43, 3, -50 },
  { 1075, 3, 18, 43, 20, -53 },
  { 1082, 18, 64, 43, 16, -54 },
  { 1226, 17, 64, 43, 9, -54 },
  { 1362, 36, 35, 43, 3, -39 },
  { 1520, 34, 34, 43, 4, -39 },
  { 1665, 8, 19, 43, 16, -7 },
  { 1684, 19, 2, 43, 12, -23 },
  { 1689, 6, 6, 43, 18, -6 },
  { 1694, 28, 64, 43, 7, -54 },
  { 1918, 33, 51, 43, 5, -50 },
  { 2129, 33, 50, 43, 6, -50 },
  { 2336, 31, 50, 43, 6, -50 },
  { 2530, 30, 51, 43, 5, -50 },
  { 2722, 36, 50, 43, 3, -50 },
  { 2947, 30, 51, 43, 6, -50 },
  { 3139, 31, 51, 43, 6, -50 },
  { 3337, 32, 50, 43, 5, -50 },
  { 3537, 33, 51, 43, 5, -50 },
  { 3748, 31, 50, 43, 6, -50 },
  { 3942, 6, 38, 43, 18, -38 },
  { 3971, 8, 50, 43, 16, -38 },
  { 4021, 31, 39, 43, 6, -41 },
  { 4173, 34, 15, 43, 4, -29 },
  { 4237, 31, 39, 43, 6, -41 },
  { 4389, 29, 50, 43, 7, -50 },
  { 4571, 30, 58, 43, 6, -50 },
  { 4789, 36, 50, 43, 3, -50 },
  { 5014, 30, 50, 43, 7, -50 },
  { 5202, 32, 51, 43, 5, -50 },
  { 5406, 31, 50, 43, 7, -50 },
  { 5600, 30, 50, 43, 7, -50 },
  { 5788, 30, 50, 43, 7, -50 },
  { 5976, 32, 51, 43, 5, -50 },
  { 6180, 29, 50, 43, 7, -50 },
  { 6362, 30, 50, 43, 6, -50 },
  { 6550, 27, 51, 43, 6, -50 },
  { 6723, 32, 50, 43, 7, -50 },
  { 6923, 28, 50, 43, 10, -50 },
  { 7098, 31, 50, 43, 6, -50 },
  { 7292, 29, 50, 43, 7, -50 },
  { 7474, 33, 51, 43, 5, -50 },
  { 7685, 31, 50, 43, 7, -50 },
  { 7879, 33, 60, 43, 5, -50 },
  { 8127, 31, 50, 43, 7, -50 },
  { 8321, 34, 51, 43, 4, -50 },
  { 8538, 37, 50, 43, 3, -50 },
  { 8770, 29, 51, 43, 7, -50 },
  { 8955, 35, 50, 43, 4, -50 },
  { 9174, 35, 50, 43, 4, -50 },
  { 9393, 37, 50, 43, 3, -50 },
  { 9625, 39, 50, 43, 2, -50 },
  { 9869, 36, 50, 43, 3, -50 },
  { 10094, 18, 64, 43, 18, -54 },
  { 10238, 28, 64, 43, 7, -54 },
  { 10462, 17, 64, 43, 7, -54 },
  { 10598, 34, 27, 43, 4, -50 },
  { 10713, 34, 2, 43, 4, 8 },
  { 10722, 10, 12, 43, 14, -54 },
  { 10737, 33, 38, 43, 5, -37 },
  { 10894, 29, 54, 43, 8, -53 },
  { 11090, 29, 38, 43, 7, -37 },
  { 11228, 29, 54, 43, 5, -53 },
  { 11424, 31, 38, 43, 6, -37 },
  { 11572, 32, 53, 43, 6, -53 },
  { 11784, 33, 55, 43, 6, -40 },
  { 12011, 26, 53, 43, 9, -53 },
  { 12184, 30, 53, 43, 8, -53 },
  { 12383, 25, 67, 43, 7, -53 },
  { 12593, 31, 53, 43, 9, -53 },
  { 12799, 30, 53, 43, 6, -53 },
  { 12998, 33, 37, 43, 5, -37 },
  { 13151, 26, 37, 43, 9, -37 },
  { 13272, 31, 38, 43, 6, -37 },
  { 13420, 29, 51, 43, 8, -37 },
  { 13605, 29, 51, 43, 5, -37 },
  { 13790, 34, 37, 43, 6, -37 },
  { 13948, 31, 38, 43, 6, -37 },
  { 14096, 34, 50, 43, 3, -50 },
  { 14309, 26, 38, 43, 8, -37 },
  { 14433, 31, 37, 43, 6, -37 },
  { 14577, 37, 37, 43, 3, -37 },
  { 14749, 31, 37, 43, 6, -37 },
  { 14893, 32, 51, 43, 5, -37 },
  { 15097, 29, 37, 43, 7, -37 },
  { 15232, 27, 64, 43, 8, -54 },
  { 15448, 2, 64, 43, 20, -54 },
  { 15464, 27, 64, 43, 8, -54 },
  { 15680, 35, 13, 43, 4, -28 },
};

const GFXfont IBMPlexMono_ExtraLight71pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLight71pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLight71pt7bGlyphs,
  0x20, 0x7E, 92
};

#endif // _IBMPLEXMONO_EXTRALIGHT71PT7B_H_
