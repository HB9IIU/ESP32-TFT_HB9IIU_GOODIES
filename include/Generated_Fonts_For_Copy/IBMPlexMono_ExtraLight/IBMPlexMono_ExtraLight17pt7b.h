#ifndef _IBMPLEXMONO_EXTRALIGHT17PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHT17PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLight.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLight17pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0x03, 0xB6, 0xD0, 0x09, 0x02, 0x40, 0x90, 0x48, 0x71,
  0xC4, 0x81, 0x23, 0xCE, 0x24, 0x09, 0x02, 0x40, 0x90, 0x10, 0x10, 0x3C,
  0x52, 0x93, 0x90, 0x50, 0x78, 0x16, 0x11, 0x11, 0x91, 0x53, 0x3C, 0x10,
  0x10, 0x70, 0xD2, 0x28, 0x92, 0x24, 0x4A, 0x1C, 0x00, 0x38, 0x52, 0x28,
  0x52, 0x14, 0x4A, 0x0E, 0x38, 0x44, 0x80, 0x80, 0x40, 0x23, 0xD2, 0x8A,
  0x86, 0x84, 0x86, 0x79, 0xF0, 0x34, 0x48, 0x88, 0x88, 0x88, 0x88, 0x44,
  0x30, 0x84, 0x22, 0x11, 0x11, 0x11, 0x12, 0x24, 0x80, 0x10, 0x10, 0x10,
  0xD3, 0x3C, 0x18, 0x24, 0x42, 0x10, 0x10, 0x10, 0x10, 0xFF, 0x10, 0x10,
  0x10, 0x10, 0x6A, 0x80, 0xF0, 0xC0, 0x04, 0x10, 0x82, 0x08, 0x41, 0x08,
  0x20, 0x84, 0x10, 0x82, 0x08, 0x00, 0x3C, 0x42, 0x81, 0x81, 0x81, 0x81,
  0x89, 0x81, 0x81, 0x81, 0x42, 0x3C, 0x18, 0x38, 0x68, 0xC8, 0x08, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x7F, 0x3C, 0x42, 0x82, 0x02, 0x02, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0xFF, 0x3C, 0x86, 0x08, 0x10, 0x27, 0x81,
  0x81, 0x03, 0x05, 0x09, 0xE0, 0x04, 0x0C, 0x14, 0x14, 0x24, 0x44, 0x84,
  0x84, 0xFF, 0x04, 0x04, 0x04, 0x7E, 0x40, 0x40, 0x40, 0xBC, 0x42, 0x01,
  0x01, 0x01, 0x82, 0x42, 0x3C, 0x0C, 0x10, 0x20, 0x40, 0x40, 0xBC, 0xC2,
  0x81, 0x81, 0x81, 0x42, 0x3C, 0xFF, 0x82, 0x82, 0x82, 0x04, 0x04, 0x08,
  0x08, 0x10, 0x10, 0x20, 0x20, 0x3C, 0x42, 0x81, 0x81, 0x42, 0x3C, 0x66,
  0x81, 0x81, 0x81, 0x43, 0x3C, 0x3C, 0x42, 0x81, 0x81, 0x81, 0x43, 0x3D,
  0x02, 0x02, 0x04, 0x08, 0x30, 0xC0, 0x00, 0xC0, 0xC0, 0x01, 0xAA, 0x01,
  0x06, 0x18, 0x20, 0xC0, 0x60, 0x10, 0x0C, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x60, 0x18, 0x04, 0x03, 0x06, 0x08, 0x30, 0xC0, 0x79, 0x0A, 0x10,
  0x30, 0x40, 0x8E, 0x10, 0x20, 0x00, 0x01, 0x00, 0x3C, 0x42, 0x42, 0x8E,
  0x91, 0xA1, 0xA1, 0xA1, 0x91, 0x8F, 0x80, 0x40, 0x60, 0x3E, 0x08, 0x18,
  0x18, 0x24, 0x24, 0x24, 0x42, 0x42, 0x7E, 0x81, 0x81, 0x81, 0xF9, 0x0A,
  0x14, 0x28, 0x5F, 0x21, 0x41, 0x83, 0x06, 0x17, 0xE0, 0x3C, 0x62, 0x41,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x41, 0x62, 0x3C, 0xF9, 0x0A, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x17, 0xC0, 0xFF, 0x02, 0x04, 0x08,
  0x1F, 0xE0, 0x40, 0x81, 0x02, 0x07, 0xF0, 0xFF, 0x02, 0x04, 0x08, 0x1F,
  0xA0, 0x40, 0x81, 0x02, 0x04, 0x00, 0x3C, 0x42, 0x82, 0x81, 0x80, 0x80,
  0x8F, 0x81, 0x81, 0x81, 0x43, 0x3D, 0x83, 0x06, 0x0C, 0x18, 0x3F, 0xE0,
  0xC1, 0x83, 0x06, 0x0C, 0x10, 0xFE, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x87, 0xF0, 0x7C, 0x10, 0x41, 0x04, 0x10, 0x41, 0x06, 0x18,
  0xDE, 0x83, 0x0A, 0x24, 0x8A, 0x14, 0x34, 0x44, 0x89, 0x0A, 0x14, 0x10,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x07, 0xF0, 0x81,
  0xC3, 0xC3, 0xA5, 0xA5, 0x99, 0x99, 0x91, 0x81, 0x81, 0x81, 0x81, 0x83,
  0x07, 0x0E, 0x1A, 0x34, 0x64, 0xC9, 0x8B, 0x16, 0x1C, 0x30, 0x3C, 0x42,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x42, 0x3C, 0xFD, 0x06,
  0x0C, 0x18, 0x30, 0x7F, 0x40, 0x81, 0x02, 0x04, 0x00, 0x3C, 0x42, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x42, 0x3C, 0x10, 0x10, 0x0E,
  0xFD, 0x06, 0x0C, 0x18, 0x30, 0x7F, 0x48, 0x89, 0x12, 0x14, 0x10, 0x3C,
  0x42, 0x83, 0x80, 0x40, 0x78, 0x06, 0x01, 0x01, 0x81, 0x43, 0x3C, 0xFF,
  0x88, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x00, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x0A, 0x13, 0xC0,
  0x81, 0x81, 0x81, 0x42, 0x42, 0x42, 0x24, 0x24, 0x24, 0x18, 0x18, 0x08,
  0x81, 0x81, 0x81, 0x81, 0x89, 0x99, 0x99, 0xA9, 0xA5, 0xA6, 0xC6, 0x42,
  0x81, 0x42, 0x42, 0x24, 0x18, 0x18, 0x18, 0x24, 0x24, 0x42, 0x82, 0x81,
  0x80, 0xD0, 0x22, 0x10, 0x88, 0x12, 0x03, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0xFF, 0x01, 0x02, 0x04, 0x08, 0x08, 0x10, 0x20, 0x40,
  0x40, 0x80, 0xFF, 0xFC, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x43,
  0xE0, 0x82, 0x08, 0x10, 0x40, 0x82, 0x08, 0x10, 0x40, 0x82, 0x08, 0x10,
  0x40, 0xF1, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0xF0, 0x18, 0x18, 0x24,
  0x44, 0x42, 0x81, 0x81, 0xFF, 0x88, 0x80, 0x3C, 0xC4, 0x02, 0x02, 0x7E,
  0x82, 0x82, 0x86, 0x7B, 0x81, 0x02, 0x04, 0x0B, 0x98, 0xA0, 0xC1, 0x83,
  0x06, 0x0C, 0x2F, 0x80, 0x79, 0x8A, 0x14, 0x08, 0x10, 0x21, 0x63, 0x78,
  0x02, 0x04, 0x08, 0x13, 0xA8, 0xE0, 0xC1, 0x83, 0x06, 0x0A, 0x33, 0xA0,
  0x3C, 0x42, 0x82, 0x81, 0xFF, 0x80, 0x80, 0x43, 0x3C, 0x0F, 0x10, 0x10,
  0x10, 0xFF, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x7F, 0x03, 0x3C,
  0x42, 0x42, 0x42, 0x42, 0x3C, 0x40, 0x40, 0x7F, 0x81, 0x81, 0x7E, 0x82,
  0x08, 0x20, 0xBB, 0x18, 0x61, 0x86, 0x18, 0x61, 0x84, 0x10, 0x00, 0x00,
  0x0F, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x8F, 0xE0, 0x0C, 0x00, 0x00,
  0xF8, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0xBE, 0x80, 0x80, 0x80,
  0x80, 0x82, 0x8C, 0x90, 0xA0, 0xD0, 0x88, 0x84, 0x84, 0x83, 0xF0, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0xFF, 0xF7,
  0x89, 0x91, 0x91, 0x91, 0x91, 0x91, 0x91, 0x91, 0xBB, 0x18, 0x61, 0x86,
  0x18, 0x61, 0x84, 0x3C, 0x42, 0x81, 0x81, 0x81, 0x81, 0x81, 0x42, 0x3C,
  0xB9, 0x8A, 0x0C, 0x18, 0x30, 0x60, 0xC2, 0xF9, 0x02, 0x04, 0x00, 0x3A,
  0x8E, 0x0C, 0x18, 0x30, 0x60, 0xA3, 0x3A, 0x04, 0x08, 0x10, 0xF7, 0x18,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0xFF, 0x3C, 0x42, 0x81, 0x40, 0x3E,
  0x01, 0x01, 0xC1, 0x3E, 0x10, 0x10, 0x10, 0xFF, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x1F, 0x86, 0x18, 0x61, 0x86, 0x18, 0x63, 0x7C, 0x81,
  0x42, 0x42, 0x44, 0x24, 0x24, 0x28, 0x18, 0x08, 0x88, 0xCC, 0xA6, 0x55,
  0x2A, 0x55, 0x2A, 0x98, 0x8C, 0x42, 0x00, 0xC3, 0x42, 0x24, 0x18, 0x10,
  0x18, 0x24, 0x42, 0x83, 0x81, 0x42, 0x42, 0x44, 0x24, 0x24, 0x18, 0x18,
  0x10, 0x10, 0x20, 0x60, 0xFC, 0x08, 0x20, 0x82, 0x08, 0x10, 0x40, 0xFE,
  0x3C, 0x82, 0x08, 0x10, 0x41, 0x38, 0x30, 0x41, 0x08, 0x20, 0x83, 0xC0,
  0xFF, 0xFE, 0xF0, 0x41, 0x04, 0x21, 0x02, 0x07, 0x31, 0x02, 0x04, 0x10,
  0x4F, 0x00, 0x61, 0x91, 0x89, 0x86,
};

const GFXglyph IBMPlexMono_ExtraLight17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 2, 12, 10, 4, -12 },
  { 4, 3, 4, 10, 4, -13 },
  { 6, 10, 12, 10, 0, -12 },
  { 21, 8, 16, 10, 1, -14 },
  { 37, 10, 12, 10, 0, -12 },
  { 52, 8, 12, 10, 1, -12 },
  { 64, 1, 4, 10, 5, -13 },
  { 65, 4, 15, 10, 4, -13 },
  { 73, 4, 15, 10, 2, -13 },
  { 81, 8, 8, 10, 1, -9 },
  { 89, 8, 9, 10, 1, -10 },
  { 98, 2, 5, 10, 4, -2 },
  { 100, 4, 1, 10, 3, -6 },
  { 101, 2, 1, 10, 4, -1 },
  { 102, 6, 15, 10, 2, -13 },
  { 114, 8, 12, 10, 1, -12 },
  { 126, 8, 12, 10, 1, -12 },
  { 138, 8, 12, 10, 1, -12 },
  { 150, 7, 12, 10, 1, -12 },
  { 161, 8, 12, 10, 1, -12 },
  { 173, 8, 12, 10, 1, -12 },
  { 185, 8, 12, 10, 1, -12 },
  { 197, 8, 12, 10, 1, -12 },
  { 209, 8, 12, 10, 1, -12 },
  { 221, 8, 12, 10, 1, -12 },
  { 233, 2, 9, 10, 4, -9 },
  { 236, 2, 12, 10, 4, -9 },
  { 239, 8, 9, 10, 1, -10 },
  { 248, 8, 4, 10, 1, -7 },
  { 252, 8, 9, 10, 1, -10 },
  { 261, 7, 12, 10, 2, -12 },
  { 272, 8, 14, 10, 1, -12 },
  { 286, 8, 12, 10, 1, -12 },
  { 298, 7, 12, 10, 2, -12 },
  { 309, 8, 12, 10, 1, -12 },
  { 321, 7, 12, 10, 2, -12 },
  { 332, 7, 12, 10, 2, -12 },
  { 343, 7, 12, 10, 2, -12 },
  { 354, 8, 12, 10, 1, -12 },
  { 366, 7, 12, 10, 2, -12 },
  { 377, 7, 12, 10, 2, -12 },
  { 388, 6, 12, 10, 2, -12 },
  { 397, 7, 12, 10, 2, -12 },
  { 408, 7, 12, 10, 2, -12 },
  { 419, 8, 12, 10, 1, -12 },
  { 431, 7, 12, 10, 2, -12 },
  { 442, 8, 12, 10, 1, -12 },
  { 454, 7, 12, 10, 2, -12 },
  { 465, 8, 15, 10, 1, -12 },
  { 480, 7, 12, 10, 2, -12 },
  { 491, 8, 12, 10, 1, -12 },
  { 503, 9, 12, 10, 1, -12 },
  { 517, 7, 12, 10, 2, -12 },
  { 528, 8, 12, 10, 1, -12 },
  { 540, 8, 12, 10, 1, -12 },
  { 552, 8, 12, 10, 1, -12 },
  { 564, 10, 12, 10, 0, -12 },
  { 579, 8, 12, 10, 1, -12 },
  { 591, 5, 15, 10, 4, -13 },
  { 601, 6, 15, 10, 2, -13 },
  { 613, 4, 15, 10, 2, -13 },
  { 621, 8, 7, 10, 1, -12 },
  { 628, 8, 1, 10, 1, 2 },
  { 629, 3, 3, 10, 3, -14 },
  { 631, 8, 9, 10, 1, -9 },
  { 640, 7, 13, 10, 2, -13 },
  { 652, 7, 9, 10, 2, -9 },
  { 660, 7, 13, 10, 1, -13 },
  { 672, 8, 9, 10, 1, -9 },
  { 681, 8, 13, 10, 1, -13 },
  { 694, 8, 13, 10, 1, -10 },
  { 707, 6, 13, 10, 2, -13 },
  { 717, 7, 13, 10, 2, -13 },
  { 729, 6, 16, 10, 2, -13 },
  { 741, 8, 13, 10, 2, -13 },
  { 754, 8, 13, 10, 1, -13 },
  { 767, 8, 9, 10, 1, -9 },
  { 776, 6, 9, 10, 2, -9 },
  { 783, 8, 9, 10, 1, -9 },
  { 792, 7, 12, 10, 2, -9 },
  { 803, 7, 12, 10, 1, -9 },
  { 814, 8, 9, 10, 1, -9 },
  { 823, 8, 9, 10, 1, -9 },
  { 832, 8, 12, 10, 1, -12 },
  { 844, 6, 9, 10, 2, -9 },
  { 851, 8, 9, 10, 1, -9 },
  { 860, 9, 9, 10, 1, -9 },
  { 871, 8, 9, 10, 1, -9 },
  { 880, 8, 12, 10, 1, -9 },
  { 892, 7, 9, 10, 2, -9 },
  { 900, 6, 15, 10, 2, -13 },
  { 912, 1, 15, 10, 5, -13 },
  { 914, 6, 15, 10, 2, -13 },
  { 926, 8, 4, 10, 1, -7 },
};

const GFXfont IBMPlexMono_ExtraLight17pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLight17pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLight17pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _IBMPLEXMONO_EXTRALIGHT17PT7B_H_
