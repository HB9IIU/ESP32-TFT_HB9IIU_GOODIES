#ifndef _IBMPLEXMONO_EXTRALIGHT36PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHT36PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLight.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLight36pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x48, 0x00, 0x1F, 0x60, 0x86,
  0x18, 0x61, 0x86, 0x18, 0x61, 0x84, 0x00, 0x81, 0x00, 0x08, 0x30, 0x00,
  0x82, 0x00, 0x08, 0x20, 0x01, 0x82, 0x00, 0x10, 0x20, 0x01, 0x06, 0x00,
  0x10, 0x40, 0x7F, 0x07, 0xF0, 0x30, 0x40, 0x03, 0x04, 0x00, 0x20, 0x40,
  0x02, 0x0C, 0x00, 0x20, 0x80, 0x02, 0x08, 0x00, 0x20, 0x80, 0xFE, 0x0F,
  0xE0, 0x40, 0x80, 0x04, 0x18, 0x00, 0x41, 0x00, 0x04, 0x10, 0x00, 0xC1,
  0x00, 0x08, 0x10, 0x00, 0x83, 0x00, 0x08, 0x30, 0x00, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x7F, 0x80, 0xE2, 0x70, 0xC1, 0x0C,
  0xC0, 0x83, 0x40, 0x40, 0x20, 0x20, 0x10, 0x10, 0x08, 0x08, 0x06, 0x04,
  0x01, 0x02, 0x00, 0x61, 0x00, 0x1E, 0x80, 0x01, 0xF8, 0x00, 0x27, 0x00,
  0x10, 0xC0, 0x08, 0x30, 0x04, 0x08, 0x02, 0x04, 0x01, 0x02, 0x00, 0x81,
  0x80, 0x40, 0xA0, 0x20, 0xCC, 0x10, 0xC3, 0x89, 0xC0, 0x7F, 0x80, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x1F, 0x00, 0x32, 0x18,
  0x02, 0x40, 0xC0, 0x4C, 0x04, 0x0C, 0x80, 0x40, 0x88, 0x04, 0x10, 0x80,
  0x41, 0x08, 0x04, 0x20, 0xC0, 0x42, 0x04, 0x0C, 0x40, 0x21, 0x8C, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x02, 0x10, 0xC0, 0x62, 0x06,
  0x04, 0x20, 0x20, 0x86, 0x02, 0x08, 0x60, 0x21, 0x06, 0x02, 0x10, 0x60,
  0x22, 0x02, 0x02, 0x60, 0x20, 0x64, 0x01, 0x0C, 0x80, 0x0F, 0x80, 0x03,
  0xE0, 0x01, 0x83, 0x00, 0x20, 0x30, 0x08, 0x02, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10,
  0x00, 0x03, 0x00, 0x01, 0xB0, 0x1E, 0x63, 0x02, 0x18, 0x30, 0x42, 0x03,
  0x18, 0x40, 0x22, 0x18, 0x02, 0x43, 0x00, 0x28, 0x60, 0x07, 0x04, 0x00,
  0x60, 0x80, 0x16, 0x08, 0x02, 0x61, 0xC1, 0x86, 0x0F, 0xC0, 0x60, 0xFF,
  0x80, 0x01, 0x81, 0x01, 0x01, 0x00, 0x80, 0x80, 0xC0, 0x40, 0x20, 0x20,
  0x10, 0x08, 0x04, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x40, 0x20, 0x18, 0x04, 0x01, 0x00, 0x80, 0x20, 0x08,
  0x03, 0xC0, 0x60, 0x30, 0x10, 0x08, 0x0C, 0x04, 0x06, 0x02, 0x02, 0x03,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x03, 0x02,
  0x02, 0x06, 0x04, 0x0C, 0x08, 0x10, 0x30, 0x60, 0xC0, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x08, 0x08,
  0x0F, 0xC2, 0x1E, 0x0E, 0xBC, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x04, 0x80,
  0x02, 0x30, 0x01, 0x84, 0x00, 0xC0, 0x80, 0x20, 0x30, 0x10, 0x06, 0x0C,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0xFF, 0xFF, 0x80, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x33, 0x66, 0x64, 0x4C, 0x80, 0xFF, 0xC0, 0x7D, 0x80,
  0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x02,
  0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x04,
  0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x0C,
  0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x18,
  0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x00, 0x03, 0xF0, 0x06, 0x0E,
  0x04, 0x01, 0x86, 0x00, 0x42, 0x00, 0x13, 0x00, 0x09, 0x00, 0x06, 0x80,
  0x03, 0x40, 0x00, 0xA0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x0C, 0x0E,
  0x06, 0x07, 0x00, 0x02, 0x80, 0x01, 0x40, 0x00, 0xA0, 0x00, 0xD0, 0x00,
  0x6C, 0x00, 0x22, 0x00, 0x11, 0x80, 0x10, 0x60, 0x18, 0x18, 0x38, 0x03,
  0xF0, 0x00, 0x01, 0x80, 0x01, 0x40, 0x03, 0x20, 0x03, 0x10, 0x03, 0x08,
  0x03, 0x04, 0x03, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xE0, 0x38, 0x30,
  0x60, 0x08, 0x40, 0x04, 0xC0, 0x04, 0x80, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0x07, 0xE0,
  0x18, 0x18, 0x30, 0x04, 0x60, 0x06, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x07, 0xE0, 0x00, 0x38,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x80, 0x02, 0x40, 0x02, 0x60, 0x04, 0x38, 0x18, 0x0F, 0xE0,
  0x00, 0x0C, 0x00, 0x05, 0x00, 0x03, 0x40, 0x00, 0x90, 0x00, 0x44, 0x00,
  0x31, 0x00, 0x18, 0x40, 0x04, 0x10, 0x02, 0x04, 0x01, 0x81, 0x00, 0x40,
  0x40, 0x20, 0x10, 0x18, 0x04, 0x04, 0x01, 0x02, 0x00, 0x41, 0x80, 0x10,
  0xC0, 0x04, 0x20, 0x01, 0x0F, 0xFF, 0xFC, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x3F, 0xFE, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x1F, 0x82, 0xC0, 0xC6, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x18, 0x00,
  0x38, 0x00, 0x98, 0x03, 0x1C, 0x0C, 0x0F, 0xE0, 0x00, 0x60, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00,
  0x20, 0x00, 0x60, 0x00, 0x47, 0xE0, 0x58, 0x18, 0xE0, 0x0C, 0xC0, 0x06,
  0xC0, 0x02, 0x80, 0x02, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x02,
  0x40, 0x02, 0x40, 0x06, 0x20, 0x0C, 0x18, 0x18, 0x07, 0xE0, 0xFF, 0xFF,
  0x80, 0x02, 0x80, 0x02, 0x80, 0x06, 0x80, 0x04, 0x80, 0x0C, 0x80, 0x08,
  0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60,
  0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00,
  0x07, 0xF0, 0x0E, 0x06, 0x0C, 0x00, 0x84, 0x00, 0x66, 0x00, 0x13, 0x00,
  0x09, 0x80, 0x04, 0xC0, 0x02, 0x20, 0x03, 0x08, 0x01, 0x03, 0x03, 0x00,
  0x7E, 0x01, 0xC0, 0xC1, 0x80, 0x11, 0x80, 0x04, 0x80, 0x03, 0x40, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x28, 0x00, 0x14, 0x00, 0x1B, 0x00, 0x08, 0xC0,
  0x0C, 0x38, 0x18, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x18, 0x18, 0x20, 0x0C,
  0x60, 0x06, 0x40, 0x02, 0xC0, 0x02, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0x40, 0x07, 0x20, 0x0A, 0x18, 0x12, 0x07, 0xC6,
  0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x7D, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x7D, 0x80, 0x37, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x33, 0x66, 0x64, 0x4C, 0x80, 0x00, 0x01, 0x00, 0x06, 0x00, 0x1C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xE0, 0x00, 0x80, 0x00, 0x07, 0xE0, 0x30, 0x30, 0xC0, 0x33,
  0x00, 0x24, 0x00, 0x78, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00,
  0x08, 0x00, 0x30, 0x01, 0x80, 0x3C, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x03, 0xC0, 0x03, 0x00, 0x07, 0xE0, 0x30, 0x60, 0xC0, 0x21, 0x00,
  0x26, 0x00, 0x48, 0x00, 0x50, 0x00, 0xA0, 0x79, 0xC1, 0x0B, 0x04, 0x0E,
  0x18, 0x0C, 0x20, 0x18, 0x40, 0x30, 0x80, 0x61, 0x00, 0xC2, 0x01, 0x84,
  0x03, 0x08, 0x06, 0x18, 0x0C, 0x10, 0x3C, 0x30, 0xA8, 0x3E, 0x50, 0x00,
  0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x60, 0x00, 0x7F, 0xC0,
  0x00, 0xC0, 0x00, 0x70, 0x00, 0x16, 0x00, 0x04, 0x80, 0x03, 0x20, 0x00,
  0x8C, 0x00, 0x21, 0x00, 0x18, 0x40, 0x04, 0x18, 0x01, 0x06, 0x00, 0xC0,
  0x80, 0x30, 0x20, 0x08, 0x0C, 0x06, 0x01, 0x01, 0x80, 0x40, 0x40, 0x18,
  0x3F, 0xFE, 0x0C, 0x00, 0x82, 0x00, 0x31, 0x80, 0x04, 0x60, 0x01, 0x10,
  0x00, 0x64, 0x00, 0x0B, 0x00, 0x02, 0x80, 0x00, 0xC0, 0xFF, 0xE0, 0xC0,
  0x18, 0xC0, 0x0C, 0xC0, 0x04, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0,
  0x06, 0xC0, 0x06, 0xC0, 0x04, 0xC0, 0x0C, 0xC0, 0x18, 0xFF, 0xF0, 0xC0,
  0x0C, 0xC0, 0x06, 0xC0, 0x02, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x02, 0xC0, 0x06, 0xC0, 0x0C, 0xFF, 0xF0, 0x03,
  0xF0, 0x0C, 0x18, 0x30, 0x04, 0x20, 0x02, 0x60, 0x03, 0x40, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x40, 0x00, 0x60, 0x03, 0x20, 0x02, 0x30, 0x04, 0x0C, 0x18, 0x07,
  0xF0, 0xFF, 0xC1, 0x00, 0xE2, 0x00, 0x64, 0x00, 0x48, 0x00, 0xD0, 0x00,
  0xA0, 0x01, 0x40, 0x03, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00,
  0x14, 0x00, 0x28, 0x00, 0xD0, 0x01, 0x20, 0x06, 0x40, 0x38, 0xFF, 0xC0,
  0xFF, 0xFF, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x0F, 0xFF,
  0xD0, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0xFF, 0xFE, 0xFF,
  0xFF, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x0F, 0xFF, 0xD0,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x00, 0x07, 0xE0,
  0x1C, 0x18, 0x30, 0x0C, 0x60, 0x06, 0x40, 0x02, 0xC0, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0xFF, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0xC0, 0x03, 0x40, 0x03, 0x60, 0x07, 0x30, 0x0B, 0x18, 0x1B, 0x07, 0xE3,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x02, 0xFF,
  0xFE, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0xFF, 0xFE, 0x1F, 0xFC,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0xC0, 0x09, 0x00,
  0x26, 0x01, 0x8C, 0x1C, 0x0F, 0xC0, 0x80, 0x03, 0x80, 0x06, 0x80, 0x0C,
  0x80, 0x18, 0x80, 0x30, 0x80, 0x60, 0x80, 0xC0, 0x80, 0x80, 0x81, 0x00,
  0x82, 0x00, 0x86, 0x00, 0x8E, 0x00, 0x9B, 0x00, 0xB1, 0x00, 0xE0, 0x80,
  0xC0, 0xC0, 0x80, 0x40, 0x80, 0x60, 0x80, 0x30, 0x80, 0x10, 0x80, 0x18,
  0x80, 0x0C, 0x80, 0x04, 0x80, 0x06, 0x80, 0x03, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0xFF, 0xFC, 0xC0, 0x03, 0xC0, 0x07, 0xA0, 0x07, 0xA0, 0x0F,
  0xB0, 0x0B, 0x90, 0x0B, 0x98, 0x13, 0x88, 0x13, 0x88, 0x23, 0x84, 0x23,
  0x84, 0x63, 0x82, 0x43, 0x82, 0xC3, 0x83, 0x83, 0x81, 0x83, 0x81, 0x03,
  0x81, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x0E,
  0x80, 0x1D, 0x80, 0x39, 0x00, 0x73, 0x00, 0xE2, 0x01, 0xC4, 0x03, 0x84,
  0x07, 0x08, 0x0E, 0x08, 0x1C, 0x10, 0x38, 0x10, 0x70, 0x20, 0xE0, 0x21,
  0xC0, 0x43, 0x80, 0x47, 0x00, 0x8E, 0x00, 0x9C, 0x01, 0x38, 0x01, 0x70,
  0x02, 0xE0, 0x03, 0xC0, 0x06, 0x03, 0xF0, 0x06, 0x0E, 0x04, 0x01, 0x86,
  0x00, 0x42, 0x00, 0x13, 0x00, 0x09, 0x00, 0x06, 0x80, 0x03, 0x40, 0x00,
  0xA0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x02, 0x80, 0x01, 0x40, 0x00, 0xA0, 0x00, 0xD0, 0x00, 0x6C, 0x00, 0x22,
  0x00, 0x11, 0x80, 0x10, 0x60, 0x18, 0x18, 0x38, 0x03, 0xF0, 0x00, 0xFF,
  0xE1, 0x00, 0x32, 0x00, 0x34, 0x00, 0x28, 0x00, 0x70, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x14, 0x00, 0x68, 0x01, 0x9F,
  0xFC, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x00, 0x03, 0xF0,
  0x06, 0x0E, 0x04, 0x01, 0x86, 0x00, 0x42, 0x00, 0x13, 0x00, 0x09, 0x00,
  0x06, 0x80, 0x03, 0x40, 0x00, 0xA0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x02, 0x80, 0x01, 0x40, 0x00, 0xA0, 0x00,
  0xD0, 0x00, 0x6C, 0x00, 0x22, 0x00, 0x11, 0x80, 0x10, 0x60, 0x18, 0x18,
  0x38, 0x03, 0xF0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x03, 0xF0, 0xFF, 0xE1, 0x00, 0x32, 0x00, 0x34, 0x00, 0x28, 0x00, 0x70,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x14, 0x00,
  0x68, 0x01, 0x9F, 0xFC, 0x20, 0x40, 0x40, 0xC0, 0x80, 0x81, 0x00, 0x82,
  0x01, 0x84, 0x01, 0x08, 0x01, 0x10, 0x03, 0x20, 0x02, 0x40, 0x02, 0x80,
  0x06, 0x07, 0xF8, 0x0C, 0x07, 0x0C, 0x00, 0xCC, 0x00, 0x34, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x06, 0x00,
  0x01, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x18, 0x00, 0x1A, 0x00, 0x08,
  0xC0, 0x0C, 0x30, 0x1C, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x05, 0x00, 0x0A, 0x00, 0x14, 0x00, 0x6C, 0x00,
  0x88, 0x03, 0x0C, 0x0C, 0x0F, 0xE0, 0x80, 0x00, 0xF0, 0x00, 0x24, 0x00,
  0x09, 0x00, 0x06, 0x60, 0x01, 0x08, 0x00, 0x42, 0x00, 0x30, 0xC0, 0x08,
  0x10, 0x02, 0x04, 0x01, 0x81, 0x80, 0x40, 0x20, 0x10, 0x08, 0x0C, 0x03,
  0x02, 0x00, 0x40, 0x80, 0x10, 0x60, 0x04, 0x10, 0x01, 0x84, 0x00, 0x23,
  0x00, 0x08, 0xC0, 0x03, 0x20, 0x00, 0x48, 0x00, 0x16, 0x00, 0x07, 0x00,
  0x00, 0xC0, 0x00, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0A, 0x00, 0x02,
  0xC0, 0x00, 0xB0, 0x00, 0x24, 0x00, 0x09, 0x03, 0x02, 0x40, 0xC0, 0x90,
  0x70, 0x24, 0x16, 0x09, 0x04, 0x86, 0x41, 0x21, 0x90, 0x88, 0x44, 0x23,
  0x11, 0x88, 0x44, 0x66, 0x11, 0x09, 0x04, 0x42, 0x40, 0x90, 0x90, 0x24,
  0x2C, 0x09, 0x0A, 0x03, 0x42, 0x80, 0x70, 0xA0, 0x1C, 0x30, 0x06, 0x00,
  0xC0, 0x00, 0xD0, 0x00, 0x62, 0x00, 0x10, 0xC0, 0x08, 0x10, 0x06, 0x02,
  0x01, 0x00, 0xC0, 0x80, 0x10, 0x60, 0x02, 0x10, 0x00, 0xC8, 0x00, 0x16,
  0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x12, 0x00, 0x08, 0xC0,
  0x06, 0x10, 0x01, 0x02, 0x00, 0x80, 0xC0, 0x60, 0x10, 0x10, 0x02, 0x08,
  0x00, 0xC6, 0x00, 0x11, 0x00, 0x02, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x34,
  0x00, 0x06, 0x20, 0x00, 0x43, 0x00, 0x08, 0x10, 0x01, 0x81, 0x80, 0x10,
  0x0C, 0x03, 0x00, 0x40, 0x60, 0x06, 0x04, 0x00, 0x30, 0xC0, 0x01, 0x18,
  0x00, 0x19, 0x00, 0x00, 0xB0, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x08, 0x00, 0x06, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xC0, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0xFF, 0x80, 0x02, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x80, 0x03, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x03, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x18,
  0x00, 0x20, 0x00, 0x80, 0x01, 0xFF, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x03, 0xFF, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x48, 0x00,
  0x46, 0x00, 0x61, 0x00, 0x20, 0xC0, 0x30, 0x20, 0x10, 0x08, 0x10, 0x06,
  0x18, 0x01, 0x08, 0x00, 0xCC, 0x00, 0x24, 0x00, 0x1C, 0x00, 0x04, 0xFF,
  0xFF, 0x80, 0xC2, 0x08, 0x61, 0x04, 0x0F, 0xC0, 0x30, 0x70, 0x60, 0x10,
  0xC0, 0x08, 0x80, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08,
  0x1F, 0xF8, 0x60, 0x08, 0xC0, 0x08, 0x80, 0x08, 0x80, 0x08, 0x80, 0x08,
  0x80, 0x08, 0xC0, 0x38, 0x60, 0x48, 0x1F, 0x87, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC7,
  0xC1, 0xB0, 0x63, 0x80, 0x66, 0x00, 0x6C, 0x00, 0x58, 0x00, 0xB0, 0x01,
  0xE0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xB0, 0x01, 0x60, 0x06, 0xE0, 0x19, 0xB0, 0x63, 0x3F, 0x00, 0x07,
  0xE0, 0x60, 0xC2, 0x00, 0x90, 0x03, 0x40, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x03, 0x00, 0x04,
  0x00, 0x90, 0x01, 0x20, 0x08, 0x60, 0xC0, 0x7C, 0x00, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x0F,
  0xC4, 0x60, 0xD2, 0x00, 0xD0, 0x03, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x1C,
  0x00, 0x50, 0x03, 0x20, 0x0C, 0x60, 0xD0, 0xFC, 0x40, 0x07, 0xE0, 0x18,
  0x38, 0x30, 0x0C, 0x60, 0x04, 0x40, 0x06, 0x40, 0x02, 0xC0, 0x02, 0xC0,
  0x02, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0x40, 0x02, 0x60, 0x06, 0x30, 0x0C, 0x18, 0x18, 0x07, 0xE0, 0x01,
  0xFF, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0xFF, 0xFF, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0x83, 0xF4, 0x06, 0x06, 0x06,
  0x01, 0x02, 0x00, 0x41, 0x00, 0x21, 0x80, 0x10, 0xC0, 0x08, 0x20, 0x04,
  0x10, 0x02, 0x0C, 0x02, 0x03, 0x02, 0x00, 0x7E, 0x00, 0xC0, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x30, 0x00, 0x1F, 0xFE, 0x04, 0x00, 0xCC, 0x00, 0x2C,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x02, 0x40, 0x03, 0x18, 0x07,
  0x03, 0xFC, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC7, 0xC3, 0x60, 0xCE, 0x01, 0xB0, 0x02,
  0xC0, 0x0B, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x03, 0xFF, 0xF8, 0x00, 0x18, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x13,
  0xFF, 0x80, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x0D, 0x00, 0x32, 0x00, 0xC4, 0x02,
  0x08, 0x08, 0x10, 0x20, 0x21, 0x80, 0x46, 0x00, 0x9E, 0x01, 0x66, 0x03,
  0x86, 0x04, 0x04, 0x08, 0x04, 0x10, 0x0C, 0x20, 0x0C, 0x40, 0x0C, 0x80,
  0x09, 0x00, 0x0A, 0x00, 0x18, 0xFF, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x03, 0xFF, 0xF8, 0xCF, 0x1E, 0x78, 0xD0,
  0xB0, 0x30, 0x38, 0x18, 0x1C, 0x0C, 0x0E, 0x04, 0x07, 0x02, 0x03, 0x81,
  0x01, 0xC0, 0x80, 0xE0, 0x40, 0x70, 0x20, 0x38, 0x10, 0x1C, 0x08, 0x0E,
  0x04, 0x07, 0x02, 0x03, 0x81, 0x01, 0xC0, 0x80, 0xE0, 0x40, 0x70, 0x20,
  0x20, 0xC7, 0xC3, 0x60, 0xCE, 0x01, 0xB0, 0x02, 0xC0, 0x0B, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xC0, 0x07,
  0xE0, 0x18, 0x38, 0x30, 0x0C, 0x60, 0x04, 0x40, 0x06, 0xC0, 0x02, 0xC0,
  0x02, 0x80, 0x02, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x02, 0xC0,
  0x02, 0x40, 0x02, 0x40, 0x06, 0x60, 0x04, 0x30, 0x0C, 0x18, 0x18, 0x07,
  0xE0, 0xC7, 0xC1, 0xB0, 0x63, 0x80, 0x66, 0x00, 0x6C, 0x00, 0x58, 0x00,
  0xB0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xB0, 0x01, 0x60, 0x06, 0xE0, 0x19, 0xB0, 0x63, 0x3F,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x00, 0x0F, 0xC4, 0x60, 0xD2, 0x00, 0xD0, 0x03, 0xC0, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x1C, 0x00, 0x50, 0x03, 0x20, 0x0C, 0x60, 0xD0, 0xFC, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10,
  0xFE, 0x1F, 0x81, 0x30, 0x00, 0xA0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xE0, 0x38, 0x18, 0x20, 0x06, 0x40,
  0x04, 0x40, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x1E, 0x00, 0x03,
  0xF0, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0xC0,
  0x02, 0x60, 0x06, 0x38, 0x0C, 0x07, 0xF0, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x0F, 0xFF, 0xFC, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x00, 0xFF, 0xC0, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x07, 0x00, 0x28, 0x03, 0x60, 0x19, 0x83, 0x47, 0xE2, 0xC0,
  0x03, 0x40, 0x02, 0x40, 0x06, 0x60, 0x04, 0x20, 0x04, 0x20, 0x0C, 0x30,
  0x08, 0x10, 0x08, 0x10, 0x10, 0x08, 0x10, 0x08, 0x30, 0x0C, 0x20, 0x04,
  0x20, 0x04, 0x60, 0x06, 0x40, 0x02, 0x40, 0x02, 0xC0, 0x03, 0x80, 0x01,
  0x80, 0xC0, 0x60, 0x28, 0x0C, 0x05, 0x02, 0x80, 0xA0, 0x50, 0x14, 0x09,
  0x06, 0x81, 0x20, 0x98, 0x44, 0x11, 0x08, 0x82, 0x21, 0x08, 0x44, 0x21,
  0x08, 0x88, 0x22, 0x11, 0x04, 0x43, 0x20, 0x48, 0x24, 0x09, 0x04, 0x81,
  0x20, 0xA0, 0x24, 0x14, 0x03, 0x02, 0x80, 0x60, 0x30, 0x0C, 0x00, 0xC0,
  0x03, 0x60, 0x04, 0x20, 0x0C, 0x10, 0x18, 0x18, 0x10, 0x0C, 0x30, 0x04,
  0x60, 0x02, 0x40, 0x03, 0x80, 0x01, 0x80, 0x03, 0x80, 0x02, 0xC0, 0x04,
  0x60, 0x0C, 0x30, 0x18, 0x10, 0x10, 0x18, 0x20, 0x0C, 0x60, 0x06, 0xC0,
  0x03, 0x80, 0x03, 0xC0, 0x02, 0x40, 0x02, 0x40, 0x04, 0x20, 0x04, 0x20,
  0x0C, 0x30, 0x08, 0x10, 0x08, 0x18, 0x10, 0x08, 0x10, 0x08, 0x30, 0x0C,
  0x20, 0x04, 0x60, 0x06, 0x40, 0x02, 0x40, 0x02, 0xC0, 0x03, 0x80, 0x01,
  0x80, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04,
  0x00, 0x04, 0x00, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x20, 0x01, 0x80, 0x0C,
  0x00, 0x20, 0x01, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x00, 0x08, 0x00, 0x60,
  0x03, 0x00, 0x08, 0x00, 0x40, 0x03, 0x00, 0x18, 0x00, 0x40, 0x02, 0x00,
  0x0F, 0xFF, 0xC0, 0x03, 0xFC, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20,
  0x00, 0xC0, 0x02, 0x00, 0x30, 0x3F, 0x00, 0x07, 0x00, 0x02, 0x00, 0x08,
  0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x18,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00,
  0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0x7F, 0x07, 0x00, 0x30, 0x00, 0x80,
  0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x3F, 0xC0, 0x1E,
  0x00, 0xC8, 0xC0, 0x26, 0x18, 0x09, 0x02, 0x02, 0x40, 0x41, 0x20, 0x08,
  0xC8, 0x01, 0xE0,
};

const GFXglyph IBMPlexMono_ExtraLight36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 3, 25, 22, 9, -25 },
  { 11, 6, 9, 22, 8, -27 },
  { 18, 20, 25, 22, 1, -25 },
  { 81, 17, 33, 22, 2, -29 },
  { 152, 20, 25, 22, 1, -25 },
  { 215, 19, 25, 22, 1, -25 },
  { 275, 1, 9, 22, 10, -27 },
  { 277, 9, 32, 22, 8, -27 },
  { 313, 8, 32, 22, 5, -27 },
  { 345, 18, 18, 22, 2, -20 },
  { 386, 17, 17, 22, 2, -19 },
  { 423, 4, 9, 22, 8, -3 },
  { 428, 10, 1, 22, 6, -11 },
  { 430, 3, 3, 22, 9, -3 },
  { 432, 14, 32, 22, 4, -27 },
  { 488, 17, 25, 22, 2, -25 },
  { 542, 17, 25, 22, 3, -25 },
  { 596, 16, 25, 22, 3, -25 },
  { 646, 16, 25, 22, 2, -25 },
  { 696, 18, 25, 22, 2, -25 },
  { 753, 15, 25, 22, 3, -25 },
  { 800, 16, 25, 22, 3, -25 },
  { 850, 16, 25, 22, 3, -25 },
  { 900, 17, 25, 22, 2, -25 },
  { 954, 16, 25, 22, 3, -25 },
  { 1004, 3, 19, 22, 9, -19 },
  { 1012, 4, 25, 22, 8, -19 },
  { 1025, 16, 20, 22, 3, -21 },
  { 1065, 17, 8, 22, 2, -15 },
  { 1082, 16, 20, 22, 3, -21 },
  { 1122, 15, 25, 22, 3, -25 },
  { 1169, 15, 29, 22, 3, -25 },
  { 1224, 18, 25, 22, 2, -25 },
  { 1281, 16, 25, 22, 3, -25 },
  { 1331, 16, 25, 22, 3, -25 },
  { 1381, 15, 25, 22, 4, -25 },
  { 1428, 15, 25, 22, 4, -25 },
  { 1475, 15, 25, 22, 4, -25 },
  { 1522, 16, 25, 22, 3, -25 },
  { 1572, 15, 25, 22, 3, -25 },
  { 1619, 15, 25, 22, 3, -25 },
  { 1666, 14, 25, 22, 3, -25 },
  { 1710, 16, 25, 22, 4, -25 },
  { 1760, 14, 25, 22, 5, -25 },
  { 1804, 16, 25, 22, 3, -25 },
  { 1854, 15, 25, 22, 3, -25 },
  { 1901, 17, 25, 22, 2, -25 },
  { 1955, 15, 25, 22, 4, -25 },
  { 2002, 17, 30, 22, 2, -25 },
  { 2066, 15, 25, 22, 4, -25 },
  { 2113, 17, 25, 22, 2, -25 },
  { 2167, 19, 25, 22, 1, -25 },
  { 2227, 15, 25, 22, 3, -25 },
  { 2274, 18, 25, 22, 2, -25 },
  { 2331, 18, 25, 22, 2, -25 },
  { 2388, 18, 25, 22, 2, -25 },
  { 2445, 20, 25, 22, 1, -25 },
  { 2508, 18, 25, 22, 2, -25 },
  { 2565, 9, 32, 22, 9, -27 },
  { 2601, 14, 32, 22, 4, -27 },
  { 2657, 9, 32, 22, 3, -27 },
  { 2693, 17, 14, 22, 2, -25 },
  { 2723, 17, 1, 22, 2, 4 },
  { 2726, 5, 6, 22, 7, -27 },
  { 2730, 16, 19, 22, 3, -19 },
  { 2768, 15, 27, 22, 4, -27 },
  { 2819, 14, 19, 22, 4, -19 },
  { 2853, 14, 27, 22, 3, -27 },
  { 2901, 16, 19, 22, 3, -19 },
  { 2939, 16, 27, 22, 3, -27 },
  { 2993, 17, 27, 22, 3, -20 },
  { 3051, 14, 27, 22, 4, -27 },
  { 3099, 15, 27, 22, 4, -27 },
  { 3150, 13, 34, 22, 3, -27 },
  { 3206, 15, 27, 22, 5, -27 },
  { 3257, 15, 27, 22, 3, -27 },
  { 3308, 17, 19, 22, 2, -19 },
  { 3349, 14, 19, 22, 4, -19 },
  { 3383, 16, 19, 22, 3, -19 },
  { 3421, 15, 26, 22, 4, -19 },
  { 3470, 14, 26, 22, 3, -19 },
  { 3516, 17, 19, 22, 3, -19 },
  { 3557, 16, 19, 22, 3, -19 },
  { 3595, 18, 25, 22, 1, -25 },
  { 3652, 13, 19, 22, 4, -19 },
  { 3683, 16, 19, 22, 3, -19 },
  { 3721, 19, 19, 22, 1, -19 },
  { 3767, 16, 19, 22, 3, -19 },
  { 3805, 16, 26, 22, 3, -19 },
  { 3857, 14, 19, 22, 4, -19 },
  { 3891, 14, 32, 22, 4, -27 },
  { 3947, 1, 32, 22, 10, -27 },
  { 3951, 14, 32, 22, 4, -27 },
  { 4007, 18, 7, 22, 2, -14 },
};

const GFXfont IBMPlexMono_ExtraLight36pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLight36pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLight36pt7bGlyphs,
  0x20, 0x7E, 47
};

#endif // _IBMPLEXMONO_EXTRALIGHT36PT7B_H_
