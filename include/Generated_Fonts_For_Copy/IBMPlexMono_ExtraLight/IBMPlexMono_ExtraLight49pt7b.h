#ifndef _IBMPLEXMONO_EXTRALIGHT49PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHT49PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLight.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLight49pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x44, 0x44, 0x44,
  0x44, 0x00, 0x00, 0x00, 0xEF, 0xFE, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x18, 0x00, 0x18, 0x0C,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x60, 0x20, 0x00, 0x0C, 0x04, 0x00, 0x01,
  0x01, 0x80, 0x00, 0x20, 0x30, 0x00, 0x0C, 0x06, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x30, 0x10, 0x00, 0x06, 0x02, 0x00, 0x00, 0x80, 0xC0, 0x1F, 0xF0,
  0x1F, 0xF3, 0xFE, 0x03, 0xFE, 0x00, 0xC0, 0x60, 0x00, 0x18, 0x08, 0x00,
  0x02, 0x01, 0x00, 0x00, 0x40, 0x60, 0x00, 0x18, 0x0C, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x60, 0x20, 0x00, 0x0C, 0x04, 0x01, 0xFF, 0x01, 0xFF, 0xBF,
  0xE0, 0x3F, 0xF0, 0x0C, 0x06, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x30, 0x10,
  0x00, 0x06, 0x02, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x10, 0x18, 0x00, 0x06,
  0x03, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x18, 0x08, 0x00, 0x02, 0x03, 0x00,
  0x00, 0x40, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0xF0,
  0x07, 0x8C, 0x78, 0x18, 0x18, 0x38, 0x60, 0x30, 0x19, 0x80, 0x60, 0x1B,
  0x00, 0xC0, 0x06, 0x01, 0x80, 0x0C, 0x03, 0x00, 0x18, 0x06, 0x00, 0x30,
  0x0C, 0x00, 0x60, 0x18, 0x00, 0xC0, 0x30, 0x00, 0xC0, 0x60, 0x01, 0xC0,
  0xC0, 0x01, 0xE1, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x18, 0xF0, 0x00, 0x30, 0x70, 0x00, 0x60, 0x30, 0x00, 0xC0,
  0x60, 0x01, 0x80, 0x60, 0x03, 0x00, 0xC0, 0x06, 0x01, 0x80, 0x0C, 0x03,
  0x00, 0x18, 0x06, 0x00, 0x30, 0x0D, 0x00, 0x60, 0x1F, 0x00, 0xC0, 0x67,
  0x01, 0x80, 0xC7, 0x03, 0x07, 0x03, 0xC6, 0x3C, 0x03, 0xFF, 0xF0, 0x00,
  0xFF, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x0C,
  0xE0, 0xE0, 0x01, 0x18, 0x0C, 0x00, 0x66, 0x00, 0xC0, 0x18, 0x80, 0x18,
  0x03, 0x10, 0x01, 0x00, 0xC2, 0x00, 0x20, 0x10, 0x40, 0x04, 0x06, 0x08,
  0x00, 0x80, 0x81, 0x00, 0x10, 0x30, 0x20, 0x06, 0x0C, 0x06, 0x00, 0xC1,
  0x00, 0x60, 0x30, 0x60, 0x0E, 0x0E, 0x08, 0x00, 0xFF, 0x83, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x04, 0x0F, 0xF0, 0x01, 0x83, 0x87, 0x00, 0x20, 0xC0, 0x30, 0x0C,
  0x10, 0x06, 0x03, 0x06, 0x00, 0x60, 0x40, 0xC0, 0x0C, 0x18, 0x18, 0x01,
  0x82, 0x03, 0x00, 0x30, 0xC0, 0x60, 0x06, 0x30, 0x0C, 0x00, 0xC6, 0x01,
  0x80, 0x19, 0x80, 0x10, 0x06, 0x20, 0x03, 0x00, 0xCC, 0x00, 0x38, 0x71,
  0x00, 0x03, 0xFC, 0x40, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x01, 0xC0, 0xE0, 0x01, 0xC0, 0x38, 0x00, 0xC0, 0x0C, 0x00, 0x40,
  0x03, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x07, 0xE0, 0x0F, 0xC7, 0x38, 0x07, 0xE6, 0x0E, 0x03, 0x07, 0x03, 0x81,
  0x83, 0x00, 0xC0, 0xC1, 0x00, 0x30, 0x61, 0x80, 0x0C, 0x20, 0xC0, 0x03,
  0x10, 0x60, 0x01, 0xC8, 0x30, 0x00, 0x7C, 0x18, 0x00, 0x1E, 0x0C, 0x00,
  0x06, 0x06, 0x00, 0x03, 0x81, 0x80, 0x03, 0x60, 0xC0, 0x01, 0x18, 0x30,
  0x03, 0x86, 0x1E, 0x07, 0x83, 0x83, 0xFF, 0x80, 0xC0, 0x7F, 0x00, 0x10,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x20, 0x0C, 0x00, 0x80, 0x10, 0x03, 0x00,
  0x60, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x20, 0x06,
  0x00, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x40, 0x04, 0x00, 0x40, 0x06,
  0x00, 0x60, 0x02, 0x00, 0x30, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x03, 0xE0, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x80,
  0x08, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x06, 0x00, 0x20, 0x02, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06, 0x00, 0x40,
  0x0C, 0x00, 0xC0, 0x18, 0x01, 0x00, 0x30, 0x06, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0xF8, 0x06, 0x03, 0xCF,
  0xC3, 0x0F, 0x80, 0xFD, 0xBE, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x66, 0x00, 0x00, 0x63, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x30, 0x30, 0x00, 0x30, 0x08, 0x00, 0x30, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x18, 0x00, 0x60, 0x18, 0x00, 0x30, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x3C, 0xE3, 0x8E, 0x31, 0xC7, 0x18, 0x61, 0x8C,
  0x30, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xEF, 0xFE, 0x00, 0x00, 0x20, 0x00,
  0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00,
  0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03,
  0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18,
  0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0,
  0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x1C,
  0x07, 0x80, 0x70, 0x03, 0x81, 0x80, 0x03, 0x07, 0x00, 0x03, 0x0C, 0x00,
  0x06, 0x18, 0x00, 0x06, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x19, 0x80, 0x00,
  0x13, 0x00, 0x00, 0x34, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xE0, 0x1E,
  0x01, 0xC0, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xA0,
  0x00, 0x03, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x33, 0x00,
  0x00, 0x63, 0x00, 0x00, 0xC6, 0x00, 0x03, 0x0E, 0x00, 0x06, 0x0C, 0x00,
  0x18, 0x0E, 0x00, 0x70, 0x0F, 0x03, 0xC0, 0x0F, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x60, 0x00, 0x1C, 0xC0,
  0x00, 0x71, 0x80, 0x01, 0xC3, 0x00, 0x07, 0x06, 0x00, 0x1C, 0x0C, 0x00,
  0x70, 0x18, 0x01, 0xC0, 0x30, 0x01, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x7F, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFC, 0x01, 0xFC, 0x00, 0x1F, 0xFC, 0x01, 0xE0, 0x3C, 0x0E,
  0x00, 0x30, 0x30, 0x00, 0x61, 0x80, 0x01, 0x86, 0x00, 0x03, 0x30, 0x00,
  0x0C, 0x40, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x3F, 0xFC, 0x03, 0xC0, 0xF0,
  0x38, 0x01, 0xC3, 0x00, 0x07, 0x18, 0x00, 0x19, 0x80, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x03, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0xA0, 0x00, 0x0F, 0x00,
  0x00, 0xCC, 0x00, 0x06, 0x38, 0x00, 0xE0, 0xF0, 0x1E, 0x01, 0xFF, 0xE0,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x26, 0x00, 0x00, 0x33, 0x00, 0x00, 0x31, 0x80, 0x00, 0x10,
  0xC0, 0x00, 0x18, 0x60, 0x00, 0x18, 0x30, 0x00, 0x18, 0x18, 0x00, 0x08,
  0x0C, 0x00, 0x0C, 0x06, 0x00, 0x0C, 0x03, 0x00, 0x04, 0x01, 0x80, 0x06,
  0x00, 0xC0, 0x06, 0x00, 0x60, 0x02, 0x00, 0x30, 0x02, 0x00, 0x18, 0x03,
  0x00, 0x0C, 0x01, 0x00, 0x06, 0x01, 0x00, 0x03, 0x01, 0x80, 0x01, 0x81,
  0x80, 0x00, 0xC0, 0x80, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x8C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x10, 0xFF, 0x00, 0x9F, 0xFE, 0x05, 0xC0, 0x78, 0x78, 0x00, 0xE3, 0x80,
  0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x34, 0x00, 0x03, 0x60, 0x00, 0x19, 0x80, 0x01, 0x87,
  0x00, 0x1C, 0x1E, 0x03, 0xC0, 0x7F, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x83,
  0xF8, 0x0C, 0xFF, 0xF0, 0x6E, 0x03, 0xC6, 0xC0, 0x07, 0x3C, 0x00, 0x1D,
  0xC0, 0x00, 0x6E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x06, 0x80, 0x00, 0x36,
  0x00, 0x01, 0xB0, 0x00, 0x18, 0xC0, 0x01, 0xC3, 0x00, 0x1C, 0x1E, 0x03,
  0xC0, 0x3F, 0xFC, 0x00, 0x7F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x40, 0x00, 0x1A, 0x00, 0x01,
  0x90, 0x00, 0x0C, 0x80, 0x00, 0x44, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x3C, 0x07, 0x80, 0xE0, 0x03, 0x83,
  0x80, 0x01, 0x86, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x30, 0x00, 0x06, 0x60,
  0x00, 0x0C, 0xC0, 0x00, 0x18, 0x80, 0x00, 0x31, 0x80, 0x00, 0x63, 0x00,
  0x01, 0x83, 0x00, 0x03, 0x07, 0x00, 0x1C, 0x03, 0x80, 0xF0, 0x03, 0xFF,
  0x80, 0x07, 0xFF, 0x00, 0x3C, 0x07, 0x80, 0xE0, 0x01, 0x83, 0x00, 0x01,
  0x8C, 0x00, 0x01, 0x98, 0x00, 0x01, 0x20, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x34, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0xD8, 0x00, 0x03, 0x18, 0x00, 0x0E, 0x1C, 0x00, 0x38, 0x1E,
  0x01, 0xE0, 0x1F, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x1F,
  0xFE, 0x00, 0xF0, 0x3C, 0x06, 0x00, 0x38, 0x30, 0x00, 0x71, 0x80, 0x00,
  0xC6, 0x00, 0x01, 0x90, 0x00, 0x06, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x2C,
  0x00, 0x00, 0xB0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x66, 0x00,
  0x01, 0x98, 0x00, 0x0E, 0x30, 0x00, 0x38, 0xE0, 0x03, 0x61, 0xF0, 0x3D,
  0x81, 0xFF, 0xC6, 0x01, 0xFC, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x00, 0xEF, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xEF, 0xFE, 0x38, 0xF3,
  0xCE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF3, 0x8E, 0x38, 0xC7, 0x1C, 0x61, 0x86, 0x30, 0xC3, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x02, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x04, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xF0, 0x1E, 0x07, 0x83, 0x80,
  0x1C, 0x60, 0x00, 0xC6, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x03, 0xE0,
  0x00, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xF8,
  0x03, 0xC0, 0xE0, 0x38, 0x01, 0x81, 0x80, 0x06, 0x18, 0x00, 0x30, 0xC0,
  0x00, 0xC4, 0x00, 0x06, 0x60, 0x00, 0x13, 0x00, 0x00, 0x98, 0x07, 0xC4,
  0x80, 0xFF, 0x24, 0x07, 0x0D, 0xE0, 0x60, 0x1F, 0x02, 0x00, 0xF8, 0x30,
  0x03, 0xC1, 0x80, 0x1E, 0x0C, 0x00, 0xF0, 0x60, 0x07, 0x83, 0x00, 0x3C,
  0x18, 0x01, 0xE0, 0xC0, 0x0F, 0x06, 0x00, 0x78, 0x30, 0x03, 0xC1, 0x80,
  0x1E, 0x0C, 0x00, 0xF0, 0x30, 0x0E, 0x81, 0xC0, 0xB4, 0x07, 0xFD, 0xA0,
  0x1F, 0xCD, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F,
  0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x05,
  0x80, 0x00, 0x06, 0xC0, 0x00, 0x03, 0x20, 0x00, 0x01, 0x18, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x41, 0x80, 0x00, 0x60, 0xC0, 0x00,
  0x30, 0x20, 0x00, 0x10, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x0C, 0x02, 0x00,
  0x04, 0x01, 0x80, 0x06, 0x00, 0xC0, 0x03, 0x00, 0x20, 0x01, 0x00, 0x18,
  0x01, 0x80, 0x0C, 0x00, 0xC0, 0x02, 0x00, 0x40, 0x01, 0x80, 0x7F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xE0, 0x18, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x0C, 0x00,
  0x06, 0x06, 0x00, 0x01, 0x86, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x61, 0x80,
  0x00, 0x19, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x06, 0x60, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xC0, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x20, 0x00, 0xE1, 0x00,
  0x03, 0x88, 0x00, 0x0C, 0x40, 0x00, 0x32, 0x00, 0x01, 0x90, 0x00, 0x0C,
  0x80, 0x00, 0x64, 0x00, 0x03, 0x20, 0x00, 0x19, 0x00, 0x00, 0xC8, 0x00,
  0x06, 0x40, 0x00, 0x62, 0x00, 0x06, 0x10, 0x00, 0x60, 0xFF, 0xFE, 0x07,
  0xFF, 0xFC, 0x20, 0x00, 0x71, 0x00, 0x00, 0xC8, 0x00, 0x03, 0x40, 0x00,
  0x1A, 0x00, 0x00, 0xD0, 0x00, 0x02, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x05, 0x00, 0x00, 0x68, 0x00, 0x03, 0x40, 0x00, 0x1A, 0x00, 0x01,
  0x90, 0x00, 0x38, 0xFF, 0xFF, 0x87, 0xFF, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x0F, 0xFE, 0x00, 0x70, 0x1C, 0x03, 0x00, 0x18, 0x18, 0x00, 0x30, 0xC0,
  0x00, 0x63, 0x00, 0x01, 0x98, 0x00, 0x03, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x63, 0x00, 0x01, 0x86, 0x00,
  0x0C, 0x0C, 0x00, 0x60, 0x1E, 0x07, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0x80,
  0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x30, 0x01, 0xE1, 0x80, 0x03, 0x8C, 0x00,
  0x0C, 0x60, 0x00, 0x33, 0x00, 0x01, 0x98, 0x00, 0x06, 0xC0, 0x00, 0x36,
  0x00, 0x01, 0xB0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x36, 0x00, 0x01, 0xB0, 0x00, 0x0D, 0x80,
  0x00, 0xCC, 0x00, 0x06, 0x60, 0x00, 0x63, 0x00, 0x07, 0x18, 0x00, 0xF0,
  0xFF, 0xFE, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x00, 0x78, 0x1E, 0x03, 0x80, 0x1C,
  0x1C, 0x00, 0x30, 0x60, 0x00, 0x63, 0x00, 0x00, 0x8C, 0x00, 0x03, 0x20,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x03, 0xFF, 0xC0, 0x0F, 0xFD, 0x00,
  0x00, 0x14, 0x00, 0x00, 0x58, 0x00, 0x01, 0x60, 0x00, 0x05, 0x80, 0x00,
  0x36, 0x00, 0x00, 0xD8, 0x00, 0x03, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x31,
  0x80, 0x01, 0x47, 0x00, 0x0D, 0x0E, 0x00, 0x64, 0x1E, 0x07, 0x10, 0x3F,
  0xF8, 0x40, 0x3F, 0x80, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xE1, 0xFF, 0xFC, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x3C, 0x00, 0x0C, 0xC0, 0x01, 0x9C, 0x00,
  0x71, 0xC0, 0x1C, 0x1C, 0x07, 0x01, 0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0xEC, 0x00, 0x03, 0x30, 0x00, 0x18, 0xC0, 0x00,
  0xC3, 0x00, 0x06, 0x0C, 0x00, 0x30, 0x30, 0x01, 0x80, 0xC0, 0x0C, 0x03,
  0x00, 0x70, 0x0C, 0x03, 0x80, 0x30, 0x0C, 0x00, 0xC0, 0x60, 0x03, 0x03,
  0x00, 0x0C, 0x18, 0x00, 0x30, 0xF0, 0x00, 0xC6, 0x60, 0x03, 0x31, 0x80,
  0x0D, 0x83, 0x00, 0x3E, 0x06, 0x00, 0xF0, 0x18, 0x03, 0x80, 0x30, 0x0C,
  0x00, 0xE0, 0x30, 0x01, 0x80, 0xC0, 0x03, 0x03, 0x00, 0x0E, 0x0C, 0x00,
  0x18, 0x30, 0x00, 0x30, 0xC0, 0x00, 0xE3, 0x00, 0x01, 0x8C, 0x00, 0x03,
  0x30, 0x00, 0x0E, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xFC,
  0x00, 0x0B, 0xE0, 0x00, 0xDD, 0x00, 0x04, 0xEC, 0x00, 0x27, 0x20, 0x03,
  0x39, 0x80, 0x11, 0xC4, 0x01, 0x8E, 0x30, 0x08, 0x71, 0x80, 0xC3, 0x86,
  0x04, 0x1C, 0x30, 0x60, 0xE0, 0xC2, 0x07, 0x06, 0x30, 0x38, 0x19, 0x81,
  0xC0, 0xC8, 0x0E, 0x02, 0xC0, 0x70, 0x1C, 0x03, 0x80, 0x60, 0x1C, 0x02,
  0x00, 0xE0, 0x10, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x40,
  0xC0, 0x00, 0x3E, 0x00, 0x03, 0xA0, 0x00, 0x3B, 0x00, 0x03, 0x90, 0x00,
  0x39, 0x80, 0x03, 0x88, 0x00, 0x38, 0xC0, 0x03, 0x84, 0x00, 0x38, 0x60,
  0x03, 0x82, 0x00, 0x38, 0x30, 0x03, 0x81, 0x00, 0x38, 0x18, 0x03, 0x80,
  0x80, 0x38, 0x0C, 0x03, 0x80, 0x40, 0x38, 0x06, 0x03, 0x80, 0x60, 0x38,
  0x03, 0x03, 0x80, 0x30, 0x38, 0x01, 0x83, 0x80, 0x18, 0x38, 0x00, 0xC3,
  0x80, 0x0C, 0x38, 0x00, 0x63, 0x80, 0x06, 0x38, 0x00, 0x33, 0x80, 0x03,
  0x38, 0x00, 0x1B, 0x80, 0x01, 0xB8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x07, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x1C, 0x07, 0x80, 0x70, 0x03,
  0x81, 0x80, 0x03, 0x07, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x06,
  0x60, 0x00, 0x0C, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x13, 0x00, 0x00, 0x34,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xA0, 0x00, 0x03, 0x60, 0x00,
  0x06, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x33, 0x00, 0x00, 0x63, 0x00, 0x00,
  0xC6, 0x00, 0x03, 0x0E, 0x00, 0x06, 0x0C, 0x00, 0x18, 0x0E, 0x00, 0x70,
  0x0F, 0x03, 0xC0, 0x0F, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0xFE, 0x07,
  0xFF, 0xFE, 0x30, 0x00, 0x79, 0x80, 0x00, 0xCC, 0x00, 0x03, 0x60, 0x00,
  0x1B, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1B, 0x00, 0x00,
  0xD8, 0x00, 0x0C, 0xC0, 0x01, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF, 0x81, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x1C, 0x07, 0x80,
  0x70, 0x03, 0x81, 0x80, 0x03, 0x07, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x18,
  0x00, 0x06, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x13, 0x00,
  0x00, 0x34, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xA0, 0x00, 0x03,
  0x60, 0x00, 0x06, 0xC0, 0x00, 0x09, 0x80, 0x00, 0x33, 0x00, 0x00, 0x63,
  0x00, 0x00, 0xC6, 0x00, 0x03, 0x0E, 0x00, 0x06, 0x0C, 0x00, 0x18, 0x0E,
  0x00, 0x70, 0x0F, 0x03, 0xC0, 0x0F, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xFE,
  0x30, 0x00, 0x79, 0x80, 0x00, 0xCC, 0x00, 0x03, 0x60, 0x00, 0x1B, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1B, 0x00, 0x00, 0xD8, 0x00,
  0x0C, 0xC0, 0x01, 0xE7, 0xFF, 0xFC, 0x3F, 0xFF, 0x81, 0x80, 0xC0, 0x0C,
  0x03, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x18, 0x01, 0x80, 0xC0, 0x06,
  0x06, 0x00, 0x30, 0x30, 0x00, 0xC1, 0x80, 0x03, 0x0C, 0x00, 0x18, 0x60,
  0x00, 0x63, 0x00, 0x01, 0x98, 0x00, 0x0C, 0xC0, 0x00, 0x36, 0x00, 0x01,
  0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x7C, 0x03, 0xC0, 0xC0, 0x01,
  0xC3, 0x00, 0x01, 0xCC, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF8, 0x00, 0x03, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x38,
  0x1E, 0x01, 0xE0, 0x1F, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x2C, 0x00, 0x06, 0xC0, 0x00,
  0x66, 0x00, 0x06, 0x60, 0x00, 0xC7, 0x00, 0x1C, 0x3C, 0x07, 0x81, 0xFF,
  0xF0, 0x03, 0xFC, 0x00, 0xE0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x98, 0x00,
  0x00, 0xC6, 0x00, 0x00, 0x63, 0x00, 0x00, 0x31, 0x80, 0x00, 0x30, 0x40,
  0x00, 0x18, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x04, 0x00, 0x06, 0x03,
  0x00, 0x03, 0x01, 0x80, 0x03, 0x00, 0xC0, 0x01, 0x80, 0x30, 0x00, 0xC0,
  0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x30,
  0x00, 0xC0, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x0C, 0x00, 0x0C, 0x06,
  0x00, 0x03, 0x03, 0x00, 0x01, 0x81, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x30,
  0xC0, 0x00, 0x18, 0x40, 0x00, 0x0C, 0x60, 0x00, 0x03, 0x30, 0x00, 0x01,
  0x90, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x02, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x02,
  0xC0, 0x00, 0x02, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0x40, 0x18, 0x06,
  0x40, 0x38, 0x06, 0x40, 0x38, 0x06, 0x40, 0x2C, 0x06, 0x60, 0x6C, 0x04,
  0x60, 0x64, 0x04, 0x60, 0x46, 0x04, 0x60, 0x46, 0x04, 0x60, 0xC2, 0x04,
  0x60, 0xC2, 0x0C, 0x60, 0x83, 0x0C, 0x21, 0x83, 0x0C, 0x21, 0x81, 0x0C,
  0x21, 0x81, 0x8C, 0x21, 0x01, 0x8C, 0x33, 0x01, 0x88, 0x33, 0x00, 0x88,
  0x32, 0x00, 0xC8, 0x36, 0x00, 0xC8, 0x36, 0x00, 0x58, 0x36, 0x00, 0x78,
  0x14, 0x00, 0x78, 0x1C, 0x00, 0x78, 0x1C, 0x00, 0x38, 0x60, 0x00, 0x01,
  0x98, 0x00, 0x01, 0x8C, 0x00, 0x01, 0x83, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0xC0, 0x60, 0x00, 0xC0, 0x18, 0x00, 0x60, 0x06, 0x00, 0x60, 0x03, 0x00,
  0x60, 0x00, 0xC0, 0x30, 0x00, 0x30, 0x30, 0x00, 0x18, 0x30, 0x00, 0x06,
  0x18, 0x00, 0x01, 0x98, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x06, 0x60, 0x00,
  0x06, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x03, 0x01, 0x80,
  0x03, 0x00, 0x60, 0x01, 0x80, 0x18, 0x01, 0x80, 0x0C, 0x01, 0x80, 0x03,
  0x00, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x18, 0x60, 0x00,
  0x06, 0x60, 0x00, 0x03, 0x70, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x18, 0xC0, 0x00, 0x03, 0x1C, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x30, 0x18, 0x00, 0x06, 0x03, 0x00, 0x01, 0x80, 0x30, 0x00, 0x60, 0x03,
  0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x06, 0x00, 0x60, 0x00, 0x60, 0x18,
  0x00, 0x0C, 0x06, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0x19, 0x80, 0x00, 0x03, 0x60, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x08, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x40,
  0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x20,
  0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x10,
  0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x08,
  0x00, 0x01, 0x80, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x38, 0x00, 0x00, 0x78, 0x00, 0x01, 0xB0, 0x00, 0x03, 0x30, 0x00, 0x0C,
  0x60, 0x00, 0x10, 0x60, 0x00, 0x60, 0x40, 0x01, 0x80, 0xC0, 0x03, 0x00,
  0xC0, 0x0C, 0x01, 0x80, 0x10, 0x01, 0x80, 0x60, 0x01, 0x01, 0x80, 0x03,
  0x03, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x10, 0x00, 0x06, 0x60, 0x00, 0x05,
  0x80, 0x00, 0x0D, 0x00, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xC3, 0x86, 0x0C, 0x18, 0x60, 0xC1, 0x03, 0xF8, 0x00, 0x3F, 0xF8, 0x03,
  0xC0, 0x70, 0x1C, 0x00, 0xE0, 0x60, 0x01, 0xC1, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x10, 0x07, 0xFF, 0xC0, 0x7F, 0xFF, 0x07, 0x80, 0x04, 0x18,
  0x00, 0x10, 0xC0, 0x00, 0x43, 0x00, 0x01, 0x0C, 0x00, 0x04, 0x30, 0x00,
  0x30, 0xC0, 0x00, 0xC3, 0x00, 0x03, 0x0C, 0x00, 0x14, 0x18, 0x00, 0xD0,
  0x78, 0x0E, 0x7C, 0xFF, 0xF1, 0xF0, 0x7F, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC3, 0xF8,
  0x0C, 0xFF, 0xE0, 0xDC, 0x0F, 0x0F, 0x00, 0x38, 0xE0, 0x01, 0xCC, 0x00,
  0x0C, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x02, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x02, 0xC0, 0x00, 0x6C, 0x00, 0x06,
  0xC0, 0x00, 0x6C, 0x00, 0x0C, 0xE0, 0x01, 0xCF, 0x00, 0x38, 0xDC, 0x0F,
  0x0C, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x0F,
  0x03, 0x81, 0xC0, 0x0C, 0x30, 0x00, 0x63, 0x00, 0x06, 0x60, 0x00, 0x46,
  0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x23, 0x00,
  0x03, 0x30, 0x00, 0x61, 0xC0, 0x0C, 0x0F, 0x03, 0x80, 0x7F, 0xF0, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x01, 0xF8, 0x30, 0xFF, 0xE3, 0x1E, 0x07, 0x33, 0x80,
  0x1B, 0x30, 0x00, 0xF6, 0x00, 0x07, 0x60, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0x60, 0x00, 0x36, 0x00, 0x07, 0x30, 0x00,
  0xF3, 0x80, 0x1B, 0x1E, 0x07, 0x30, 0xFF, 0xE3, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xC0, 0xF0, 0x38, 0x01, 0x83, 0x80, 0x06,
  0x18, 0x00, 0x19, 0x80, 0x00, 0xCC, 0x00, 0x02, 0x40, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x01, 0x18, 0x00, 0x0C, 0xE0, 0x00, 0xC3,
  0x80, 0x0C, 0x0F, 0x03, 0xC0, 0x3F, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x80, 0x00, 0x02, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x0F, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFE, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x03, 0xF2, 0x00, 0x3F, 0xFC,
  0x00, 0xF0, 0x38, 0x03, 0x80, 0x18, 0x06, 0x00, 0x18, 0x18, 0x00, 0x30,
  0x30, 0x00, 0x20, 0x60, 0x00, 0x60, 0xC0, 0x00, 0xC1, 0x80, 0x01, 0x83,
  0x00, 0x03, 0x02, 0x00, 0x0C, 0x06, 0x00, 0x18, 0x06, 0x00, 0x60, 0x0F,
  0x03, 0x80, 0x07, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x60, 0x00, 0x01, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF0, 0x20, 0x00, 0xF1, 0x80, 0x00, 0x66, 0x00, 0x00,
  0x68, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x19, 0xC0, 0x00, 0x71, 0xE0, 0x07, 0xC1, 0xFF, 0xFE, 0x00,
  0x7F, 0xE0, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x3F, 0x83, 0x3F, 0xF8, 0xDC, 0x0F, 0x3C, 0x00, 0xEE, 0x00,
  0x1B, 0x00, 0x06, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xEF, 0xFF, 0xF0, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x6F, 0xFF, 0xF7, 0xFF, 0xF0, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0xE3, 0x00, 0x06, 0x0C, 0x00,
  0x30, 0x30, 0x01, 0x80, 0xC0, 0x0C, 0x03, 0x00, 0x60, 0x0C, 0x07, 0x00,
  0x30, 0x38, 0x00, 0xC1, 0x80, 0x03, 0x0F, 0x00, 0x0C, 0x6E, 0x00, 0x33,
  0x18, 0x00, 0xD8, 0x30, 0x03, 0xC0, 0x60, 0x0C, 0x00, 0xC0, 0x30, 0x01,
  0x80, 0xC0, 0x06, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x30,
  0xC0, 0x00, 0x63, 0x00, 0x01, 0xCC, 0x00, 0x03, 0x30, 0x00, 0x07, 0xFF,
  0xF0, 0x07, 0xFF, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x81,
  0xF1, 0x9F, 0xC7, 0xFB, 0x61, 0x98, 0x77, 0x01, 0xA0, 0x3E, 0x01, 0x80,
  0x78, 0x03, 0x00, 0xF0, 0x06, 0x01, 0xE0, 0x0C, 0x03, 0xC0, 0x18, 0x07,
  0x80, 0x30, 0x0F, 0x00, 0x60, 0x1E, 0x00, 0xC0, 0x3C, 0x01, 0x80, 0x78,
  0x03, 0x00, 0xF0, 0x06, 0x01, 0xE0, 0x0C, 0x03, 0xC0, 0x18, 0x07, 0x80,
  0x30, 0x0F, 0x00, 0x60, 0x1E, 0x00, 0xC0, 0x3C, 0x01, 0x80, 0x78, 0x03,
  0x00, 0xF0, 0x06, 0x01, 0xE0, 0x0C, 0x03, 0xC0, 0x18, 0x07, 0x80, 0x30,
  0x0C, 0x03, 0xF8, 0x33, 0xFF, 0x8D, 0xC0, 0xF3, 0xC0, 0x0E, 0xE0, 0x01,
  0xB0, 0x00, 0x6C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x30,
  0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xC0, 0xF0, 0x38, 0x01, 0xC3, 0x00,
  0x06, 0x18, 0x00, 0x19, 0x80, 0x00, 0xCC, 0x00, 0x03, 0x40, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xD0,
  0x00, 0x06, 0xC0, 0x00, 0x36, 0x00, 0x03, 0x18, 0x00, 0x18, 0xC0, 0x01,
  0x83, 0x80, 0x1C, 0x0F, 0x03, 0xC0, 0x3F, 0xF8, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x0C, 0xFF, 0xE0, 0xDC, 0x0F, 0x0F, 0x00, 0x38, 0xE0, 0x01, 0xCC,
  0x00, 0x0C, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x02,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x02, 0xC0, 0x00, 0x6C, 0x00,
  0x06, 0xC0, 0x00, 0x6C, 0x00, 0x0C, 0xE0, 0x01, 0xCF, 0x00, 0x38, 0xDC,
  0x0F, 0x0C, 0xFF, 0xE0, 0xC3, 0xF8, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xE3, 0x1E, 0x07,
  0x33, 0x80, 0x1B, 0x30, 0x00, 0xF6, 0x00, 0x07, 0x60, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x60, 0x00, 0x36, 0x00, 0x07,
  0x30, 0x00, 0xF3, 0x80, 0x1B, 0x1E, 0x07, 0x30, 0xFF, 0xE3, 0x03, 0xF8,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0xFF,
  0xC1, 0xFF, 0xFF, 0x8F, 0xFC, 0x03, 0x38, 0x00, 0x06, 0xC0, 0x00, 0x0D,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0x01,
  0xFE, 0x00, 0x7F, 0xFC, 0x07, 0x80, 0xF8, 0x70, 0x00, 0xE3, 0x00, 0x03,
  0x90, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0xE0, 0x00, 0x0D, 0x80, 0x00, 0x67,
  0x00, 0x06, 0x1E, 0x01, 0xE0, 0x3F, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0D, 0x00,
  0x01, 0xB0, 0x00, 0x36, 0x00, 0x0E, 0xE0, 0x02, 0xCC, 0x00, 0xD8, 0xE0,
  0x73, 0x0F, 0xFC, 0x60, 0x7E, 0x00, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0xD8,
  0x00, 0x04, 0x40, 0x00, 0x63, 0x00, 0x03, 0x18, 0x00, 0x30, 0x40, 0x01,
  0x83, 0x00, 0x08, 0x18, 0x00, 0xC0, 0x60, 0x06, 0x03, 0x00, 0x20, 0x08,
  0x03, 0x00, 0x60, 0x18, 0x03, 0x01, 0x80, 0x08, 0x0C, 0x00, 0x60, 0x40,
  0x03, 0x06, 0x00, 0x08, 0x30, 0x00, 0x61, 0x00, 0x01, 0x18, 0x00, 0x0C,
  0x80, 0x00, 0x6C, 0x00, 0x01, 0x60, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x80, 0x1C, 0x00, 0xF0, 0x07, 0x00, 0x2C, 0x01, 0x40, 0x0B, 0x00, 0x58,
  0x06, 0x40, 0x32, 0x01, 0x90, 0x0C, 0x80, 0x66, 0x02, 0x20, 0x11, 0x80,
  0x8C, 0x04, 0x60, 0x61, 0x01, 0x18, 0x18, 0x40, 0xC2, 0x04, 0x18, 0x30,
  0x81, 0x06, 0x0C, 0x30, 0xC0, 0x82, 0x0C, 0x30, 0x20, 0x83, 0x08, 0x0C,
  0x60, 0x42, 0x03, 0x18, 0x11, 0x80, 0x46, 0x06, 0x60, 0x11, 0x01, 0x90,
  0x06, 0x40, 0x64, 0x01, 0x90, 0x0B, 0x00, 0x2C, 0x02, 0xC0, 0x0B, 0x00,
  0xA0, 0x03, 0xC0, 0x38, 0x00, 0xE0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x00,
  0x1B, 0x00, 0x01, 0x8C, 0x00, 0x18, 0x30, 0x00, 0xC0, 0xC0, 0x0C, 0x06,
  0x00, 0xC0, 0x18, 0x0C, 0x00, 0x60, 0x40, 0x01, 0x86, 0x00, 0x0C, 0x60,
  0x00, 0x36, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x3C, 0x00, 0x03,
  0x60, 0x00, 0x31, 0x80, 0x03, 0x06, 0x00, 0x18, 0x18, 0x01, 0x80, 0xC0,
  0x18, 0x03, 0x01, 0x80, 0x0C, 0x0C, 0x00, 0x30, 0xC0, 0x01, 0x8C, 0x00,
  0x06, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x66, 0x00, 0x01,
  0x98, 0x00, 0x0C, 0x20, 0x00, 0x30, 0xC0, 0x00, 0x83, 0x00, 0x06, 0x06,
  0x00, 0x18, 0x18, 0x00, 0xC0, 0x20, 0x03, 0x00, 0xC0, 0x08, 0x03, 0x00,
  0x60, 0x06, 0x01, 0x80, 0x18, 0x0C, 0x00, 0x20, 0x30, 0x00, 0xC0, 0x80,
  0x01, 0x06, 0x00, 0x06, 0x10, 0x00, 0x18, 0xC0, 0x00, 0x33, 0x00, 0x00,
  0xD8, 0x00, 0x01, 0x60, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x7F,
  0xF0, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x01, 0xE0, 0x3F, 0xE0, 0x0F, 0xF8, 0x00,
  0x07, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x60,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0xF0, 0x07, 0xFC, 0x07, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0x0F, 0x00, 0x03, 0x1F,
  0xC0, 0x02, 0x38, 0xE0, 0x02, 0x20, 0x70, 0x06, 0x60, 0x30, 0x06, 0x40,
  0x18, 0x04, 0xC0, 0x0C, 0x0C, 0xC0, 0x07, 0x18, 0x80, 0x03, 0xF0, 0x80,
  0x01, 0xE0,
};

const GFXglyph IBMPlexMono_ExtraLight49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 29, 0, -1 },
  { 1, 4, 34, 29, 13, -34 },
  { 18, 9, 13, 29, 10, -36 },
  { 33, 27, 34, 29, 1, -34 },
  { 148, 23, 46, 29, 3, -40 },
  { 281, 27, 36, 29, 1, -35 },
  { 403, 25, 36, 29, 2, -35 },
  { 516, 2, 13, 29, 14, -36 },
  { 520, 12, 44, 29, 11, -37 },
  { 586, 12, 44, 29, 6, -37 },
  { 652, 25, 24, 29, 2, -27 },
  { 727, 23, 24, 29, 3, -27 },
  { 796, 6, 13, 29, 11, -5 },
  { 806, 13, 2, 29, 8, -16 },
  { 810, 4, 4, 29, 13, -4 },
  { 812, 19, 44, 29, 5, -37 },
  { 917, 23, 36, 29, 3, -35 },
  { 1021, 23, 34, 29, 4, -34 },
  { 1119, 22, 35, 29, 4, -35 },
  { 1216, 21, 36, 29, 3, -35 },
  { 1311, 25, 34, 29, 2, -34 },
  { 1418, 21, 35, 29, 4, -34 },
  { 1510, 21, 35, 29, 4, -34 },
  { 1602, 21, 34, 29, 4, -34 },
  { 1692, 23, 36, 29, 3, -35 },
  { 1796, 22, 35, 29, 4, -35 },
  { 1893, 4, 26, 29, 13, -26 },
  { 1906, 6, 34, 29, 11, -26 },
  { 1932, 21, 27, 29, 4, -28 },
  { 2003, 23, 10, 29, 3, -20 },
  { 2032, 21, 27, 29, 4, -28 },
  { 2103, 20, 35, 29, 5, -35 },
  { 2191, 21, 40, 29, 4, -35 },
  { 2296, 25, 34, 29, 2, -34 },
  { 2403, 21, 34, 29, 5, -34 },
  { 2493, 22, 36, 29, 4, -35 },
  { 2592, 21, 34, 29, 5, -34 },
  { 2682, 20, 34, 29, 5, -34 },
  { 2767, 21, 34, 29, 5, -34 },
  { 2857, 22, 36, 29, 3, -35 },
  { 2956, 20, 34, 29, 5, -34 },
  { 3041, 21, 34, 29, 4, -34 },
  { 3131, 19, 35, 29, 4, -34 },
  { 3215, 22, 34, 29, 5, -34 },
  { 3309, 19, 34, 29, 7, -34 },
  { 3390, 21, 34, 29, 4, -34 },
  { 3480, 20, 34, 29, 5, -34 },
  { 3565, 23, 36, 29, 3, -35 },
  { 3669, 21, 34, 29, 5, -34 },
  { 3759, 23, 43, 29, 3, -35 },
  { 3883, 21, 34, 29, 5, -34 },
  { 3973, 23, 36, 29, 3, -35 },
  { 4077, 26, 34, 29, 2, -34 },
  { 4188, 20, 35, 29, 5, -34 },
  { 4276, 25, 34, 29, 2, -34 },
  { 4383, 24, 34, 29, 3, -34 },
  { 4485, 25, 34, 29, 2, -34 },
  { 4592, 27, 34, 29, 1, -34 },
  { 4707, 25, 34, 29, 2, -34 },
  { 4814, 12, 44, 29, 13, -37 },
  { 4880, 19, 44, 29, 5, -37 },
  { 4985, 12, 44, 29, 5, -37 },
  { 5051, 23, 19, 29, 3, -34 },
  { 5106, 23, 2, 29, 3, 5 },
  { 5112, 6, 8, 29, 10, -37 },
  { 5118, 22, 27, 29, 4, -26 },
  { 5193, 20, 37, 29, 6, -36 },
  { 5286, 20, 27, 29, 5, -26 },
  { 5354, 20, 37, 29, 4, -36 },
  { 5447, 21, 27, 29, 4, -26 },
  { 5518, 22, 36, 29, 4, -36 },
  { 5617, 23, 38, 29, 4, -28 },
  { 5727, 18, 36, 29, 6, -36 },
  { 5808, 20, 36, 29, 6, -36 },
  { 5898, 17, 46, 29, 5, -36 },
  { 5996, 22, 36, 29, 6, -36 },
  { 6095, 21, 36, 29, 4, -36 },
  { 6190, 23, 26, 29, 3, -26 },
  { 6265, 18, 26, 29, 6, -26 },
  { 6324, 21, 27, 29, 4, -26 },
  { 6395, 20, 36, 29, 6, -26 },
  { 6485, 20, 36, 29, 4, -26 },
  { 6575, 23, 25, 29, 4, -25 },
  { 6647, 21, 27, 29, 4, -26 },
  { 6718, 24, 34, 29, 2, -34 },
  { 6820, 19, 26, 29, 5, -25 },
  { 6882, 21, 25, 29, 4, -25 },
  { 6948, 26, 25, 29, 2, -25 },
  { 7030, 21, 25, 29, 4, -25 },
  { 7096, 22, 35, 29, 4, -25 },
  { 7193, 20, 25, 29, 5, -25 },
  { 7256, 18, 44, 29, 6, -37 },
  { 7355, 1, 44, 29, 14, -37 },
  { 7361, 18, 44, 29, 6, -37 },
  { 7460, 24, 10, 29, 3, -20 },
};

const GFXfont IBMPlexMono_ExtraLight49pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLight49pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLight49pt7bGlyphs,
  0x20, 0x7E, 64
};

#endif // _IBMPLEXMONO_EXTRALIGHT49PT7B_H_
