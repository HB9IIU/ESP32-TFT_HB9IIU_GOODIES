#ifndef _IBMPLEXMONO_EXTRALIGHT67PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHT67PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLight.ttf
// Size: 67pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLight67pt7bBitmaps[] PROGMEM = {
  0x00, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x10, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xBF, 0xFF, 0xF7,
  0x80, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x30, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0x18, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x06,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x03, 0x00, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFC,
  0x7F, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0x60, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x18, 0x00, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00,
  0x00, 0xC0, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x60, 0x00, 0x00, 0x18, 0x01, 0x80, 0x03, 0xFF, 0xE0, 0x07,
  0xFF, 0xCF, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00,
  0x38, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x0E, 0x00,
  0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x03,
  0xE0, 0xC7, 0xE0, 0x07, 0x80, 0xC0, 0xF0, 0x0E, 0x00, 0xC0, 0x38, 0x1C,
  0x00, 0xC0, 0x1C, 0x38, 0x00, 0xC0, 0x0E, 0x38, 0x00, 0xC0, 0x04, 0x30,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x70, 0x00, 0xC0, 0x00, 0x70,
  0x00, 0xC0, 0x00, 0x70, 0x00, 0xC0, 0x00, 0x70, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x38, 0x00, 0xC0, 0x00, 0x38,
  0x00, 0xC0, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x0F,
  0x00, 0xC0, 0x00, 0x03, 0xC0, 0xC0, 0x00, 0x01, 0xFC, 0xC0, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xDF, 0xC0, 0x00,
  0x00, 0xC1, 0xF0, 0x00, 0x00, 0xC0, 0x78, 0x00, 0x00, 0xC0, 0x3C, 0x00,
  0x00, 0xC0, 0x1C, 0x00, 0x00, 0xC0, 0x0E, 0x00, 0x00, 0xC0, 0x0E, 0x00,
  0x00, 0xC0, 0x06, 0x00, 0x00, 0xC0, 0x07, 0x00, 0x00, 0xC0, 0x07, 0x00,
  0x00, 0xC0, 0x07, 0x00, 0x00, 0xC0, 0x07, 0x00, 0x00, 0xC0, 0x07, 0x00,
  0x00, 0xC0, 0x07, 0x00, 0x00, 0xC0, 0x06, 0x40, 0x00, 0xC0, 0x06, 0xE0,
  0x00, 0xC0, 0x0E, 0x70, 0x00, 0xC0, 0x0C, 0x38, 0x00, 0xC0, 0x1C, 0x1E,
  0x00, 0xC0, 0x38, 0x0F, 0x80, 0xC0, 0xF0, 0x03, 0xF0, 0xC7, 0xE0, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0x1E, 0x0F, 0x00, 0x00,
  0x73, 0x80, 0x38, 0x00, 0x06, 0x30, 0x01, 0x80, 0x00, 0xC6, 0x00, 0x0C,
  0x00, 0x0C, 0x60, 0x00, 0xC0, 0x01, 0x8E, 0x00, 0x0E, 0x00, 0x38, 0xC0,
  0x00, 0x60, 0x03, 0x0C, 0x00, 0x06, 0x00, 0x70, 0xC0, 0x00, 0x60, 0x06,
  0x0C, 0x00, 0x06, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0x0C, 0x0C, 0x00, 0x06,
  0x01, 0x80, 0xC0, 0x00, 0x60, 0x38, 0x0E, 0x00, 0x0E, 0x03, 0x00, 0x60,
  0x00, 0xC0, 0x60, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x30, 0x01, 0x80, 0xC0,
  0x03, 0x80, 0x38, 0x0C, 0x00, 0x1E, 0x0F, 0x01, 0x80, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1C, 0x0F, 0x07, 0x80, 0x03, 0x81,
  0xC0, 0x1C, 0x00, 0x30, 0x18, 0x00, 0xE0, 0x07, 0x03, 0x80, 0x06, 0x00,
  0x60, 0x30, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x03, 0x00, 0xC0, 0x70, 0x00,
  0x30, 0x18, 0x06, 0x00, 0x03, 0x03, 0x80, 0x60, 0x00, 0x30, 0x30, 0x06,
  0x00, 0x03, 0x06, 0x00, 0x60, 0x00, 0x30, 0x60, 0x07, 0x00, 0x03, 0x0C,
  0x00, 0x70, 0x00, 0x30, 0xC0, 0x03, 0x00, 0x03, 0x18, 0x00, 0x30, 0x00,
  0x63, 0x80, 0x03, 0x80, 0x06, 0x30, 0x00, 0x18, 0x00, 0xE6, 0x00, 0x01,
  0xC0, 0x1C, 0x60, 0x00, 0x0F, 0x07, 0x8C, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x38, 0x00, 0x03, 0x80, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x08, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0x1C,
  0x00, 0x3F, 0xC3, 0x83, 0x00, 0x0F, 0xF1, 0xC0, 0x60, 0x03, 0x00, 0xE0,
  0x1C, 0x00, 0xC0, 0x70, 0x03, 0x80, 0x30, 0x18, 0x00, 0x70, 0x0C, 0x06,
  0x00, 0x0E, 0x03, 0x03, 0x80, 0x01, 0x80, 0xC0, 0xC0, 0x00, 0x30, 0x30,
  0x30, 0x00, 0x0E, 0x1C, 0x0C, 0x00, 0x01, 0xC6, 0x03, 0x00, 0x00, 0x39,
  0x80, 0xC0, 0x00, 0x07, 0x60, 0x30, 0x00, 0x00, 0xF8, 0x0C, 0x00, 0x00,
  0x1C, 0x03, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x38, 0x00,
  0x00, 0x5C, 0x07, 0x00, 0x00, 0x33, 0x81, 0xC0, 0x00, 0x18, 0x70, 0x38,
  0x00, 0x0C, 0x0E, 0x07, 0x80, 0x0E, 0x01, 0xC0, 0xF8, 0x0F, 0x00, 0x38,
  0x0F, 0xFF, 0x80, 0x06, 0x00, 0xFF, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xE0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80,
  0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x03, 0x00,
  0x02, 0xF0, 0x00, 0xC0, 0x03, 0xFF, 0x80, 0x30, 0x07, 0xF1, 0xFC, 0x0C,
  0x0F, 0xE0, 0x0F, 0xF3, 0x1F, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0x30, 0x00, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x00, 0xE1, 0xC0, 0x00,
  0x00, 0x30, 0x38, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x0E, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x38, 0x00, 0x01, 0x80, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x07, 0x00, 0x0C, 0x00,
  0x00, 0xE0, 0x07, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x1F, 0x1E, 0x1E, 0x1E, 0x1C, 0x3C, 0x3C, 0x38, 0x38,
  0x38, 0x70, 0x70, 0x70, 0x60, 0x60, 0xC0, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x7B, 0xFF, 0xFF, 0x78, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0x80, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x70,
  0x0C, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x1C,
  0x38, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x0C,
  0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x07,
  0xE0, 0x03, 0xC0, 0x07, 0xE0, 0x03, 0xC0, 0x07, 0xE0, 0x03, 0xC0, 0x07,
  0xE0, 0x03, 0xC0, 0x07, 0xE0, 0x03, 0xC0, 0x07, 0x60, 0x00, 0x00, 0x07,
  0x60, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x06,
  0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x0C,
  0x30, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x1C,
  0x1C, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x70,
  0x07, 0x00, 0x00, 0x60, 0x03, 0x80, 0x00, 0xE0, 0x03, 0xC0, 0x03, 0xC0,
  0x00, 0xF0, 0x0F, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0xC0, 0x00,
  0x00, 0x3C, 0xC0, 0x00, 0x00, 0x78, 0xC0, 0x00, 0x00, 0xF0, 0xC0, 0x00,
  0x01, 0xC0, 0xC0, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x0F, 0x00, 0xC0, 0x00,
  0x1E, 0x00, 0xC0, 0x00, 0x3C, 0x00, 0xC0, 0x00, 0x78, 0x00, 0xC0, 0x00,
  0xF0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x3E, 0x03, 0xE0, 0x03, 0xC0, 0x01, 0xE0, 0x1E,
  0x00, 0x03, 0x80, 0x70, 0x00, 0x07, 0x03, 0x80, 0x00, 0x0E, 0x0C, 0x00,
  0x00, 0x38, 0x70, 0x00, 0x00, 0x61, 0x80, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0xF8, 0x07, 0xC0, 0x0F, 0x00, 0x0F, 0x00, 0xE0,
  0x00, 0x1C, 0x0E, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x03, 0x87, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x40, 0x00, 0x00,
  0x33, 0x00, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x01, 0xC3,
  0xC0, 0x00, 0x1C, 0x07, 0x80, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x00, 0x0E, 0xC0, 0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0x00, 0xE3, 0x00, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x00, 0x18, 0x30,
  0x00, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x07, 0x03, 0x00, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x18,
  0x03, 0x00, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x0C, 0x00, 0x00, 0xE0, 0x03, 0x00, 0x00, 0x70, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x70, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x07, 0x00, 0x00,
  0x30, 0x01, 0x80, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x70, 0x00,
  0x00, 0xC0, 0x18, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x0C, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x83, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x3F, 0xE0, 0x01, 0x8F, 0xFF, 0xE0, 0x0C, 0xF0, 0x0F, 0x80, 0x6C, 0x00,
  0x0E, 0x07, 0xC0, 0x00, 0x38, 0x3C, 0x00, 0x00, 0xE0, 0x40, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE8,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x77, 0x80, 0x00, 0x03, 0x0E, 0x00,
  0x00, 0x38, 0x38, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x78, 0x03, 0xE0, 0x0F,
  0x80, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x07, 0xFC, 0x00, 0x38,
  0x7F, 0xFE, 0x00, 0xC7, 0x80, 0x7C, 0x03, 0x38, 0x00, 0x78, 0x1D, 0x80,
  0x00, 0x70, 0x6C, 0x00, 0x00, 0xE1, 0xA0, 0x00, 0x01, 0xC7, 0x80, 0x00,
  0x03, 0x1C, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x39, 0x80, 0x00, 0x00,
  0x6E, 0x00, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x1D,
  0x80, 0x00, 0x00, 0x76, 0x00, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x07, 0x60,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x67, 0x00, 0x00, 0x03, 0x8C, 0x00,
  0x00, 0x0E, 0x38, 0x00, 0x00, 0x30, 0x60, 0x00, 0x01, 0xC1, 0xC0, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0x70, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x7C,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0E, 0xC0,
  0x00, 0x00, 0x3B, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x07, 0x30, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x1C, 0x30, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x0F, 0x80, 0x7C, 0x00, 0x78, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x1E,
  0x03, 0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x18,
  0x70, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x07, 0x1C,
  0x00, 0x00, 0x0E, 0x18, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0x30, 0x70,
  0x00, 0x00, 0xE0, 0x70, 0x00, 0x03, 0x80, 0x70, 0x00, 0x0E, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x70, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x03, 0x8C, 0x00, 0x00,
  0x03, 0x38, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0x70, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00, 0x31,
  0xC0, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x0E, 0x01,
  0xE0, 0x00, 0x78, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xF0,
  0x0F, 0x80, 0x1E, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x38, 0x1C, 0x00, 0x00,
  0xE0, 0xC0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x76, 0x00, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x3C, 0xC0,
  0x00, 0x03, 0xC7, 0x00, 0x00, 0x36, 0x1C, 0x00, 0x03, 0x30, 0x78, 0x00,
  0x33, 0x81, 0xF0, 0x0F, 0x1C, 0x03, 0xFF, 0xF0, 0xC0, 0x07, 0xFC, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7B, 0xFF, 0xFF,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xBF, 0xFF, 0xF7, 0x80,
  0x1E, 0x3F, 0x3F, 0x3F, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x1E, 0x1E, 0x1E, 0x1C, 0x3C, 0x3C,
  0x38, 0x38, 0x38, 0x70, 0x70, 0x70, 0x60, 0x60, 0xC0, 0xC0, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xFF, 0x80, 0x07, 0xC0, 0x3E, 0x00, 0xF0, 0x00, 0x70, 0x1C, 0x00,
  0x03, 0x81, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x0E,
  0x60, 0x00, 0x00, 0x66, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xFF, 0x80, 0x03, 0xE0, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x0E, 0x00,
  0x07, 0x00, 0xC0, 0x00, 0x38, 0x1C, 0x00, 0x01, 0x81, 0x80, 0x00, 0x0C,
  0x38, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x06, 0x60, 0x00, 0x00, 0x66, 0x00, 0x00, 0x06, 0x60, 0x01, 0xF8,
  0x6E, 0x00, 0x7F, 0xE6, 0xE0, 0x0F, 0x07, 0x6C, 0x01, 0xC0, 0x17, 0xC0,
  0x18, 0x00, 0xFC, 0x03, 0x00, 0x07, 0xC0, 0x30, 0x00, 0x7C, 0x07, 0x00,
  0x07, 0xC0, 0x60, 0x00, 0x7C, 0x06, 0x00, 0x07, 0xC0, 0x60, 0x00, 0x7C,
  0x06, 0x00, 0x07, 0xC0, 0x60, 0x00, 0x7C, 0x06, 0x00, 0x07, 0xC0, 0x60,
  0x00, 0x7C, 0x06, 0x00, 0x07, 0xC0, 0x60, 0x00, 0x7C, 0x06, 0x00, 0x07,
  0xC0, 0x60, 0x00, 0x7C, 0x06, 0x00, 0x07, 0xC0, 0x70, 0x00, 0x7C, 0x03,
  0x00, 0x07, 0xC0, 0x30, 0x00, 0x7C, 0x03, 0x80, 0x0F, 0xC0, 0x18, 0x00,
  0xFE, 0x01, 0xE0, 0x17, 0x60, 0x0F, 0x9E, 0x76, 0x00, 0x3F, 0xC7, 0x60,
  0x00, 0xE0, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x00,
  0x73, 0x80, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x06, 0x1C, 0x00, 0x00,
  0x03, 0x87, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x30, 0x38, 0x00,
  0x00, 0x1C, 0x0E, 0x00, 0x00, 0x07, 0x01, 0x80, 0x00, 0x01, 0x80, 0x60,
  0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x38, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0xC0, 0x00, 0x07, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x06, 0x00, 0x00, 0x60,
  0x01, 0x80, 0x00, 0x38, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x70,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xE0, 0x06, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x38, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x0E, 0x07, 0x00,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x1C, 0x38,
  0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x39,
  0xC0, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1C, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0,
  0x38, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x38, 0x70,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x18, 0xE0, 0x00,
  0x00, 0xE7, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x01,
  0xCE, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x73, 0x80, 0x00, 0x03, 0x9C,
  0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x0E, 0x38, 0x00,
  0x00, 0x71, 0xC0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x70, 0x70, 0x00, 0x0F,
  0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0xE0, 0x00, 0x0F, 0x07,
  0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0xCE, 0x00,
  0x00, 0x07, 0x70, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xDC, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x03, 0x38, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x07, 0x8E, 0x00, 0x00, 0xF8,
  0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x70, 0x00, 0x70, 0x03,
  0x80, 0x00, 0xE0, 0x1C, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x03, 0x87, 0x00,
  0x00, 0x06, 0x18, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x33, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x18, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x60, 0xE0, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0x1C, 0x07, 0x80, 0x00, 0xE0, 0x0F, 0x00, 0x07,
  0x00, 0x0F, 0x80, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x30, 0x00, 0x3E, 0x01, 0x80,
  0x00, 0x3C, 0x0C, 0x00, 0x00, 0xF0, 0x60, 0x00, 0x03, 0x83, 0x00, 0x00,
  0x0E, 0x18, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x07,
  0x30, 0x00, 0x00, 0x39, 0x80, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0x3B, 0x00, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00,
  0x1B, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x76,
  0x00, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x0E, 0x60, 0x00, 0x00, 0x73, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00,
  0x38, 0xC0, 0x00, 0x03, 0x86, 0x00, 0x00, 0x18, 0x30, 0x00, 0x03, 0xC1,
  0x80, 0x00, 0x3C, 0x0C, 0x00, 0x0F, 0x80, 0x7F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFE, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xE0,
  0x07, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x07, 0x06,
  0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x07,
  0x60, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x01, 0xCC,
  0x00, 0x00, 0x0F, 0x38, 0x00, 0x00, 0x3C, 0x60, 0x00, 0x00, 0xF1, 0xC0,
  0x00, 0x05, 0xC3, 0x80, 0x00, 0x37, 0x07, 0x00, 0x01, 0x9C, 0x0E, 0x00,
  0x0C, 0x70, 0x1F, 0x01, 0xE1, 0xC0, 0x1F, 0xFF, 0x07, 0x00, 0x1F, 0xE0,
  0x00, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x70, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0x38, 0x00, 0x03, 0x9C, 0x00, 0x01, 0x87, 0x00, 0x01,
  0xC1, 0xC0, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x0F, 0xFF, 0x80, 0x01, 0xFE,
  0x00, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x07,
  0x30, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x0E, 0x0C,
  0x00, 0x00, 0x70, 0x30, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x1C, 0x03, 0x00,
  0x00, 0x70, 0x0C, 0x00, 0x03, 0x80, 0x30, 0x00, 0x1C, 0x00, 0xC0, 0x00,
  0xE0, 0x03, 0x00, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x30, 0x01, 0xC0,
  0x00, 0xC0, 0x0E, 0x00, 0x03, 0x00, 0x38, 0x00, 0x0C, 0x01, 0xC0, 0x00,
  0x30, 0x0E, 0x00, 0x00, 0xC0, 0x78, 0x00, 0x03, 0x03, 0xF0, 0x00, 0x0C,
  0x1D, 0xC0, 0x00, 0x30, 0xE3, 0x80, 0x00, 0xC7, 0x07, 0x00, 0x03, 0x18,
  0x1C, 0x00, 0x0C, 0xC0, 0x38, 0x00, 0x37, 0x00, 0x60, 0x00, 0xF8, 0x01,
  0xC0, 0x03, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x1C,
  0x00, 0xC0, 0x00, 0x38, 0x03, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x01, 0xC0,
  0x30, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x1C, 0x0C,
  0x00, 0x00, 0x38, 0x30, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x01, 0xC3, 0x00,
  0x00, 0x03, 0x8C, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x1C, 0xC0, 0x00,
  0x00, 0x3B, 0x00, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x01, 0xC0, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xB0, 0x00, 0x03, 0xFE,
  0xE0, 0x00, 0x0D, 0xF9, 0x80, 0x00, 0x77, 0xE6, 0x00, 0x01, 0x9F, 0x8C,
  0x00, 0x0E, 0x7E, 0x30, 0x00, 0x31, 0xF8, 0xE0, 0x01, 0xC7, 0xE1, 0x80,
  0x06, 0x1F, 0x87, 0x00, 0x18, 0x7E, 0x0C, 0x00, 0xE1, 0xF8, 0x38, 0x03,
  0x07, 0xE0, 0x60, 0x1C, 0x1F, 0x81, 0x80, 0x60, 0x7E, 0x03, 0x03, 0x81,
  0xF8, 0x0C, 0x0C, 0x07, 0xE0, 0x38, 0x30, 0x1F, 0x80, 0x61, 0x80, 0x7E,
  0x01, 0xC6, 0x01, 0xF8, 0x03, 0x38, 0x07, 0xE0, 0x0C, 0xC0, 0x1F, 0x80,
  0x1F, 0x00, 0x7E, 0x00, 0x78, 0x01, 0xF8, 0x01, 0xE0, 0x07, 0xE0, 0x03,
  0x00, 0x1F, 0x80, 0x0C, 0x00, 0x7E, 0x00, 0x20, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xC0, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3E, 0xE0, 0x00, 0x03, 0xEE, 0x00, 0x00, 0x3E, 0x60,
  0x00, 0x03, 0xE7, 0x00, 0x00, 0x3E, 0x30, 0x00, 0x03, 0xE3, 0x80, 0x00,
  0x3E, 0x18, 0x00, 0x03, 0xE1, 0xC0, 0x00, 0x3E, 0x0C, 0x00, 0x03, 0xE0,
  0xE0, 0x00, 0x3E, 0x06, 0x00, 0x03, 0xE0, 0x70, 0x00, 0x3E, 0x03, 0x00,
  0x03, 0xE0, 0x38, 0x00, 0x3E, 0x01, 0x80, 0x03, 0xE0, 0x1C, 0x00, 0x3E,
  0x00, 0xC0, 0x03, 0xE0, 0x0E, 0x00, 0x3E, 0x00, 0x60, 0x03, 0xE0, 0x07,
  0x00, 0x3E, 0x00, 0x30, 0x03, 0xE0, 0x03, 0x80, 0x3E, 0x00, 0x18, 0x03,
  0xE0, 0x01, 0xC0, 0x3E, 0x00, 0x0C, 0x03, 0xE0, 0x00, 0xE0, 0x3E, 0x00,
  0x06, 0x03, 0xE0, 0x00, 0x70, 0x3E, 0x00, 0x03, 0x03, 0xE0, 0x00, 0x38,
  0x3E, 0x00, 0x01, 0x83, 0xE0, 0x00, 0x1C, 0x3E, 0x00, 0x00, 0xC3, 0xE0,
  0x00, 0x0E, 0x3E, 0x00, 0x00, 0x63, 0xE0, 0x00, 0x07, 0x3E, 0x00, 0x00,
  0x33, 0xE0, 0x00, 0x03, 0xBE, 0x00, 0x00, 0x1B, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0x80, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x70, 0x0C,
  0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x1C, 0x38,
  0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x0C, 0x70,
  0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x07, 0x60,
  0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x06, 0x70,
  0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x0C, 0x30,
  0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x1C, 0x1C,
  0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x70, 0x07,
  0x00, 0x00, 0x60, 0x03, 0x80, 0x00, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x00,
  0xF0, 0x0F, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x30, 0x00, 0x03, 0xC1, 0x80, 0x00,
  0x07, 0x0C, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x00, 0x73, 0x00, 0x00, 0x01,
  0x98, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x01, 0xB0,
  0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x0E, 0x18, 0x00,
  0x01, 0xE0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xF0,
  0x0F, 0x00, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x00, 0xE0, 0x07, 0x00,
  0x00, 0x60, 0x0E, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x38, 0x1C, 0x00,
  0x00, 0x18, 0x18, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x1C, 0x30, 0x00,
  0x00, 0x0C, 0x30, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00,
  0x00, 0x0E, 0x70, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0x60, 0x00,
  0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x07, 0x60, 0x00,
  0x00, 0x07, 0x60, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0x60, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x07, 0x60, 0x00,
  0x00, 0x07, 0x60, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0x60, 0x00,
  0x00, 0x06, 0x70, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00,
  0x00, 0x0E, 0x30, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x0C, 0x38, 0x00,
  0x00, 0x1C, 0x18, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x18, 0x1C, 0x00,
  0x00, 0x38, 0x0E, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x60, 0x07, 0x80,
  0x00, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xF0, 0x30, 0x00, 0x03, 0xC1, 0x80, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x1C,
  0x60, 0x00, 0x00, 0x73, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x0E, 0xC0,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x0D, 0x80, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xD8, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x03, 0xB0,
  0x00, 0x00, 0x1D, 0x80, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x0E, 0x60, 0x00,
  0x00, 0xE3, 0x00, 0x00, 0x0E, 0x18, 0x00, 0x01, 0xE0, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0x80, 0x30, 0x01, 0x80, 0x01, 0x80, 0x0E, 0x00, 0x0C,
  0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x07, 0x00, 0x18, 0x00,
  0x1C, 0x00, 0xC0, 0x00, 0xE0, 0x06, 0x00, 0x03, 0x80, 0x30, 0x00, 0x0C,
  0x01, 0x80, 0x00, 0x70, 0x0C, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x07, 0x06, 0x00,
  0x00, 0x1C, 0x30, 0x00, 0x00, 0x71, 0x80, 0x00, 0x03, 0x8C, 0x00, 0x00,
  0x0E, 0x60, 0x00, 0x00, 0x33, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0x80, 0x00,
  0xF0, 0x0E, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00,
  0x0E, 0x38, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x06, 0x40, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00,
  0x1C, 0x38, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00,
  0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x76,
  0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x66, 0x00, 0x00, 0x06, 0x60, 0x00,
  0x00, 0x67, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x0C,
  0x38, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x38, 0x0E, 0x00, 0x07, 0x00, 0x7C,
  0x01, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xDC, 0x00, 0x00, 0x00, 0x67, 0x00, 0x00, 0x00, 0x39, 0xC0, 0x00,
  0x00, 0x0E, 0x30, 0x00, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x00, 0xC3, 0x80,
  0x00, 0x00, 0x70, 0x60, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x06, 0x07,
  0x00, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x00, 0x30,
  0x0E, 0x00, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x07, 0x00, 0x70, 0x00, 0x01,
  0x80, 0x1C, 0x00, 0x00, 0xE0, 0x03, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00,
  0x0C, 0x00, 0x38, 0x00, 0x07, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x01, 0xC0,
  0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x70, 0x00,
  0x06, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x06, 0x00, 0x00, 0x70, 0x03, 0x80,
  0x00, 0x0C, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x30, 0x00, 0x00, 0xE0, 0x1C,
  0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x07, 0x01, 0x80, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x03,
  0x87, 0x00, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00,
  0x07, 0x38, 0x00, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x00, 0x33, 0x00, 0x00,
  0x00, 0x0E, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x0D, 0x80, 0x00,
  0x00, 0x06, 0xE0, 0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0x01, 0x98, 0x00,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x00, 0x73, 0x00,
  0x00, 0x00, 0x31, 0x80, 0x07, 0x00, 0x18, 0xC0, 0x07, 0x80, 0x0C, 0x60,
  0x03, 0xC0, 0x06, 0x30, 0x01, 0xF0, 0x03, 0x18, 0x01, 0xD8, 0x01, 0x8E,
  0x00, 0xCC, 0x00, 0xC7, 0x00, 0x66, 0x00, 0x61, 0x80, 0x33, 0x80, 0x30,
  0xC0, 0x38, 0xC0, 0x38, 0x60, 0x18, 0x60, 0x1C, 0x30, 0x0C, 0x38, 0x0C,
  0x18, 0x0E, 0x0C, 0x06, 0x0C, 0x06, 0x06, 0x03, 0x06, 0x03, 0x03, 0x01,
  0x83, 0x01, 0x81, 0xC0, 0xC1, 0x81, 0xC0, 0x60, 0x60, 0xE0, 0xC0, 0x30,
  0x30, 0x70, 0x60, 0x18, 0x18, 0x18, 0x30, 0x0E, 0x0C, 0x0C, 0x30, 0x03,
  0x0E, 0x06, 0x18, 0x01, 0x87, 0x03, 0x0C, 0x00, 0xE3, 0x01, 0x8E, 0x00,
  0x31, 0x80, 0xC6, 0x00, 0x18, 0xC0, 0x63, 0x00, 0x0C, 0x60, 0x31, 0x80,
  0x07, 0x30, 0x19, 0xC0, 0x01, 0x98, 0x0E, 0xC0, 0x00, 0xCC, 0x07, 0x60,
  0x00, 0x76, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x78,
  0x00, 0x07, 0xC0, 0x3C, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x00, 0x01, 0xCC,
  0x00, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x18,
  0x1C, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x07, 0x00, 0x70, 0x00, 0x01,
  0x80, 0x1C, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x07, 0x00, 0x00, 0x70,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x30, 0x00, 0x00,
  0x70, 0x1C, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x03, 0x83, 0x00, 0x00,
  0x00, 0x61, 0xC0, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x03, 0xB0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x00, 0x73,
  0x80, 0x00, 0x00, 0x18, 0x70, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x07,
  0x03, 0x80, 0x00, 0x01, 0x80, 0x70, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00,
  0x30, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x60, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x30, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00,
  0x1C, 0x03, 0x00, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x00, 0x60, 0xE0, 0x00,
  0x00, 0x1C, 0x30, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x00, 0x7B, 0x00, 0x00, 0x00, 0x03,
  0x9C, 0x00, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x01, 0x83, 0x80, 0x00,
  0x00, 0x1C, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x0C, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x01, 0x80,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x06, 0x00, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x00, 0x03, 0x87, 0x00, 0x00, 0x00, 0x0C, 0x30,
  0x00, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x06, 0x60, 0x00,
  0x00, 0x0E, 0x30, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x18, 0x18, 0x00,
  0x00, 0x38, 0x1C, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x70, 0x0E, 0x00,
  0x00, 0x60, 0x07, 0x00, 0x00, 0xE0, 0x03, 0x00, 0x01, 0xC0, 0x03, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x03, 0x00, 0x00, 0xE0,
  0x07, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x30,
  0x1C, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x0C,
  0x30, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x07,
  0x40, 0x00, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x60, 0x78, 0x0C, 0x07, 0x01, 0xC0, 0x60, 0x18, 0x0E, 0x03, 0x00, 0xC0,
  0x60, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0x01, 0xF0,
  0x00, 0x70, 0x00, 0xF0, 0x01, 0xC0, 0x00, 0x70, 0x07, 0x00, 0x00, 0xE0,
  0x0C, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x01, 0xC0, 0x20, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0xF8, 0x00, 0x0C, 0x03, 0xC0, 0x00, 0x18, 0x0E, 0x00,
  0x00, 0x30, 0x18, 0x00, 0x00, 0x60, 0x70, 0x00, 0x00, 0xC0, 0xE0, 0x00,
  0x01, 0x81, 0xC0, 0x00, 0x03, 0x03, 0x80, 0x00, 0x06, 0x07, 0x00, 0x00,
  0x0C, 0x0E, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x70, 0x18, 0x00, 0x01,
  0xE0, 0x38, 0x00, 0x06, 0xC0, 0x38, 0x00, 0x19, 0x80, 0x3E, 0x01, 0xE3,
  0xFC, 0x3F, 0xFF, 0x83, 0xF8, 0x0F, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x03, 0xFC, 0x00, 0xC1, 0xFF, 0xF0, 0x18, 0xF0, 0x1F, 0x03, 0x38, 0x00,
  0x78, 0x6C, 0x00, 0x07, 0x0D, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x07, 0x38,
  0x00, 0x00, 0x67, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0xD8, 0x00, 0x00,
  0x1B, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x07, 0x70, 0x00,
  0x00, 0xCE, 0x00, 0x00, 0x39, 0xA0, 0x00, 0x0E, 0x36, 0x00, 0x03, 0x86,
  0x70, 0x00, 0xF0, 0xC7, 0x80, 0x78, 0x18, 0x3F, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0x80, 0xF8,
  0x03, 0x80, 0x07, 0x80, 0xE0, 0x00, 0x38, 0x38, 0x00, 0x03, 0x0E, 0x00,
  0x00, 0x71, 0x80, 0x00, 0x06, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x43, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x01, 0x87, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x1C, 0x07, 0x00, 0x07, 0x00, 0x7C, 0x07, 0xC0, 0x03, 0xFF, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x01, 0xFE, 0x03, 0x01, 0xFF,
  0xF0, 0x60, 0x7C, 0x07, 0x8C, 0x1C, 0x00, 0x39, 0x87, 0x00, 0x01, 0xB1,
  0xC0, 0x00, 0x16, 0x70, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x3B, 0x80, 0x00,
  0x03, 0x70, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x6E, 0x00,
  0x00, 0x0D, 0xC0, 0x00, 0x01, 0x98, 0x00, 0x00, 0x73, 0x80, 0x00, 0x0E,
  0x38, 0x00, 0x02, 0xC3, 0x80, 0x00, 0xD8, 0x38, 0x00, 0x73, 0x03, 0xE0,
  0x3C, 0x60, 0x3F, 0xFE, 0x0C, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xF0, 0x0F, 0x80, 0x0E, 0x00, 0x1E, 0x00,
  0xE0, 0x00, 0x38, 0x0E, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x03, 0x06, 0x00,
  0x00, 0x1C, 0x70, 0x00, 0x00, 0x63, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00,
  0x1D, 0xC0, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x1B,
  0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0xE0,
  0x00, 0x00, 0xE3, 0x00, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x07, 0x01, 0xC0, 0x00, 0x70, 0x07, 0x00, 0x07, 0x00, 0x1F, 0x01, 0xF0,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x08, 0x00, 0x01, 0xFE,
  0x10, 0x00, 0x0F, 0xFF, 0xA0, 0x00, 0x7C, 0x07, 0xC0, 0x01, 0xC0, 0x03,
  0xC0, 0x07, 0x00, 0x03, 0x80, 0x0C, 0x00, 0x03, 0x80, 0x38, 0x00, 0x03,
  0x80, 0x60, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x06, 0x03, 0x80, 0x00, 0x0C,
  0x07, 0x00, 0x00, 0x18, 0x0E, 0x00, 0x00, 0x30, 0x1C, 0x00, 0x00, 0x60,
  0x38, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x01, 0x80, 0x60, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x38, 0x01, 0xC0, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x01, 0xF0, 0x1E, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0xE0, 0x00, 0x0F, 0x03, 0x00, 0x00,
  0x07, 0x1C, 0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x07,
  0x38, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0xF0, 0x3E, 0x00, 0x0F, 0xC0,
  0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0xFF, 0x00, 0xC1, 0xFF,
  0xF0, 0x63, 0xC0, 0x7C, 0x33, 0x00, 0x0F, 0x1B, 0x00, 0x01, 0xCD, 0x00,
  0x00, 0x67, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x0D, 0xC0, 0x00, 0x06, 0xE0,
  0x00, 0x03, 0x60, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x3C, 0xC0, 0x00, 0x03, 0x86, 0x00, 0x00,
  0x38, 0x30, 0x00, 0x03, 0x81, 0x80, 0x00, 0x38, 0x0C, 0x00, 0x03, 0x80,
  0x60, 0x00, 0x38, 0x03, 0x00, 0x07, 0x80, 0x18, 0x00, 0x78, 0x00, 0xC0,
  0x07, 0x00, 0x06, 0x00, 0x70, 0x00, 0x30, 0x07, 0x00, 0x01, 0x80, 0x70,
  0x00, 0x0C, 0x07, 0x00, 0x00, 0x60, 0x78, 0x00, 0x03, 0x07, 0xE0, 0x00,
  0x18, 0xE3, 0x80, 0x00, 0xCE, 0x0E, 0x00, 0x06, 0xE0, 0x38, 0x00, 0x3E,
  0x01, 0xC0, 0x01, 0xE0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x60, 0x00,
  0x70, 0x03, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x38,
  0x06, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x03, 0x81, 0x80, 0x00, 0x0E, 0x0C,
  0x00, 0x00, 0x70, 0x60, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x07, 0x18, 0x00,
  0x00, 0x1C, 0xC0, 0x00, 0x00, 0x76, 0x00, 0x00, 0x03, 0xC0, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xF0, 0x0F, 0xC1, 0x9F, 0xF8, 0x3F,
  0xE3, 0x70, 0x70, 0xC1, 0xE6, 0x80, 0x73, 0x00, 0xEE, 0x00, 0x64, 0x00,
  0xDC, 0x00, 0x70, 0x01, 0xB0, 0x00, 0xE0, 0x03, 0x60, 0x01, 0x80, 0x07,
  0xC0, 0x03, 0x00, 0x0F, 0x80, 0x06, 0x00, 0x1F, 0x00, 0x0C, 0x00, 0x3E,
  0x00, 0x18, 0x00, 0x7C, 0x00, 0x30, 0x00, 0xF8, 0x00, 0x60, 0x01, 0xF0,
  0x00, 0xC0, 0x03, 0xE0, 0x01, 0x80, 0x07, 0xC0, 0x03, 0x00, 0x0F, 0x80,
  0x06, 0x00, 0x1F, 0x00, 0x0C, 0x00, 0x3E, 0x00, 0x18, 0x00, 0x7C, 0x00,
  0x30, 0x00, 0xF8, 0x00, 0x60, 0x01, 0xF0, 0x00, 0xC0, 0x03, 0xE0, 0x01,
  0x80, 0x07, 0xC0, 0x03, 0x00, 0x0F, 0x80, 0x06, 0x00, 0x1F, 0x00, 0x0C,
  0x00, 0x3E, 0x00, 0x18, 0x00, 0x7C, 0x00, 0x30, 0x00, 0xF8, 0x00, 0x60,
  0x01, 0xF0, 0x00, 0xC0, 0x03, 0xE0, 0x01, 0x80, 0x07, 0xC0, 0x03, 0x00,
  0x0F, 0x80, 0x06, 0x00, 0x1F, 0x00, 0x0C, 0x00, 0x38, 0xC0, 0x7F, 0x80,
  0x60, 0xFF, 0xF8, 0x31, 0xE0, 0x3E, 0x19, 0x80, 0x07, 0x8D, 0x80, 0x00,
  0xE6, 0x80, 0x00, 0x33, 0x80, 0x00, 0x1D, 0xC0, 0x00, 0x06, 0xE0, 0x00,
  0x03, 0x70, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xF0, 0x0F, 0x80, 0x1E, 0x00,
  0x1E, 0x00, 0xE0, 0x00, 0x38, 0x0E, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x07,
  0x06, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x63, 0x00, 0x00, 0x03, 0x38,
  0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x03, 0x60, 0x00,
  0x00, 0x1B, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0x06, 0xE0, 0x00, 0x00, 0x33, 0x00, 0x00, 0x03, 0x98, 0x00, 0x00,
  0x18, 0xE0, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0xE0,
  0x70, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x70, 0x0F, 0x00, 0x0F, 0x00, 0x1E,
  0x01, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xC0, 0x7F,
  0x80, 0x18, 0x3F, 0xFE, 0x03, 0x1E, 0x03, 0xE0, 0x67, 0x00, 0x0F, 0x0D,
  0x80, 0x00, 0xE1, 0xA0, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x0C, 0xE0, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x03, 0x60,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1B, 0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x19,
  0xC0, 0x00, 0x07, 0x34, 0x00, 0x01, 0xC6, 0xC0, 0x00, 0x70, 0xCE, 0x00,
  0x1E, 0x18, 0xF0, 0x0F, 0x03, 0x07, 0xFF, 0xC0, 0x60, 0x3F, 0xC0, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x60, 0x3F, 0xFE, 0x0C, 0x0F,
  0x80, 0xF1, 0x83, 0x80, 0x07, 0x30, 0xE0, 0x00, 0x36, 0x38, 0x00, 0x02,
  0xCE, 0x00, 0x00, 0x39, 0x80, 0x00, 0x07, 0x70, 0x00, 0x00, 0x6E, 0x00,
  0x00, 0x0D, 0x80, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0x60, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x01, 0xB8,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x01, 0xC7, 0x00, 0x00,
  0x58, 0x70, 0x00, 0x1B, 0x07, 0x00, 0x0E, 0x60, 0x7C, 0x07, 0x8C, 0x07,
  0xFF, 0xC1, 0x80, 0x1F, 0xE0, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x0C,
  0x60, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x0D,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF,
  0xE0, 0x01, 0xF0, 0x0F, 0xC0, 0x1C, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x1E,
  0x1C, 0x00, 0x00, 0x78, 0xC0, 0x00, 0x01, 0x06, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x74,
  0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x01, 0xC7, 0x00,
  0x00, 0x1C, 0x1E, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x7C, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xB0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x37, 0x00,
  0x00, 0x39, 0x80, 0x00, 0x1C, 0xE0, 0x00, 0x16, 0x38, 0x00, 0x1B, 0x1E,
  0x00, 0x19, 0x87, 0xC0, 0x78, 0xC0, 0xFF, 0xF8, 0x60, 0x1F, 0xE0, 0x00,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x76, 0x00,
  0x00, 0x06, 0x70, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x1C, 0x18, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x18, 0x0C,
  0x00, 0x03, 0x80, 0xC0, 0x00, 0x30, 0x0E, 0x00, 0x03, 0x00, 0x60, 0x00,
  0x60, 0x06, 0x00, 0x06, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00,
  0x38, 0x00, 0xC0, 0x01, 0x80, 0x1C, 0x00, 0x18, 0x01, 0x80, 0x01, 0xC0,
  0x18, 0x00, 0x0C, 0x03, 0x80, 0x00, 0xC0, 0x30, 0x00, 0x0E, 0x03, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x19, 0x80,
  0x00, 0x01, 0xD8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x36, 0x00, 0x0F, 0x00, 0x07,
  0x60, 0x00, 0xF0, 0x00, 0x66, 0x00, 0x0D, 0x00, 0x06, 0x60, 0x00, 0xD8,
  0x00, 0x67, 0x00, 0x19, 0x80, 0x06, 0x30, 0x01, 0x98, 0x00, 0x63, 0x00,
  0x18, 0x80, 0x0C, 0x30, 0x01, 0x8C, 0x00, 0xC3, 0x00, 0x30, 0xC0, 0x0C,
  0x30, 0x03, 0x0C, 0x00, 0xC3, 0x80, 0x30, 0x40, 0x0C, 0x18, 0x03, 0x06,
  0x00, 0xC1, 0x80, 0x60, 0x60, 0x18, 0x18, 0x06, 0x06, 0x01, 0x81, 0x80,
  0x60, 0x60, 0x18, 0x18, 0x06, 0x03, 0x01, 0x80, 0xC0, 0xC0, 0x30, 0x18,
  0x0C, 0x0C, 0x03, 0x03, 0x80, 0xC0, 0xC0, 0x30, 0x30, 0x0C, 0x0C, 0x01,
  0x83, 0x00, 0xC1, 0x80, 0x18, 0x30, 0x0C, 0x18, 0x01, 0x83, 0x00, 0x61,
  0x80, 0x18, 0x30, 0x06, 0x18, 0x00, 0xC6, 0x00, 0x63, 0x00, 0x0C, 0x60,
  0x06, 0x30, 0x00, 0xC6, 0x00, 0x63, 0x00, 0x0C, 0x60, 0x07, 0x30, 0x00,
  0x66, 0x00, 0x36, 0x00, 0x06, 0x60, 0x03, 0x60, 0x00, 0x6C, 0x00, 0x36,
  0x00, 0x06, 0xC0, 0x03, 0x60, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x01, 0xC0, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x07, 0x07, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x01, 0xC0,
  0x1C, 0x00, 0x06, 0x00, 0x30, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x01,
  0xC0, 0x0E, 0x00, 0x03, 0x80, 0x30, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x1C,
  0x0E, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x71, 0x80, 0x00, 0x00, 0xCE,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1C, 0xE0, 0x00,
  0x00, 0x61, 0xC0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00,
  0xE0, 0x1C, 0x00, 0x03, 0x00, 0x38, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0xE0,
  0x01, 0xC0, 0x07, 0x00, 0x03, 0x80, 0x18, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0x1C, 0x07, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x00,
  0xEF, 0x00, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x00,
  0x77, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x30,
  0xE0, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x06, 0x07, 0x00, 0x00, 0x18, 0x0C,
  0x00, 0x00, 0xE0, 0x30, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x1C, 0x01, 0x80,
  0x00, 0x60, 0x07, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x0E, 0x00, 0x38, 0x00,
  0x30, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x07, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0xC0, 0x00, 0x38, 0x03, 0x00, 0x00, 0x60, 0x1C, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x07, 0x03, 0x80, 0x00, 0x0C, 0x0C, 0x00, 0x00,
  0x38, 0x30, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x01, 0x86, 0x00, 0x00, 0x07,
  0x38, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x07, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x7C, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0x0F, 0xF8, 0x00, 0x03, 0x1E, 0x3C, 0x00, 0x03, 0x18,
  0x0E, 0x00, 0x03, 0x30, 0x07, 0x00, 0x06, 0x30, 0x03, 0x80, 0x06, 0x60,
  0x01, 0xC0, 0x0E, 0x60, 0x00, 0xE0, 0x0C, 0xE0, 0x00, 0x70, 0x1C, 0xC0,
  0x00, 0x3C, 0x38, 0xC0, 0x00, 0x1F, 0xF0, 0xC0, 0x00, 0x07, 0xC0,
};

const GFXglyph IBMPlexMono_ExtraLight67pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 40, 0, -1 },
  { 1, 6, 47, 40, 17, -47 },
  { 37, 12, 17, 40, 14, -50 },
  { 63, 38, 47, 40, 1, -47 },
  { 287, 32, 63, 40, 4, -55 },
  { 539, 36, 49, 40, 2, -48 },
  { 760, 34, 49, 40, 3, -48 },
  { 969, 2, 17, 40, 19, -50 },
  { 974, 17, 60, 40, 15, -51 },
  { 1102, 16, 60, 40, 9, -51 },
  { 1222, 34, 33, 40, 3, -37 },
  { 1363, 32, 32, 40, 4, -36 },
  { 1491, 8, 17, 40, 15, -6 },
  { 1508, 18, 2, 40, 11, -21 },
  { 1513, 6, 5, 40, 17, -5 },
  { 1517, 26, 60, 40, 7, -51 },
  { 1712, 32, 49, 40, 4, -48 },
  { 1908, 32, 47, 40, 5, -47 },
  { 2096, 30, 48, 40, 5, -48 },
  { 2276, 29, 49, 40, 4, -48 },
  { 2454, 34, 47, 40, 3, -47 },
  { 2654, 29, 48, 40, 5, -47 },
  { 2828, 30, 48, 40, 5, -47 },
  { 3008, 30, 47, 40, 5, -47 },
  { 3185, 31, 49, 40, 5, -48 },
  { 3375, 29, 48, 40, 6, -48 },
  { 3549, 6, 35, 40, 17, -35 },
  { 3576, 8, 46, 40, 15, -35 },
  { 3622, 29, 36, 40, 6, -38 },
  { 3753, 32, 15, 40, 4, -28 },
  { 3813, 29, 36, 40, 6, -38 },
  { 3944, 28, 48, 40, 6, -48 },
  { 4112, 28, 55, 40, 6, -48 },
  { 4305, 34, 47, 40, 3, -47 },
  { 4505, 29, 47, 40, 6, -47 },
  { 4676, 30, 49, 40, 5, -48 },
  { 4860, 29, 47, 40, 7, -47 },
  { 5031, 28, 47, 40, 7, -47 },
  { 5196, 28, 47, 40, 7, -47 },
  { 5361, 30, 49, 40, 5, -48 },
  { 5545, 28, 47, 40, 6, -47 },
  { 5710, 28, 47, 40, 6, -47 },
  { 5875, 25, 48, 40, 6, -47 },
  { 6025, 30, 47, 40, 7, -47 },
  { 6202, 27, 47, 40, 9, -47 },
  { 6361, 30, 47, 40, 5, -47 },
  { 6538, 28, 47, 40, 6, -47 },
  { 6703, 32, 49, 40, 4, -48 },
  { 6899, 29, 47, 40, 7, -47 },
  { 7070, 32, 58, 40, 4, -48 },
  { 7302, 29, 47, 40, 7, -47 },
  { 7473, 32, 49, 40, 4, -48 },
  { 7669, 36, 47, 40, 2, -47 },
  { 7881, 28, 48, 40, 6, -47 },
  { 8049, 34, 47, 40, 3, -47 },
  { 8249, 33, 47, 40, 4, -47 },
  { 8443, 34, 47, 40, 3, -47 },
  { 8643, 37, 47, 40, 2, -47 },
  { 8861, 34, 47, 40, 3, -47 },
  { 9061, 17, 60, 40, 17, -51 },
  { 9189, 26, 60, 40, 7, -51 },
  { 9384, 17, 60, 40, 6, -51 },
  { 9512, 32, 26, 40, 4, -47 },
  { 9616, 32, 2, 40, 4, 8 },
  { 9624, 9, 11, 40, 13, -51 },
  { 9637, 31, 36, 40, 5, -35 },
  { 9777, 27, 51, 40, 8, -50 },
  { 9950, 27, 36, 40, 7, -35 },
  { 10072, 27, 51, 40, 5, -50 },
  { 10245, 29, 36, 40, 6, -35 },
  { 10376, 31, 50, 40, 5, -50 },
  { 10570, 31, 52, 40, 6, -38 },
  { 10772, 25, 50, 40, 8, -50 },
  { 10929, 28, 51, 40, 8, -51 },
  { 11108, 24, 64, 40, 6, -51 },
  { 11300, 29, 50, 40, 9, -50 },
  { 11482, 28, 50, 40, 6, -50 },
  { 11657, 31, 35, 40, 5, -35 },
  { 11793, 25, 35, 40, 8, -35 },
  { 11903, 29, 36, 40, 6, -35 },
  { 12034, 27, 48, 40, 8, -35 },
  { 12196, 27, 48, 40, 5, -35 },
  { 12358, 32, 35, 40, 5, -35 },
  { 12498, 29, 36, 40, 6, -35 },
  { 12629, 33, 47, 40, 2, -47 },
  { 12823, 25, 36, 40, 7, -35 },
  { 12936, 28, 35, 40, 6, -35 },
  { 13059, 36, 35, 40, 2, -35 },
  { 13217, 30, 35, 40, 5, -35 },
  { 13349, 30, 48, 40, 5, -35 },
  { 13529, 27, 35, 40, 7, -35 },
  { 13648, 25, 60, 40, 8, -51 },
  { 13836, 2, 60, 40, 19, -51 },
  { 13851, 25, 60, 40, 8, -51 },
  { 14039, 32, 12, 40, 4, -26 },
};

const GFXfont IBMPlexMono_ExtraLight67pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLight67pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLight67pt7bGlyphs,
  0x20, 0x7E, 87
};

#endif // _IBMPLEXMONO_EXTRALIGHT67PT7B_H_
