#ifndef _IBMPLEXMONO_EXTRALIGHT46PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHT46PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLight.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLight46pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x44, 0x44, 0x44,
  0x40, 0x00, 0x00, 0xEF, 0xFE, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83,
  0x83, 0x83, 0x83, 0x83, 0x83, 0x00, 0x10, 0x18, 0x00, 0x04, 0x04, 0x00,
  0x03, 0x01, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x08, 0x0C,
  0x00, 0x02, 0x02, 0x00, 0x01, 0x80, 0x80, 0x00, 0x60, 0x60, 0x00, 0x18,
  0x18, 0x00, 0x04, 0x06, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x40, 0x40, 0x00,
  0x30, 0x10, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x00, 0x80, 0xC0,
  0x00, 0x20, 0x20, 0x00, 0x08, 0x08, 0x00, 0x06, 0x02, 0x00, 0xFF, 0x81,
  0xFF, 0x00, 0x60, 0x60, 0x00, 0x10, 0x18, 0x00, 0x04, 0x04, 0x00, 0x03,
  0x01, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x08, 0x0C, 0x00,
  0x02, 0x02, 0x00, 0x00, 0x80, 0x80, 0x00, 0x60, 0x20, 0x00, 0x18, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x07, 0xFC, 0x00, 0xE3, 0x1C, 0x06, 0x0C, 0x1C, 0x30,
  0x30, 0x39, 0x80, 0xC0, 0x66, 0x03, 0x00, 0x10, 0x0C, 0x00, 0x40, 0x30,
  0x01, 0x00, 0xC0, 0x04, 0x03, 0x00, 0x18, 0x0C, 0x00, 0x60, 0x30, 0x00,
  0x80, 0xC0, 0x03, 0x03, 0x00, 0x07, 0x0C, 0x00, 0x07, 0x30, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0x78, 0x00, 0x0C, 0x38, 0x00, 0x30, 0x30, 0x00, 0xC0,
  0x40, 0x03, 0x01, 0x80, 0x0C, 0x06, 0x00, 0x30, 0x08, 0x00, 0xC0, 0x20,
  0x03, 0x00, 0xC0, 0x0C, 0x02, 0x00, 0x30, 0x0A, 0x00, 0xC0, 0x6C, 0x03,
  0x01, 0x98, 0x0C, 0x0C, 0x38, 0x30, 0x60, 0x78, 0xC7, 0x00, 0x3F, 0xE0,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x0F, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x48, 0x0C, 0x00, 0x6C,
  0x03, 0x00, 0x64, 0x01, 0x80, 0x22, 0x00, 0x40, 0x33, 0x00, 0x20, 0x11,
  0x80, 0x10, 0x18, 0xC0, 0x08, 0x08, 0x60, 0x04, 0x08, 0x10, 0x02, 0x0C,
  0x08, 0x03, 0x04, 0x06, 0x01, 0x86, 0x01, 0x01, 0x82, 0x00, 0x61, 0x83,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x18, 0x70, 0xC0, 0x18, 0x20, 0x30, 0x08, 0x30, 0x08, 0x0C,
  0x10, 0x06, 0x04, 0x18, 0x03, 0x06, 0x0C, 0x00, 0x82, 0x06, 0x00, 0x43,
  0x03, 0x00, 0x23, 0x01, 0x80, 0x11, 0x00, 0xC0, 0x19, 0x80, 0x20, 0x0C,
  0x80, 0x18, 0x04, 0xC0, 0x04, 0x06, 0xC0, 0x03, 0x86, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF8, 0x00, 0x06, 0x0C, 0x00, 0x10, 0x0C, 0x00, 0x40, 0x0C,
  0x01, 0x80, 0x08, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x0D,
  0x80, 0x00, 0x31, 0x80, 0x7C, 0xC1, 0x00, 0x83, 0x01, 0x01, 0x04, 0x01,
  0x02, 0x18, 0x03, 0x04, 0x30, 0x03, 0x08, 0x60, 0x03, 0x10, 0x80, 0x02,
  0x61, 0x00, 0x02, 0xC2, 0x00, 0x07, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x0E,
  0x08, 0x00, 0x26, 0x18, 0x00, 0xC6, 0x18, 0x03, 0x06, 0x1C, 0x1C, 0x06,
  0x0F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xE0, 0x30, 0x0C, 0x03, 0x00,
  0x40, 0x10, 0x06, 0x00, 0x80, 0x30, 0x04, 0x01, 0x80, 0x30, 0x04, 0x01,
  0x80, 0x30, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x03, 0x00, 0x60, 0x04, 0x00, 0x80, 0x18,
  0x01, 0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xE0, 0xC0, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00,
  0x80, 0x18, 0x01, 0x00, 0x30, 0x02, 0x00, 0x60, 0x0C, 0x00, 0x80, 0x10,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x20, 0x0C, 0x01,
  0x00, 0x60, 0x08, 0x03, 0x00, 0xC0, 0x10, 0x04, 0x01, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0xE0,
  0x18, 0x06, 0xF8, 0x30, 0x7C, 0x3E, 0x67, 0xC0, 0x0F, 0xF8, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x19, 0x00, 0x00, 0x63, 0x00, 0x00, 0xC3,
  0x00, 0x03, 0x03, 0x00, 0x0C, 0x02, 0x00, 0x30, 0x06, 0x00, 0x60, 0x06,
  0x01, 0x80, 0x06, 0x02, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x1C, 0xE3, 0x8C, 0x30, 0xC6, 0x18, 0x61,
  0x04, 0x30, 0xFF, 0xF0, 0xEF, 0xFE, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00,
  0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x1C, 0x0C, 0x00, 0xC0, 0x08, 0x06,
  0x00, 0x10, 0x10, 0x00, 0x60, 0xC0, 0x00, 0xC2, 0x00, 0x03, 0x18, 0x00,
  0x04, 0x60, 0x00, 0x19, 0x00, 0x00, 0x64, 0x00, 0x01, 0xB0, 0x00, 0x06,
  0xC0, 0x00, 0x0B, 0x00, 0x00, 0x2C, 0x00, 0x00, 0xB0, 0x1C, 0x02, 0xC0,
  0x70, 0x0F, 0x01, 0xC0, 0x3C, 0x00, 0x00, 0xB0, 0x00, 0x02, 0xC0, 0x00,
  0x0B, 0x00, 0x00, 0x2C, 0x00, 0x01, 0x90, 0x00, 0x06, 0x40, 0x00, 0x19,
  0x80, 0x00, 0x66, 0x00, 0x01, 0x08, 0x00, 0x0C, 0x30, 0x00, 0x30, 0x40,
  0x01, 0x81, 0x80, 0x04, 0x03, 0x00, 0x20, 0x07, 0x03, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x70, 0x00, 0x0F, 0x80, 0x00, 0xCC, 0x00, 0x0C, 0x60, 0x00,
  0xC3, 0x00, 0x0C, 0x18, 0x00, 0xC0, 0xC0, 0x1C, 0x06, 0x00, 0x80, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x1F, 0xFF,
  0xFF, 0x07, 0xF8, 0x01, 0xC0, 0x60, 0x30, 0x03, 0x06, 0x00, 0x18, 0x60,
  0x00, 0xCC, 0x00, 0x0C, 0xC0, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x03, 0xFC, 0x00, 0xE0, 0x70, 0x18, 0x01, 0x83, 0x00, 0x0C, 0x60, 0x00,
  0x40, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x03, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x6C, 0x00, 0x06, 0x60, 0x00, 0xC3, 0x00, 0x18, 0x1C, 0x07, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0D, 0x00, 0x00, 0x12,
  0x00, 0x00, 0x64, 0x00, 0x01, 0x88, 0x00, 0x02, 0x10, 0x00, 0x0C, 0x20,
  0x00, 0x30, 0x40, 0x00, 0xC0, 0x80, 0x01, 0x81, 0x00, 0x06, 0x02, 0x00,
  0x18, 0x04, 0x00, 0x30, 0x08, 0x00, 0xC0, 0x10, 0x03, 0x00, 0x20, 0x06,
  0x00, 0x40, 0x18, 0x00, 0x80, 0x60, 0x01, 0x00, 0xC0, 0x02, 0x03, 0x00,
  0x04, 0x0C, 0x00, 0x08, 0x18, 0x00, 0x10, 0x60, 0x00, 0x20, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x3F, 0xFF, 0xC3,
  0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x1F, 0xC0, 0x6E, 0x07, 0x07, 0x00,
  0x18, 0x60, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x4E, 0x00, 0x0C,
  0x70, 0x01, 0x81, 0xC0, 0x60, 0x07, 0xF8, 0x00, 0x00, 0x1C, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x1F, 0xC0, 0x46, 0x07, 0x0C, 0x80, 0x18,
  0xD0, 0x00, 0xCE, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x02, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x24, 0x00, 0x06, 0x60, 0x00, 0x43, 0x00, 0x0C, 0x18,
  0x01, 0x80, 0xE0, 0x60, 0x03, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0xF0, 0x00, 0x0D, 0x80, 0x00, 0x6C, 0x00, 0x06, 0x60, 0x00, 0x33, 0x00,
  0x01, 0x98, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x38, 0x1C,
  0x07, 0x00, 0x30, 0x30, 0x00, 0xC3, 0x00, 0x03, 0x10, 0x00, 0x19, 0x80,
  0x00, 0xCC, 0x00, 0x02, 0x60, 0x00, 0x13, 0x00, 0x00, 0x98, 0x00, 0x0C,
  0x40, 0x00, 0x63, 0x00, 0x03, 0x08, 0x00, 0x30, 0x30, 0x03, 0x00, 0xE0,
  0x70, 0x01, 0xFE, 0x00, 0x70, 0x1C, 0x06, 0x00, 0x18, 0x60, 0x00, 0x66,
  0x00, 0x01, 0x20, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x34, 0x00, 0x01, 0xB0,
  0x00, 0x08, 0xC0, 0x00, 0xC3, 0x00, 0x0C, 0x0E, 0x03, 0x80, 0x0F, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0xE0, 0x70, 0x18, 0x01, 0x83, 0x00, 0x0C, 0x60,
  0x00, 0x44, 0x00, 0x06, 0xC0, 0x00, 0x2C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0x40, 0x00, 0x76, 0x00, 0x07, 0x30, 0x00, 0xA1, 0x80, 0x12, 0x0E, 0x06,
  0x60, 0x3F, 0x86, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00,
  0xEF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0xFF,
  0xE0, 0x38, 0xF3, 0xCE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x73, 0x8E, 0x30, 0xC3, 0x18, 0x61, 0x84,
  0x10, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x00, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x06,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x03, 0xFC, 0x01, 0xC0, 0xE0, 0x60, 0x06, 0x18, 0x00, 0x66, 0x00, 0x04,
  0xC0, 0x00, 0xF0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0xFC, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0xC0, 0xC0,
  0x20, 0x0C, 0x08, 0x00, 0xC3, 0x00, 0x0C, 0x40, 0x00, 0x98, 0x00, 0x13,
  0x00, 0x03, 0x40, 0x00, 0x68, 0x00, 0x0F, 0x00, 0xF9, 0xE0, 0x30, 0x9C,
  0x08, 0x0B, 0x83, 0x00, 0xF0, 0x40, 0x1E, 0x08, 0x03, 0xC3, 0x00, 0x38,
  0x60, 0x07, 0x0C, 0x00, 0xE1, 0x80, 0x1C, 0x30, 0x03, 0x86, 0x00, 0x70,
  0xC0, 0x0E, 0x18, 0x01, 0xC1, 0x00, 0x78, 0x30, 0x0F, 0x06, 0x02, 0xE0,
  0x60, 0x54, 0x07, 0xF2, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x20,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xB0, 0x00, 0x01,
  0x60, 0x00, 0x06, 0x40, 0x00, 0x08, 0xC0, 0x00, 0x11, 0x80, 0x00, 0x61,
  0x00, 0x00, 0x83, 0x00, 0x01, 0x06, 0x00, 0x06, 0x04, 0x00, 0x0C, 0x0C,
  0x00, 0x10, 0x18, 0x00, 0x60, 0x10, 0x00, 0xC0, 0x30, 0x01, 0x00, 0x60,
  0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x10, 0x01, 0x80, 0x60, 0x01, 0x00,
  0xFF, 0xFF, 0x01, 0x00, 0x06, 0x06, 0x00, 0x04, 0x0C, 0x00, 0x0C, 0x10,
  0x00, 0x18, 0x60, 0x00, 0x10, 0xC0, 0x00, 0x31, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x4C, 0x00, 0x00, 0xD0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xFF, 0xFC,
  0x0C, 0x00, 0x70, 0xC0, 0x01, 0x8C, 0x00, 0x0C, 0xC0, 0x00, 0xCC, 0x00,
  0x04, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0,
  0x00, 0x4C, 0x00, 0x0C, 0xC0, 0x00, 0xCC, 0x00, 0x18, 0xC0, 0x07, 0x0F,
  0xFF, 0xC0, 0xC0, 0x03, 0x8C, 0x00, 0x0C, 0xC0, 0x00, 0x6C, 0x00, 0x02,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x02, 0xC0, 0x00, 0x6C, 0x00,
  0x0C, 0xC0, 0x03, 0x8F, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x70, 0x38, 0x0C,
  0x00, 0xC1, 0x80, 0x06, 0x30, 0x00, 0x62, 0x00, 0x03, 0x60, 0x00, 0x24,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x40,
  0x00, 0x06, 0x00, 0x02, 0x20, 0x00, 0x33, 0x00, 0x02, 0x18, 0x00, 0x60,
  0xC0, 0x0C, 0x07, 0x03, 0x80, 0x1F, 0xC0, 0xFF, 0xF0, 0x10, 0x01, 0x82,
  0x00, 0x1C, 0x40, 0x00, 0x88, 0x00, 0x19, 0x00, 0x01, 0xA0, 0x00, 0x34,
  0x00, 0x02, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x50, 0x00, 0x1A, 0x00, 0x03, 0x40,
  0x00, 0xC8, 0x00, 0x11, 0x00, 0x06, 0x20, 0x03, 0x07, 0xFF, 0x80, 0xFF,
  0xFF, 0xF0, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x07, 0xFF,
  0xFE, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x07, 0xFF, 0xFE, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x18, 0x1C,
  0x03, 0x00, 0x30, 0x30, 0x00, 0xC1, 0x00, 0x03, 0x18, 0x00, 0x18, 0x80,
  0x00, 0x8C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x07, 0xFF, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0D, 0x00, 0x00, 0x68, 0x00, 0x03, 0x60, 0x00,
  0x1B, 0x00, 0x00, 0xD8, 0x00, 0x06, 0x40, 0x00, 0x33, 0x00, 0x03, 0x88,
  0x00, 0x1C, 0x60, 0x01, 0x61, 0x80, 0x13, 0x03, 0x03, 0x18, 0x07, 0xE0,
  0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x07, 0xFF, 0xFF, 0x1F, 0xFF, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x38, 0x00, 0x34, 0x00, 0x13, 0x00,
  0x18, 0xC0, 0x18, 0x38, 0x18, 0x07, 0xF0, 0x00, 0x80, 0x00, 0x34, 0x00,
  0x03, 0x20, 0x00, 0x31, 0x00, 0x03, 0x08, 0x00, 0x30, 0x40, 0x03, 0x82,
  0x00, 0x18, 0x10, 0x01, 0x80, 0x80, 0x18, 0x04, 0x01, 0x80, 0x20, 0x18,
  0x01, 0x01, 0x80, 0x08, 0x18, 0x00, 0x41, 0x80, 0x02, 0x1E, 0x00, 0x10,
  0xD8, 0x00, 0x8C, 0xC0, 0x04, 0xC3, 0x00, 0x2C, 0x0C, 0x01, 0xC0, 0x60,
  0x0C, 0x01, 0x80, 0x40, 0x06, 0x02, 0x00, 0x30, 0x10, 0x00, 0xC0, 0x80,
  0x03, 0x04, 0x00, 0x18, 0x20, 0x00, 0x61, 0x00, 0x01, 0x88, 0x00, 0x0C,
  0x40, 0x00, 0x32, 0x00, 0x00, 0xD0, 0x00, 0x07, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0xFB, 0x00, 0x0B, 0xB0, 0x00, 0xB9, 0x80, 0x1B, 0x98,
  0x01, 0x38, 0x80, 0x33, 0x8C, 0x02, 0x38, 0x40, 0x63, 0x86, 0x04, 0x38,
  0x20, 0xC3, 0x83, 0x08, 0x38, 0x31, 0x83, 0x81, 0x98, 0x38, 0x19, 0x03,
  0x80, 0xF0, 0x38, 0x0E, 0x03, 0x80, 0x60, 0x38, 0x04, 0x03, 0x80, 0x40,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0xE8,
  0x00, 0x1D, 0x80, 0x03, 0x90, 0x00, 0x73, 0x00, 0x0E, 0x20, 0x01, 0xC6,
  0x00, 0x38, 0x40, 0x07, 0x0C, 0x00, 0xE0, 0x80, 0x1C, 0x18, 0x03, 0x81,
  0x00, 0x70, 0x30, 0x0E, 0x02, 0x01, 0xC0, 0x60, 0x38, 0x04, 0x07, 0x00,
  0xC0, 0xE0, 0x08, 0x1C, 0x01, 0x83, 0x80, 0x10, 0x70, 0x03, 0x0E, 0x00,
  0x21, 0xC0, 0x06, 0x38, 0x00, 0x47, 0x00, 0x0C, 0xE0, 0x00, 0x9C, 0x00,
  0x1B, 0x80, 0x01, 0x70, 0x00, 0x3E, 0x00, 0x03, 0x00, 0xFC, 0x00, 0x1C,
  0x0C, 0x00, 0xC0, 0x08, 0x06, 0x00, 0x10, 0x10, 0x00, 0x60, 0xC0, 0x00,
  0xC2, 0x00, 0x03, 0x18, 0x00, 0x04, 0x60, 0x00, 0x19, 0x00, 0x00, 0x64,
  0x00, 0x01, 0xB0, 0x00, 0x06, 0xC0, 0x00, 0x0B, 0x00, 0x00, 0x2C, 0x00,
  0x00, 0xB0, 0x00, 0x02, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xB0, 0x00, 0x02, 0xC0, 0x00, 0x0B, 0x00, 0x00, 0x2C, 0x00, 0x01, 0x90,
  0x00, 0x06, 0x40, 0x00, 0x19, 0x80, 0x00, 0x66, 0x00, 0x01, 0x08, 0x00,
  0x0C, 0x30, 0x00, 0x30, 0x40, 0x01, 0x81, 0x80, 0x04, 0x03, 0x00, 0x20,
  0x07, 0x03, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0xFC, 0x10, 0x00, 0x62, 0x00,
  0x02, 0x40, 0x00, 0x68, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x01, 0xA0, 0x00, 0x24, 0x00, 0x18, 0xFF, 0xFE, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x1C, 0x0C, 0x00, 0xC0, 0x08, 0x06, 0x00, 0x10, 0x10, 0x00, 0x60,
  0xC0, 0x00, 0xC2, 0x00, 0x03, 0x18, 0x00, 0x04, 0x60, 0x00, 0x19, 0x00,
  0x00, 0x64, 0x00, 0x01, 0xB0, 0x00, 0x06, 0xC0, 0x00, 0x0B, 0x00, 0x00,
  0x2C, 0x00, 0x00, 0xB0, 0x00, 0x02, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xB0, 0x00, 0x02, 0xC0, 0x00, 0x0B, 0x00, 0x00, 0x2C, 0x00,
  0x01, 0x90, 0x00, 0x06, 0x40, 0x00, 0x19, 0x80, 0x00, 0x66, 0x00, 0x01,
  0x08, 0x00, 0x0C, 0x30, 0x00, 0x30, 0x40, 0x01, 0x81, 0x80, 0x04, 0x03,
  0x00, 0x20, 0x07, 0x03, 0x00, 0x07, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x07, 0xF8,
  0xFF, 0xFC, 0x10, 0x00, 0x62, 0x00, 0x02, 0x40, 0x00, 0x68, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xA0, 0x00, 0x24,
  0x00, 0x18, 0xFF, 0xFE, 0x10, 0x08, 0x02, 0x01, 0x80, 0x40, 0x18, 0x08,
  0x03, 0x01, 0x00, 0x30, 0x20, 0x02, 0x04, 0x00, 0x60, 0x80, 0x06, 0x10,
  0x00, 0xC2, 0x00, 0x0C, 0x40, 0x00, 0xC8, 0x00, 0x19, 0x00, 0x01, 0xA0,
  0x00, 0x34, 0x00, 0x03, 0x01, 0xFF, 0x00, 0x70, 0x0E, 0x06, 0x00, 0x1C,
  0x60, 0x00, 0x76, 0x00, 0x01, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x02,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x09, 0x80,
  0x00, 0xC7, 0x00, 0x0C, 0x1E, 0x01, 0x80, 0x1F, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x40, 0x00, 0x68, 0x00, 0x0D,
  0x00, 0x01, 0xB0, 0x00, 0x26, 0x00, 0x04, 0x60, 0x01, 0x84, 0x00, 0x60,
  0x60, 0x38, 0x03, 0xFC, 0x00, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x0D, 0x80,
  0x00, 0x1B, 0x00, 0x00, 0x63, 0x00, 0x00, 0xC6, 0x00, 0x01, 0x8C, 0x00,
  0x06, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x30, 0x00, 0x60, 0x20, 0x00,
  0xC0, 0x60, 0x01, 0x80, 0xC0, 0x02, 0x00, 0x80, 0x0C, 0x01, 0x80, 0x18,
  0x03, 0x00, 0x20, 0x02, 0x00, 0xC0, 0x06, 0x01, 0x80, 0x0C, 0x02, 0x00,
  0x08, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x30, 0x20, 0x00, 0x20, 0xC0, 0x00,
  0x61, 0x80, 0x00, 0xC2, 0x00, 0x00, 0x8C, 0x00, 0x01, 0x98, 0x00, 0x03,
  0x20, 0x00, 0x02, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0xC0, 0x00, 0x02, 0x80, 0x00, 0x05, 0x00, 0x00, 0x1A, 0x00, 0x00,
  0x34, 0x00, 0x00, 0x68, 0x00, 0x00, 0xD8, 0x00, 0x01, 0xB0, 0x00, 0x02,
  0x60, 0x00, 0x04, 0xC0, 0x30, 0x09, 0x80, 0xE0, 0x13, 0x01, 0xE0, 0x22,
  0x02, 0xC0, 0x44, 0x04, 0x81, 0x88, 0x19, 0x03, 0x10, 0x33, 0x06, 0x20,
  0x46, 0x0C, 0x61, 0x84, 0x18, 0xC3, 0x08, 0x21, 0x84, 0x18, 0x43, 0x08,
  0x30, 0x86, 0x30, 0x21, 0x04, 0x60, 0x62, 0x08, 0x80, 0xC4, 0x11, 0x00,
  0x98, 0x26, 0x01, 0x30, 0x4C, 0x03, 0x60, 0xD0, 0x06, 0xC1, 0xE0, 0x05,
  0x83, 0xC0, 0x0A, 0x07, 0x00, 0x1C, 0x0E, 0x00, 0x38, 0xE0, 0x00, 0x06,
  0x60, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x18, 0x00, 0x30,
  0x0C, 0x00, 0x30, 0x06, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x03, 0x00, 0xC0,
  0x01, 0x81, 0x80, 0x01, 0x83, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x2C, 0x00, 0x00, 0x66, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x83, 0x00,
  0x01, 0x81, 0x80, 0x03, 0x01, 0x80, 0x03, 0x00, 0xC0, 0x06, 0x00, 0x60,
  0x0C, 0x00, 0x60, 0x0C, 0x00, 0x30, 0x18, 0x00, 0x18, 0x30, 0x00, 0x18,
  0x30, 0x00, 0x0C, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xB0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0xC6, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x60, 0x60, 0x00, 0x60, 0x30, 0x00, 0x60, 0x0C, 0x00, 0x30, 0x02, 0x00,
  0x30, 0x01, 0x80, 0x10, 0x00, 0x60, 0x18, 0x00, 0x30, 0x18, 0x00, 0x0C,
  0x0C, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x16, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0xFF, 0xE0, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00,
  0x18, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18,
  0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80,
  0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00,
  0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00,
  0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x02,
  0x00, 0x00, 0xC0, 0xFF, 0xF0, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0xFF, 0xF0, 0x00, 0x30, 0x00, 0x01, 0xE0, 0x00, 0x0D,
  0x80, 0x00, 0x33, 0x00, 0x01, 0x84, 0x00, 0x04, 0x18, 0x00, 0x30, 0x30,
  0x01, 0x80, 0xC0, 0x06, 0x01, 0x80, 0x30, 0x02, 0x00, 0x80, 0x0C, 0x06,
  0x00, 0x10, 0x10, 0x00, 0x60, 0xC0, 0x00, 0xC6, 0x00, 0x03, 0x10, 0x00,
  0x06, 0xC0, 0x00, 0x0A, 0x00, 0x00, 0x30, 0xFF, 0xFF, 0xFC, 0x43, 0x06,
  0x0C, 0x10, 0x60, 0xC1, 0x03, 0xF8, 0x00, 0x38, 0x38, 0x01, 0x80, 0x30,
  0x0C, 0x00, 0x60, 0x20, 0x00, 0x81, 0x80, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x07, 0xFF, 0xC0, 0x70, 0x03, 0x03, 0x00, 0x0C, 0x18, 0x00, 0x30,
  0x40, 0x00, 0xC3, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x10, 0x00, 0x30, 0x40,
  0x00, 0xC1, 0x80, 0x07, 0x03, 0x00, 0x2C, 0x06, 0x03, 0x1F, 0x07, 0xF0,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x0F, 0xE0, 0x66, 0x07, 0x0D, 0x00, 0x31, 0xC0, 0x03, 0x38, 0x00,
  0x36, 0x00, 0x06, 0xC0, 0x00, 0x58, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x05, 0x80, 0x01,
  0xB8, 0x00, 0x37, 0x00, 0x0C, 0xD0, 0x03, 0x19, 0x81, 0xC0, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x03, 0x81, 0x81, 0x80, 0x18, 0xC0, 0x02, 0x60, 0x00,
  0xD8, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x02, 0x60, 0x00,
  0xCC, 0x00, 0x31, 0x80, 0x18, 0x38, 0x1C, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x07, 0xE0,
  0x83, 0x03, 0x10, 0xC0, 0x12, 0x30, 0x01, 0x4C, 0x00, 0x19, 0x00, 0x03,
  0x60, 0x00, 0x2C, 0x00, 0x05, 0x00, 0x00, 0xA0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x40, 0x00, 0x28, 0x00, 0x05,
  0x00, 0x00, 0xB0, 0x00, 0x16, 0x00, 0x06, 0x40, 0x00, 0xCC, 0x00, 0x18,
  0x80, 0x05, 0x0C, 0x01, 0x20, 0xC0, 0xC4, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0xE0, 0x60, 0x18, 0x01, 0x03, 0x00, 0x08, 0x20, 0x00, 0xC6, 0x00,
  0x04, 0x60, 0x00, 0x6C, 0x00, 0x02, 0xC0, 0x00, 0x2C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x02,
  0x20, 0x00, 0x63, 0x00, 0x0C, 0x18, 0x01, 0x80, 0xE0, 0x70, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0xF8, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x04,
  0x00, 0x1F, 0x90, 0x01, 0x81, 0xC0, 0x08, 0x01, 0x80, 0x40, 0x06, 0x03,
  0x00, 0x0C, 0x0C, 0x00, 0x30, 0x20, 0x00, 0xC0, 0x80, 0x03, 0x02, 0x00,
  0x0C, 0x08, 0x00, 0x30, 0x30, 0x00, 0xC0, 0xC0, 0x02, 0x01, 0x00, 0x18,
  0x02, 0x00, 0x40, 0x06, 0x06, 0x00, 0x1F, 0xE0, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x60, 0x01, 0x86, 0x00, 0x01, 0x30, 0x00, 0x06,
  0xC0, 0x00, 0x0B, 0x00, 0x00, 0x2C, 0x00, 0x01, 0xB0, 0x00, 0x06, 0xC0,
  0x00, 0x11, 0x80, 0x01, 0xC3, 0x80, 0x1C, 0x01, 0xFF, 0x80, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x21, 0xFC, 0x13, 0x03, 0x8A,
  0x00, 0x66, 0x00, 0x13, 0x00, 0x0D, 0x00, 0x02, 0x80, 0x01, 0x40, 0x00,
  0xA0, 0x00, 0x50, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x0F, 0xFF, 0xFF,
  0x00, 0x07, 0x00, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x9F, 0xFF, 0x80, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0xEC,
  0x00, 0x18, 0xC0, 0x03, 0x0C, 0x00, 0x60, 0xC0, 0x0C, 0x0C, 0x03, 0x80,
  0xC0, 0x60, 0x0C, 0x0C, 0x00, 0xC1, 0x80, 0x0C, 0x30, 0x00, 0xC7, 0x80,
  0x0C, 0xCC, 0x00, 0xD8, 0x60, 0x0E, 0x07, 0x00, 0xC0, 0x30, 0x0C, 0x01,
  0x80, 0xC0, 0x0C, 0x0C, 0x00, 0x60, 0xC0, 0x07, 0x0C, 0x00, 0x30, 0xC0,
  0x01, 0x8C, 0x00, 0x0C, 0xC0, 0x00, 0x6C, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x0F, 0xFF, 0xFF, 0xCF, 0x83,
  0xE6, 0x86, 0x21, 0xB8, 0x1A, 0x07, 0x80, 0x60, 0x1C, 0x03, 0x00, 0xE0,
  0x18, 0x07, 0x00, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0x80,
  0x70, 0x0C, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x00, 0xE0, 0x18, 0x07, 0x00,
  0xC0, 0x38, 0x06, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0x80, 0x70, 0x0C, 0x03,
  0x80, 0x60, 0x1C, 0x03, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xC0, 0x38, 0x06,
  0x01, 0x87, 0xF0, 0x4C, 0x0E, 0x28, 0x01, 0x98, 0x00, 0x4C, 0x00, 0x34,
  0x00, 0x0A, 0x00, 0x05, 0x00, 0x02, 0x80, 0x01, 0x40, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x03, 0xF8, 0x00, 0xE0, 0x60, 0x18, 0x01, 0x03,
  0x00, 0x08, 0x20, 0x00, 0xC6, 0x00, 0x06, 0x40, 0x00, 0x6C, 0x00, 0x02,
  0xC0, 0x00, 0x2C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x2C, 0x00,
  0x02, 0x40, 0x00, 0x66, 0x00, 0x06, 0x20, 0x00, 0xC3, 0x00, 0x08, 0x18,
  0x01, 0x00, 0xE0, 0x60, 0x03, 0xF8, 0x00, 0xC3, 0xF8, 0x19, 0x81, 0xC3,
  0x40, 0x0C, 0x70, 0x00, 0xCE, 0x00, 0x0D, 0x80, 0x01, 0xB0, 0x00, 0x16,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0x60, 0x00, 0x6E, 0x00, 0x0D, 0xC0, 0x03, 0x34,
  0x00, 0xC6, 0x60, 0x70, 0xC3, 0xF8, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0xF8, 0x20, 0xC0, 0xC4, 0x30, 0x04, 0x8C, 0x00, 0x53,
  0x00, 0x06, 0x40, 0x00, 0xD8, 0x00, 0x0B, 0x00, 0x01, 0x40, 0x00, 0x28,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x50,
  0x00, 0x0A, 0x00, 0x01, 0x40, 0x00, 0x2C, 0x00, 0x05, 0x80, 0x01, 0x90,
  0x00, 0x33, 0x00, 0x06, 0x20, 0x01, 0x43, 0x00, 0x48, 0x30, 0x31, 0x01,
  0xF8, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0xFF, 0x83, 0xFC,
  0x02, 0x30, 0x00, 0x09, 0x00, 0x00, 0x28, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00,
  0x3F, 0xFF, 0xF8, 0x03, 0xFC, 0x00, 0xC0, 0x70, 0x30, 0x01, 0xC2, 0x00,
  0x06, 0x60, 0x00, 0x46, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x26, 0x00, 0x06, 0x30, 0x00,
  0xC0, 0xE0, 0x38, 0x03, 0xFC, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x30, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x68, 0x00, 0x34, 0x00, 0x1B, 0x00, 0x1C, 0xC0, 0x16, 0x38,
  0x33, 0x07, 0xE0, 0x00, 0xC0, 0x00, 0x3C, 0x00, 0x06, 0x60, 0x00, 0x66,
  0x00, 0x04, 0x20, 0x00, 0xC3, 0x00, 0x0C, 0x30, 0x00, 0x81, 0x00, 0x18,
  0x18, 0x01, 0x81, 0x80, 0x10, 0x08, 0x03, 0x00, 0xC0, 0x20, 0x04, 0x06,
  0x00, 0x60, 0x60, 0x06, 0x04, 0x00, 0x20, 0xC0, 0x03, 0x0C, 0x00, 0x30,
  0x80, 0x01, 0x18, 0x00, 0x19, 0x00, 0x01, 0x90, 0x00, 0x0B, 0x00, 0x00,
  0xE0, 0x00, 0x06, 0x00, 0x80, 0x18, 0x03, 0x80, 0x38, 0x03, 0xC0, 0x38,
  0x03, 0xC0, 0x2C, 0x02, 0xC0, 0x24, 0x02, 0x40, 0x64, 0x02, 0x40, 0x64,
  0x06, 0x40, 0x46, 0x06, 0x60, 0x42, 0x04, 0x60, 0xC2, 0x04, 0x20, 0xC2,
  0x04, 0x20, 0x83, 0x04, 0x20, 0x81, 0x0C, 0x20, 0x81, 0x0C, 0x31, 0x81,
  0x08, 0x31, 0x01, 0x88, 0x11, 0x00, 0x88, 0x11, 0x00, 0x88, 0x13, 0x00,
  0x98, 0x12, 0x00, 0xD0, 0x1A, 0x00, 0x50, 0x1A, 0x00, 0x50, 0x0E, 0x00,
  0x50, 0x0C, 0x00, 0x70, 0xC0, 0x00, 0x76, 0x00, 0x06, 0x30, 0x00, 0xC1,
  0x00, 0x18, 0x18, 0x03, 0x00, 0xC0, 0x30, 0x06, 0x06, 0x00, 0x60, 0xC0,
  0x03, 0x18, 0x00, 0x19, 0x80, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0F, 0x00, 0x01, 0x98, 0x00, 0x31, 0x80, 0x06, 0x0C, 0x00, 0x60,
  0x60, 0x0C, 0x03, 0x01, 0x80, 0x30, 0x30, 0x01, 0x83, 0x00, 0x0C, 0x60,
  0x00, 0x6C, 0x00, 0x07, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0xC8, 0x00, 0x0C,
  0x60, 0x00, 0x63, 0x00, 0x02, 0x08, 0x00, 0x30, 0x60, 0x01, 0x01, 0x00,
  0x18, 0x0C, 0x00, 0xC0, 0x60, 0x04, 0x01, 0x00, 0x60, 0x0C, 0x02, 0x00,
  0x20, 0x30, 0x01, 0x81, 0x80, 0x0C, 0x08, 0x00, 0x30, 0xC0, 0x01, 0x84,
  0x00, 0x04, 0x60, 0x00, 0x32, 0x00, 0x00, 0xB0, 0x00, 0x07, 0x80, 0x00,
  0x38, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x20, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0x40, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0xFF,
  0xFF, 0x01, 0xFF, 0x80, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x20,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x18, 0x0F, 0xF0, 0x00, 0x0E, 0x00,
  0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x20, 0x00, 0x30, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x03,
  0xF8, 0x0F, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0xFF, 0xC0, 0x00, 0x0F, 0x00, 0x04, 0xC6,
  0x00, 0x36, 0x04, 0x00, 0x90, 0x08, 0x02, 0xC0, 0x30, 0x1A, 0x00, 0x60,
  0x48, 0x00, 0xC2, 0x20, 0x00, 0xF0,
};

const GFXglyph IBMPlexMono_ExtraLight46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 28, 0, -1 },
  { 1, 4, 32, 28, 12, -32 },
  { 17, 8, 12, 28, 10, -34 },
  { 29, 26, 32, 28, 1, -32 },
  { 133, 22, 44, 28, 3, -38 },
  { 254, 25, 34, 28, 1, -33 },
  { 361, 23, 34, 28, 2, -33 },
  { 459, 2, 12, 28, 13, -34 },
  { 462, 11, 41, 28, 11, -35 },
  { 519, 11, 41, 28, 6, -35 },
  { 576, 23, 23, 28, 2, -25 },
  { 643, 22, 21, 28, 3, -25 },
  { 701, 6, 12, 28, 10, -4 },
  { 710, 12, 1, 28, 8, -15 },
  { 712, 4, 4, 28, 12, -4 },
  { 714, 18, 41, 28, 5, -35 },
  { 807, 22, 34, 28, 3, -33 },
  { 901, 21, 32, 28, 4, -32 },
  { 985, 20, 33, 28, 4, -33 },
  { 1068, 20, 34, 28, 3, -33 },
  { 1153, 23, 32, 28, 2, -32 },
  { 1245, 20, 33, 28, 4, -32 },
  { 1328, 20, 33, 28, 4, -32 },
  { 1411, 21, 32, 28, 3, -32 },
  { 1495, 21, 34, 28, 3, -33 },
  { 1585, 20, 33, 28, 4, -33 },
  { 1668, 4, 25, 28, 12, -25 },
  { 1681, 6, 33, 28, 10, -25 },
  { 1706, 20, 25, 28, 4, -27 },
  { 1769, 22, 10, 28, 3, -19 },
  { 1797, 20, 25, 28, 4, -27 },
  { 1860, 19, 33, 28, 4, -33 },
  { 1939, 19, 38, 28, 4, -33 },
  { 2030, 23, 32, 28, 2, -32 },
  { 2122, 20, 32, 28, 4, -32 },
  { 2202, 20, 34, 28, 4, -33 },
  { 2287, 19, 32, 28, 5, -32 },
  { 2363, 19, 32, 28, 5, -32 },
  { 2439, 19, 32, 28, 5, -32 },
  { 2515, 21, 34, 28, 3, -33 },
  { 2605, 19, 32, 28, 4, -32 },
  { 2681, 19, 32, 28, 4, -32 },
  { 2757, 17, 33, 28, 4, -32 },
  { 2828, 21, 32, 28, 5, -32 },
  { 2912, 18, 32, 28, 6, -32 },
  { 2984, 20, 32, 28, 4, -32 },
  { 3064, 19, 32, 28, 4, -32 },
  { 3140, 22, 34, 28, 3, -33 },
  { 3234, 19, 32, 28, 5, -32 },
  { 3310, 22, 40, 28, 3, -33 },
  { 3420, 19, 32, 28, 5, -32 },
  { 3496, 21, 34, 28, 3, -33 },
  { 3586, 24, 32, 28, 2, -32 },
  { 3682, 19, 33, 28, 4, -32 },
  { 3761, 23, 32, 28, 2, -32 },
  { 3853, 23, 32, 28, 2, -32 },
  { 3945, 24, 32, 28, 2, -32 },
  { 4041, 25, 32, 28, 1, -32 },
  { 4141, 23, 32, 28, 2, -32 },
  { 4233, 11, 41, 28, 12, -35 },
  { 4290, 18, 41, 28, 5, -35 },
  { 4383, 12, 41, 28, 4, -35 },
  { 4445, 22, 18, 28, 3, -32 },
  { 4495, 22, 1, 28, 3, 6 },
  { 4498, 6, 8, 28, 9, -35 },
  { 4504, 22, 25, 28, 3, -24 },
  { 4573, 19, 35, 28, 5, -34 },
  { 4657, 18, 25, 28, 5, -24 },
  { 4714, 19, 35, 28, 3, -34 },
  { 4798, 20, 25, 28, 4, -24 },
  { 4861, 21, 34, 28, 4, -34 },
  { 4951, 22, 36, 28, 4, -26 },
  { 5050, 17, 34, 28, 6, -34 },
  { 5123, 20, 34, 28, 5, -34 },
  { 5208, 17, 43, 28, 4, -34 },
  { 5300, 20, 34, 28, 6, -34 },
  { 5385, 20, 34, 28, 4, -34 },
  { 5470, 21, 24, 28, 3, -24 },
  { 5533, 17, 24, 28, 6, -24 },
  { 5584, 20, 25, 28, 4, -24 },
  { 5647, 19, 33, 28, 5, -24 },
  { 5726, 19, 33, 28, 3, -24 },
  { 5805, 22, 24, 28, 4, -24 },
  { 5871, 20, 25, 28, 4, -24 },
  { 5934, 22, 32, 28, 2, -32 },
  { 6022, 17, 25, 28, 5, -24 },
  { 6076, 20, 24, 28, 4, -24 },
  { 6136, 24, 24, 28, 2, -24 },
  { 6208, 20, 24, 28, 4, -24 },
  { 6268, 21, 33, 28, 3, -24 },
  { 6355, 18, 24, 28, 5, -24 },
  { 6409, 17, 41, 28, 5, -35 },
  { 6497, 2, 41, 28, 13, -35 },
  { 6508, 17, 41, 28, 5, -35 },
  { 6596, 22, 8, 28, 3, -18 },
};

const GFXfont IBMPlexMono_ExtraLight46pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLight46pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLight46pt7bGlyphs,
  0x20, 0x7E, 60
};

#endif // _IBMPLEXMONO_EXTRALIGHT46PT7B_H_
