#ifndef _IBMPLEXMONO_EXTRALIGHT56PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHT56PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLight.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLight56pt7bBitmaps[] PROGMEM = {
  0x00, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31,
  0x8C, 0x63, 0x18, 0xC4, 0x21, 0x08, 0x40, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFD, 0xE0, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x30, 0x00, 0x06, 0x01, 0x80,
  0x00, 0x0C, 0x03, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x30, 0x0C, 0x00,
  0x00, 0x40, 0x30, 0x00, 0x01, 0x80, 0x60, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x06, 0x01, 0x80, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00,
  0x60, 0x18, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x01, 0x80, 0x60, 0x07, 0xFF,
  0x00, 0xFF, 0xCF, 0xFE, 0x01, 0xFF, 0x80, 0x0C, 0x02, 0x00, 0x00, 0x30,
  0x0C, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x01, 0x80,
  0x60, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x04, 0x03, 0x00, 0x00, 0x18, 0x06,
  0x00, 0x00, 0x30, 0x0C, 0x00, 0xFF, 0xE0, 0x1F, 0xFD, 0xFF, 0xC0, 0x3F,
  0xF8, 0x01, 0x80, 0x60, 0x00, 0x06, 0x01, 0x80, 0x00, 0x0C, 0x03, 0x00,
  0x00, 0x18, 0x06, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x60, 0x18, 0x00,
  0x00, 0xC0, 0x20, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x0C, 0x03, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00,
  0xC0, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xC6, 0x3E, 0x01, 0xC0,
  0xC0, 0xE0, 0x70, 0x18, 0x0E, 0x1C, 0x03, 0x00, 0x63, 0x00, 0x60, 0x08,
  0x60, 0x0C, 0x00, 0x0C, 0x01, 0x80, 0x03, 0x80, 0x30, 0x00, 0x70, 0x06,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0xC0, 0x18, 0x00, 0x18, 0x03, 0x00, 0x03,
  0x80, 0x60, 0x00, 0x30, 0x0C, 0x00, 0x07, 0x01, 0x80, 0x00, 0x78, 0x30,
  0x00, 0x07, 0xF6, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x03, 0x7F, 0x00, 0x00, 0x60, 0xF0, 0x00, 0x0C, 0x07, 0x00, 0x01, 0x80,
  0x70, 0x00, 0x30, 0x06, 0x00, 0x06, 0x00, 0xC0, 0x00, 0xC0, 0x0C, 0x00,
  0x18, 0x01, 0x80, 0x03, 0x00, 0x30, 0x00, 0x60, 0x06, 0x00, 0x0C, 0x00,
  0xC0, 0x01, 0x80, 0x1A, 0x00, 0x30, 0x06, 0xE0, 0x06, 0x00, 0xCE, 0x00,
  0xC0, 0x38, 0xE0, 0x18, 0x0E, 0x0F, 0x03, 0x03, 0x80, 0x7C, 0x63, 0xE0,
  0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x0C, 0x70,
  0x70, 0x00, 0x31, 0xC0, 0x30, 0x00, 0x63, 0x00, 0x30, 0x01, 0x8C, 0x00,
  0x60, 0x03, 0x18, 0x00, 0xC0, 0x0C, 0x30, 0x00, 0x80, 0x10, 0x60, 0x01,
  0x00, 0x60, 0xC0, 0x03, 0x01, 0x81, 0x80, 0x06, 0x03, 0x03, 0x00, 0x08,
  0x0C, 0x06, 0x00, 0x30, 0x10, 0x0C, 0x00, 0x60, 0x60, 0x0C, 0x00, 0xC1,
  0x80, 0x1C, 0x03, 0x03, 0x00, 0x1C, 0x1C, 0x0C, 0x00, 0x1F, 0xF0, 0x18,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x18, 0x1F, 0xF8,
  0x00, 0x60, 0x70, 0x78, 0x00, 0xC1, 0xC0, 0x30, 0x03, 0x03, 0x00, 0x30,
  0x06, 0x04, 0x00, 0x60, 0x18, 0x18, 0x00, 0x60, 0x20, 0x30, 0x00, 0xC0,
  0xC0, 0x60, 0x01, 0x83, 0x00, 0xC0, 0x03, 0x06, 0x01, 0x80, 0x06, 0x18,
  0x03, 0x00, 0x0C, 0x30, 0x06, 0x00, 0x18, 0xC0, 0x04, 0x00, 0x63, 0x00,
  0x0C, 0x00, 0xC6, 0x00, 0x1C, 0x03, 0x18, 0x00, 0x1C, 0x1E, 0x30, 0x00,
  0x1F, 0xF8, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xF0, 0x38, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x60, 0x03, 0x80,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x50, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x07, 0xC0, 0x07, 0xF0, 0x77, 0x00, 0x3F, 0x8E, 0x1C,
  0x01, 0x80, 0x60, 0x70, 0x0C, 0x06, 0x01, 0xC0, 0x60, 0x70, 0x06, 0x03,
  0x03, 0x00, 0x18, 0x18, 0x18, 0x00, 0x60, 0xC1, 0x80, 0x03, 0x86, 0x0C,
  0x00, 0x0E, 0x20, 0x60, 0x00, 0x3B, 0x03, 0x00, 0x00, 0xD8, 0x18, 0x00,
  0x03, 0xC0, 0xC0, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x70, 0x18, 0x00, 0x07,
  0xC0, 0xE0, 0x00, 0x27, 0x03, 0x00, 0x03, 0x1C, 0x1E, 0x00, 0x70, 0x70,
  0x7C, 0x0F, 0x01, 0x80, 0xFF, 0xF0, 0x06, 0x01, 0xFC, 0x00, 0x08, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0x00,
  0x18, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x40, 0x02, 0x00, 0x18, 0x00,
  0xC0, 0x02, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x40, 0x03,
  0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03,
  0x80, 0x06, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00,
  0x60, 0x00, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x08, 0x00, 0x20, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18,
  0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0xE0, 0x06, 0x00, 0x7F, 0xC0,
  0x60, 0x7E, 0x1F, 0x86, 0x3F, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00,
  0x31, 0xC0, 0x00, 0x07, 0x0C, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x0C, 0x03,
  0x00, 0x01, 0x80, 0x38, 0x00, 0x38, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00,
  0x60, 0x00, 0xE0, 0x0C, 0x00, 0x06, 0x00, 0x40, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x3C, 0xF3, 0x8E,
  0x31, 0xC7, 0x18, 0x63, 0x8C, 0x30, 0xC2, 0x00, 0xFF, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFE, 0xF0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x78, 0x0F, 0x00, 0x38, 0x00,
  0xE0, 0x1C, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x83, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x0C, 0x60, 0x00, 0x03, 0x18, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x06, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x01,
  0xC0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x01, 0x98, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x19, 0x80, 0x00, 0x0E, 0x60, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x60, 0x60, 0x00, 0x38, 0x1C, 0x00, 0x0C,
  0x03, 0x80, 0x0E, 0x00, 0x78, 0x0F, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x73, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x07, 0x0C, 0x00, 0x01, 0xC1,
  0x80, 0x00, 0x70, 0x30, 0x00, 0x3C, 0x06, 0x00, 0x0F, 0x00, 0xC0, 0x03,
  0xC0, 0x18, 0x00, 0x30, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xF8, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0x01, 0xE0, 0x1C,
  0x00, 0x70, 0x30, 0x00, 0x38, 0x70, 0x00, 0x18, 0xE0, 0x00, 0x1C, 0xC0,
  0x00, 0x0C, 0xC0, 0x00, 0x0C, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0x01, 0xF0, 0x1C,
  0x00, 0x38, 0x38, 0x00, 0x1C, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x0E, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xE0,
  0x00, 0x0C, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x1F, 0x01, 0xF0, 0x07,
  0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x06, 0x60, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x30, 0x30, 0x00, 0x01, 0x81, 0x80, 0x00, 0x18, 0x0C,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x0C, 0x03, 0x00, 0x00, 0xC0, 0x18, 0x00,
  0x0C, 0x00, 0xC0, 0x00, 0xC0, 0x06, 0x00, 0x06, 0x00, 0x30, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x03, 0x00, 0x03,
  0x00, 0x30, 0x00, 0x18, 0x01, 0x80, 0x00, 0xC0, 0x18, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x30, 0x08, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x0C, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x60, 0xFF, 0x00, 0x63, 0xFF, 0xE0, 0x67, 0x01, 0xF0,
  0x6C, 0x00, 0x38, 0x70, 0x00, 0x1C, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x0C,
  0x70, 0x00, 0x18, 0x38, 0x00, 0x38, 0x1F, 0x01, 0xF0, 0x07, 0xFF, 0xC0,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x60, 0xFF, 0x00, 0x63, 0xFF, 0xE0, 0x67, 0x01, 0xF0,
  0xCC, 0x00, 0x38, 0xD0, 0x00, 0x1C, 0xF0, 0x00, 0x0C, 0xE0, 0x00, 0x06,
  0xC0, 0x00, 0x06, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x40, 0x00, 0x06, 0x60, 0x00, 0x06, 0x70, 0x00, 0x0C,
  0x38, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x0F, 0x01, 0xF0, 0x07, 0xFF, 0xC0,
  0x00, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x36, 0x00, 0x00, 0x33, 0x00, 0x00,
  0x19, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x0E, 0x30, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xFC, 0x00,
  0xF8, 0x07, 0x80, 0x78, 0x00, 0x70, 0x18, 0x00, 0x0E, 0x0C, 0x00, 0x01,
  0xC3, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x03, 0x18, 0x00,
  0x00, 0xC6, 0x00, 0x00, 0x39, 0x80, 0x00, 0x0C, 0x70, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x60, 0x60, 0x00, 0x38, 0x0E, 0x00, 0x1C,
  0x01, 0xE0, 0x1E, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x07, 0x80,
  0x78, 0x07, 0x00, 0x07, 0x03, 0x80, 0x00, 0x61, 0xC0, 0x00, 0x0C, 0x60,
  0x00, 0x03, 0xB8, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x66, 0x00, 0x00, 0x39, 0xC0,
  0x00, 0x0C, 0x38, 0x00, 0x07, 0x07, 0x00, 0x07, 0x80, 0xF8, 0x07, 0xC0,
  0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x0F, 0x01, 0xF0, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x70, 0x00,
  0x0C, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x02, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x60, 0x00,
  0x07, 0x70, 0x00, 0x0B, 0x38, 0x00, 0x1B, 0x1C, 0x00, 0x36, 0x0F, 0x00,
  0xE6, 0x07, 0xFF, 0xC6, 0x00, 0xFE, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x7F, 0xFE, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xF7, 0x80, 0x3D, 0xF7, 0xCF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0xF3, 0x8E, 0x31,
  0xC7, 0x18, 0x63, 0x8C, 0x30, 0xC2, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x3C, 0x03, 0xC0, 0xE0, 0x01, 0xC3,
  0x80, 0x01, 0x86, 0x00, 0x01, 0x98, 0x00, 0x03, 0x30, 0x00, 0x03, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF,
  0x80, 0x1E, 0x07, 0x80, 0x70, 0x03, 0x81, 0xC0, 0x03, 0x83, 0x00, 0x03,
  0x0C, 0x00, 0x03, 0x18, 0x00, 0x06, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x0D,
  0x80, 0x00, 0x1B, 0x00, 0x00, 0x3C, 0x00, 0xFC, 0x78, 0x03, 0xFC, 0xF0,
  0x0E, 0x0D, 0xE0, 0x30, 0x07, 0xC0, 0xE0, 0x0F, 0x81, 0x80, 0x0F, 0x03,
  0x00, 0x1E, 0x06, 0x00, 0x3C, 0x08, 0x00, 0x78, 0x30, 0x00, 0xF0, 0x60,
  0x01, 0xE0, 0xC0, 0x03, 0xC1, 0x80, 0x07, 0x83, 0x00, 0x0F, 0x06, 0x00,
  0x1E, 0x04, 0x00, 0x3C, 0x0C, 0x00, 0x78, 0x18, 0x00, 0xF0, 0x30, 0x01,
  0xE0, 0x30, 0x07, 0xC0, 0x70, 0x17, 0x80, 0x7F, 0xED, 0x00, 0x7F, 0x9B,
  0x00, 0x10, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x01, 0x98, 0x00, 0x00, 0x31, 0x80, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x60, 0x60, 0x00, 0x06,
  0x06, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x0C, 0x03, 0x00, 0x00, 0xC0, 0x30,
  0x00, 0x18, 0x03, 0x00, 0x01, 0x80, 0x38, 0x00, 0x18, 0x01, 0x80, 0x03,
  0x00, 0x18, 0x00, 0x30, 0x01, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x00,
  0xC0, 0x06, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x60, 0x0E, 0x00, 0x06, 0x00,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x01, 0xC0, 0x00, 0x30, 0x18, 0x00,
  0x03, 0x81, 0x80, 0x00, 0x18, 0x38, 0x00, 0x01, 0x83, 0x00, 0x00, 0x1C,
  0x30, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0xE6, 0x00,
  0x00, 0x06, 0xE0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0x30, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0xC0, 0x00, 0xF0, 0xC0, 0x00,
  0x38, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00,
  0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x0E, 0xC0, 0x00,
  0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00,
  0x18, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xE0, 0xC0, 0x00, 0x78, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x0E, 0xC0, 0x00,
  0x06, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x0E, 0xC0, 0x00,
  0x1C, 0xC0, 0x00, 0x78, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0xF8, 0x00, 0xF8, 0x0E, 0x00, 0xE0, 0x01, 0x80, 0xE0,
  0x00, 0x60, 0xE0, 0x00, 0x18, 0x60, 0x00, 0x0E, 0x70, 0x00, 0x03, 0x30,
  0x00, 0x01, 0x98, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x9C, 0x00, 0x00, 0xC6, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x60, 0xE0, 0x00, 0x60, 0x38, 0x00, 0x60, 0x0F, 0x80, 0xE0,
  0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x80, 0xC0, 0x03, 0xC0, 0xC0, 0x00, 0xE0, 0xC0, 0x00, 0x70, 0xC0, 0x00,
  0x38, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00,
  0x0E, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00,
  0x06, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00,
  0x0E, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x18, 0xC0, 0x00,
  0x38, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0xE0, 0xC0, 0x03, 0xC0, 0xFF, 0xFF,
  0x80, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xEC, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEC, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0xF0, 0x1E, 0x00,
  0xE0, 0x03, 0x80, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0xE0, 0x00, 0x1C,
  0x60, 0x00, 0x06, 0x30, 0x00, 0x03, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x36, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x0D,
  0x80, 0x00, 0x06, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x03, 0x98, 0x00, 0x01,
  0xCE, 0x00, 0x00, 0xE3, 0x00, 0x00, 0xB0, 0xC0, 0x00, 0xD8, 0x78, 0x00,
  0xCC, 0x1F, 0x01, 0xC6, 0x03, 0xFF, 0xC3, 0x00, 0x7F, 0x80, 0x00, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0xC0, 0x00, 0x1F, 0x00, 0x01, 0x98, 0x00, 0x0C, 0xE0, 0x00, 0xC3,
  0x80, 0x0E, 0x0F, 0x01, 0xE0, 0x3F, 0xFC, 0x00, 0x3F, 0x80, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xB0, 0x00, 0x03, 0x98, 0x00, 0x03, 0x8C, 0x00,
  0x03, 0x86, 0x00, 0x03, 0x83, 0x00, 0x01, 0x81, 0x80, 0x01, 0x80, 0xC0,
  0x01, 0x80, 0x60, 0x01, 0x80, 0x30, 0x01, 0xC0, 0x18, 0x01, 0xC0, 0x0C,
  0x01, 0xC0, 0x06, 0x01, 0xC0, 0x03, 0x00, 0xC0, 0x01, 0x80, 0xC0, 0x00,
  0xC0, 0xC0, 0x00, 0x60, 0xF0, 0x00, 0x30, 0xDC, 0x00, 0x18, 0xC6, 0x00,
  0x0C, 0xE1, 0x80, 0x06, 0xE0, 0xE0, 0x03, 0xE0, 0x30, 0x01, 0xE0, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x60, 0x01, 0x80, 0x30, 0x00, 0xE0, 0x18, 0x00,
  0x38, 0x0C, 0x00, 0x0C, 0x06, 0x00, 0x07, 0x03, 0x00, 0x01, 0xC1, 0x80,
  0x00, 0x60, 0xC0, 0x00, 0x38, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x18,
  0x00, 0x01, 0xCC, 0x00, 0x00, 0x66, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x0E,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xB0, 0x00, 0x0F,
  0xB0, 0x00, 0x1B, 0x98, 0x00, 0x1B, 0x98, 0x00, 0x33, 0x8C, 0x00, 0x33,
  0x8C, 0x00, 0x33, 0x86, 0x00, 0x63, 0x86, 0x00, 0x63, 0x86, 0x00, 0xC3,
  0x83, 0x00, 0xC3, 0x83, 0x01, 0x83, 0x81, 0x81, 0x83, 0x81, 0x83, 0x03,
  0x80, 0xC3, 0x03, 0x80, 0xC3, 0x03, 0x80, 0x66, 0x03, 0x80, 0x66, 0x03,
  0x80, 0x6C, 0x03, 0x80, 0x3C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x18, 0x03,
  0x80, 0x10, 0x03, 0x80, 0x10, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1E, 0xC0, 0x00, 0x3D, 0x80, 0x00, 0x79,
  0x80, 0x00, 0xF3, 0x00, 0x01, 0xE3, 0x00, 0x03, 0xC6, 0x00, 0x07, 0x86,
  0x00, 0x0F, 0x0C, 0x00, 0x1E, 0x0C, 0x00, 0x3C, 0x18, 0x00, 0x78, 0x18,
  0x00, 0xF0, 0x30, 0x01, 0xE0, 0x30, 0x03, 0xC0, 0x60, 0x07, 0x80, 0x60,
  0x0F, 0x00, 0xC0, 0x1E, 0x00, 0xC0, 0x3C, 0x01, 0x80, 0x78, 0x01, 0x80,
  0xF0, 0x03, 0x01, 0xE0, 0x03, 0x03, 0xC0, 0x06, 0x07, 0x80, 0x06, 0x0F,
  0x00, 0x0C, 0x1E, 0x00, 0x0C, 0x3C, 0x00, 0x18, 0x78, 0x00, 0x18, 0xF0,
  0x00, 0x31, 0xE0, 0x00, 0x33, 0xC0, 0x00, 0x67, 0x80, 0x00, 0x6F, 0x00,
  0x00, 0xDE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x78, 0x0F, 0x00,
  0x38, 0x00, 0xE0, 0x1C, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x83, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x03, 0x18, 0x00, 0x00, 0xE6, 0x00,
  0x00, 0x19, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x01,
  0x98, 0x00, 0x00, 0x66, 0x00, 0x00, 0x19, 0x80, 0x00, 0x0E, 0x60, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x60, 0x60, 0x00, 0x38, 0x1C,
  0x00, 0x0C, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x0F, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xC0, 0x00,
  0x78, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0E, 0xC0, 0x00,
  0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x0C, 0xC0, 0x00,
  0x1C, 0xC0, 0x00, 0x78, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x78, 0x0F, 0x00, 0x38,
  0x00, 0xE0, 0x1C, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x83, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x0C, 0x60, 0x00, 0x03, 0x18, 0x00, 0x00, 0xE6, 0x00, 0x00,
  0x19, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x01, 0x98,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x19, 0x80, 0x00, 0x0E, 0x60, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x60, 0x60, 0x00, 0x38, 0x1C, 0x00,
  0x0C, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x0F, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xC0,
  0x00, 0x78, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0E, 0xC0,
  0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x0C, 0xC0,
  0x00, 0x1C, 0xC0, 0x00, 0x78, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xC0,
  0x38, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0E, 0x00, 0xC0,
  0x06, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x03, 0x80, 0xC0, 0x01, 0x80, 0xC0,
  0x00, 0xC0, 0xC0, 0x00, 0xE0, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x30, 0xC0,
  0x00, 0x38, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0E, 0xC0,
  0x00, 0x07, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x1E, 0x00, 0xF8,
  0x07, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x03, 0x8C, 0x00,
  0x00, 0x21, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xE8, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x03,
  0x38, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x38, 0x3C, 0x00, 0x0E, 0x01, 0xF0,
  0x0F, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0xD8, 0x00, 0x01, 0xB0, 0x00, 0x03, 0x60, 0x00, 0x0E, 0xC0,
  0x00, 0x18, 0xC0, 0x00, 0x31, 0xC0, 0x00, 0xC1, 0xC0, 0x03, 0x81, 0xE0,
  0x1E, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0x80, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x06, 0x60, 0x00, 0x00, 0x66, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x18, 0x18,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x18, 0x18, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x30, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x60, 0x0E, 0x00, 0x06, 0x00,
  0x60, 0x00, 0x60, 0x06, 0x00, 0x0C, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x01, 0xC0, 0x03, 0x80, 0x18, 0x00, 0x18, 0x01, 0x80,
  0x01, 0x80, 0x38, 0x00, 0x1C, 0x03, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x0C,
  0x03, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x31, 0x80, 0x00, 0x01, 0x98, 0x00, 0x00, 0x19, 0x80, 0x00, 0x01, 0xB0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x2C, 0x00,
  0x00, 0x02, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x66, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x06, 0x60, 0x0E, 0x00, 0x46, 0x00, 0xE0,
  0x04, 0x60, 0x0F, 0x00, 0xC6, 0x00, 0xB0, 0x0C, 0x60, 0x1B, 0x00, 0xC2,
  0x01, 0x98, 0x0C, 0x30, 0x19, 0x80, 0xC3, 0x03, 0x18, 0x0C, 0x30, 0x30,
  0x80, 0xC3, 0x03, 0x0C, 0x0C, 0x30, 0x20, 0xC0, 0xC3, 0x06, 0x0C, 0x08,
  0x30, 0x60, 0x60, 0x83, 0x06, 0x06, 0x18, 0x30, 0xC0, 0x61, 0x83, 0x0C,
  0x02, 0x18, 0x10, 0xC0, 0x31, 0x81, 0x88, 0x03, 0x18, 0x19, 0x80, 0x31,
  0x81, 0x98, 0x01, 0x98, 0x19, 0x80, 0x19, 0x81, 0xB0, 0x01, 0x98, 0x1B,
  0x00, 0x09, 0x01, 0xB0, 0x00, 0xD0, 0x1B, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0xF0, 0x1E, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0x39, 0x80, 0x00, 0x03,
  0x86, 0x00, 0x00, 0x18, 0x38, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x1C, 0x03,
  0x00, 0x00, 0xC0, 0x1C, 0x00, 0x0C, 0x00, 0x60, 0x00, 0xE0, 0x01, 0x80,
  0x06, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x30, 0x07, 0x00, 0x00, 0xC0, 0x30,
  0x00, 0x07, 0x03, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x03, 0x98, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x06, 0xE0,
  0x00, 0x00, 0x73, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x30, 0x70, 0x00,
  0x03, 0x81, 0x80, 0x00, 0x18, 0x06, 0x00, 0x01, 0x80, 0x38, 0x00, 0x1C,
  0x00, 0xC0, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0xE0, 0x00,
  0x60, 0x06, 0x00, 0x01, 0x80, 0x60, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x30,
  0x30, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x1B, 0x80,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x00, 0x70, 0xC0, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0x18, 0x03, 0x00, 0x00, 0x70, 0x03, 0x00,
  0x00, 0xC0, 0x07, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x06, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x1C, 0x03,
  0x00, 0x00, 0x18, 0x0E, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x38, 0x60,
  0x00, 0x00, 0x31, 0xC0, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x60, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x63, 0x80, 0x00, 0x38, 0x60, 0x00, 0x0C, 0x0C, 0x00,
  0x06, 0x03, 0x00, 0x01, 0x80, 0x60, 0x00, 0xC0, 0x18, 0x00, 0x30, 0x03,
  0x00, 0x18, 0x00, 0x60, 0x0C, 0x00, 0x18, 0x03, 0x00, 0x03, 0x01, 0x80,
  0x00, 0xC0, 0x60, 0x00, 0x18, 0x30, 0x00, 0x07, 0x18, 0x00, 0x00, 0xC6,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x40, 0xE0, 0x60, 0x30,
  0x38, 0x18, 0x0C, 0x06, 0x06, 0x03, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0xF0, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x30, 0x00, 0x30, 0x18, 0x00,
  0x06, 0x02, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x3E, 0x00,
  0x18, 0x0E, 0x00, 0x06, 0x07, 0x00, 0x01, 0x81, 0x80, 0x00, 0x60, 0xC0,
  0x00, 0x18, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x83, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x18, 0x18, 0x00, 0x0A, 0x06, 0x00, 0x06, 0x80, 0xC0, 0x03,
  0x20, 0x3C, 0x03, 0x8F, 0xC3, 0xFF, 0xC3, 0xF0, 0x3F, 0xC0, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x7F, 0x00, 0xC7, 0xFF, 0x83, 0x38,
  0x0F, 0x0D, 0x80, 0x0E, 0x3C, 0x00, 0x1C, 0xE0, 0x00, 0x33, 0x00, 0x00,
  0x6C, 0x00, 0x01, 0xB0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xB0,
  0x00, 0x06, 0xE0, 0x00, 0x33, 0xC0, 0x01, 0xCD, 0x80, 0x0E, 0x33, 0x80,
  0xF0, 0xC7, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xFF,
  0x00, 0xF0, 0x1E, 0x07, 0x00, 0x1C, 0x18, 0x00, 0x18, 0xC0, 0x00, 0x67,
  0x00, 0x00, 0xD8, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x02, 0x70, 0x00, 0x0C, 0xC0, 0x00, 0x31, 0x80, 0x01, 0x87, 0x00, 0x1C,
  0x0F, 0x01, 0xE0, 0x0F, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x07, 0xF0, 0x30, 0x3F, 0xF8, 0x60, 0xF0,
  0x3C, 0xC3, 0x80, 0x0D, 0x8E, 0x00, 0x0B, 0x38, 0x00, 0x0E, 0x60, 0x00,
  0x1D, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x36, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xB0, 0x00, 0x03, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x0D, 0xC0,
  0x00, 0x19, 0x80, 0x00, 0x73, 0x80, 0x00, 0xE3, 0x80, 0x02, 0xC3, 0x80,
  0x0D, 0x83, 0xC0, 0x73, 0x03, 0xFF, 0x86, 0x01, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x0F, 0x81, 0xE0, 0x1C, 0x00, 0x70, 0x18, 0x00,
  0x18, 0x30, 0x00, 0x1C, 0x70, 0x00, 0x0C, 0x60, 0x00, 0x06, 0x60, 0x00,
  0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x02, 0x70, 0x00,
  0x06, 0x30, 0x00, 0x0E, 0x18, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x07, 0x80,
  0xF0, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x0F,
  0xFF, 0xC0, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x01, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x0F,
  0xF2, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0x81, 0xE0, 0x03, 0x80, 0x1C, 0x01,
  0xC0, 0x03, 0x00, 0x60, 0x00, 0x60, 0x30, 0x00, 0x18, 0x0C, 0x00, 0x03,
  0x03, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x0C, 0x0C, 0x00,
  0x03, 0x03, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x70, 0x18, 0x00, 0x18, 0x07,
  0x00, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0xF0, 0x00, 0x3C,
  0x70, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x1B, 0x80,
  0x00, 0x0E, 0x70, 0x00, 0x07, 0x0F, 0x00, 0x0F, 0x81, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x1F, 0xC0, 0xC7, 0xFF, 0x0C,
  0xE0, 0x7C, 0xD8, 0x01, 0xCF, 0x00, 0x06, 0xE0, 0x00, 0x6C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x30, 0x00, 0x1C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x67,
  0xFF, 0xFE, 0x7F, 0xFF, 0xC0, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xE6, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0xC1, 0x80, 0x00, 0xC0, 0xC0, 0x01, 0xC0, 0x60, 0x01,
  0xC0, 0x30, 0x01, 0xC0, 0x18, 0x01, 0xC0, 0x0C, 0x01, 0xC0, 0x06, 0x01,
  0x80, 0x03, 0x01, 0x80, 0x01, 0x83, 0x80, 0x00, 0xC3, 0xE0, 0x00, 0x63,
  0x98, 0x00, 0x33, 0x8E, 0x00, 0x1B, 0x03, 0x80, 0x0F, 0x00, 0xC0, 0x07,
  0x00, 0x30, 0x03, 0x00, 0x0C, 0x01, 0x80, 0x07, 0x00, 0xC0, 0x01, 0xC0,
  0x60, 0x00, 0x70, 0x30, 0x00, 0x18, 0x18, 0x00, 0x06, 0x0C, 0x00, 0x03,
  0x86, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x39, 0x80, 0x00, 0x0C, 0xC0, 0x00,
  0x03, 0x80, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xC0, 0x7E, 0x33, 0xFC, 0x3F, 0xCD,
  0x83, 0x98, 0x3B, 0x80, 0x6C, 0x06, 0xE0, 0x1A, 0x01, 0xB0, 0x03, 0x00,
  0x3C, 0x00, 0xC0, 0x0F, 0x00, 0x30, 0x03, 0xC0, 0x0C, 0x00, 0xF0, 0x03,
  0x00, 0x3C, 0x00, 0xC0, 0x0F, 0x00, 0x30, 0x03, 0xC0, 0x0C, 0x00, 0xF0,
  0x03, 0x00, 0x3C, 0x00, 0xC0, 0x0F, 0x00, 0x30, 0x03, 0xC0, 0x0C, 0x00,
  0xF0, 0x03, 0x00, 0x3C, 0x00, 0xC0, 0x0F, 0x00, 0x30, 0x03, 0xC0, 0x0C,
  0x00, 0xF0, 0x03, 0x00, 0x3C, 0x00, 0xC0, 0x0F, 0x00, 0x30, 0x03, 0xC0,
  0x0C, 0x00, 0xF0, 0x03, 0x00, 0x3C, 0x00, 0xC0, 0x0F, 0x00, 0x30, 0x03,
  0xC0, 0x0C, 0x00, 0xF0, 0x03, 0x00, 0x30, 0x01, 0xFC, 0x0C, 0x7F, 0xF0,
  0xCE, 0x07, 0xCD, 0x80, 0x1C, 0xF0, 0x00, 0x6E, 0x00, 0x06, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x00, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x0F, 0x01, 0xE0, 0x1C, 0x00, 0x70, 0x38, 0x00,
  0x18, 0x30, 0x00, 0x1C, 0x70, 0x00, 0x0C, 0x60, 0x00, 0x06, 0x60, 0x00,
  0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x06, 0xC0, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x70, 0x00,
  0x0C, 0x30, 0x00, 0x1C, 0x38, 0x00, 0x18, 0x1C, 0x00, 0x70, 0x0F, 0x01,
  0xE0, 0x03, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x03, 0x1F, 0xFE,
  0x0C, 0xE0, 0x3C, 0x36, 0x00, 0x38, 0xF0, 0x00, 0x73, 0x80, 0x00, 0xCC,
  0x00, 0x01, 0xB0, 0x00, 0x06, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00,
  0x06, 0xC0, 0x00, 0x1B, 0x80, 0x00, 0xCF, 0x00, 0x07, 0x36, 0x00, 0x38,
  0xCE, 0x03, 0xC3, 0x1F, 0xFE, 0x0C, 0x1F, 0xC0, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x07, 0xFF, 0x0C, 0x1E, 0x07, 0x98, 0x70, 0x01, 0xB1,
  0xC0, 0x01, 0x67, 0x00, 0x01, 0xCC, 0x00, 0x03, 0xB0, 0x00, 0x03, 0x60,
  0x00, 0x06, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0xD8, 0x00, 0x01, 0xB8, 0x00, 0x03, 0x30, 0x00, 0x0E,
  0x70, 0x00, 0x1C, 0x70, 0x00, 0x58, 0x70, 0x01, 0xB0, 0x78, 0x0E, 0x60,
  0x7F, 0xF0, 0xC0, 0x3F, 0x81, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFE, 0x1F, 0xFC, 0x00, 0xC7, 0x00, 0x00, 0x19, 0x80, 0x00,
  0x03, 0x40, 0x00, 0x00, 0x68, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x0F, 0x00, 0xF0, 0x18, 0x00, 0x3C,
  0x30, 0x00, 0x0E, 0x30, 0x00, 0x04, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x06, 0x70, 0x00, 0x06, 0x3C, 0x00, 0x1C,
  0x1F, 0x00, 0x78, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0D, 0x80, 0x00, 0x6C, 0x00, 0x07,
  0x60, 0x00, 0x39, 0x80, 0x03, 0xCE, 0x00, 0x36, 0x3C, 0x07, 0x30, 0xFF,
  0xF1, 0x81, 0xFE, 0x00, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x06, 0x60, 0x00,
  0x06, 0x60, 0x00, 0x04, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00,
  0x18, 0x18, 0x00, 0x18, 0x18, 0x00, 0x18, 0x18, 0x00, 0x30, 0x0C, 0x00,
  0x30, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x40, 0x03, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x03, 0x01, 0x80, 0x01, 0x81,
  0x80, 0x01, 0x81, 0x80, 0x01, 0x83, 0x00, 0x00, 0xC3, 0x00, 0x00, 0xC2,
  0x00, 0x00, 0x46, 0x00, 0x00, 0x66, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x0F, 0x00,
  0x1C, 0x00, 0x2C, 0x00, 0x78, 0x01, 0x90, 0x01, 0x60, 0x06, 0x60, 0x0C,
  0x80, 0x19, 0x80, 0x32, 0x00, 0x66, 0x00, 0xCC, 0x01, 0x18, 0x02, 0x30,
  0x0C, 0x20, 0x18, 0x40, 0x30, 0xC0, 0x61, 0x00, 0xC3, 0x01, 0x86, 0x03,
  0x0C, 0x04, 0x18, 0x0C, 0x30, 0x30, 0x20, 0x20, 0xC0, 0xC0, 0x81, 0x81,
  0x03, 0x03, 0x06, 0x06, 0x08, 0x0C, 0x18, 0x18, 0x60, 0x10, 0x60, 0x61,
  0x80, 0x41, 0x01, 0x86, 0x01, 0x84, 0x02, 0x10, 0x06, 0x30, 0x08, 0xC0,
  0x18, 0xC0, 0x33, 0x00, 0x23, 0x00, 0xCC, 0x00, 0xCC, 0x03, 0x20, 0x03,
  0x20, 0x0D, 0x80, 0x0D, 0x80, 0x16, 0x00, 0x16, 0x00, 0x78, 0x00, 0x78,
  0x01, 0xC0, 0x01, 0xE0, 0x07, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x07, 0x60,
  0x00, 0x0E, 0x30, 0x00, 0x0C, 0x38, 0x00, 0x18, 0x1C, 0x00, 0x30, 0x0C,
  0x00, 0x70, 0x06, 0x00, 0x60, 0x07, 0x00, 0xC0, 0x03, 0x81, 0x80, 0x01,
  0x83, 0x80, 0x00, 0xC3, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x6E, 0x00, 0x00,
  0xE6, 0x00, 0x00, 0xC3, 0x00, 0x01, 0x83, 0x80, 0x03, 0x01, 0xC0, 0x07,
  0x00, 0xC0, 0x0E, 0x00, 0x60, 0x0C, 0x00, 0x70, 0x18, 0x00, 0x38, 0x38,
  0x00, 0x18, 0x70, 0x00, 0x0C, 0x60, 0x00, 0x0E, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xB0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x18, 0x30, 0x00, 0x18,
  0x0C, 0x00, 0x0C, 0x06, 0x00, 0x0C, 0x01, 0x80, 0x06, 0x00, 0xC0, 0x03,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x01, 0x80, 0x03, 0x00,
  0xC0, 0x01, 0x80, 0x60, 0x00, 0xE0, 0x60, 0x00, 0x30, 0x30, 0x00, 0x18,
  0x30, 0x00, 0x06, 0x18, 0x00, 0x03, 0x18, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x36, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00,
  0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xF0, 0x07, 0xFF, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xC0, 0x1E, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x40, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x07, 0xC0, 0x00,
  0x21, 0xFC, 0x00, 0x04, 0x71, 0xC0, 0x01, 0x9C, 0x0C, 0x00, 0x33, 0x00,
  0xC0, 0x06, 0xC0, 0x1C, 0x01, 0x98, 0x01, 0xC0, 0x33, 0x00, 0x1C, 0x0C,
  0x40, 0x01, 0xC3, 0x98, 0x00, 0x1F, 0xE3, 0x00, 0x00, 0xF0, 0x00,
};

const GFXglyph IBMPlexMono_ExtraLight56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 34, 0, -1 },
  { 1, 5, 39, 34, 14, -39 },
  { 26, 10, 14, 34, 12, -41 },
  { 44, 31, 39, 34, 1, -39 },
  { 196, 27, 53, 34, 3, -46 },
  { 375, 31, 41, 34, 1, -40 },
  { 534, 29, 41, 34, 2, -40 },
  { 683, 2, 14, 34, 16, -41 },
  { 687, 13, 51, 34, 13, -43 },
  { 770, 14, 51, 34, 7, -43 },
  { 860, 28, 28, 34, 3, -31 },
  { 958, 27, 28, 34, 3, -31 },
  { 1053, 6, 14, 34, 13, -5 },
  { 1064, 15, 2, 34, 9, -18 },
  { 1068, 5, 4, 34, 14, -4 },
  { 1071, 22, 51, 34, 6, -43 },
  { 1212, 26, 41, 34, 4, -40 },
  { 1346, 27, 39, 34, 4, -39 },
  { 1478, 24, 40, 34, 5, -40 },
  { 1598, 24, 41, 34, 4, -40 },
  { 1721, 29, 39, 34, 2, -39 },
  { 1863, 24, 40, 34, 5, -39 },
  { 1983, 24, 40, 34, 5, -39 },
  { 2103, 25, 39, 34, 4, -39 },
  { 2225, 26, 41, 34, 4, -40 },
  { 2359, 24, 40, 34, 5, -40 },
  { 2479, 5, 29, 34, 14, -29 },
  { 2498, 6, 38, 34, 13, -29 },
  { 2527, 24, 30, 34, 5, -32 },
  { 2617, 27, 12, 34, 3, -23 },
  { 2658, 24, 30, 34, 5, -32 },
  { 2748, 23, 40, 34, 5, -40 },
  { 2863, 23, 46, 34, 5, -40 },
  { 2996, 28, 39, 34, 3, -39 },
  { 3133, 24, 39, 34, 5, -39 },
  { 3250, 25, 41, 34, 4, -40 },
  { 3379, 24, 39, 34, 6, -39 },
  { 3496, 23, 39, 34, 6, -39 },
  { 3609, 23, 39, 34, 6, -39 },
  { 3722, 25, 41, 34, 4, -40 },
  { 3851, 23, 39, 34, 5, -39 },
  { 3964, 24, 39, 34, 5, -39 },
  { 4081, 21, 40, 34, 5, -39 },
  { 4186, 25, 39, 34, 6, -39 },
  { 4308, 22, 39, 34, 8, -39 },
  { 4416, 24, 39, 34, 5, -39 },
  { 4533, 23, 39, 34, 5, -39 },
  { 4646, 26, 41, 34, 4, -40 },
  { 4780, 24, 39, 34, 6, -39 },
  { 4897, 26, 49, 34, 4, -40 },
  { 5057, 24, 39, 34, 6, -39 },
  { 5174, 27, 41, 34, 3, -40 },
  { 5313, 30, 39, 34, 2, -39 },
  { 5460, 23, 40, 34, 5, -39 },
  { 5575, 28, 39, 34, 3, -39 },
  { 5712, 28, 39, 34, 3, -39 },
  { 5849, 29, 39, 34, 2, -39 },
  { 5991, 31, 39, 34, 1, -39 },
  { 6143, 28, 39, 34, 3, -39 },
  { 6280, 14, 51, 34, 14, -43 },
  { 6370, 22, 51, 34, 6, -43 },
  { 6511, 14, 51, 34, 5, -43 },
  { 6601, 26, 22, 34, 4, -39 },
  { 6673, 27, 2, 34, 3, 6 },
  { 6680, 8, 10, 34, 11, -43 },
  { 6690, 26, 31, 34, 4, -30 },
  { 6791, 22, 42, 34, 7, -41 },
  { 6907, 22, 31, 34, 6, -30 },
  { 6993, 23, 42, 34, 4, -41 },
  { 7114, 24, 31, 34, 5, -30 },
  { 7207, 25, 41, 34, 5, -41 },
  { 7336, 26, 44, 34, 5, -32 },
  { 7479, 20, 41, 34, 7, -41 },
  { 7582, 24, 42, 34, 6, -42 },
  { 7708, 20, 53, 34, 5, -42 },
  { 7841, 25, 41, 34, 7, -41 },
  { 7970, 24, 41, 34, 5, -41 },
  { 8093, 26, 30, 34, 4, -30 },
  { 8191, 20, 30, 34, 7, -30 },
  { 8266, 24, 31, 34, 5, -30 },
  { 8359, 22, 41, 34, 7, -30 },
  { 8472, 23, 41, 34, 4, -30 },
  { 8590, 27, 29, 34, 4, -29 },
  { 8688, 24, 31, 34, 5, -30 },
  { 8781, 27, 39, 34, 2, -39 },
  { 8913, 21, 30, 34, 6, -29 },
  { 8992, 24, 29, 34, 5, -29 },
  { 9079, 30, 29, 34, 2, -29 },
  { 9188, 24, 29, 34, 5, -29 },
  { 9275, 25, 40, 34, 4, -29 },
  { 9400, 23, 29, 34, 5, -29 },
  { 9484, 21, 51, 34, 6, -43 },
  { 9618, 2, 51, 34, 16, -43 },
  { 9631, 21, 51, 34, 6, -43 },
  { 9765, 27, 11, 34, 3, -22 },
};

const GFXfont IBMPlexMono_ExtraLight56pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLight56pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLight56pt7bGlyphs,
  0x20, 0x7E, 73
};

#endif // _IBMPLEXMONO_EXTRALIGHT56PT7B_H_
