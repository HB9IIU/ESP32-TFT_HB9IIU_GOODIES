#ifndef _IBMPLEXMONO_EXTRALIGHT37PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHT37PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLight.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLight37pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x6D, 0xB6, 0xDB, 0x64, 0x92, 0x52, 0x00, 0x06, 0xF8, 0x86,
  0x18, 0x61, 0x86, 0x18, 0x61, 0x84, 0x00, 0xC1, 0x00, 0x08, 0x10, 0x00,
  0x81, 0x00, 0x08, 0x30, 0x00, 0x83, 0x00, 0x08, 0x20, 0x01, 0x82, 0x00,
  0x10, 0x20, 0x01, 0x02, 0x07, 0xF0, 0x7F, 0x01, 0x04, 0x00, 0x30, 0x40,
  0x03, 0x04, 0x00, 0x20, 0x40, 0x02, 0x04, 0x00, 0x20, 0xC0, 0xFE, 0x0F,
  0xE0, 0x60, 0x80, 0x04, 0x08, 0x00, 0x40, 0x80, 0x04, 0x18, 0x00, 0x41,
  0x80, 0x0C, 0x10, 0x00, 0xC1, 0x00, 0x08, 0x10, 0x00, 0x83, 0x00, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x07, 0xF8, 0x07, 0x11,
  0x83, 0x04, 0x18, 0x81, 0x02, 0x60, 0x40, 0x10, 0x10, 0x04, 0x04, 0x01,
  0x81, 0x00, 0x60, 0x40, 0x08, 0x10, 0x03, 0x04, 0x00, 0x71, 0x00, 0x07,
  0xE0, 0x00, 0x17, 0x00, 0x04, 0x30, 0x01, 0x06, 0x00, 0x40, 0x80, 0x10,
  0x30, 0x04, 0x0C, 0x01, 0x03, 0x00, 0x40, 0xD0, 0x10, 0x2E, 0x04, 0x18,
  0xC1, 0x04, 0x1C, 0x46, 0x01, 0xFE, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x1F, 0x00, 0x12, 0x18, 0x02, 0x40, 0xC0, 0x2C,
  0x04, 0x04, 0x80, 0x40, 0xC8, 0x06, 0x08, 0x80, 0x61, 0x08, 0x04, 0x10,
  0xC0, 0x42, 0x04, 0x0C, 0x20, 0x21, 0x84, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x31, 0x86, 0x06, 0x30, 0x20, 0x42,
  0x01, 0x0C, 0x20, 0x10, 0x82, 0x01, 0x10, 0x20, 0x11, 0x02, 0x01, 0x20,
  0x20, 0x16, 0x03, 0x02, 0x40, 0x18, 0x68, 0x00, 0x78, 0x03, 0xF0, 0x00,
  0xC3, 0x00, 0x20, 0x30, 0x0C, 0x03, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03,
  0x00, 0x00, 0xF0, 0x00, 0x23, 0x03, 0xC8, 0x20, 0x43, 0x02, 0x08, 0x40,
  0x21, 0x08, 0x06, 0x23, 0x00, 0x64, 0x60, 0x07, 0x8C, 0x00, 0x60, 0x80,
  0x06, 0x18, 0x01, 0x41, 0x00, 0x44, 0x18, 0x30, 0x41, 0xF8, 0x0C, 0xFF,
  0xFF, 0xC0, 0x03, 0x06, 0x0C, 0x08, 0x10, 0x30, 0x20, 0x60, 0x40, 0x40,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x40, 0x40, 0x60, 0x20, 0x30, 0x10, 0x08, 0x0C, 0x06, 0x03, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x10, 0x04, 0x02, 0x01, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x08,
  0x04, 0x06, 0x02, 0x01, 0x01, 0x00, 0x80, 0x80, 0xC0, 0xC0, 0xC0, 0xC0,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x20, 0x10, 0x17, 0x82, 0x1F, 0x1E, 0x5E, 0x00, 0x7E,
  0x00, 0x03, 0x00, 0x00, 0xD0, 0x00, 0x33, 0x00, 0x04, 0x30, 0x01, 0x02,
  0x00, 0x60, 0x20, 0x18, 0x06, 0x02, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0xFF, 0xFF, 0xC0, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x39,
  0x8C, 0xC6, 0x31, 0x08, 0xC0, 0xFF, 0xC0, 0xDF, 0x00, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00,
  0x20, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00,
  0x40, 0x03, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00,
  0x80, 0x02, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x20, 0x01,
  0x00, 0x04, 0x00, 0x30, 0x00, 0x80, 0x00, 0x03, 0xF0, 0x03, 0x03, 0x01,
  0x80, 0x60, 0xC0, 0x0C, 0x20, 0x01, 0x18, 0x00, 0x66, 0x00, 0x09, 0x00,
  0x02, 0x40, 0x00, 0x90, 0x00, 0x34, 0x00, 0x0F, 0x03, 0x03, 0xC0, 0xC0,
  0xF0, 0x30, 0x34, 0x00, 0x0D, 0x00, 0x03, 0x40, 0x00, 0xD0, 0x00, 0x24,
  0x00, 0x09, 0x80, 0x02, 0x60, 0x01, 0x88, 0x00, 0x43, 0x00, 0x30, 0x60,
  0x18, 0x0C, 0x0C, 0x00, 0xFC, 0x00, 0x01, 0xC0, 0x01, 0xE0, 0x01, 0xB0,
  0x01, 0x98, 0x03, 0x0C, 0x03, 0x06, 0x03, 0x03, 0x01, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x3F,
  0xFF, 0xC0, 0x07, 0xE0, 0x18, 0x18, 0x20, 0x0C, 0x40, 0x04, 0xC0, 0x06,
  0x80, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x04, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0x07, 0xF0, 0x1C, 0x1C, 0x30, 0x06,
  0x20, 0x02, 0x40, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0x07, 0xE0, 0x00, 0x1C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x80, 0x01, 0x40, 0x03, 0x60, 0x06, 0x18, 0x1C, 0x07, 0xF0, 0x00, 0x0C,
  0x00, 0x07, 0x00, 0x01, 0x40, 0x00, 0x90, 0x00, 0x64, 0x00, 0x11, 0x00,
  0x08, 0x40, 0x06, 0x10, 0x01, 0x04, 0x00, 0x81, 0x00, 0x60, 0x40, 0x10,
  0x10, 0x08, 0x04, 0x06, 0x01, 0x01, 0x00, 0x40, 0x80, 0x10, 0x60, 0x04,
  0x30, 0x01, 0x08, 0x00, 0x43, 0xFF, 0xFF, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x3F, 0xFE, 0x20,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x47, 0xF0, 0x58, 0x18, 0x60, 0x04, 0x40,
  0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x80, 0x02, 0xC0, 0x06, 0x60, 0x0C, 0x38, 0x18, 0x0F,
  0xE0, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x47, 0xE0, 0x48,
  0x18, 0x50, 0x04, 0xE0, 0x06, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x03, 0x40, 0x02, 0x60, 0x06, 0x30,
  0x04, 0x18, 0x18, 0x07, 0xE0, 0xFF, 0xFF, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x02, 0x80, 0x06, 0x80, 0x04, 0x80, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00,
  0xC0, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x02,
  0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x07, 0xF0, 0x0C,
  0x0C, 0x08, 0x01, 0x8C, 0x00, 0x44, 0x00, 0x36, 0x00, 0x1B, 0x00, 0x0D,
  0x80, 0x06, 0x40, 0x03, 0x30, 0x01, 0x08, 0x01, 0x03, 0x03, 0x00, 0x7E,
  0x00, 0xC0, 0xE1, 0x80, 0x19, 0x80, 0x06, 0x80, 0x01, 0x40, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0B, 0x00, 0x0C, 0xC0, 0x0C,
  0x38, 0x1C, 0x07, 0xF8, 0x00, 0x07, 0xE0, 0x18, 0x18, 0x30, 0x04, 0x60,
  0x02, 0x40, 0x02, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0x40, 0x03, 0x60, 0x05, 0x30, 0x07, 0x18, 0x1B, 0x07,
  0xE2, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x0E, 0x00, 0xDF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1B, 0xE0, 0x31, 0xCC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xCC, 0x66, 0x31, 0x88, 0x46, 0x00, 0x00, 0x01,
  0x00, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x06, 0x00,
  0x1C, 0x00, 0x30, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x0E, 0x00, 0x03, 0x00, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xE0, 0x00, 0x80, 0x00,
  0x0F, 0xC0, 0x60, 0x61, 0x80, 0x26, 0x00, 0x68, 0x00, 0x50, 0x00, 0x80,
  0x01, 0x00, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x0E,
  0x00, 0x70, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x07, 0xE0, 0x0C, 0x18, 0x10, 0x0C, 0x20, 0x04, 0x20, 0x02, 0x40,
  0x02, 0x40, 0x02, 0x40, 0x02, 0x40, 0xFA, 0xC1, 0x87, 0xC2, 0x03, 0xC2,
  0x03, 0x86, 0x03, 0x86, 0x03, 0x84, 0x03, 0x84, 0x03, 0x84, 0x03, 0xC4,
  0x03, 0x86, 0x03, 0xC2, 0x03, 0xC2, 0x03, 0x43, 0x07, 0x41, 0xFB, 0x40,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03,
  0xFC, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x1A, 0x00, 0x04, 0x80, 0x01, 0x20,
  0x00, 0xCC, 0x00, 0x21, 0x00, 0x08, 0x40, 0x06, 0x18, 0x01, 0x02, 0x00,
  0x40, 0x80, 0x30, 0x30, 0x08, 0x04, 0x02, 0x01, 0x01, 0x80, 0x60, 0x40,
  0x08, 0x1F, 0xFE, 0x0C, 0x00, 0xC2, 0x00, 0x10, 0x80, 0x04, 0x20, 0x01,
  0x98, 0x00, 0x24, 0x00, 0x09, 0x00, 0x03, 0xC0, 0x00, 0x60, 0x00, 0x10,
  0xFF, 0xE1, 0x00, 0x62, 0x00, 0x24, 0x00, 0x68, 0x00, 0x50, 0x00, 0xA0,
  0x01, 0x40, 0x02, 0x80, 0x05, 0x00, 0x1A, 0x00, 0x24, 0x01, 0x8F, 0xFE,
  0x10, 0x03, 0x20, 0x03, 0x40, 0x03, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x06, 0x80, 0x19, 0xFF,
  0xE0, 0x03, 0xF0, 0x0C, 0x0C, 0x10, 0x06, 0x20, 0x03, 0x60, 0x01, 0x40,
  0x02, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x40, 0x00, 0x40, 0x02, 0x60, 0x01, 0x20, 0x03, 0x10,
  0x06, 0x0C, 0x0C, 0x03, 0xF0, 0xFF, 0xC0, 0x80, 0x30, 0x80, 0x18, 0x80,
  0x0C, 0x80, 0x04, 0x80, 0x06, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80,
  0x02, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x06, 0x80,
  0x04, 0x80, 0x0C, 0x80, 0x18, 0x80, 0x30, 0xFF, 0xC0, 0xFF, 0xFF, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0xFF, 0xFC, 0xFF, 0xFF,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x0F, 0xFF, 0xD0, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x00, 0x07,
  0xE0, 0x1C, 0x18, 0x30, 0x04, 0x20, 0x02, 0x40, 0x03, 0x40, 0x02, 0xC0,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0xFF, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0xC0, 0x01, 0x40, 0x03, 0x40, 0x03, 0x20, 0x05, 0x30, 0x05, 0x1C,
  0x19, 0x07, 0xE1, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xFF, 0xFF, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0xFF, 0xFF, 0x1F,
  0xFC, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x07,
  0x00, 0x34, 0x00, 0x98, 0x06, 0x38, 0x30, 0x3F, 0x00, 0x80, 0x03, 0x40,
  0x03, 0x20, 0x01, 0x10, 0x01, 0x08, 0x01, 0x04, 0x01, 0x82, 0x01, 0x81,
  0x01, 0x80, 0x81, 0x80, 0x41, 0x80, 0x20, 0x80, 0x10, 0xC0, 0x08, 0xB0,
  0x04, 0x88, 0x02, 0xC6, 0x01, 0xC1, 0x80, 0xC0, 0x40, 0x40, 0x30, 0x20,
  0x0C, 0x10, 0x02, 0x08, 0x01, 0x84, 0x00, 0x62, 0x00, 0x11, 0x00, 0x0C,
  0x80, 0x03, 0x40, 0x00, 0xC0, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0xFF, 0xFC, 0xC0, 0x03, 0xE0, 0x03, 0xA0, 0x07,
  0xA0, 0x05, 0x90, 0x0D, 0x90, 0x09, 0x98, 0x09, 0x88, 0x11, 0x8C, 0x11,
  0x84, 0x21, 0x84, 0x21, 0x82, 0x61, 0x82, 0x41, 0x81, 0xC1, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xE0, 0x03,
  0xE0, 0x03, 0xF0, 0x03, 0xD0, 0x03, 0xD8, 0x03, 0xC8, 0x03, 0xCC, 0x03,
  0xC4, 0x03, 0xC6, 0x03, 0xC2, 0x03, 0xC3, 0x03, 0xC1, 0x03, 0xC1, 0x83,
  0xC0, 0x83, 0xC0, 0xC3, 0xC0, 0x43, 0xC0, 0x63, 0xC0, 0x23, 0xC0, 0x33,
  0xC0, 0x13, 0xC0, 0x1B, 0xC0, 0x0B, 0xC0, 0x0B, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x03, 0x03, 0xF0, 0x03, 0x03, 0x01, 0x80, 0x60, 0xC0, 0x0C, 0x20,
  0x01, 0x18, 0x00, 0x66, 0x00, 0x09, 0x00, 0x02, 0x40, 0x00, 0x90, 0x00,
  0x34, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x34, 0x00, 0x0D,
  0x00, 0x03, 0x40, 0x00, 0xD0, 0x00, 0x24, 0x00, 0x09, 0x80, 0x02, 0x60,
  0x01, 0x88, 0x00, 0x43, 0x00, 0x30, 0x60, 0x18, 0x0C, 0x0C, 0x00, 0xFC,
  0x00, 0xFF, 0xF0, 0x80, 0x1C, 0x80, 0x04, 0x80, 0x02, 0x80, 0x02, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x02, 0x80, 0x02, 0x80,
  0x04, 0x80, 0x1C, 0xFF, 0xF0, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x03, 0xF0, 0x03, 0x03, 0x01, 0x80, 0x60,
  0xC0, 0x0C, 0x20, 0x01, 0x18, 0x00, 0x66, 0x00, 0x09, 0x00, 0x02, 0x40,
  0x00, 0x90, 0x00, 0x34, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x34, 0x00, 0x0D, 0x00, 0x03, 0x40, 0x00, 0xD0, 0x00, 0x24, 0x00, 0x09,
  0x80, 0x02, 0x60, 0x01, 0x88, 0x00, 0x43, 0x00, 0x30, 0x60, 0x18, 0x0C,
  0x0C, 0x00, 0xFC, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x07, 0xF0, 0xFF, 0xF0, 0x80, 0x1C, 0x80, 0x04, 0x80, 0x02, 0x80,
  0x02, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x02, 0x80,
  0x02, 0x80, 0x04, 0x80, 0x1C, 0xFF, 0xF0, 0x81, 0x00, 0x80, 0x80, 0x80,
  0xC0, 0x80, 0x40, 0x80, 0x60, 0x80, 0x30, 0x80, 0x10, 0x80, 0x18, 0x80,
  0x08, 0x80, 0x0C, 0x80, 0x06, 0x80, 0x03, 0x07, 0xF8, 0x07, 0x03, 0x83,
  0x00, 0x30, 0x80, 0x02, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xD0, 0x00, 0x2E, 0x00, 0x18, 0xC0,
  0x0C, 0x1C, 0x0E, 0x01, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x40, 0x03, 0x40,
  0x03, 0x40, 0x02, 0x40, 0x02, 0x40, 0x02, 0x60, 0x06, 0x20, 0x04, 0x18,
  0x18, 0x0F, 0xF0, 0x80, 0x00, 0x70, 0x00, 0x34, 0x00, 0x0D, 0x00, 0x02,
  0x60, 0x01, 0x88, 0x00, 0x62, 0x00, 0x10, 0xC0, 0x04, 0x10, 0x03, 0x04,
  0x00, 0x81, 0x80, 0x20, 0x20, 0x18, 0x08, 0x04, 0x03, 0x01, 0x00, 0xC0,
  0xC0, 0x10, 0x20, 0x06, 0x08, 0x01, 0x86, 0x00, 0x21, 0x00, 0x08, 0x40,
  0x03, 0x30, 0x00, 0x48, 0x00, 0x12, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00,
  0x30, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x14, 0x00, 0x0D, 0x00, 0x03, 0x40, 0xC0, 0x90, 0x30,
  0x24, 0x0E, 0x09, 0x06, 0x82, 0x41, 0x20, 0x90, 0x48, 0x26, 0x33, 0x09,
  0x88, 0x42, 0x62, 0x10, 0x88, 0x86, 0x62, 0x60, 0x98, 0x90, 0x24, 0x24,
  0x09, 0x0B, 0x03, 0x42, 0x80, 0x50, 0xA0, 0x14, 0x28, 0x07, 0x0E, 0x00,
  0xC0, 0xC0, 0x00, 0xCC, 0x00, 0x10, 0x80, 0x06, 0x18, 0x01, 0x81, 0x80,
  0x20, 0x10, 0x0C, 0x03, 0x01, 0x00, 0x20, 0x40, 0x02, 0x18, 0x00, 0x62,
  0x00, 0x04, 0x80, 0x00, 0xF0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x68,
  0x00, 0x09, 0x80, 0x02, 0x10, 0x00, 0xC1, 0x00, 0x10, 0x30, 0x04, 0x02,
  0x01, 0x80, 0x60, 0x20, 0x06, 0x08, 0x00, 0x43, 0x00, 0x0C, 0x40, 0x00,
  0xD0, 0x00, 0x0C, 0xC0, 0x00, 0x34, 0x00, 0x02, 0x60, 0x00, 0x63, 0x00,
  0x04, 0x10, 0x00, 0xC1, 0x80, 0x18, 0x08, 0x01, 0x00, 0x40, 0x30, 0x06,
  0x02, 0x00, 0x20, 0x40, 0x03, 0x0C, 0x00, 0x18, 0x80, 0x00, 0x98, 0x00,
  0x0F, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x20, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x20, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x20, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01,
  0x00, 0x00, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0xFF, 0xF0, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xFF,
  0xC0, 0x80, 0x03, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x03,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20,
  0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x80, 0x01,
  0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x04, 0xFF,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0xFF,
  0x80, 0x00, 0xC0, 0x00, 0x78, 0x00, 0x12, 0x00, 0x0C, 0xC0, 0x02, 0x10,
  0x01, 0x82, 0x00, 0x40, 0xC0, 0x20, 0x10, 0x18, 0x06, 0x04, 0x00, 0x83,
  0x00, 0x10, 0x80, 0x06, 0x40, 0x00, 0xB0, 0x00, 0x30, 0xFF, 0xFF, 0xC0,
  0xC3, 0x08, 0x21, 0x84, 0x0F, 0xC0, 0x18, 0x18, 0x18, 0x06, 0x08, 0x01,
  0x08, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x0F,
  0xFE, 0x1C, 0x03, 0x18, 0x01, 0x88, 0x00, 0xC4, 0x00, 0x62, 0x00, 0x31,
  0x00, 0x28, 0xC0, 0x14, 0x30, 0x32, 0x07, 0xE1, 0xE0, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC7, 0xE1, 0xB0, 0x63, 0x80, 0x26, 0x00, 0x2C, 0x00, 0x78, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x01, 0xE0, 0x02, 0xE0, 0x09, 0xB0, 0x63, 0x1F, 0x80,
  0x07, 0xE0, 0x30, 0x30, 0x80, 0x33, 0x00, 0x24, 0x00, 0x98, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x18, 0x00, 0x10, 0x01, 0x30, 0x03, 0x20, 0x0C, 0x30, 0x30, 0x1F, 0x80,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x07, 0xC2, 0x30, 0x64, 0x80, 0x2B, 0x00, 0x34, 0x00,
  0x78, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x38, 0x00, 0x50, 0x01, 0xB0, 0x03, 0x20, 0x0A, 0x30,
  0x64, 0x1F, 0x08, 0x07, 0xE0, 0x18, 0x18, 0x30, 0x0C, 0x20, 0x06, 0x40,
  0x02, 0x40, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x40, 0x03, 0x20, 0x02, 0x30,
  0x06, 0x18, 0x18, 0x07, 0xE0, 0x00, 0xFF, 0x80, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0xFF, 0xFF,
  0x80, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xC1, 0xFA, 0x00, 0xC1, 0x80, 0x40, 0x30,
  0x20, 0x04, 0x08, 0x01, 0x82, 0x00, 0x60, 0x80, 0x18, 0x20, 0x06, 0x08,
  0x01, 0x01, 0x00, 0xC0, 0x70, 0x60, 0x07, 0xE0, 0x06, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x30, 0x00, 0x0F, 0xFF, 0x01, 0x00, 0x31, 0x80, 0x06,
  0x40, 0x00, 0xB0, 0x00, 0x2C, 0x00, 0x0B, 0x00, 0x02, 0x40, 0x01, 0x0C,
  0x01, 0x80, 0xFF, 0x80, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC7, 0xE3, 0x60, 0xCE, 0x01, 0xB0,
  0x02, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x40, 0x01, 0x80, 0x01, 0xC0, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0xFF, 0xFF,
  0x00, 0x30, 0x01, 0xC0, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0xBF, 0xF8, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x06, 0x80, 0x18, 0x80, 0x30, 0x80, 0x60, 0x80, 0xC0, 0x81,
  0x80, 0x83, 0x00, 0x84, 0x00, 0x9A, 0x00, 0xB3, 0x00, 0xE1, 0x80, 0xC0,
  0xC0, 0x80, 0x60, 0x80, 0x20, 0x80, 0x10, 0x80, 0x18, 0x80, 0x0C, 0x80,
  0x06, 0x80, 0x03, 0xFF, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0xFF, 0xFF, 0x9E, 0x1E, 0x51,
  0xB1, 0xB0, 0x60, 0x50, 0x30, 0x38, 0x18, 0x1C, 0x04, 0x0E, 0x02, 0x07,
  0x01, 0x03, 0x80, 0x81, 0xC0, 0x40, 0xE0, 0x20, 0x70, 0x10, 0x38, 0x08,
  0x1C, 0x04, 0x0E, 0x02, 0x07, 0x01, 0x03, 0x80, 0x81, 0xC0, 0x40, 0xE0,
  0x20, 0x60, 0xC7, 0xE3, 0x60, 0xCE, 0x01, 0xB0, 0x02, 0xC0, 0x0F, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x40,
  0x07, 0xE0, 0x18, 0x18, 0x30, 0x0C, 0x60, 0x06, 0x40, 0x02, 0x40, 0x03,
  0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x03, 0x40, 0x03, 0x40, 0x02, 0x60, 0x06, 0x30, 0x0C, 0x18, 0x18,
  0x07, 0xE0, 0xC7, 0xE1, 0xB0, 0x63, 0x80, 0x26, 0x00, 0x2C, 0x00, 0x78,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x02, 0xE0, 0x09, 0xB0, 0x63,
  0x1F, 0x86, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x00, 0x07, 0xC2, 0x30, 0x64, 0x80, 0x2B, 0x00, 0x34, 0x00,
  0x78, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x38, 0x00, 0x50, 0x01, 0xB0, 0x03, 0x20, 0x0A, 0x30,
  0x64, 0x1F, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0xFF, 0x1F, 0xC0, 0xD8, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x0F, 0xFF, 0xF0, 0x07,
  0xF0, 0x18, 0x1C, 0x20, 0x06, 0x60, 0x03, 0x40, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x1E, 0x00, 0x03, 0xF8, 0x00, 0x0E, 0x00, 0x03, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0xC0, 0x03, 0x60, 0x02, 0x18, 0x0C, 0x07,
  0xF0, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x18, 0x03, 0xFF, 0xFF, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x3F, 0xF0,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x3C, 0x00, 0xD0, 0x03, 0x60, 0x1C, 0xC0, 0xB0, 0xFC, 0xC0, 0xC0, 0x01,
  0x40, 0x02, 0x40, 0x02, 0x60, 0x06, 0x20, 0x04, 0x30, 0x04, 0x10, 0x0C,
  0x10, 0x08, 0x18, 0x08, 0x08, 0x10, 0x08, 0x10, 0x0C, 0x30, 0x04, 0x20,
  0x06, 0x20, 0x02, 0x60, 0x02, 0x40, 0x03, 0x40, 0x01, 0x80, 0x01, 0x80,
  0xC0, 0x60, 0x14, 0x06, 0x03, 0x40, 0x50, 0x24, 0x0D, 0x02, 0x40, 0x90,
  0x24, 0x09, 0x02, 0x20, 0x98, 0x22, 0x18, 0x86, 0x21, 0x08, 0x42, 0x10,
  0x84, 0x21, 0x0C, 0x43, 0x30, 0x44, 0x12, 0x04, 0xC1, 0x20, 0x48, 0x12,
  0x06, 0x81, 0x60, 0x28, 0x14, 0x02, 0x81, 0xC0, 0x28, 0x0C, 0x03, 0x80,
  0xC0, 0x03, 0x60, 0x06, 0x30, 0x04, 0x10, 0x08, 0x08, 0x18, 0x0C, 0x30,
  0x06, 0x20, 0x02, 0x40, 0x01, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x02, 0x40,
  0x04, 0x20, 0x0C, 0x30, 0x18, 0x18, 0x10, 0x0C, 0x20, 0x04, 0x60, 0x06,
  0xC0, 0x03, 0x80, 0x01, 0xC0, 0x03, 0x40, 0x02, 0x60, 0x02, 0x20, 0x04,
  0x20, 0x04, 0x10, 0x0C, 0x10, 0x08, 0x18, 0x18, 0x08, 0x10, 0x0C, 0x10,
  0x04, 0x30, 0x04, 0x20, 0x06, 0x60, 0x02, 0x40, 0x03, 0x40, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x04, 0x00, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x18, 0x00, 0x20,
  0x00, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x40, 0x01, 0x00, 0x06,
  0x00, 0x18, 0x00, 0x20, 0x00, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x40, 0x01, 0x00, 0x03, 0xFF, 0xF8, 0x03, 0xFC, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0xE0, 0xFC, 0x00,
  0x0C, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x40,
  0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x03, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0x00, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x00,
  0xC0, 0x00, 0xFC, 0x0E, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0xFF, 0x00, 0x1E, 0x00, 0x4C, 0xC0, 0x16,
  0x18, 0x0D, 0x03, 0x02, 0x40, 0x60, 0xA0, 0x0C, 0x48, 0x01, 0xE0,
};

const GFXglyph IBMPlexMono_ExtraLight37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 3, 26, 22, 10, -26 },
  { 11, 6, 9, 22, 8, -27 },
  { 18, 20, 26, 22, 1, -26 },
  { 83, 18, 34, 22, 2, -30 },
  { 160, 20, 26, 22, 1, -26 },
  { 225, 19, 26, 22, 1, -26 },
  { 287, 2, 9, 22, 10, -27 },
  { 290, 8, 33, 22, 9, -28 },
  { 323, 9, 33, 22, 5, -28 },
  { 361, 19, 18, 22, 2, -20 },
  { 404, 18, 17, 22, 2, -20 },
  { 443, 5, 9, 22, 8, -3 },
  { 449, 10, 1, 22, 6, -12 },
  { 451, 3, 3, 22, 10, -3 },
  { 453, 14, 33, 22, 4, -28 },
  { 511, 18, 26, 22, 2, -26 },
  { 570, 17, 26, 22, 3, -26 },
  { 626, 16, 26, 22, 3, -26 },
  { 678, 16, 26, 22, 2, -26 },
  { 730, 18, 26, 22, 2, -26 },
  { 789, 16, 26, 22, 3, -26 },
  { 841, 16, 26, 22, 3, -26 },
  { 893, 16, 26, 22, 3, -26 },
  { 945, 17, 26, 22, 3, -26 },
  { 1001, 16, 26, 22, 3, -26 },
  { 1053, 3, 20, 22, 10, -20 },
  { 1061, 5, 26, 22, 8, -20 },
  { 1078, 16, 20, 22, 3, -21 },
  { 1118, 18, 8, 22, 2, -15 },
  { 1136, 16, 20, 22, 3, -21 },
  { 1176, 15, 26, 22, 4, -26 },
  { 1225, 16, 30, 22, 3, -26 },
  { 1285, 18, 26, 22, 2, -26 },
  { 1344, 15, 26, 22, 4, -26 },
  { 1393, 16, 26, 22, 3, -26 },
  { 1445, 16, 26, 22, 4, -26 },
  { 1497, 15, 26, 22, 4, -26 },
  { 1546, 15, 26, 22, 4, -26 },
  { 1595, 16, 26, 22, 3, -26 },
  { 1647, 16, 26, 22, 3, -26 },
  { 1699, 16, 26, 22, 3, -26 },
  { 1751, 14, 26, 22, 3, -26 },
  { 1797, 17, 26, 22, 4, -26 },
  { 1853, 15, 26, 22, 5, -26 },
  { 1902, 16, 26, 22, 3, -26 },
  { 1954, 16, 26, 22, 3, -26 },
  { 2006, 18, 26, 22, 2, -26 },
  { 2065, 16, 26, 22, 4, -26 },
  { 2117, 18, 31, 22, 2, -26 },
  { 2187, 16, 26, 22, 4, -26 },
  { 2239, 18, 26, 22, 2, -26 },
  { 2298, 20, 26, 22, 1, -26 },
  { 2363, 16, 26, 22, 3, -26 },
  { 2415, 18, 26, 22, 2, -26 },
  { 2474, 18, 26, 22, 2, -26 },
  { 2533, 19, 26, 22, 2, -26 },
  { 2595, 20, 26, 22, 1, -26 },
  { 2660, 18, 26, 22, 2, -26 },
  { 2719, 10, 33, 22, 9, -28 },
  { 2761, 14, 33, 22, 4, -28 },
  { 2819, 9, 33, 22, 4, -28 },
  { 2857, 18, 14, 22, 2, -26 },
  { 2889, 18, 1, 22, 2, 4 },
  { 2892, 5, 6, 22, 7, -28 },
  { 2896, 17, 19, 22, 3, -19 },
  { 2937, 15, 27, 22, 4, -27 },
  { 2988, 15, 19, 22, 4, -19 },
  { 3024, 15, 27, 22, 3, -27 },
  { 3075, 16, 19, 22, 3, -19 },
  { 3113, 17, 27, 22, 3, -27 },
  { 3171, 18, 27, 22, 3, -20 },
  { 3232, 14, 27, 22, 4, -27 },
  { 3280, 16, 28, 22, 4, -28 },
  { 3336, 13, 35, 22, 4, -28 },
  { 3393, 16, 27, 22, 5, -27 },
  { 3447, 16, 27, 22, 3, -27 },
  { 3501, 17, 19, 22, 3, -19 },
  { 3542, 14, 19, 22, 4, -19 },
  { 3576, 16, 19, 22, 3, -19 },
  { 3614, 15, 26, 22, 4, -19 },
  { 3663, 15, 26, 22, 3, -19 },
  { 3712, 18, 19, 22, 3, -19 },
  { 3755, 16, 19, 22, 3, -19 },
  { 3793, 18, 26, 22, 1, -26 },
  { 3852, 14, 19, 22, 4, -19 },
  { 3886, 16, 19, 22, 3, -19 },
  { 3924, 20, 19, 22, 1, -19 },
  { 3972, 16, 19, 22, 3, -19 },
  { 4010, 16, 26, 22, 3, -19 },
  { 4062, 15, 19, 22, 4, -19 },
  { 4098, 14, 33, 22, 4, -28 },
  { 4156, 1, 33, 22, 11, -28 },
  { 4161, 14, 33, 22, 4, -28 },
  { 4219, 18, 7, 22, 2, -15 },
};

const GFXfont IBMPlexMono_ExtraLight37pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLight37pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLight37pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _IBMPLEXMONO_EXTRALIGHT37PT7B_H_
