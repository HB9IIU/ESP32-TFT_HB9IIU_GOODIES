#ifndef _IBMPLEXMONO_EXTRALIGHT21PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHT21PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLight.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLight21pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x55, 0x60, 0x3C, 0x99, 0x99, 0x90, 0x04, 0x40, 0x44, 0x04,
  0x80, 0x88, 0x08, 0x87, 0x8F, 0x08, 0x80, 0x88, 0x09, 0x0F, 0x1E, 0x11,
  0x01, 0x10, 0x11, 0x01, 0x10, 0x12, 0x00, 0x04, 0x01, 0x01, 0xF1, 0x92,
  0x44, 0x61, 0x04, 0x41, 0x10, 0x34, 0x03, 0xC0, 0x48, 0x11, 0x04, 0x41,
  0x18, 0x45, 0x92, 0x1F, 0x01, 0x00, 0x40, 0x70, 0x31, 0x0A, 0x21, 0x42,
  0x48, 0x91, 0x12, 0x1C, 0x00, 0x00, 0x03, 0xC6, 0x84, 0x90, 0xA2, 0x14,
  0x43, 0x08, 0x60, 0xF0, 0x1C, 0x04, 0x41, 0x04, 0x20, 0x04, 0x00, 0x40,
  0x04, 0x03, 0x87, 0x88, 0x90, 0x92, 0x0A, 0x40, 0x88, 0x18, 0x85, 0x0F,
  0x18, 0xF8, 0x19, 0x08, 0x88, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x08,
  0x21, 0x06, 0x82, 0x08, 0x41, 0x08, 0x41, 0x08, 0x42, 0x11, 0x08, 0x44,
  0x22, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x0E, 0x4E, 0x3E, 0x03, 0x00,
  0x90, 0x11, 0x04, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x3F, 0xF0,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x7A, 0x80, 0xFC, 0xF0, 0x01, 0x01,
  0x02, 0x02, 0x02, 0x04, 0x04, 0x08, 0x08, 0x08, 0x10, 0x10, 0x20, 0x20,
  0x20, 0x40, 0x40, 0x80, 0x80, 0x1E, 0x08, 0x64, 0x09, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x11, 0x80, 0x60, 0x18, 0x05, 0x01, 0x40, 0x88, 0x61, 0xE0,
  0x18, 0x0E, 0x06, 0x83, 0x20, 0x88, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x0F, 0xFC, 0x3C, 0x21, 0xA0, 0x50, 0x20,
  0x10, 0x08, 0x04, 0x04, 0x06, 0x06, 0x04, 0x04, 0x04, 0x04, 0x03, 0xFE,
  0x1E, 0x10, 0xD0, 0x20, 0x10, 0x08, 0x08, 0x78, 0x06, 0x00, 0x80, 0x40,
  0x20, 0x18, 0x0B, 0x08, 0x78, 0x01, 0x00, 0x60, 0x14, 0x02, 0x80, 0x90,
  0x22, 0x04, 0x41, 0x08, 0x41, 0x08, 0x22, 0x04, 0x7F, 0xF0, 0x10, 0x02,
  0x00, 0x40, 0x7F, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0xF9, 0x82, 0x01,
  0x00, 0x40, 0x20, 0x18, 0x12, 0x18, 0xF0, 0x04, 0x0C, 0x08, 0x08, 0x04,
  0x04, 0x02, 0xF9, 0x86, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x12, 0x18, 0xF8,
  0xFF, 0xC0, 0x60, 0x50, 0x20, 0x20, 0x10, 0x10, 0x08, 0x08, 0x04, 0x02,
  0x02, 0x01, 0x01, 0x00, 0x80, 0x1F, 0x08, 0x24, 0x09, 0x01, 0x40, 0x50,
  0x22, 0x08, 0x7C, 0x31, 0x90, 0x18, 0x06, 0x01, 0x40, 0x58, 0x21, 0xF0,
  0x3E, 0x21, 0xA0, 0x50, 0x18, 0x0C, 0x06, 0x02, 0x83, 0x3F, 0x00, 0x80,
  0x40, 0x40, 0x40, 0x40, 0xC0, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x1E, 0xA0,
  0x00, 0x81, 0x83, 0x02, 0x06, 0x04, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x00,
  0x60, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x80, 0x20, 0x0C, 0x01,
  0x80, 0x30, 0x04, 0x0C, 0x08, 0x18, 0x30, 0x20, 0x00, 0x3E, 0x20, 0xA0,
  0x50, 0x30, 0x10, 0x08, 0x08, 0x38, 0x10, 0x08, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x60, 0x3C, 0x21, 0x90, 0x50, 0x28, 0xF4, 0x8E, 0x43, 0x41, 0xA0,
  0xD0, 0x64, 0x32, 0x38, 0xEC, 0x01, 0x00, 0xC0, 0x3F, 0x00, 0x04, 0x01,
  0x80, 0x28, 0x09, 0x01, 0x20, 0x22, 0x08, 0x41, 0x08, 0x20, 0x87, 0xF1,
  0x02, 0x20, 0x44, 0x05, 0x00, 0xA0, 0x18, 0xFE, 0x40, 0xA0, 0x50, 0x28,
  0x14, 0x0A, 0x05, 0xFC, 0x81, 0x40, 0x60, 0x30, 0x18, 0x0C, 0x0B, 0xF8,
  0x3E, 0x30, 0x90, 0x30, 0x18, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x14, 0x0B, 0x08, 0xF8, 0xFC, 0x41, 0xA0, 0x50, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x14, 0x1B, 0xF0, 0xFF, 0xC0,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0xFF, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x03, 0xFE, 0xFF, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0xFE,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x00, 0x1E, 0x08, 0x64, 0x09,
  0x03, 0x40, 0x20, 0x08, 0x02, 0x00, 0x87, 0xE0, 0x14, 0x05, 0x01, 0x40,
  0x48, 0x71, 0xE4, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0xFF,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x02, 0xFF, 0x84, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x43,
  0xFE, 0x7F, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x81, 0x42, 0x3C, 0x80, 0xE0, 0x48, 0x22, 0x08, 0x84, 0x22, 0x09,
  0x02, 0xA0, 0xC8, 0x21, 0x08, 0x22, 0x08, 0x81, 0x20, 0x28, 0x0C, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0xFF, 0x80, 0xC0, 0xF0, 0xB8, 0x5A, 0x2D, 0x26, 0x53, 0x31, 0x88,
  0xC8, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x02, 0x80, 0xE0, 0x70, 0x34, 0x1A,
  0x0C, 0x86, 0x43, 0x11, 0x88, 0xC2, 0x61, 0x30, 0x58, 0x2C, 0x0E, 0x06,
  0x1E, 0x08, 0x64, 0x09, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x05, 0x01, 0x40, 0x88, 0x61, 0xE0, 0xFE, 0x40, 0xA0, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x02, 0xFE, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x00,
  0x1E, 0x08, 0x64, 0x09, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x05, 0x01, 0x40, 0x88, 0x61, 0xF0, 0x10, 0x04, 0x01, 0xE0, 0xFE,
  0x40, 0xA0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x02, 0xFE, 0x44, 0x21, 0x10,
  0x48, 0x24, 0x0A, 0x02, 0x1F, 0x18, 0x24, 0x06, 0x00, 0x40, 0x10, 0x03,
  0x00, 0x7C, 0x00, 0x80, 0x10, 0x04, 0x01, 0x80, 0x58, 0x21, 0xF0, 0xFF,
  0xE0, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x28, 0x12, 0x08,
  0xF8, 0x80, 0x70, 0x09, 0x01, 0x20, 0x44, 0x08, 0x41, 0x08, 0x21, 0x08,
  0x11, 0x02, 0x20, 0x48, 0x09, 0x00, 0xA0, 0x18, 0x01, 0x00, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x84, 0x63, 0x18, 0xC6, 0x29, 0x52, 0x54, 0x95, 0x25,
  0x46, 0x61, 0x98, 0x66, 0x08, 0x80, 0x68, 0x08, 0x82, 0x10, 0x81, 0x10,
  0x14, 0x03, 0x00, 0x20, 0x0A, 0x02, 0x40, 0x44, 0x10, 0x84, 0x08, 0x80,
  0xA0, 0x18, 0x80, 0x30, 0x09, 0x01, 0x10, 0x42, 0x10, 0x22, 0x04, 0x80,
  0x60, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0xFF,
  0xC0, 0x08, 0x02, 0x00, 0x80, 0x10, 0x04, 0x01, 0x00, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x10, 0x04, 0x01, 0x00, 0x3F, 0xF8, 0xFE, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x0F, 0xC0, 0x80,
  0x80, 0x40, 0x40, 0x20, 0x20, 0x20, 0x10, 0x10, 0x08, 0x08, 0x08, 0x04,
  0x04, 0x02, 0x02, 0x02, 0x01, 0x01, 0xF8, 0x42, 0x10, 0x84, 0x21, 0x08,
  0x42, 0x10, 0x84, 0x21, 0x08, 0x7E, 0x04, 0x02, 0x81, 0x20, 0x44, 0x21,
  0x10, 0x24, 0x06, 0x01, 0xFF, 0xC0, 0x89, 0x10, 0x7C, 0x41, 0x00, 0x80,
  0x20, 0x13, 0xFA, 0x05, 0x02, 0x81, 0x43, 0x9E, 0x60, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0xF3, 0x85, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x07, 0x05, 0x7C, 0x1E, 0x30, 0x90, 0x50, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x40, 0xB0, 0x87, 0x80, 0x01, 0x01, 0x01, 0x01, 0x01, 0x3D, 0x43, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x43, 0x3D, 0x3C, 0x21, 0xA0, 0x50,
  0x18, 0x0F, 0xFE, 0x01, 0x00, 0x80, 0x20, 0xCF, 0x80, 0x0F, 0x84, 0x02,
  0x01, 0x00, 0x87, 0xFC, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x21, 0xFF, 0x01, 0xCF, 0x84, 0x21, 0x04, 0x81, 0x10, 0x44, 0x30,
  0xF0, 0x40, 0x10, 0x07, 0xF2, 0x02, 0x80, 0xA0, 0x28, 0x09, 0xFC, 0x81,
  0x02, 0x04, 0x08, 0x17, 0xB1, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x0C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x43, 0xFE, 0x02, 0x00, 0x00, 0x0F, 0xE0, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x07, 0xF8, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x0A, 0x09, 0x08, 0x98, 0x58, 0x34, 0x11,
  0x08, 0x44, 0x12, 0x05, 0x03, 0xF8, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x21, 0xFF, 0xB9,
  0xB3, 0x98, 0xC6, 0x11, 0x84, 0x61, 0x18, 0x46, 0x11, 0x84, 0x61, 0x18,
  0x44, 0xBD, 0x8E, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x08, 0x3E,
  0x21, 0xA0, 0x50, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x81, 0x21, 0x8F, 0x80,
  0x9E, 0x70, 0xA0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xE0, 0xAF,
  0x90, 0x08, 0x04, 0x02, 0x00, 0x3D, 0x43, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x43, 0x3D, 0x01, 0x01, 0x01, 0x01, 0xF3, 0xC7, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x0F, 0xF8, 0x3E, 0x20,
  0xA0, 0x30, 0x04, 0x01, 0xF0, 0x06, 0x01, 0x80, 0xE0, 0x8F, 0x80, 0x08,
  0x02, 0x00, 0x80, 0x20, 0xFF, 0xC2, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0xFC, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x43, 0x3D, 0x80, 0xC0, 0xA0, 0x48, 0x24, 0x21, 0x10,
  0x90, 0x48, 0x14, 0x0C, 0x02, 0x00, 0x84, 0x31, 0x86, 0x31, 0x45, 0x29,
  0x25, 0x24, 0x94, 0x92, 0x8A, 0x61, 0x8C, 0x30, 0x82, 0x00, 0x81, 0xA0,
  0x88, 0x84, 0x81, 0x80, 0x40, 0x50, 0x48, 0x42, 0x20, 0xA0, 0x20, 0x80,
  0xC0, 0xA0, 0x48, 0x24, 0x21, 0x10, 0x90, 0x48, 0x18, 0x04, 0x02, 0x02,
  0x01, 0x01, 0x03, 0x80, 0xFF, 0x00, 0x80, 0x80, 0x80, 0x80, 0x40, 0x40,
  0x40, 0x40, 0x40, 0x3F, 0xE0, 0x1F, 0x10, 0x10, 0x10, 0x10, 0x08, 0x04,
  0x04, 0x0C, 0xF0, 0x1C, 0x04, 0x04, 0x08, 0x10, 0x10, 0x10, 0x10, 0x1F,
  0xFF, 0xFF, 0xE0, 0xF8, 0x08, 0x08, 0x08, 0x08, 0x10, 0x10, 0x20, 0x10,
  0x0F, 0x18, 0x20, 0x10, 0x10, 0x08, 0x08, 0x08, 0x08, 0xF8, 0x30, 0x52,
  0x18, 0x66, 0x0E,
};

const GFXglyph IBMPlexMono_ExtraLight21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 2, 15, 13, 5, -15 },
  { 5, 4, 5, 13, 4, -16 },
  { 8, 12, 15, 13, 0, -15 },
  { 31, 10, 19, 13, 1, -17 },
  { 55, 11, 15, 13, 1, -15 },
  { 76, 11, 15, 13, 1, -15 },
  { 97, 1, 5, 13, 6, -16 },
  { 98, 5, 19, 13, 5, -16 },
  { 110, 5, 19, 13, 3, -16 },
  { 122, 11, 10, 13, 1, -12 },
  { 136, 10, 11, 13, 1, -12 },
  { 150, 2, 5, 13, 5, -2 },
  { 152, 6, 1, 13, 3, -7 },
  { 153, 2, 2, 13, 5, -2 },
  { 154, 8, 19, 13, 2, -16 },
  { 173, 10, 15, 13, 1, -15 },
  { 192, 10, 15, 13, 2, -15 },
  { 211, 9, 15, 13, 2, -15 },
  { 228, 9, 15, 13, 1, -15 },
  { 245, 11, 15, 13, 1, -15 },
  { 266, 9, 15, 13, 2, -15 },
  { 283, 9, 15, 13, 2, -15 },
  { 300, 9, 15, 13, 2, -15 },
  { 317, 10, 15, 13, 1, -15 },
  { 336, 9, 15, 13, 2, -15 },
  { 353, 2, 11, 13, 5, -11 },
  { 356, 2, 14, 13, 5, -11 },
  { 360, 9, 11, 13, 2, -12 },
  { 373, 10, 5, 13, 1, -9 },
  { 380, 9, 11, 13, 2, -12 },
  { 393, 9, 15, 13, 2, -15 },
  { 410, 9, 17, 13, 2, -15 },
  { 430, 11, 15, 13, 1, -15 },
  { 451, 9, 15, 13, 2, -15 },
  { 468, 9, 15, 13, 2, -15 },
  { 485, 9, 15, 13, 2, -15 },
  { 502, 9, 15, 13, 2, -15 },
  { 519, 9, 15, 13, 2, -15 },
  { 536, 10, 15, 13, 1, -15 },
  { 555, 9, 15, 13, 2, -15 },
  { 572, 9, 15, 13, 2, -15 },
  { 589, 8, 15, 13, 2, -15 },
  { 604, 10, 15, 13, 2, -15 },
  { 623, 8, 15, 13, 3, -15 },
  { 638, 9, 15, 13, 2, -15 },
  { 655, 9, 15, 13, 2, -15 },
  { 672, 10, 15, 13, 1, -15 },
  { 691, 9, 15, 13, 2, -15 },
  { 708, 10, 18, 13, 1, -15 },
  { 731, 9, 15, 13, 2, -15 },
  { 748, 10, 15, 13, 1, -15 },
  { 767, 11, 15, 13, 1, -15 },
  { 788, 9, 15, 13, 2, -15 },
  { 805, 11, 15, 13, 1, -15 },
  { 826, 10, 15, 13, 1, -15 },
  { 845, 11, 15, 13, 1, -15 },
  { 866, 11, 15, 13, 1, -15 },
  { 887, 11, 15, 13, 1, -15 },
  { 908, 6, 19, 13, 5, -16 },
  { 923, 8, 19, 13, 2, -16 },
  { 942, 5, 19, 13, 2, -16 },
  { 954, 10, 8, 13, 1, -15 },
  { 964, 10, 1, 13, 1, 2 },
  { 966, 3, 4, 13, 4, -17 },
  { 968, 9, 11, 13, 2, -11 },
  { 981, 9, 16, 13, 2, -16 },
  { 999, 9, 11, 13, 2, -11 },
  { 1012, 8, 16, 13, 2, -16 },
  { 1028, 9, 11, 13, 2, -11 },
  { 1041, 9, 16, 13, 2, -16 },
  { 1059, 10, 16, 13, 2, -12 },
  { 1079, 7, 16, 13, 3, -16 },
  { 1093, 9, 15, 13, 2, -15 },
  { 1110, 7, 19, 13, 2, -15 },
  { 1127, 9, 16, 13, 3, -16 },
  { 1145, 9, 16, 13, 2, -16 },
  { 1163, 10, 11, 13, 1, -11 },
  { 1177, 7, 11, 13, 3, -11 },
  { 1187, 9, 11, 13, 2, -11 },
  { 1200, 9, 15, 13, 2, -11 },
  { 1217, 8, 15, 13, 2, -11 },
  { 1232, 10, 11, 13, 2, -11 },
  { 1246, 9, 11, 13, 2, -11 },
  { 1259, 10, 15, 13, 1, -15 },
  { 1278, 8, 11, 13, 2, -11 },
  { 1289, 9, 11, 13, 2, -11 },
  { 1302, 11, 11, 13, 1, -11 },
  { 1318, 9, 11, 13, 2, -11 },
  { 1331, 9, 15, 13, 2, -11 },
  { 1348, 9, 11, 13, 2, -11 },
  { 1361, 8, 19, 13, 2, -16 },
  { 1380, 1, 19, 13, 6, -16 },
  { 1383, 8, 19, 13, 2, -16 },
  { 1402, 10, 4, 13, 1, -8 },
};

const GFXfont IBMPlexMono_ExtraLight21pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLight21pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLight21pt7bGlyphs,
  0x20, 0x7E, 27
};

#endif // _IBMPLEXMONO_EXTRALIGHT21PT7B_H_
