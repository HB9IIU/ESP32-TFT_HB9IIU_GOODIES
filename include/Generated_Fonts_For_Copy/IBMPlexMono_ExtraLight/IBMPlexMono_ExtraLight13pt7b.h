#ifndef _IBMPLEXMONO_EXTRALIGHT13PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHT13PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLight.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLight13pt7bBitmaps[] PROGMEM = {
  0x00, 0xFC, 0x80, 0xFC, 0x14, 0x14, 0x67, 0x28, 0x28, 0x28, 0xEE, 0x48,
  0x48, 0x21, 0xEA, 0x68, 0xA1, 0xE2, 0x49, 0xA5, 0xE2, 0x00, 0x73, 0x26,
  0x53, 0xC0, 0x05, 0xD4, 0xA9, 0x8E, 0x38, 0x91, 0x01, 0x07, 0x32, 0xA3,
  0x42, 0x7A, 0xE0, 0x2A, 0x49, 0x24, 0x91, 0x10, 0x89, 0x22, 0x49, 0x49,
  0x40, 0x20, 0x8A, 0x5E, 0x51, 0x20, 0x20, 0x82, 0x3F, 0x20, 0x82, 0x00,
  0xE0, 0xF0, 0x80, 0x08, 0x44, 0x21, 0x10, 0x84, 0x42, 0x21, 0x00, 0x7A,
  0x28, 0x61, 0xA6, 0x18, 0x62, 0x78, 0x31, 0x49, 0x24, 0x10, 0x41, 0x04,
  0xFC, 0x3B, 0x28, 0x82, 0x08, 0x42, 0x30, 0xFC, 0x74, 0x42, 0x17, 0x04,
  0x31, 0x78, 0x08, 0xE2, 0x92, 0x8A, 0x2F, 0xC2, 0x08, 0x7A, 0x08, 0x1E,
  0x88, 0x10, 0x62, 0x78, 0x10, 0x84, 0x20, 0xBB, 0x18, 0x61, 0x78, 0xFE,
  0x28, 0x84, 0x10, 0x82, 0x08, 0x40, 0x7A, 0x28, 0x62, 0x73, 0x38, 0x61,
  0x78, 0x7A, 0x28, 0x61, 0x7C, 0x20, 0x84, 0x20, 0x82, 0x83, 0x80, 0x04,
  0x66, 0x20, 0x40, 0xC0, 0xC0, 0xFC, 0x00, 0x3F, 0x81, 0x81, 0x03, 0x18,
  0x8C, 0x00, 0x7A, 0x28, 0xC2, 0x30, 0x80, 0x00, 0x20, 0x7A, 0x28, 0xAF,
  0xA7, 0x1C, 0x6F, 0x41, 0xE0, 0x20, 0xC5, 0x14, 0x4A, 0x2F, 0xA1, 0x84,
  0xFA, 0x28, 0xA2, 0xFA, 0x18, 0x61, 0xF8, 0x79, 0x28, 0x60, 0x82, 0x08,
  0x52, 0x78, 0xFA, 0x28, 0x61, 0x86, 0x18, 0x62, 0xF8, 0xFE, 0x08, 0x20,
  0xFE, 0x08, 0x20, 0xFC, 0xFE, 0x08, 0x20, 0xFA, 0x08, 0x20, 0x80, 0x72,
  0x28, 0xE0, 0x9E, 0x18, 0x61, 0x7C, 0x86, 0x18, 0x61, 0xFE, 0x18, 0x61,
  0x84, 0xFC, 0x82, 0x08, 0x20, 0x82, 0x08, 0xFC, 0x78, 0x42, 0x10, 0x84,
  0x31, 0x70, 0x86, 0x29, 0x28, 0xE2, 0x48, 0xA2, 0x84, 0x84, 0x21, 0x08,
  0x42, 0x10, 0xF8, 0x86, 0x3C, 0xF5, 0xB6, 0x98, 0x61, 0x84, 0x87, 0x1C,
  0x69, 0xA6, 0x59, 0x63, 0x84, 0x7A, 0x28, 0x61, 0x86, 0x18, 0x62, 0x78,
  0xFA, 0x18, 0x61, 0x87, 0xE8, 0x20, 0x80, 0x7A, 0x28, 0x61, 0x86, 0x18,
  0x62, 0x78, 0x81, 0x80, 0xFA, 0x18, 0x61, 0x87, 0xE9, 0x22, 0x8C, 0x7A,
  0x28, 0x60, 0x78, 0x10, 0x61, 0x78, 0xFE, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x86, 0x18, 0x61, 0x86, 0x18, 0x62, 0x78, 0x86, 0x18, 0xA2,
  0x49, 0x45, 0x0C, 0x20, 0x86, 0x18, 0x69, 0xB7, 0x5D, 0x72, 0x88, 0x86,
  0x25, 0x0C, 0x21, 0x44, 0xA2, 0x84, 0x82, 0x85, 0x11, 0x41, 0x82, 0x04,
  0x08, 0x10, 0xFC, 0x20, 0x84, 0x21, 0x08, 0x20, 0xFC, 0xF8, 0x88, 0x88,
  0x88, 0x88, 0x8F, 0x84, 0x10, 0x82, 0x10, 0x82, 0x10, 0x82, 0x10, 0xE4,
  0x92, 0x49, 0x24, 0xF0, 0x21, 0x44, 0xA2, 0x84, 0xFC, 0xC0, 0x72, 0x20,
  0x9E, 0x8A, 0x27, 0x40, 0x84, 0x21, 0xE9, 0x46, 0x31, 0x97, 0x80, 0x31,
  0x28, 0x20, 0x81, 0x33, 0x00, 0x08, 0x42, 0xF8, 0xC6, 0x31, 0x8B, 0xC0,
  0x72, 0x28, 0x7F, 0x82, 0x07, 0xC0, 0x1C, 0x82, 0x3F, 0x20, 0x82, 0x08,
  0x23, 0xF0, 0x0D, 0xE8, 0xA2, 0x89, 0xCC, 0x1F, 0x86, 0x17, 0x80, 0x88,
  0x8F, 0x99, 0x99, 0x99, 0x10, 0x00, 0x3C, 0x10, 0x41, 0x04, 0x13, 0xF0,
  0x08, 0x01, 0xF0, 0x84, 0x21, 0x08, 0x42, 0x1F, 0x80, 0x84, 0x21, 0x3A,
  0x62, 0x94, 0x94, 0x40, 0xE0, 0x82, 0x08, 0x20, 0x82, 0x08, 0x23, 0xF0,
  0xEE, 0xDA, 0x69, 0xA6, 0x9A, 0x40, 0xF9, 0x99, 0x99, 0x90, 0x7A, 0x28,
  0x61, 0x86, 0x27, 0x80, 0xF4, 0xA3, 0x18, 0xCB, 0xD0, 0x84, 0x00, 0x7C,
  0x63, 0x18, 0xC5, 0xE1, 0x08, 0x40, 0xEC, 0xC2, 0x08, 0x20, 0x8F, 0xC0,
  0x7A, 0x38, 0x1E, 0x06, 0x17, 0x80, 0x20, 0x43, 0xF9, 0x02, 0x04, 0x08,
  0x10, 0x1E, 0x8C, 0x63, 0x18, 0xC5, 0xE0, 0x86, 0x28, 0x94, 0x50, 0xC2,
  0x00, 0x93, 0x36, 0xAD, 0x56, 0xAD, 0x91, 0x00, 0x8D, 0x25, 0x08, 0x51,
  0x28, 0xC0, 0x86, 0x28, 0x94, 0x50, 0xC2, 0x08, 0x23, 0x00, 0xF8, 0x21,
  0x08, 0x42, 0x0F, 0xC0, 0x39, 0x08, 0x41, 0x70, 0xC2, 0x21, 0x08, 0x70,
  0xFF, 0xF0, 0xE1, 0x08, 0x82, 0x0C, 0x88, 0x21, 0x09, 0xC0, 0x66, 0x99,
  0x80,
};

const GFXglyph IBMPlexMono_ExtraLight13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 1, 9, 8, 3, -9 },
  { 3, 2, 3, 8, 3, -10 },
  { 4, 8, 9, 8, 0, -9 },
  { 13, 6, 11, 8, 1, -10 },
  { 22, 7, 9, 8, 0, -9 },
  { 30, 7, 9, 8, 0, -9 },
  { 38, 1, 3, 8, 3, -10 },
  { 39, 3, 12, 8, 3, -10 },
  { 44, 3, 12, 8, 2, -10 },
  { 49, 6, 6, 8, 1, -7 },
  { 54, 6, 7, 8, 1, -7 },
  { 60, 1, 3, 8, 3, -1 },
  { 61, 4, 1, 8, 2, -4 },
  { 62, 1, 1, 8, 3, -1 },
  { 63, 5, 12, 8, 1, -10 },
  { 71, 6, 9, 8, 1, -9 },
  { 78, 6, 9, 8, 1, -9 },
  { 85, 6, 9, 8, 1, -9 },
  { 92, 5, 9, 8, 1, -9 },
  { 98, 6, 9, 8, 1, -9 },
  { 105, 6, 9, 8, 1, -9 },
  { 112, 6, 9, 8, 1, -9 },
  { 119, 6, 9, 8, 1, -9 },
  { 126, 6, 9, 8, 1, -9 },
  { 133, 6, 9, 8, 1, -9 },
  { 140, 1, 7, 8, 3, -7 },
  { 141, 1, 9, 8, 3, -7 },
  { 143, 6, 7, 8, 1, -7 },
  { 149, 6, 4, 8, 1, -6 },
  { 152, 6, 7, 8, 1, -7 },
  { 158, 6, 9, 8, 1, -9 },
  { 165, 6, 10, 8, 1, -9 },
  { 173, 6, 9, 8, 1, -9 },
  { 180, 6, 9, 8, 1, -9 },
  { 187, 6, 9, 8, 1, -9 },
  { 194, 6, 9, 8, 1, -9 },
  { 201, 6, 9, 8, 1, -9 },
  { 208, 6, 9, 8, 1, -9 },
  { 215, 6, 9, 8, 1, -9 },
  { 222, 6, 9, 8, 1, -9 },
  { 229, 6, 9, 8, 1, -9 },
  { 236, 5, 9, 8, 1, -9 },
  { 242, 6, 9, 8, 1, -9 },
  { 249, 5, 9, 8, 2, -9 },
  { 255, 6, 9, 8, 1, -9 },
  { 262, 6, 9, 8, 1, -9 },
  { 269, 6, 9, 8, 1, -9 },
  { 276, 6, 9, 8, 1, -9 },
  { 283, 6, 11, 8, 1, -9 },
  { 292, 6, 9, 8, 1, -9 },
  { 299, 6, 9, 8, 1, -9 },
  { 306, 7, 9, 8, 0, -9 },
  { 314, 6, 9, 8, 1, -9 },
  { 321, 6, 9, 8, 1, -9 },
  { 328, 6, 9, 8, 1, -9 },
  { 335, 6, 9, 8, 1, -9 },
  { 342, 7, 9, 8, 0, -9 },
  { 350, 6, 9, 8, 1, -9 },
  { 357, 4, 12, 8, 3, -10 },
  { 363, 5, 12, 8, 1, -10 },
  { 371, 3, 12, 8, 1, -10 },
  { 376, 6, 5, 8, 1, -9 },
  { 380, 6, 1, 8, 1, 1 },
  { 381, 1, 2, 8, 3, -11 },
  { 382, 6, 7, 8, 1, -7 },
  { 388, 5, 10, 8, 2, -10 },
  { 395, 6, 7, 8, 1, -7 },
  { 401, 5, 10, 8, 1, -10 },
  { 408, 6, 7, 8, 1, -7 },
  { 414, 6, 10, 8, 1, -10 },
  { 422, 6, 11, 8, 1, -8 },
  { 431, 4, 10, 8, 2, -10 },
  { 436, 6, 10, 8, 1, -10 },
  { 444, 5, 13, 8, 1, -10 },
  { 453, 5, 10, 8, 2, -10 },
  { 460, 6, 10, 8, 1, -10 },
  { 468, 6, 7, 8, 1, -7 },
  { 474, 4, 7, 8, 2, -7 },
  { 478, 6, 7, 8, 1, -7 },
  { 484, 5, 10, 8, 2, -7 },
  { 491, 5, 10, 8, 1, -7 },
  { 498, 6, 7, 8, 1, -7 },
  { 504, 6, 7, 8, 1, -7 },
  { 510, 7, 9, 8, 0, -9 },
  { 518, 5, 7, 8, 1, -7 },
  { 523, 6, 7, 8, 1, -7 },
  { 529, 7, 7, 8, 0, -7 },
  { 536, 6, 7, 8, 1, -7 },
  { 542, 6, 10, 8, 1, -7 },
  { 550, 6, 7, 8, 1, -7 },
  { 556, 5, 12, 8, 1, -10 },
  { 564, 1, 12, 8, 3, -10 },
  { 566, 5, 12, 8, 1, -10 },
  { 574, 6, 3, 8, 1, -5 },
};

const GFXfont IBMPlexMono_ExtraLight13pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLight13pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLight13pt7bGlyphs,
  0x20, 0x7E, 17
};

#endif // _IBMPLEXMONO_EXTRALIGHT13PT7B_H_
