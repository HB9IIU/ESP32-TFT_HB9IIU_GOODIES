#ifndef _IBMPLEXMONO_EXTRALIGHT27PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHT27PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLight.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLight27pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x55, 0x6A, 0x80, 0x3C, 0x8C, 0x63, 0x18, 0xC6, 0x20, 0x02,
  0x10, 0x04, 0x40, 0x10, 0x80, 0x21, 0x00, 0x42, 0x00, 0x84, 0x1F, 0x0F,
  0x82, 0x20, 0x08, 0x40, 0x10, 0x80, 0x21, 0x00, 0x42, 0x0F, 0x87, 0xC2,
  0x10, 0x04, 0x20, 0x08, 0x40, 0x10, 0x80, 0x21, 0x00, 0x44, 0x00, 0x02,
  0x00, 0x20, 0x02, 0x01, 0xF8, 0x62, 0x64, 0x21, 0x82, 0x08, 0x20, 0x82,
  0x0C, 0x20, 0x42, 0x03, 0xA0, 0x0F, 0x80, 0x26, 0x02, 0x10, 0x21, 0x02,
  0x10, 0x21, 0x82, 0x1C, 0x21, 0x62, 0x61, 0xF8, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x3C, 0x06, 0x8C, 0x0A, 0x08, 0x24, 0x10, 0x88, 0x21, 0x10, 0x44,
  0x20, 0x88, 0x23, 0x20, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x44, 0x61,
  0x10, 0x42, 0x20, 0x88, 0x41, 0x10, 0x82, 0x41, 0x05, 0x01, 0x1A, 0x01,
  0xC0, 0x0F, 0x00, 0x43, 0x02, 0x04, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0xF0, 0x74, 0x61, 0x10, 0xC4, 0x81, 0x22,
  0x02, 0x88, 0x06, 0x20, 0x08, 0x40, 0x51, 0x82, 0x61, 0xF0, 0xC0, 0xFE,
  0x06, 0x10, 0x40, 0x82, 0x04, 0x10, 0x20, 0x41, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x80, 0x81, 0x03, 0x02, 0x02, 0x04, 0x04, 0x06, 0xC0, 0x40,
  0x40, 0x40, 0x80, 0x81, 0x02, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x08, 0x10, 0x20, 0x81, 0x04, 0x10, 0xC0, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x03, 0x84, 0x71, 0xFE, 0x00, 0xC0, 0x02, 0x80,
  0x12, 0x00, 0x84, 0x04, 0x08, 0x30, 0x30, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x03, 0xFF, 0xE0, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x00, 0x6D, 0x29, 0x00, 0xFF, 0xF0, 0x00, 0x40,
  0x10, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x40,
  0x10, 0x04, 0x02, 0x00, 0x80, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x40,
  0x10, 0x04, 0x02, 0x00, 0x80, 0x00, 0x0F, 0x83, 0x0C, 0x40, 0x24, 0x02,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x86, 0x18, 0x61, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x14, 0x02, 0x40, 0x23, 0x0C, 0x1F, 0x80, 0x06,
  0x00, 0x70, 0x06, 0x80, 0x64, 0x04, 0x20, 0x41, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x1F, 0xFE, 0x1F, 0x83, 0x0C, 0x40, 0x6C, 0x02,
  0x80, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0xFF, 0xF0, 0x1F,
  0x04, 0x19, 0x01, 0xC0, 0x10, 0x02, 0x00, 0x40, 0x10, 0x04, 0x1F, 0x00,
  0x38, 0x01, 0x80, 0x10, 0x02, 0x00, 0x40, 0x0C, 0x01, 0x80, 0x6C, 0x18,
  0x7C, 0x00, 0x00, 0x60, 0x01, 0x80, 0x0A, 0x00, 0x48, 0x01, 0x20, 0x08,
  0x80, 0x42, 0x02, 0x08, 0x08, 0x20, 0x40, 0x82, 0x02, 0x08, 0x08, 0x40,
  0x22, 0x00, 0x8F, 0xFF, 0xC0, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x3F, 0xE4, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0xF8,
  0x70, 0xC4, 0x02, 0x00, 0x20, 0x01, 0x00, 0x10, 0x01, 0x00, 0x18, 0x02,
  0x40, 0x22, 0x0C, 0x1F, 0x80, 0x01, 0x80, 0x60, 0x08, 0x01, 0x00, 0x10,
  0x02, 0x00, 0x40, 0x04, 0xF8, 0x70, 0xCC, 0x02, 0xC0, 0x38, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x14, 0x03, 0x40, 0x23, 0x0C, 0x1F, 0x80, 0xFF, 0xF8,
  0x01, 0x80, 0x28, 0x02, 0x80, 0x40, 0x04, 0x00, 0xC0, 0x08, 0x00, 0x80,
  0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00,
  0x80, 0x10, 0x00, 0x1F, 0x83, 0x04, 0x40, 0x24, 0x03, 0xC0, 0x18, 0x01,
  0x40, 0x24, 0x02, 0x30, 0x40, 0xF8, 0x30, 0xE4, 0x03, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0xC0, 0x36, 0x06, 0x1F, 0x80, 0x0F, 0x83, 0x0C, 0x40,
  0x24, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x40, 0x14, 0x03, 0x30,
  0x51, 0xFA, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x1C,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x6C, 0x00, 0x00, 0x00, 0x06, 0xD2, 0x90,
  0x00, 0x10, 0x06, 0x00, 0x80, 0x30, 0x0C, 0x01, 0x00, 0x60, 0x08, 0x00,
  0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x10, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x80, 0x06, 0x00,
  0x10, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x60, 0x08,
  0x03, 0x00, 0xC0, 0x10, 0x06, 0x00, 0x80, 0x00, 0x1F, 0x0C, 0x13, 0x01,
  0x40, 0x28, 0x06, 0x00, 0x80, 0x10, 0x04, 0x01, 0x01, 0xC0, 0x20, 0x04,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x70, 0x00, 0x0F,
  0x83, 0x0C, 0x20, 0x24, 0x02, 0x40, 0x24, 0x3A, 0x84, 0x58, 0x83, 0x88,
  0x18, 0x81, 0x88, 0x18, 0x81, 0x88, 0x18, 0x83, 0x84, 0x58, 0x7D, 0x40,
  0x04, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0xFE, 0x03, 0x00, 0x0C, 0x00,
  0x28, 0x01, 0x20, 0x04, 0x80, 0x11, 0x00, 0x84, 0x02, 0x10, 0x08, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x0C, 0x3F, 0xF0, 0x80, 0x42, 0x01, 0x10, 0x02,
  0x40, 0x09, 0x00, 0x28, 0x00, 0x40, 0xFF, 0x10, 0x12, 0x01, 0x40, 0x28,
  0x05, 0x00, 0xA0, 0x14, 0x02, 0x80, 0x9F, 0xE2, 0x03, 0x40, 0x38, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x70, 0x1B, 0xFE, 0x00, 0x0F, 0x81, 0x06,
  0x20, 0x24, 0x01, 0x40, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x40, 0x04, 0x01, 0x20, 0x23, 0x06,
  0x0F, 0x80, 0xFF, 0x10, 0x32, 0x01, 0x40, 0x28, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x02,
  0x80, 0x50, 0x33, 0xF8, 0x00, 0xFF, 0xF0, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x1F, 0xFE, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x1F, 0xFA, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x00, 0x0F,
  0x83, 0x04, 0x60, 0x24, 0x03, 0xC0, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x83, 0xF8, 0x01, 0x80, 0x18, 0x01, 0xC0, 0x14, 0x01, 0x60,
  0x33, 0x05, 0x0F, 0x90, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x3F, 0xFE, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x80, 0xFF, 0xF0, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0xFF, 0xF0,
  0x3F, 0xE0, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x0E, 0x02, 0x40, 0x44,
  0x10, 0x7C, 0x00, 0x80, 0x38, 0x06, 0x80, 0xC8, 0x08, 0x81, 0x08, 0x20,
  0x84, 0x08, 0x80, 0x98, 0x0B, 0x40, 0xE4, 0x0C, 0x20, 0x81, 0x08, 0x10,
  0x80, 0x88, 0x04, 0x80, 0x48, 0x02, 0x80, 0x30, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x0F, 0xFC, 0xC0, 0x3C, 0x03, 0xA0,
  0x3A, 0x05, 0xA0, 0x59, 0x09, 0x90, 0x98, 0x89, 0x89, 0x18, 0x51, 0x86,
  0x18, 0x61, 0x84, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x10, 0x80, 0x38, 0x07, 0x00, 0xD0, 0x1A, 0x03, 0x20, 0x64, 0x0C, 0x41,
  0x88, 0x30, 0x86, 0x10, 0xC1, 0x18, 0x23, 0x02, 0x60, 0x4C, 0x05, 0x80,
  0xB0, 0x0E, 0x01, 0x80, 0x0F, 0x83, 0x0C, 0x40, 0x24, 0x02, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x14, 0x02, 0x40, 0x23, 0x0C, 0x1F, 0x80, 0xFF, 0x90, 0x1A,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x1B, 0xFE,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x00,
  0x0F, 0x83, 0x0C, 0x40, 0x24, 0x02, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x14, 0x02,
  0x40, 0x23, 0x0C, 0x1F, 0x80, 0x20, 0x02, 0x00, 0x20, 0x03, 0xE0, 0xFF,
  0x90, 0x1A, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x1B, 0xFE, 0x42, 0x08, 0x21, 0x06, 0x20, 0x44, 0x04, 0x80, 0xD0, 0x0A,
  0x00, 0x80, 0x1F, 0x86, 0x06, 0x40, 0x38, 0x00, 0x80, 0x08, 0x00, 0xC0,
  0x04, 0x00, 0x38, 0x00, 0xF8, 0x00, 0x60, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x18, 0x01, 0xC0, 0x36, 0x06, 0x1F, 0x80, 0xFF, 0xFC, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x14, 0x02, 0x80, 0x4C, 0x10, 0xFC, 0x00, 0xC0, 0x05, 0x00, 0x24,
  0x00, 0x98, 0x02, 0x20, 0x10, 0x80, 0x42, 0x01, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x80, 0x86, 0x02, 0x10, 0x08, 0x40, 0x11, 0x00, 0x48, 0x01, 0x20,
  0x02, 0x80, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x14, 0x00, 0x50,
  0x02, 0x40, 0x09, 0x00, 0x24, 0x30, 0x90, 0xC2, 0x43, 0x09, 0x12, 0x24,
  0x48, 0x91, 0x22, 0x44, 0x48, 0xA1, 0x22, 0x85, 0x0A, 0x14, 0x30, 0x30,
  0xC0, 0xC3, 0x03, 0x00, 0xC0, 0x0D, 0x80, 0x22, 0x01, 0x04, 0x0C, 0x18,
  0x20, 0x21, 0x00, 0x4C, 0x01, 0x20, 0x03, 0x00, 0x0C, 0x00, 0x38, 0x01,
  0x20, 0x0C, 0x40, 0x21, 0x01, 0x02, 0x0C, 0x04, 0x20, 0x11, 0x00, 0x2C,
  0x00, 0x40, 0x80, 0x06, 0x80, 0x19, 0x00, 0x21, 0x00, 0x83, 0x01, 0x02,
  0x04, 0x02, 0x10, 0x06, 0x20, 0x04, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x7F, 0xF8, 0x00, 0x20, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x60, 0x01, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x0F, 0xFF, 0xC0,
  0xFF, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0xFE, 0x80, 0x20,
  0x04, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x10, 0x04, 0x00, 0x80,
  0x20, 0x04, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x10, 0x04, 0x00,
  0x80, 0x20, 0x08, 0x01, 0x00, 0x40, 0xFC, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41,
  0xFC, 0x06, 0x00, 0x38, 0x02, 0x40, 0x11, 0x01, 0x08, 0x10, 0x20, 0x81,
  0x08, 0x04, 0x40, 0x14, 0x00, 0xC0, 0xFF, 0xF8, 0x84, 0x22, 0x10, 0x1F,
  0x06, 0x08, 0x80, 0x40, 0x04, 0x00, 0x40, 0x04, 0x3F, 0xC6, 0x04, 0x80,
  0x48, 0x04, 0x80, 0x48, 0x04, 0x41, 0xC3, 0xE3, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x27, 0xC5, 0x04, 0xC0, 0x50, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x38, 0x0A, 0x82, 0x4F, 0x80,
  0x1F, 0x04, 0x11, 0x01, 0x40, 0x28, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x01, 0x20, 0x32, 0x08, 0x3E, 0x00, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x47, 0xC9, 0x85, 0x40, 0x68, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x40, 0x28, 0x0C, 0xC2, 0x8F, 0x90,
  0x0F, 0x83, 0x04, 0x40, 0x24, 0x02, 0x80, 0x18, 0x01, 0xFF, 0xF8, 0x00,
  0x80, 0x04, 0x00, 0x40, 0x16, 0x02, 0x30, 0x40, 0xF8, 0x03, 0xF0, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0xFF, 0xF0, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x0F, 0xFF, 0x00, 0x78, 0x7E, 0x0C, 0x30, 0x40, 0x44, 0x02, 0x20,
  0x11, 0x00, 0x84, 0x04, 0x30, 0xC0, 0x7C, 0x0C, 0x00, 0x80, 0x02, 0x00,
  0x0F, 0xF1, 0x80, 0x48, 0x01, 0x80, 0x0E, 0x00, 0xD8, 0x0C, 0x7F, 0x80,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x09, 0xF2, 0x86, 0xC0, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x06, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x0F, 0xFF, 0x01, 0x80, 0xC0, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0xFF, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x1C, 0x04, 0x83,
  0x10, 0xC2, 0x20, 0x48, 0x0A, 0x81, 0x88, 0x20, 0x84, 0x18, 0x81, 0x10,
  0x12, 0x01, 0x40, 0x10, 0xFE, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x0F, 0xFF, 0xB8, 0xEC,
  0x51, 0x86, 0x18, 0x21, 0x82, 0x18, 0x21, 0x82, 0x18, 0x21, 0x82, 0x18,
  0x21, 0x82, 0x18, 0x21, 0x82, 0x18, 0x21, 0x9F, 0x28, 0x6C, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x10, 0x0F, 0x83, 0x0C, 0x40, 0x24, 0x02, 0xC0, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x40, 0x24, 0x02, 0x30, 0xC1, 0xF8, 0x9F, 0x14,
  0x13, 0x01, 0x40, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xE0, 0x2A, 0x09, 0x3E, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x00, 0x1F, 0x26, 0x15, 0x01, 0xA0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x05, 0x00, 0xA0, 0x33, 0x0A, 0x3E, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0xFC, 0xF8, 0x28, 0x01, 0x80, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x7F, 0xF8, 0x1F, 0x82, 0x06, 0x40, 0x34, 0x00, 0x40, 0x06, 0x00,
  0x1F, 0x00, 0x1E, 0x00, 0x30, 0x01, 0x00, 0x1C, 0x01, 0x30, 0x61, 0xFC,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x7F, 0xFC, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0xFE, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x07, 0x03, 0x61, 0xCF,
  0x90, 0x80, 0x14, 0x02, 0x40, 0x22, 0x02, 0x20, 0x42, 0x04, 0x10, 0x81,
  0x08, 0x10, 0x80, 0x90, 0x09, 0x00, 0x50, 0x06, 0x00, 0x60, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x61, 0x21, 0x44, 0x89, 0x12, 0x24, 0x48, 0x92, 0x12,
  0x48, 0x48, 0xA1, 0x22, 0x85, 0x0C, 0x0C, 0x30, 0x30, 0xC0, 0xC0, 0xC0,
  0x36, 0x02, 0x20, 0x41, 0x08, 0x09, 0x80, 0xD0, 0x06, 0x00, 0x60, 0x09,
  0x00, 0x98, 0x10, 0x82, 0x04, 0x40, 0x2C, 0x03, 0x80, 0x14, 0x01, 0x40,
  0x22, 0x02, 0x20, 0x42, 0x04, 0x10, 0x81, 0x08, 0x08, 0x80, 0x90, 0x09,
  0x00, 0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0xF0,
  0x00, 0xFF, 0xC0, 0x08, 0x02, 0x00, 0x80, 0x30, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x06, 0x00, 0x80, 0x20, 0x08, 0x01, 0xFF, 0xC0, 0x0F, 0xC2, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x10, 0x02, 0x00, 0x80, 0x20, 0x10,
  0xF8, 0x03, 0x00, 0x20, 0x08, 0x02, 0x01, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFC, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x20, 0x10, 0x04, 0x01, 0x00, 0x20,
  0x07, 0xC3, 0x01, 0x00, 0x40, 0x10, 0x02, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0xFC, 0x00, 0x38, 0x0A, 0x60, 0xA1, 0x85, 0x06, 0x68,
  0x0E, 0x00,
};

const GFXglyph IBMPlexMono_ExtraLight27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 2, 19, 16, 7, -19 },
  { 6, 5, 7, 16, 6, -20 },
  { 11, 15, 19, 16, 1, -19 },
  { 47, 12, 25, 16, 2, -22 },
  { 85, 15, 19, 16, 1, -19 },
  { 121, 14, 19, 16, 1, -19 },
  { 155, 1, 7, 16, 8, -20 },
  { 156, 7, 25, 16, 6, -21 },
  { 178, 7, 25, 16, 3, -21 },
  { 200, 14, 13, 16, 1, -15 },
  { 223, 13, 13, 16, 2, -15 },
  { 245, 3, 6, 16, 6, -2 },
  { 248, 8, 1, 16, 4, -9 },
  { 249, 2, 2, 16, 7, -2 },
  { 250, 10, 25, 16, 3, -21 },
  { 282, 12, 19, 16, 2, -19 },
  { 311, 13, 19, 16, 2, -19 },
  { 342, 12, 19, 16, 2, -19 },
  { 371, 11, 19, 16, 2, -19 },
  { 398, 14, 19, 16, 1, -19 },
  { 432, 12, 19, 16, 2, -19 },
  { 461, 12, 19, 16, 2, -19 },
  { 490, 12, 19, 16, 2, -19 },
  { 519, 12, 19, 16, 2, -19 },
  { 548, 12, 19, 16, 2, -19 },
  { 577, 2, 14, 16, 7, -14 },
  { 581, 3, 18, 16, 6, -14 },
  { 588, 12, 15, 16, 2, -16 },
  { 611, 13, 6, 16, 2, -11 },
  { 621, 12, 15, 16, 2, -16 },
  { 644, 11, 19, 16, 3, -19 },
  { 671, 12, 22, 16, 2, -19 },
  { 704, 14, 19, 16, 1, -19 },
  { 738, 11, 19, 16, 3, -19 },
  { 765, 12, 19, 16, 2, -19 },
  { 794, 11, 19, 16, 3, -19 },
  { 821, 11, 19, 16, 3, -19 },
  { 848, 11, 19, 16, 3, -19 },
  { 875, 12, 19, 16, 2, -19 },
  { 904, 11, 19, 16, 3, -19 },
  { 931, 12, 19, 16, 2, -19 },
  { 960, 11, 19, 16, 2, -19 },
  { 987, 12, 19, 16, 3, -19 },
  { 1016, 10, 19, 16, 4, -19 },
  { 1040, 12, 19, 16, 2, -19 },
  { 1069, 11, 19, 16, 3, -19 },
  { 1096, 12, 19, 16, 2, -19 },
  { 1125, 11, 19, 16, 3, -19 },
  { 1152, 12, 23, 16, 2, -19 },
  { 1187, 11, 19, 16, 3, -19 },
  { 1214, 12, 19, 16, 2, -19 },
  { 1243, 14, 19, 16, 1, -19 },
  { 1277, 11, 19, 16, 3, -19 },
  { 1304, 14, 19, 16, 1, -19 },
  { 1338, 14, 19, 16, 1, -19 },
  { 1372, 14, 19, 16, 1, -19 },
  { 1406, 15, 19, 16, 1, -19 },
  { 1442, 14, 19, 16, 1, -19 },
  { 1476, 7, 25, 16, 7, -21 },
  { 1498, 10, 25, 16, 3, -21 },
  { 1530, 6, 25, 16, 3, -21 },
  { 1549, 13, 10, 16, 2, -19 },
  { 1566, 13, 1, 16, 2, 3 },
  { 1568, 4, 5, 16, 5, -21 },
  { 1571, 12, 14, 16, 2, -14 },
  { 1592, 11, 20, 16, 3, -20 },
  { 1620, 11, 14, 16, 3, -14 },
  { 1640, 11, 20, 16, 2, -20 },
  { 1668, 12, 14, 16, 2, -14 },
  { 1689, 12, 20, 16, 2, -20 },
  { 1719, 13, 20, 16, 2, -15 },
  { 1752, 10, 20, 16, 3, -20 },
  { 1777, 12, 20, 16, 3, -20 },
  { 1807, 9, 25, 16, 3, -20 },
  { 1836, 11, 20, 16, 4, -20 },
  { 1864, 12, 20, 16, 2, -20 },
  { 1894, 12, 14, 16, 2, -14 },
  { 1915, 10, 14, 16, 3, -14 },
  { 1933, 12, 14, 16, 2, -14 },
  { 1954, 11, 19, 16, 3, -14 },
  { 1981, 11, 19, 16, 2, -14 },
  { 2008, 13, 14, 16, 2, -14 },
  { 2031, 12, 14, 16, 2, -14 },
  { 2052, 13, 19, 16, 1, -19 },
  { 2083, 10, 14, 16, 3, -14 },
  { 2101, 12, 14, 16, 2, -14 },
  { 2122, 14, 14, 16, 1, -14 },
  { 2147, 12, 14, 16, 2, -14 },
  { 2168, 12, 19, 16, 2, -14 },
  { 2197, 11, 14, 16, 3, -14 },
  { 2217, 10, 25, 16, 3, -21 },
  { 2249, 1, 25, 16, 8, -21 },
  { 2253, 10, 25, 16, 3, -21 },
  { 2285, 13, 5, 16, 2, -11 },
};

const GFXfont IBMPlexMono_ExtraLight27pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLight27pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLight27pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _IBMPLEXMONO_EXTRALIGHT27PT7B_H_
