#ifndef _IBMPLEXMONO_EXTRALIGHT34PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHT34PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLight.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLight34pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x00, 0x01, 0xBE, 0x86, 0x18,
  0x61, 0x86, 0x18, 0x61, 0x84, 0x00, 0x82, 0x00, 0x30, 0xC0, 0x04, 0x10,
  0x00, 0x82, 0x00, 0x10, 0x40, 0x02, 0x08, 0x00, 0x41, 0x00, 0x18, 0x60,
  0x7E, 0x0F, 0xE0, 0x41, 0x00, 0x08, 0x20, 0x01, 0x04, 0x00, 0x20, 0x80,
  0x0C, 0x30, 0x01, 0x04, 0x07, 0xE0, 0xFE, 0x04, 0x10, 0x00, 0x82, 0x00,
  0x30, 0x40, 0x04, 0x18, 0x00, 0x82, 0x00, 0x10, 0x40, 0x02, 0x08, 0x00,
  0x41, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x07, 0xF0, 0x18, 0x8C,
  0x20, 0x86, 0x40, 0x83, 0x40, 0x80, 0x40, 0x80, 0x40, 0x80, 0x40, 0x80,
  0x60, 0x80, 0x20, 0x80, 0x18, 0x80, 0x07, 0xC0, 0x00, 0xB8, 0x00, 0x86,
  0x00, 0x82, 0x00, 0x81, 0x00, 0x81, 0x00, 0x81, 0x00, 0x81, 0x80, 0x81,
  0xC0, 0x83, 0x60, 0x86, 0x38, 0x8C, 0x0F, 0xF0, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x1E, 0x00, 0x6C, 0x20, 0x09, 0x02, 0x02, 0x40, 0x40, 0x88,
  0x0C, 0x11, 0x00, 0x84, 0x20, 0x30, 0x84, 0x04, 0x20, 0x40, 0x8C, 0x0C,
  0x21, 0x00, 0x78, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x01,
  0x8C, 0x60, 0x23, 0x02, 0x08, 0x40, 0x41, 0x08, 0x08, 0x41, 0x01, 0x18,
  0x20, 0x22, 0x04, 0x04, 0x80, 0xC0, 0x90, 0x0C, 0x64, 0x00, 0xF8, 0x03,
  0xE0, 0x03, 0x0C, 0x01, 0x81, 0x80, 0x40, 0x20, 0x10, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x38, 0x00, 0x33, 0x03, 0xC8, 0x60, 0x84, 0x0C, 0x21, 0x01, 0x08, 0xC0,
  0x26, 0x30, 0x05, 0x0C, 0x01, 0xC3, 0x00, 0x30, 0x40, 0x0E, 0x18, 0x04,
  0xC3, 0x02, 0x10, 0x3F, 0x03, 0xFF, 0x80, 0x03, 0x04, 0x08, 0x18, 0x10,
  0x20, 0x20, 0x40, 0x40, 0x40, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x40, 0x40, 0x40, 0x20, 0x20, 0x10, 0x18, 0x08,
  0x04, 0x03, 0xC0, 0x10, 0x04, 0x01, 0x00, 0xC0, 0x20, 0x08, 0x04, 0x02,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x06, 0x03, 0x01, 0x80, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x08, 0x04, 0x02, 0x02, 0x03, 0x01, 0x01, 0x01, 0x03,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x03, 0x02, 0x0E, 0x71, 0x3C, 0x07, 0xF0, 0x00, 0xC0, 0x00, 0xD0,
  0x00, 0x4C, 0x00, 0x42, 0x00, 0x60, 0x80, 0x60, 0x20, 0x20, 0x18, 0x20,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0xFF, 0xFF, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x76, 0x64, 0xCC, 0x88, 0x80, 0xFF, 0x80, 0xDF, 0x00, 0x00, 0x04, 0x00,
  0x20, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00,
  0x60, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00,
  0x40, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00,
  0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01,
  0x00, 0x0C, 0x00, 0x00, 0x07, 0xE0, 0x0C, 0x18, 0x10, 0x0C, 0x20, 0x04,
  0x60, 0x02, 0x40, 0x02, 0x40, 0x03, 0x40, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC1, 0x81, 0xC1, 0x81, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0x40, 0x01, 0x40, 0x03, 0x40, 0x02, 0x60, 0x02, 0x20, 0x04, 0x10, 0x0C,
  0x0C, 0x18, 0x07, 0xE0, 0x03, 0x80, 0x06, 0x80, 0x0C, 0x80, 0x18, 0x80,
  0x20, 0x80, 0xC0, 0x80, 0x80, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0xFF, 0xFF, 0x0F, 0xC0, 0x60, 0x61, 0x80, 0x66, 0x00, 0x48,
  0x00, 0x90, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x60, 0x00, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x7F,
  0xFF, 0x07, 0xE0, 0x30, 0x60, 0x80, 0x23, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0xC0, 0x7E, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x06, 0x00, 0x04, 0x00,
  0x18, 0x00, 0x3C, 0x00, 0x4C, 0x01, 0x8C, 0x0E, 0x07, 0xF0, 0x00, 0x0C,
  0x00, 0x05, 0x00, 0x01, 0x40, 0x00, 0x90, 0x00, 0x64, 0x00, 0x11, 0x00,
  0x08, 0x40, 0x06, 0x10, 0x01, 0x04, 0x00, 0x81, 0x00, 0x60, 0x40, 0x10,
  0x10, 0x08, 0x04, 0x06, 0x01, 0x01, 0x00, 0x40, 0x80, 0x10, 0x60, 0x04,
  0x10, 0x01, 0x0F, 0xFF, 0xFC, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x3F, 0xFD, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0xFC, 0x14,
  0x0C, 0x60, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x80, 0x0D, 0x00, 0x63, 0x03, 0x03, 0xF0, 0x00, 0xE0,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10,
  0x00, 0x60, 0x00, 0x8F, 0x81, 0x60, 0xC5, 0x00, 0xCC, 0x00, 0xD8, 0x00,
  0xA0, 0x01, 0x40, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x16, 0x00, 0x24,
  0x00, 0xCC, 0x03, 0x0E, 0x0C, 0x07, 0xE0, 0xFF, 0xFF, 0x00, 0x0A, 0x00,
  0x14, 0x00, 0x68, 0x00, 0x90, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20,
  0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00,
  0x80, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80,
  0x02, 0x00, 0x0C, 0x00, 0x07, 0xE0, 0x18, 0x18, 0x30, 0x04, 0x20, 0x06,
  0x60, 0x02, 0x40, 0x02, 0x40, 0x02, 0x60, 0x02, 0x20, 0x06, 0x30, 0x04,
  0x18, 0x18, 0x07, 0xE0, 0x18, 0x18, 0x20, 0x06, 0x40, 0x02, 0x40, 0x03,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x40, 0x03, 0x40, 0x02, 0x20, 0x06,
  0x18, 0x1C, 0x07, 0xF0, 0x0F, 0xC0, 0x30, 0x60, 0x80, 0x62, 0x00, 0x6C,
  0x00, 0x50, 0x00, 0xA0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0F, 0x00,
  0x1A, 0x00, 0x66, 0x01, 0x47, 0x04, 0x83, 0xF3, 0x00, 0x04, 0x00, 0x18,
  0x00, 0x20, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x06,
  0x00, 0xDF, 0x00, 0x00, 0x00, 0x00, 0x06, 0xF8, 0x67, 0x60, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x66, 0x4C, 0xC8, 0x88, 0x00, 0x02, 0x00, 0x18,
  0x00, 0xE0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x08, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x0E, 0x00, 0x30,
  0x01, 0x80, 0x06, 0x00, 0x30, 0x01, 0x80, 0x02, 0x00, 0x00, 0x0F, 0xC0,
  0x60, 0xC2, 0x00, 0x90, 0x03, 0xC0, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0xF0, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0xC0, 0x60, 0xC2, 0x01, 0x88, 0x02, 0x40,
  0x09, 0x00, 0x14, 0x00, 0x60, 0x79, 0x83, 0x16, 0x18, 0x38, 0x40, 0x61,
  0x01, 0x84, 0x06, 0x10, 0x18, 0x40, 0x61, 0x01, 0x84, 0x06, 0x10, 0x18,
  0x40, 0x60, 0x87, 0x81, 0xF5, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00,
  0xC0, 0x01, 0x80, 0x01, 0xFE, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x50, 0x00,
  0x48, 0x00, 0x26, 0x00, 0x11, 0x00, 0x10, 0x80, 0x08, 0x40, 0x04, 0x10,
  0x04, 0x08, 0x02, 0x04, 0x01, 0x01, 0x01, 0x80, 0x80, 0x80, 0x40, 0x40,
  0x10, 0x7F, 0xF8, 0x20, 0x04, 0x10, 0x03, 0x18, 0x00, 0x88, 0x00, 0x44,
  0x00, 0x36, 0x00, 0x0A, 0x00, 0x05, 0x00, 0x03, 0xFF, 0xE1, 0x00, 0x62,
  0x00, 0x64, 0x00, 0x48, 0x00, 0xD0, 0x01, 0xA0, 0x03, 0x40, 0x06, 0x80,
  0x09, 0x00, 0x32, 0x00, 0xC7, 0xFF, 0x08, 0x01, 0x90, 0x01, 0xA0, 0x01,
  0x40, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x50,
  0x01, 0xA0, 0x06, 0x7F, 0xF0, 0x07, 0xE0, 0x30, 0x70, 0xC0, 0x33, 0x00,
  0x24, 0x00, 0x78, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x36, 0x00, 0x46, 0x01, 0x86, 0x06,
  0x03, 0xF0, 0xFF, 0x82, 0x03, 0x88, 0x03, 0x20, 0x04, 0x80, 0x0A, 0x00,
  0x28, 0x00, 0xE0, 0x03, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xA0,
  0x02, 0x80, 0x12, 0x00, 0xC8, 0x06, 0x3F, 0xE0, 0xFF, 0xFE, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x3F, 0xFE, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x3F, 0xFE, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x03, 0xE0, 0x0C, 0x18,
  0x10, 0x0C, 0x20, 0x06, 0x20, 0x02, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0xFF,
  0xC0, 0x03, 0x40, 0x03, 0x40, 0x03, 0x40, 0x03, 0x40, 0x03, 0x20, 0x03,
  0x20, 0x07, 0x10, 0x07, 0x0C, 0x1B, 0x07, 0xE3, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x7F, 0xFF, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0xFF, 0xFC, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x3F, 0xFF, 0x3F, 0xF8, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x03, 0x00, 0x3C, 0x01, 0x20, 0x18, 0xC1, 0x83, 0xF0, 0xC0,
  0x03, 0xC0, 0x04, 0xC0, 0x0C, 0xC0, 0x18, 0xC0, 0x30, 0xC0, 0x60, 0xC0,
  0x40, 0xC0, 0x80, 0xC1, 0x00, 0xC2, 0x00, 0xC6, 0x00, 0xCF, 0x00, 0xD9,
  0x00, 0xF0, 0x80, 0xE0, 0xC0, 0xC0, 0x40, 0xC0, 0x20, 0xC0, 0x30, 0xC0,
  0x10, 0xC0, 0x18, 0xC0, 0x0C, 0xC0, 0x04, 0xC0, 0x06, 0xC0, 0x03, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x1F, 0xFF, 0xC0, 0x07, 0x80, 0x1F, 0x80, 0x3D, 0x00, 0xFA, 0x01, 0x72,
  0x02, 0xE4, 0x09, 0xC4, 0x13, 0x88, 0x47, 0x18, 0x8E, 0x13, 0x1C, 0x24,
  0x38, 0x28, 0x70, 0x60, 0xE0, 0x41, 0xC1, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0xC0,
  0x07, 0x80, 0x1A, 0x00, 0x6C, 0x01, 0x90, 0x06, 0x60, 0x18, 0x80, 0x63,
  0x01, 0x84, 0x06, 0x18, 0x18, 0x20, 0x60, 0xC1, 0x81, 0x06, 0x06, 0x18,
  0x08, 0x60, 0x31, 0x80, 0x46, 0x01, 0x98, 0x02, 0x60, 0x0D, 0x80, 0x16,
  0x00, 0x78, 0x00, 0xE0, 0x03, 0x07, 0xE0, 0x0C, 0x18, 0x10, 0x0C, 0x20,
  0x04, 0x60, 0x02, 0x40, 0x02, 0x40, 0x03, 0x40, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0x40, 0x01, 0x40, 0x03, 0x40, 0x02, 0x60, 0x02, 0x20, 0x04, 0x10,
  0x0C, 0x0C, 0x18, 0x07, 0xE0, 0xFF, 0xE2, 0x00, 0xC8, 0x00, 0xA0, 0x03,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x28, 0x00,
  0xA0, 0x0C, 0xFF, 0xE2, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x07,
  0xE0, 0x0C, 0x18, 0x10, 0x0C, 0x20, 0x04, 0x60, 0x02, 0x40, 0x02, 0x40,
  0x03, 0x40, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x40, 0x01, 0x40, 0x03, 0x40,
  0x02, 0x60, 0x02, 0x20, 0x04, 0x10, 0x0C, 0x0C, 0x18, 0x07, 0xE0, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0xFC, 0xFF, 0xE2, 0x00, 0xC8, 0x00,
  0xA0, 0x02, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x38, 0x00, 0xA0, 0x0C, 0xFF, 0xE2, 0x08, 0x08, 0x10, 0x20, 0x60, 0x80,
  0x82, 0x01, 0x08, 0x06, 0x20, 0x08, 0x80, 0x32, 0x00, 0x48, 0x00, 0xA0,
  0x03, 0x07, 0xF0, 0x18, 0x1C, 0x20, 0x06, 0x40, 0x03, 0x40, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x18, 0x00, 0x07,
  0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x02, 0x60, 0x06, 0x38, 0x1C, 0x0F,
  0xF0, 0xFF, 0xFF, 0xC0, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x07, 0x00, 0x1C, 0x00, 0x50, 0x01, 0x40, 0x09, 0x80, 0x23, 0x03, 0x03,
  0xF8, 0x80, 0x01, 0xE0, 0x00, 0xB0, 0x00, 0x48, 0x00, 0x64, 0x00, 0x23,
  0x00, 0x10, 0x80, 0x18, 0x40, 0x08, 0x30, 0x04, 0x08, 0x06, 0x04, 0x02,
  0x03, 0x01, 0x00, 0x81, 0x80, 0x40, 0x80, 0x30, 0x40, 0x08, 0x20, 0x04,
  0x20, 0x03, 0x10, 0x00, 0x88, 0x00, 0x4C, 0x00, 0x24, 0x00, 0x0A, 0x00,
  0x07, 0x00, 0x03, 0x00, 0x80, 0x01, 0xC0, 0x00, 0xA0, 0x00, 0x50, 0x00,
  0x28, 0x00, 0x14, 0x00, 0x0B, 0x00, 0x05, 0x83, 0x02, 0x41, 0x81, 0x20,
  0xA0, 0x90, 0x50, 0x48, 0x48, 0x64, 0x24, 0x22, 0x11, 0x11, 0x18, 0x88,
  0x88, 0x44, 0x44, 0x32, 0x32, 0x09, 0x1A, 0x04, 0x85, 0x02, 0x42, 0x81,
  0xA1, 0xC0, 0x50, 0xC0, 0x38, 0x60, 0x18, 0x60, 0x00, 0xC8, 0x00, 0x63,
  0x00, 0x10, 0x60, 0x08, 0x08, 0x06, 0x03, 0x01, 0x00, 0x40, 0x80, 0x08,
  0x60, 0x03, 0x10, 0x00, 0x48, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x68, 0x00, 0x13, 0x00, 0x08, 0x40, 0x06, 0x08, 0x01, 0x03, 0x00,
  0x80, 0x40, 0x60, 0x08, 0x10, 0x03, 0x0C, 0x00, 0x46, 0x00, 0x1B, 0x00,
  0x03, 0xC0, 0x00, 0x68, 0x00, 0x19, 0x80, 0x02, 0x10, 0x00, 0x81, 0x00,
  0x30, 0x30, 0x04, 0x02, 0x01, 0x80, 0x60, 0x20, 0x04, 0x08, 0x00, 0x43,
  0x00, 0x0C, 0x40, 0x00, 0x98, 0x00, 0x1A, 0x00, 0x01, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0xFF, 0xFF,
  0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x60, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x10, 0x00, 0x18, 0x00, 0x18, 0x00, 0x08, 0x00, 0x08, 0x00, 0x0C, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x02, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0xC0, 0x01, 0x00, 0x06,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x40, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40,
  0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x06,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x40, 0xFF, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x07, 0xFE, 0x01, 0x80, 0x01, 0xC0, 0x02, 0x40, 0x06, 0x20, 0x04, 0x30,
  0x0C, 0x10, 0x08, 0x18, 0x10, 0x08, 0x10, 0x04, 0x20, 0x04, 0x60, 0x02,
  0x40, 0x03, 0x80, 0x01, 0xFF, 0xFF, 0x8C, 0x42, 0x31, 0x1F, 0x80, 0x60,
  0xC1, 0x00, 0xC4, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x1F, 0xF0, 0xC0, 0x23, 0x00, 0x44, 0x00, 0x88, 0x01, 0x10, 0x02, 0x20,
  0x04, 0x40, 0x38, 0x60, 0xD0, 0x7E, 0x1C, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x23, 0xF0, 0x90, 0x63, 0x80,
  0x4C, 0x01, 0xA0, 0x02, 0x80, 0x0A, 0x00, 0x38, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0xE0, 0x02, 0x80, 0x0B, 0x00, 0x6C, 0x01, 0x2C,
  0x18, 0x8F, 0x80, 0x0F, 0xC1, 0x83, 0x18, 0x04, 0x80, 0x18, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x01, 0x00, 0x2C, 0x02, 0x30, 0x20, 0x7E, 0x00, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x21, 0xF1, 0x30, 0x6B,
  0x00, 0xD0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xA0, 0x05, 0x80, 0x66, 0x0D,
  0x0F, 0x88, 0x0F, 0xC0, 0x30, 0x60, 0x80, 0x62, 0x00, 0x44, 0x00, 0x50,
  0x00, 0xA0, 0x01, 0x40, 0x03, 0xFF, 0xFF, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x0C, 0x00, 0x08, 0x00, 0x90, 0x03, 0x10, 0x04, 0x18, 0x30, 0x0F, 0x80,
  0x01, 0xFE, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x7F, 0xFF, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0xFF, 0xFC, 0x00,
  0x1F, 0x07, 0xD0, 0x18, 0x30, 0x20, 0x10, 0x20, 0x08, 0x60, 0x08, 0x60,
  0x08, 0x60, 0x08, 0x60, 0x08, 0x20, 0x08, 0x30, 0x10, 0x18, 0x30, 0x0F,
  0xC0, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x20, 0x00, 0x1F, 0xF8, 0x60,
  0x06, 0xC0, 0x02, 0x80, 0x03, 0x80, 0x03, 0x80, 0x02, 0xC0, 0x06, 0x60,
  0x0C, 0x1F, 0xF0, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x11, 0xF0, 0xB0, 0x66, 0x01, 0xB0, 0x05, 0x00, 0x28, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x18, 0x03, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0xFF, 0xFC, 0x00, 0x30, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x37, 0xFE, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x06, 0xC0, 0x19, 0x80, 0x63, 0x01,
  0x06, 0x04, 0x0C, 0x10, 0x18, 0xC0, 0x33, 0x80, 0x6D, 0x80, 0xF1, 0x01,
  0xC1, 0x03, 0x03, 0x06, 0x03, 0x0C, 0x03, 0x18, 0x02, 0x30, 0x02, 0x60,
  0x06, 0xC0, 0x06, 0xFF, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0xFF, 0xFC, 0x9E,
  0x3C, 0xA1, 0x42, 0xC1, 0x81, 0xC0, 0x81, 0x80, 0x81, 0x80, 0x81, 0x80,
  0x81, 0x80, 0x81, 0x80, 0x81, 0x80, 0x81, 0x80, 0x81, 0x80, 0x81, 0x80,
  0x81, 0x80, 0x81, 0x80, 0x81, 0x80, 0x81, 0x80, 0x81, 0x80, 0x81, 0x8F,
  0x85, 0x83, 0x30, 0x0D, 0x80, 0x28, 0x01, 0x40, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xC0, 0x0F, 0xC0, 0x30, 0x60, 0x80, 0x62, 0x00,
  0x44, 0x00, 0x50, 0x00, 0xA0, 0x01, 0x40, 0x02, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x14, 0x00, 0x28, 0x00, 0x48, 0x00, 0x90, 0x02, 0x10, 0x0C, 0x18,
  0x30, 0x1F, 0x80, 0x8F, 0xC2, 0x41, 0x8E, 0x01, 0x30, 0x06, 0x80, 0x0A,
  0x00, 0x28, 0x00, 0xE0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03,
  0x80, 0x0A, 0x00, 0x2C, 0x01, 0xB0, 0x04, 0xB0, 0x62, 0x3E, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x00, 0x0F,
  0x89, 0x83, 0x58, 0x06, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x05, 0x00, 0x2C,
  0x03, 0x30, 0x68, 0x7C, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0xFE, 0x3F, 0x02, 0xC0, 0x03, 0x00, 0x03, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x02, 0x00, 0xFF, 0xFC, 0x0F, 0xE0, 0x60, 0x71, 0x80, 0x32, 0x00, 0x44,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x18, 0x00, 0x1F, 0x80, 0x00, 0xF0, 0x00,
  0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0xE0, 0x01, 0x20, 0x06, 0x30, 0x18,
  0x1F, 0xC0, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x03, 0xFF, 0xFE, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x03, 0xFF, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0xC0, 0x14, 0x03, 0x70, 0x51, 0xF1, 0x80, 0x07, 0x00, 0x14,
  0x00, 0xD0, 0x02, 0x20, 0x08, 0x80, 0x42, 0x01, 0x04, 0x04, 0x10, 0x20,
  0x60, 0x80, 0x82, 0x02, 0x10, 0x0C, 0x40, 0x13, 0x00, 0x48, 0x00, 0xA0,
  0x03, 0x80, 0x0C, 0x00, 0x80, 0xC0, 0x70, 0x30, 0x14, 0x0A, 0x05, 0x02,
  0x81, 0x41, 0x20, 0x90, 0x48, 0x24, 0x11, 0x08, 0x84, 0x42, 0x22, 0x10,
  0x88, 0x84, 0x62, 0x20, 0x90, 0x88, 0x24, 0x24, 0x09, 0x05, 0x02, 0x41,
  0x40, 0x90, 0x50, 0x18, 0x18, 0x06, 0x06, 0x01, 0x80, 0xC0, 0x04, 0x80,
  0x10, 0x80, 0x61, 0x80, 0x81, 0x82, 0x01, 0x08, 0x01, 0x30, 0x03, 0x40,
  0x03, 0x00, 0x06, 0x00, 0x1A, 0x00, 0x26, 0x00, 0x86, 0x03, 0x04, 0x0C,
  0x04, 0x10, 0x0C, 0x40, 0x0D, 0x80, 0x0C, 0x80, 0x07, 0x00, 0x09, 0x00,
  0x12, 0x00, 0x46, 0x00, 0x84, 0x03, 0x08, 0x04, 0x08, 0x08, 0x10, 0x20,
  0x30, 0x40, 0x21, 0x80, 0x42, 0x00, 0x44, 0x00, 0x90, 0x01, 0xA0, 0x01,
  0xC0, 0x03, 0x00, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80,
  0x01, 0x00, 0x04, 0x00, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x20, 0x01, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x00, 0x08, 0x00,
  0x60, 0x03, 0x00, 0x08, 0x00, 0x40, 0x03, 0x00, 0x18, 0x00, 0x40, 0x03,
  0xFF, 0xF0, 0x07, 0xF8, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00,
  0x80, 0x0C, 0x1F, 0x80, 0x07, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x10,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x1F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0x40, 0x06, 0x00,
  0x20, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x18, 0x00, 0x3F, 0x07,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x40,
  0x02, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x83, 0xF8, 0x00,
  0x1C, 0x01, 0x22, 0x01, 0x41, 0x01, 0xC0, 0x82, 0x80, 0x66, 0x80, 0x3C,
};

const GFXglyph IBMPlexMono_ExtraLight34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 20, 0, -1 },
  { 1, 3, 24, 20, 9, -24 },
  { 10, 6, 9, 20, 7, -25 },
  { 17, 19, 24, 20, 1, -24 },
  { 74, 16, 30, 20, 2, -27 },
  { 134, 19, 24, 20, 1, -24 },
  { 191, 18, 24, 20, 1, -24 },
  { 245, 1, 9, 20, 10, -25 },
  { 247, 8, 31, 20, 8, -26 },
  { 278, 9, 31, 20, 4, -26 },
  { 313, 17, 17, 20, 2, -19 },
  { 350, 16, 17, 20, 2, -19 },
  { 384, 4, 9, 20, 8, -3 },
  { 389, 9, 1, 20, 6, -11 },
  { 391, 3, 3, 20, 9, -3 },
  { 393, 14, 31, 20, 3, -26 },
  { 448, 16, 24, 20, 2, -24 },
  { 496, 16, 24, 20, 3, -24 },
  { 544, 15, 24, 20, 3, -24 },
  { 589, 15, 24, 20, 2, -24 },
  { 634, 18, 24, 20, 1, -24 },
  { 688, 14, 24, 20, 3, -24 },
  { 730, 15, 24, 20, 3, -24 },
  { 775, 15, 24, 20, 3, -24 },
  { 820, 16, 24, 20, 2, -24 },
  { 868, 15, 24, 20, 3, -24 },
  { 913, 3, 18, 20, 9, -18 },
  { 920, 4, 24, 20, 8, -18 },
  { 932, 15, 19, 20, 3, -20 },
  { 968, 16, 7, 20, 2, -14 },
  { 982, 15, 19, 20, 3, -20 },
  { 1018, 14, 24, 20, 3, -24 },
  { 1060, 14, 28, 20, 3, -24 },
  { 1109, 17, 24, 20, 2, -24 },
  { 1160, 15, 24, 20, 3, -24 },
  { 1205, 15, 24, 20, 3, -24 },
  { 1250, 14, 24, 20, 4, -24 },
  { 1292, 14, 24, 20, 4, -24 },
  { 1334, 14, 24, 20, 4, -24 },
  { 1376, 16, 24, 20, 2, -24 },
  { 1424, 14, 24, 20, 3, -24 },
  { 1466, 14, 24, 20, 3, -24 },
  { 1508, 13, 24, 20, 3, -24 },
  { 1547, 16, 24, 20, 3, -24 },
  { 1595, 13, 24, 20, 5, -24 },
  { 1634, 15, 24, 20, 3, -24 },
  { 1679, 14, 24, 20, 3, -24 },
  { 1721, 16, 24, 20, 2, -24 },
  { 1769, 14, 24, 20, 4, -24 },
  { 1811, 16, 28, 20, 2, -24 },
  { 1867, 14, 24, 20, 4, -24 },
  { 1909, 16, 24, 20, 2, -24 },
  { 1957, 18, 24, 20, 1, -24 },
  { 2011, 14, 24, 20, 3, -24 },
  { 2053, 17, 24, 20, 2, -24 },
  { 2104, 17, 24, 20, 2, -24 },
  { 2155, 18, 24, 20, 1, -24 },
  { 2209, 19, 24, 20, 1, -24 },
  { 2266, 17, 24, 20, 2, -24 },
  { 2317, 8, 31, 20, 9, -26 },
  { 2348, 14, 31, 20, 3, -26 },
  { 2403, 9, 31, 20, 3, -26 },
  { 2438, 16, 13, 20, 2, -24 },
  { 2464, 16, 1, 20, 2, 4 },
  { 2466, 4, 6, 20, 7, -26 },
  { 2469, 15, 18, 20, 3, -18 },
  { 2503, 14, 25, 20, 4, -25 },
  { 2547, 13, 18, 20, 4, -18 },
  { 2577, 13, 25, 20, 3, -25 },
  { 2618, 15, 18, 20, 3, -18 },
  { 2652, 15, 25, 20, 3, -25 },
  { 2699, 16, 26, 20, 3, -19 },
  { 2751, 13, 25, 20, 4, -25 },
  { 2792, 14, 25, 20, 4, -25 },
  { 2836, 12, 32, 20, 3, -25 },
  { 2884, 15, 25, 20, 4, -25 },
  { 2931, 14, 25, 20, 3, -25 },
  { 2975, 16, 18, 20, 2, -18 },
  { 3011, 13, 18, 20, 4, -18 },
  { 3041, 15, 18, 20, 3, -18 },
  { 3075, 14, 25, 20, 4, -18 },
  { 3119, 13, 25, 20, 3, -18 },
  { 3160, 16, 18, 20, 3, -18 },
  { 3196, 15, 18, 20, 3, -18 },
  { 3230, 17, 24, 20, 1, -24 },
  { 3281, 12, 18, 20, 4, -18 },
  { 3308, 14, 18, 20, 3, -18 },
  { 3340, 18, 18, 20, 1, -18 },
  { 3381, 15, 18, 20, 3, -18 },
  { 3415, 15, 25, 20, 3, -18 },
  { 3462, 14, 18, 20, 3, -18 },
  { 3494, 13, 31, 20, 4, -26 },
  { 3545, 1, 31, 20, 10, -26 },
  { 3549, 13, 31, 20, 4, -26 },
  { 3600, 16, 6, 20, 2, -13 },
};

const GFXfont IBMPlexMono_ExtraLight34pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLight34pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLight34pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _IBMPLEXMONO_EXTRALIGHT34PT7B_H_
