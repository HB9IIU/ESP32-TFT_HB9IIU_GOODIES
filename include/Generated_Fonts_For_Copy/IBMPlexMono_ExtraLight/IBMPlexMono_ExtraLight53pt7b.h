#ifndef _IBMPLEXMONO_EXTRALIGHT53PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHT53PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLight.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLight53pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x44, 0x40, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x30, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0xC0,
  0x20, 0x00, 0x03, 0x01, 0x80, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x20, 0x18,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x06, 0x01, 0x00, 0x00, 0x18, 0x0C, 0x00,
  0x00, 0x60, 0x30, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x0C, 0x03, 0x00, 0x3F,
  0xF0, 0x0F, 0xFC, 0xFF, 0xC0, 0x3F, 0xF0, 0x03, 0x01, 0x80, 0x00, 0x0C,
  0x06, 0x00, 0x00, 0x20, 0x18, 0x00, 0x00, 0x80, 0x60, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x18, 0x04, 0x00, 0x00, 0x60, 0x30, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x04, 0x03, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0xFF, 0xC0, 0x3F, 0xF0,
  0x03, 0x01, 0x80, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00,
  0x80, 0x60, 0x00, 0x06, 0x01, 0x80, 0x00, 0x18, 0x04, 0x00, 0x00, 0x60,
  0x30, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x04, 0x03, 0x00, 0x00, 0x30, 0x0C,
  0x00, 0x00, 0xC0, 0x30, 0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0x18, 0xF8, 0x1C, 0x0C,
  0x0E, 0x0C, 0x06, 0x03, 0x8C, 0x03, 0x00, 0xE6, 0x01, 0x80, 0x26, 0x00,
  0xC0, 0x03, 0x00, 0x60, 0x01, 0x80, 0x30, 0x00, 0xC0, 0x18, 0x00, 0x60,
  0x0C, 0x00, 0x18, 0x06, 0x00, 0x0C, 0x03, 0x00, 0x07, 0x01, 0x80, 0x01,
  0xC0, 0xC0, 0x00, 0x70, 0x60, 0x00, 0x1F, 0xB0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x06, 0xFC, 0x00, 0x03, 0x07, 0x80, 0x01, 0x80,
  0xE0, 0x00, 0xC0, 0x30, 0x00, 0x60, 0x1C, 0x00, 0x30, 0x06, 0x00, 0x18,
  0x03, 0x00, 0x0C, 0x01, 0x80, 0x06, 0x00, 0xC0, 0x03, 0x00, 0x60, 0x01,
  0x80, 0x34, 0x00, 0xC0, 0x1F, 0x00, 0x60, 0x0D, 0xC0, 0x30, 0x0C, 0x70,
  0x18, 0x0E, 0x1C, 0x0C, 0x0E, 0x07, 0xC6, 0x3E, 0x00, 0xFF, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0xC7, 0x07, 0x00, 0x06, 0x60, 0x18, 0x00, 0x66, 0x00, 0x60,
  0x02, 0x30, 0x03, 0x00, 0x31, 0x80, 0x08, 0x03, 0x08, 0x00, 0x60, 0x18,
  0x40, 0x03, 0x01, 0x82, 0x00, 0x18, 0x0C, 0x10, 0x00, 0xC0, 0xC0, 0xC0,
  0x04, 0x04, 0x06, 0x00, 0x60, 0x60, 0x30, 0x03, 0x06, 0x00, 0xC0, 0x30,
  0x30, 0x07, 0x83, 0x83, 0x00, 0x1F, 0xF8, 0x10, 0x00, 0x3F, 0x01, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x01, 0x81, 0xFF, 0x00, 0x0C, 0x1C, 0x1C, 0x00, 0xC1,
  0xC0, 0x30, 0x04, 0x0C, 0x01, 0x80, 0x60, 0x40, 0x06, 0x06, 0x06, 0x00,
  0x30, 0x30, 0x30, 0x01, 0x83, 0x01, 0x80, 0x0C, 0x10, 0x0C, 0x00, 0x61,
  0x80, 0x60, 0x03, 0x08, 0x03, 0x00, 0x18, 0xC0, 0x08, 0x00, 0xCC, 0x00,
  0x60, 0x0C, 0x60, 0x03, 0x80, 0x66, 0x00, 0x0E, 0x0E, 0x20, 0x00, 0x3F,
  0xE2, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x0E, 0x07, 0x00, 0x03, 0x80, 0x70, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0x60, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0x87, 0x30, 0x03,
  0xF1, 0xC3, 0x00, 0x60, 0x70, 0x30, 0x0C, 0x0C, 0x07, 0x01, 0x83, 0x00,
  0x70, 0x30, 0x60, 0x07, 0x04, 0x18, 0x00, 0x60, 0x83, 0x00, 0x06, 0x30,
  0x60, 0x00, 0x66, 0x0C, 0x00, 0x06, 0xC1, 0x80, 0x00, 0xF8, 0x30, 0x00,
  0x0E, 0x06, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x3C, 0x0C, 0x00, 0x04, 0xC1,
  0xC0, 0x01, 0x8C, 0x1C, 0x00, 0x60, 0xC1, 0xE0, 0x78, 0x1C, 0x1F, 0xFE,
  0x01, 0xC0, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x38, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x01, 0x80, 0x18, 0x01, 0x80, 0x0C, 0x00,
  0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x02, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x04, 0x00, 0x20, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xE0, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00,
  0x30, 0x00, 0x80, 0x06, 0x00, 0x30, 0x01, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00,
  0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x20, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x10, 0x01, 0x80, 0x18, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x08, 0x00, 0xC0, 0x0D, 0xF0, 0x18, 0x0F, 0xCF, 0xC3, 0x0F, 0xC0,
  0x3F, 0x6F, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x06, 0x38, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x30, 0x30, 0x00, 0x0C, 0x03, 0x00, 0x03, 0x80, 0x60, 0x00, 0x60, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x06, 0x00, 0x06, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x1C, 0xF3, 0x8E, 0x38, 0xC7, 0x1C, 0x61, 0x86, 0x30, 0xC3, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00,
  0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00,
  0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x03, 0xFF, 0xC0, 0x07, 0x81, 0xE0, 0x0E, 0x00, 0x70, 0x18, 0x00, 0x38,
  0x38, 0x00, 0x1C, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x0E, 0x60, 0x00, 0x06,
  0x60, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x38, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x06,
  0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x0E, 0x30, 0x00, 0x0C,
  0x38, 0x00, 0x1C, 0x18, 0x00, 0x38, 0x0E, 0x00, 0x70, 0x07, 0x81, 0xE0,
  0x03, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3D, 0x80, 0x00, 0x38, 0xC0, 0x00, 0x38, 0x60,
  0x00, 0x38, 0x30, 0x00, 0x38, 0x18, 0x00, 0x38, 0x0C, 0x00, 0x38, 0x06,
  0x00, 0x38, 0x03, 0x00, 0x08, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x0F, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xF8, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0x01, 0xE0, 0x1C,
  0x00, 0x70, 0x38, 0x00, 0x38, 0x30, 0x00, 0x18, 0x60, 0x00, 0x18, 0x60,
  0x00, 0x0C, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0x07,
  0xFF, 0x80, 0x1E, 0x03, 0xC0, 0x60, 0x01, 0xC1, 0x80, 0x01, 0x86, 0x00,
  0x01, 0x8C, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x03, 0xFE, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x40, 0x00, 0x0F, 0xC0, 0x00, 0x18, 0xC0, 0x00,
  0x70, 0xE0, 0x01, 0xC0, 0xF0, 0x1F, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x03, 0x30, 0x00, 0x00, 0xC6,
  0x00, 0x00, 0x10, 0xC0, 0x00, 0x06, 0x18, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x20, 0x60, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x01, 0x80, 0x00, 0x40, 0x30,
  0x00, 0x18, 0x06, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x80, 0x18, 0x00, 0x30,
  0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80,
  0x18, 0x00, 0x30, 0x02, 0x00, 0x06, 0x00, 0xC0, 0x00, 0xC0, 0x30, 0x00,
  0x18, 0x0C, 0x00, 0x03, 0x01, 0x80, 0x00, 0x60, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x7F, 0x80, 0x33, 0xFF, 0xC0, 0x6E, 0x03, 0xE0, 0xF0, 0x00,
  0xE1, 0xC0, 0x00, 0xC1, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xA0,
  0x00, 0x06, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x30, 0xE0, 0x01, 0xC0, 0x78,
  0x0F, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x3F, 0x80, 0x31, 0xFF, 0xC0, 0xCE, 0x03, 0xE1,
  0xB0, 0x00, 0xE3, 0xC0, 0x00, 0xE7, 0x00, 0x00, 0xDC, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x34, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xD8, 0x00,
  0x01, 0xB0, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x30, 0x70, 0x01,
  0xE0, 0x78, 0x0F, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xD8, 0x00, 0x01, 0xB0, 0x00, 0x06, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x31,
  0x80, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x07, 0xFF, 0xC0, 0x0F, 0x00, 0xF0, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x1C,
  0x30, 0x00, 0x0C, 0x60, 0x00, 0x0E, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06,
  0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06,
  0x60, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x38, 0x00, 0x18, 0x1C, 0x00, 0x30,
  0x0F, 0x00, 0xE0, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x0F, 0x00, 0xF0,
  0x18, 0x00, 0x38, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x06,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x60, 0x00, 0x06, 0x70, 0x00, 0x0C, 0x38, 0x00, 0x3C, 0x1F, 0x00, 0xF0,
  0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x0F, 0x81, 0xF0, 0x1C, 0x00, 0x38, 0x18, 0x00, 0x18, 0x30, 0x00, 0x0C,
  0x70, 0x00, 0x0C, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06,
  0x60, 0x00, 0x02, 0xE0, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x07,
  0x60, 0x00, 0x07, 0x60, 0x00, 0x07, 0x70, 0x00, 0x06, 0x30, 0x00, 0x0E,
  0x38, 0x00, 0x16, 0x1C, 0x00, 0x36, 0x0F, 0x80, 0xE6, 0x03, 0xFF, 0x8C,
  0x00, 0xFE, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0x3C, 0xF3, 0xCF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x3C, 0xE3, 0x8E, 0x31,
  0xC7, 0x18, 0x61, 0x8C, 0x30, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x1F, 0xFE, 0x00, 0xF0, 0x1E, 0x07, 0x00, 0x1C, 0x30, 0x00, 0x31, 0x80,
  0x00, 0xE6, 0x00, 0x01, 0xB0, 0x00, 0x06, 0xC0, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00,
  0x78, 0x00, 0x1F, 0x80, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x00,
  0xF0, 0x3C, 0x07, 0x00, 0x38, 0x18, 0x00, 0x70, 0xC0, 0x00, 0xC3, 0x00,
  0x01, 0x18, 0x00, 0x06, 0x60, 0x00, 0x19, 0x00, 0x00, 0x6C, 0x00, 0x01,
  0xB0, 0x07, 0xE2, 0xC0, 0x3F, 0xCB, 0x01, 0xC1, 0xBC, 0x0C, 0x02, 0xF0,
  0x30, 0x07, 0x81, 0x80, 0x0E, 0x06, 0x00, 0x38, 0x18, 0x00, 0xE0, 0x60,
  0x03, 0x81, 0x80, 0x0E, 0x06, 0x00, 0x38, 0x18, 0x00, 0xE0, 0x60, 0x03,
  0x81, 0x80, 0x0E, 0x06, 0x00, 0x38, 0x18, 0x00, 0xE0, 0x60, 0x03, 0x81,
  0x80, 0x1F, 0x03, 0x00, 0x7C, 0x0E, 0x02, 0xF0, 0x1F, 0xF3, 0xC0, 0x3F,
  0x8F, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x01, 0x98, 0x00,
  0x00, 0x33, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x01, 0x86, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x04, 0x18, 0x00, 0x01, 0x81, 0x80, 0x00, 0x30, 0x30, 0x00,
  0x04, 0x06, 0x00, 0x01, 0x80, 0x60, 0x00, 0x30, 0x0C, 0x00, 0x04, 0x01,
  0x80, 0x01, 0x80, 0x18, 0x00, 0x30, 0x03, 0x00, 0x04, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x04, 0x00, 0x18, 0x01, 0x80, 0x01,
  0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x01, 0x80, 0x00, 0x60, 0x30,
  0x00, 0x0C, 0x06, 0x00, 0x01, 0x81, 0x80, 0x00, 0x18, 0x30, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x61, 0x80, 0x00, 0x06, 0x30, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x19, 0x80, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x06,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x83, 0x00, 0x07, 0x86, 0x00, 0x03, 0x8C,
  0x00, 0x03, 0x18, 0x00, 0x07, 0x30, 0x00, 0x06, 0x60, 0x00, 0x0C, 0xC0,
  0x00, 0x19, 0x80, 0x00, 0x33, 0x00, 0x00, 0x66, 0x00, 0x00, 0xCC, 0x00,
  0x01, 0x98, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x30, 0xC0, 0x01,
  0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x06, 0x00, 0x07, 0x8C, 0x00, 0x03,
  0x98, 0x00, 0x03, 0x30, 0x00, 0x03, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x0D,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xB0, 0x00, 0x03, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x19, 0x80,
  0x00, 0x73, 0x00, 0x03, 0xC7, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x01, 0xFF, 0xE0, 0x07, 0xC0, 0xF0, 0x0E, 0x00, 0x38, 0x0C,
  0x00, 0x0C, 0x18, 0x00, 0x0E, 0x38, 0x00, 0x06, 0x30, 0x00, 0x03, 0x30,
  0x00, 0x04, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x04, 0x30, 0x00, 0x03, 0x38,
  0x00, 0x06, 0x18, 0x00, 0x0E, 0x0C, 0x00, 0x0C, 0x0E, 0x00, 0x38, 0x07,
  0xC0, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0x80, 0xFF, 0xF8, 0x03, 0xFF,
  0xFC, 0x08, 0x00, 0x78, 0x20, 0x00, 0x70, 0x80, 0x00, 0xE2, 0x00, 0x01,
  0xC8, 0x00, 0x03, 0x20, 0x00, 0x0E, 0x80, 0x00, 0x1A, 0x00, 0x00, 0x68,
  0x00, 0x01, 0xA0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xA0, 0x00,
  0x06, 0x80, 0x00, 0x1A, 0x00, 0x00, 0xE8, 0x00, 0x03, 0x20, 0x00, 0x1C,
  0x80, 0x00, 0xE2, 0x00, 0x07, 0x08, 0x00, 0x78, 0x3F, 0xFF, 0xC0, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x80, 0x00, 0x03, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x07, 0xFF, 0x80, 0x1E, 0x03, 0x80, 0x70, 0x01, 0x81, 0xC0, 0x01,
  0x87, 0x00, 0x01, 0x8C, 0x00, 0x03, 0x38, 0x00, 0x03, 0x60, 0x00, 0x08,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x01,
  0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x36, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0xD8, 0x00, 0x01, 0xB8, 0x00, 0x03, 0x30, 0x00, 0x0E, 0x70, 0x00, 0x1C,
  0x70, 0x00, 0x58, 0x70, 0x01, 0xB0, 0x78, 0x0E, 0x60, 0x7F, 0xF8, 0xC0,
  0x3F, 0xC0, 0x00, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0C, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xE0,
  0x00, 0x66, 0x00, 0x0C, 0x30, 0x01, 0xC1, 0xC0, 0x78, 0x0F, 0xFE, 0x00,
  0x3F, 0x80, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x0C, 0xC0,
  0x00, 0x18, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0xC0, 0xC0,
  0x01, 0xC0, 0xC0, 0x03, 0x80, 0xC0, 0x07, 0x00, 0xC0, 0x06, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x30, 0x00, 0xC0, 0x60, 0x00, 0xC0,
  0xE0, 0x00, 0xC1, 0xE0, 0x00, 0xC3, 0xF0, 0x00, 0xC3, 0x30, 0x00, 0xC6,
  0x18, 0x00, 0xCC, 0x1C, 0x00, 0xD8, 0x0C, 0x00, 0xF0, 0x06, 0x00, 0xE0,
  0x07, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x01, 0x80, 0xC0, 0x01, 0xC0, 0xC0,
  0x00, 0xC0, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0x30, 0xC0,
  0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0E, 0xC0,
  0x00, 0x06, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xD0, 0x00, 0x1B, 0xD8, 0x00, 0x1B, 0xD8, 0x00,
  0x33, 0xCC, 0x00, 0x33, 0xCC, 0x00, 0x33, 0xC6, 0x00, 0x63, 0xC6, 0x00,
  0x63, 0xC3, 0x00, 0xC3, 0xC3, 0x00, 0xC3, 0xC1, 0x01, 0x83, 0xC1, 0x81,
  0x83, 0xC1, 0x81, 0x03, 0xC0, 0xC3, 0x03, 0xC0, 0xC3, 0x03, 0xC0, 0x66,
  0x03, 0xC0, 0x66, 0x03, 0xC0, 0x2C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x18,
  0x03, 0xC0, 0x18, 0x03, 0xC0, 0x10, 0x03, 0xC0, 0x10, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xD8, 0x00, 0x0F,
  0x60, 0x00, 0x3C, 0xC0, 0x00, 0xF3, 0x00, 0x03, 0xC6, 0x00, 0x0F, 0x18,
  0x00, 0x3C, 0x30, 0x00, 0xF0, 0xC0, 0x03, 0xC1, 0x80, 0x0F, 0x06, 0x00,
  0x3C, 0x0C, 0x00, 0xF0, 0x30, 0x03, 0xC0, 0x60, 0x0F, 0x01, 0x80, 0x3C,
  0x03, 0x00, 0xF0, 0x0C, 0x03, 0xC0, 0x18, 0x0F, 0x00, 0x60, 0x3C, 0x00,
  0xC0, 0xF0, 0x03, 0x03, 0xC0, 0x06, 0x0F, 0x00, 0x18, 0x3C, 0x00, 0x30,
  0xF0, 0x00, 0xC3, 0xC0, 0x01, 0x8F, 0x00, 0x06, 0x3C, 0x00, 0x0C, 0xF0,
  0x00, 0x33, 0xC0, 0x00, 0x6F, 0x00, 0x01, 0xBC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x1C, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0x81,
  0xE0, 0x0E, 0x00, 0x70, 0x18, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x30, 0x00,
  0x0C, 0x60, 0x00, 0x0E, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0xC0, 0x00,
  0x06, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00,
  0x06, 0x60, 0x00, 0x0E, 0x30, 0x00, 0x0C, 0x38, 0x00, 0x1C, 0x18, 0x00,
  0x38, 0x0E, 0x00, 0x70, 0x07, 0x81, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0xFE,
  0x00, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x08, 0x00, 0x0E, 0x20, 0x00, 0x1C,
  0x80, 0x00, 0x3A, 0x00, 0x00, 0x68, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x80, 0x00, 0x3A,
  0x00, 0x01, 0xC8, 0x00, 0x0E, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x02, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x07, 0x81, 0xE0, 0x0E, 0x00, 0x70, 0x18, 0x00, 0x38, 0x38, 0x00,
  0x1C, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x0E, 0x60, 0x00, 0x06, 0x60, 0x00,
  0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x06, 0x60, 0x00,
  0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x38, 0x00,
  0x1C, 0x18, 0x00, 0x38, 0x0E, 0x00, 0x70, 0x07, 0x81, 0xE0, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xF8, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x08, 0x00, 0x0E, 0x20, 0x00, 0x1C,
  0x80, 0x00, 0x3A, 0x00, 0x00, 0x68, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x80, 0x00, 0x3A,
  0x00, 0x01, 0xC8, 0x00, 0x0E, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x02, 0x00,
  0xC0, 0x08, 0x03, 0x00, 0x20, 0x06, 0x00, 0x80, 0x0C, 0x02, 0x00, 0x30,
  0x08, 0x00, 0x60, 0x20, 0x00, 0xC0, 0x80, 0x03, 0x02, 0x00, 0x06, 0x08,
  0x00, 0x1C, 0x20, 0x00, 0x30, 0x80, 0x00, 0x62, 0x00, 0x01, 0xC8, 0x00,
  0x03, 0x20, 0x00, 0x06, 0x80, 0x00, 0x1C, 0x00, 0x7F, 0x80, 0x01, 0xFF,
  0xF8, 0x03, 0xE0, 0x1F, 0x03, 0x80, 0x01, 0xC3, 0x80, 0x00, 0x71, 0x80,
  0x00, 0x1C, 0xC0, 0x00, 0x04, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xB8, 0x00, 0x01, 0x8E, 0x00, 0x01, 0xC3, 0x80, 0x01, 0xC0,
  0xF8, 0x07, 0xC0, 0x1F, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0B, 0x00, 0x00, 0x66, 0x00, 0x01, 0x98, 0x00, 0x06, 0x60,
  0x00, 0x38, 0xC0, 0x00, 0xC3, 0x80, 0x07, 0x07, 0x80, 0x78, 0x0F, 0xFF,
  0xC0, 0x0F, 0xF8, 0x00, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x19, 0x80, 0x00, 0x06, 0x60, 0x00, 0x01, 0x9C, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x06, 0x00, 0x01,
  0x81, 0x80, 0x00, 0x60, 0x60, 0x00, 0x30, 0x0C, 0x00, 0x0C, 0x03, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x80, 0x18, 0x00, 0x60, 0x06, 0x00, 0x18, 0x01,
  0x80, 0x06, 0x00, 0x30, 0x03, 0x00, 0x0C, 0x00, 0xC0, 0x03, 0x00, 0x30,
  0x00, 0x60, 0x18, 0x00, 0x18, 0x06, 0x00, 0x06, 0x01, 0x80, 0x00, 0xC0,
  0xC0, 0x00, 0x30, 0x30, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x06, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x18, 0x60, 0x00, 0x06, 0x30, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x33, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x2C, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x02, 0x40, 0x00, 0x01, 0x90, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x19, 0x80, 0x30, 0x06, 0x60, 0x1C, 0x01, 0x98,
  0x07, 0x80, 0x66, 0x01, 0xE0, 0x19, 0x80, 0x48, 0x06, 0x60, 0x33, 0x01,
  0x18, 0x0C, 0xC0, 0x42, 0x02, 0x30, 0x10, 0x81, 0x84, 0x0C, 0x20, 0x61,
  0x83, 0x0C, 0x18, 0x60, 0xC3, 0x04, 0x18, 0x30, 0xC3, 0x03, 0x0C, 0x30,
  0xC0, 0xC3, 0x0C, 0x20, 0x30, 0xC3, 0x18, 0x04, 0x30, 0xC6, 0x01, 0x88,
  0x31, 0x80, 0x62, 0x04, 0x40, 0x18, 0x81, 0x30, 0x03, 0x60, 0x4C, 0x00,
  0xD8, 0x1B, 0x00, 0x36, 0x07, 0x80, 0x05, 0x81, 0xE0, 0x01, 0xE0, 0x78,
  0x00, 0x78, 0x1C, 0x00, 0x1E, 0x00, 0x60, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x0C, 0x38, 0x00, 0x01, 0x81, 0x80, 0x00, 0x18, 0x0C, 0x00, 0x03, 0x00,
  0xE0, 0x00, 0x60, 0x06, 0x00, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x80,
  0x18, 0x00, 0x18, 0x01, 0x80, 0x00, 0xC0, 0x30, 0x00, 0x0E, 0x06, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x01,
  0x98, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x01, 0x98, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x60, 0x60, 0x00, 0x0C, 0x03,
  0x00, 0x01, 0x80, 0x38, 0x00, 0x18, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00,
  0x60, 0x00, 0xE0, 0x06, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x30, 0x18, 0x00,
  0x03, 0x81, 0x80, 0x00, 0x18, 0x30, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x0E,
  0xE0, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x01, 0xCC,
  0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x06, 0x06, 0x00,
  0x00, 0x60, 0x38, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x30, 0x03, 0x00, 0x03,
  0x00, 0x18, 0x00, 0x38, 0x00, 0x60, 0x01, 0x80, 0x03, 0x80, 0x18, 0x00,
  0x0C, 0x00, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x06,
  0x06, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x03, 0x30,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xC0, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x06, 0x60, 0x00, 0x06,
  0x18, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x03, 0x01, 0x80, 0x01,
  0x80, 0x60, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x03, 0x00,
  0xC0, 0x01, 0x80, 0x60, 0x00, 0x60, 0x60, 0x00, 0x30, 0x30, 0x00, 0x0C,
  0x30, 0x00, 0x03, 0x18, 0x00, 0x01, 0x98, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x60, 0xE0, 0x30, 0x38,
  0x18, 0x0C, 0x06, 0x06, 0x03, 0x01, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x1E,
  0x03, 0xC0, 0x38, 0x00, 0xE0, 0x70, 0x00, 0x60, 0x60, 0x00, 0x70, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x03, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF0, 0x3C, 0x00, 0x30, 0x70, 0x00, 0x30, 0x60, 0x00, 0x30, 0xC0,
  0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0,
  0x00, 0x30, 0xC0, 0x00, 0x70, 0x60, 0x00, 0xB0, 0x70, 0x01, 0xB0, 0x3C,
  0x07, 0x3F, 0x1F, 0xFE, 0x1F, 0x07, 0xF8, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x7F, 0x00, 0xC7, 0xFF, 0x83, 0x38, 0x0F, 0x0D, 0x80,
  0x0E, 0x34, 0x00, 0x1C, 0xE0, 0x00, 0x33, 0x80, 0x00, 0xEC, 0x00, 0x01,
  0xB0, 0x00, 0x06, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xB0, 0x00, 0x06,
  0xC0, 0x00, 0x1B, 0x80, 0x00, 0xEE, 0x00, 0x03, 0x34, 0x00, 0x1C, 0xD8,
  0x00, 0xE3, 0x38, 0x0F, 0x0C, 0x7F, 0xF8, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x3F, 0xFC, 0x03, 0xC0, 0xF0, 0x38, 0x01, 0xC3, 0x00, 0x06, 0x38,
  0x00, 0x19, 0x80, 0x00, 0x58, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x6E, 0x00,
  0x06, 0x30, 0x00, 0x70, 0xE0, 0x07, 0x03, 0xC0, 0xF0, 0x0F, 0xFE, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x3F, 0x03,
  0x07, 0xFF, 0x0C, 0x3C, 0x07, 0x31, 0xC0, 0x06, 0xCE, 0x00, 0x0B, 0x30,
  0x00, 0x1D, 0x80, 0x00, 0x76, 0x00, 0x00, 0xD8, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xD8, 0x00, 0x03, 0x60, 0x00, 0x0D, 0x80, 0x00,
  0x73, 0x00, 0x01, 0xCE, 0x00, 0x0B, 0x1C, 0x00, 0x6C, 0x3C, 0x07, 0x30,
  0x7F, 0xF0, 0xC0, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xF0,
  0x3C, 0x07, 0x00, 0x38, 0x30, 0x00, 0x31, 0xC0, 0x00, 0xC6, 0x00, 0x01,
  0x90, 0x00, 0x06, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x00, 0x00, 0x26, 0x00, 0x00, 0xDC, 0x00, 0x06, 0x30,
  0x00, 0x30, 0x70, 0x01, 0xC0, 0xF0, 0x1E, 0x01, 0xFF, 0xE0, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x1F, 0xC8, 0x00, 0x7F, 0xFC, 0x00, 0x78,
  0x1E, 0x00, 0x70, 0x03, 0x80, 0x30, 0x00, 0xC0, 0x30, 0x00, 0x30, 0x18,
  0x00, 0x18, 0x0C, 0x00, 0x04, 0x06, 0x00, 0x03, 0x03, 0x00, 0x01, 0x81,
  0x80, 0x00, 0xC0, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x38, 0x00, 0x70,
  0x0E, 0x00, 0x70, 0x03, 0xC0, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x80, 0xC0, 0x00, 0xF0, 0x80, 0x00, 0x18, 0x80, 0x00, 0x06, 0xC0,
  0x00, 0x03, 0x40, 0x00, 0x01, 0xA0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x33, 0xC0, 0x00, 0x30, 0xF8, 0x00, 0xF0,
  0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x1F,
  0xC0, 0xC7, 0xFF, 0x0C, 0xE0, 0x78, 0xD8, 0x01, 0xCD, 0x00, 0x0E, 0xE0,
  0x00, 0x6E, 0x00, 0x06, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x30, 0x00, 0x38, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xBF, 0xFF, 0xF0, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xCF, 0xFF, 0xF9, 0xFF, 0xFE, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x03, 0x98, 0x00, 0x0E, 0x30, 0x00,
  0x38, 0x60, 0x00, 0xC0, 0xC0, 0x03, 0x01, 0x80, 0x0C, 0x03, 0x00, 0x30,
  0x06, 0x01, 0xC0, 0x0C, 0x07, 0x00, 0x18, 0x1C, 0x00, 0x30, 0x60, 0x00,
  0x61, 0xE0, 0x00, 0xC6, 0x60, 0x01, 0xB8, 0xE0, 0x03, 0xE0, 0xE0, 0x07,
  0x80, 0xC0, 0x0C, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x30, 0x00, 0xC0, 0x60,
  0x01, 0xC0, 0xC0, 0x01, 0xC1, 0x80, 0x01, 0x83, 0x00, 0x01, 0x86, 0x00,
  0x01, 0x8C, 0x00, 0x01, 0x98, 0x00, 0x03, 0xB0, 0x00, 0x03, 0x80, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07,
  0xC0, 0xF8, 0x9F, 0xE1, 0xFE, 0x90, 0x73, 0x0E, 0xA0, 0x34, 0x07, 0xC0,
  0x14, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03, 0x80, 0x18, 0x03, 0x80,
  0x18, 0x03, 0x80, 0x18, 0x03, 0x80, 0x18, 0x03, 0x80, 0x18, 0x03, 0x80,
  0x18, 0x03, 0x80, 0x18, 0x03, 0x80, 0x18, 0x03, 0x80, 0x18, 0x03, 0x80,
  0x18, 0x03, 0x80, 0x18, 0x03, 0x80, 0x18, 0x03, 0x80, 0x18, 0x03, 0x80,
  0x18, 0x03, 0x80, 0x18, 0x03, 0x80, 0x18, 0x03, 0x80, 0x18, 0x03, 0x80,
  0x18, 0x03, 0x80, 0x18, 0x03, 0x80, 0x18, 0x03, 0x80, 0x18, 0x03, 0x01,
  0xFC, 0x0C, 0x7F, 0xF0, 0xCE, 0x07, 0x8D, 0x80, 0x1C, 0xD0, 0x00, 0xEE,
  0x00, 0x06, 0xE0, 0x00, 0x6C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x00, 0xFF, 0x00,
  0x07, 0xFF, 0x80, 0x1E, 0x07, 0x80, 0x60, 0x03, 0x81, 0x80, 0x03, 0x86,
  0x00, 0x03, 0x8C, 0x00, 0x03, 0x30, 0x00, 0x06, 0x60, 0x00, 0x06, 0xC0,
  0x00, 0x0D, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x40, 0x00, 0x06, 0xC0, 0x00,
  0x0D, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x36, 0x00, 0x00, 0x6C, 0x00, 0x01,
  0x8C, 0x00, 0x03, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x38, 0x1C, 0x00, 0xE0,
  0x1E, 0x07, 0x80, 0x1F, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x03,
  0x1F, 0xFE, 0x0C, 0xE0, 0x3C, 0x36, 0x00, 0x38, 0xD0, 0x00, 0x73, 0x80,
  0x00, 0xCE, 0x00, 0x03, 0xB0, 0x00, 0x06, 0xC0, 0x00, 0x1B, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x06, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x6E, 0x00, 0x03,
  0xB8, 0x00, 0x0C, 0xD0, 0x00, 0x73, 0x60, 0x03, 0x8C, 0xE0, 0x3C, 0x31,
  0xFF, 0xE0, 0xC1, 0xFC, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x1F, 0xFC, 0x30, 0xF0, 0x1C, 0xC7, 0x00, 0x1B, 0x38, 0x00, 0x2C, 0xC0,
  0x00, 0x76, 0x00, 0x01, 0xD8, 0x00, 0x03, 0x60, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0x60, 0x00, 0x0D, 0x80, 0x00, 0x36, 0x00, 0x01,
  0xCC, 0x00, 0x07, 0x38, 0x00, 0x2C, 0x70, 0x01, 0xB0, 0xF0, 0x1C, 0xC1,
  0xFF, 0xC3, 0x01, 0xFC, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF8, 0x7F, 0xF0, 0x06, 0x70, 0x00, 0x01, 0x90, 0x00, 0x00, 0x68,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x0F, 0x00, 0xF0, 0x1C, 0x00,
  0x3C, 0x38, 0x00, 0x0E, 0x30, 0x00, 0x04, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x40, 0x00, 0x06, 0xE0, 0x00,
  0x06, 0x70, 0x00, 0x0E, 0x3C, 0x00, 0x1C, 0x0F, 0x80, 0x78, 0x07, 0xFF,
  0xF0, 0x00, 0xFF, 0x80, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xD8, 0x00, 0x1B,
  0x00, 0x05, 0x30, 0x01, 0xA7, 0x80, 0xE4, 0x3F, 0xF8, 0x81, 0xFC, 0x00,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0x98, 0x00, 0x06, 0x60,
  0x00, 0x18, 0xC0, 0x00, 0xC3, 0x00, 0x03, 0x0C, 0x00, 0x08, 0x18, 0x00,
  0x60, 0x60, 0x01, 0x80, 0x80, 0x0C, 0x03, 0x00, 0x30, 0x0C, 0x00, 0xC0,
  0x10, 0x06, 0x00, 0x60, 0x18, 0x01, 0x80, 0x40, 0x03, 0x03, 0x00, 0x0C,
  0x0C, 0x00, 0x10, 0x60, 0x00, 0x61, 0x80, 0x01, 0x86, 0x00, 0x02, 0x30,
  0x00, 0x0C, 0xC0, 0x00, 0x32, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x24, 0x00, 0xB0, 0x02, 0x40, 0x09, 0x00, 0x66, 0x01, 0x98, 0x06,
  0x60, 0x19, 0x80, 0x66, 0x01, 0x18, 0x06, 0x60, 0x10, 0x80, 0x42, 0x03,
  0x0C, 0x04, 0x30, 0x30, 0xC0, 0xC3, 0x02, 0x0C, 0x0C, 0x30, 0x20, 0x40,
  0xC3, 0x06, 0x06, 0x08, 0x10, 0x60, 0x60, 0x81, 0x04, 0x06, 0x18, 0x18,
  0x40, 0x21, 0x81, 0x8C, 0x03, 0x18, 0x18, 0xC0, 0x31, 0x81, 0x88, 0x03,
  0x10, 0x08, 0x80, 0x13, 0x00, 0xD8, 0x01, 0xB0, 0x0D, 0x80, 0x1B, 0x00,
  0xD0, 0x01, 0xB0, 0x0F, 0x00, 0x0A, 0x00, 0x70, 0x00, 0xE0, 0x07, 0x00,
  0x0E, 0x00, 0x60, 0x00, 0x06, 0x60, 0x00, 0x18, 0xE0, 0x00, 0x60, 0xC0,
  0x01, 0xC0, 0xC0, 0x03, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x30, 0x01, 0xC0,
  0xC0, 0x01, 0x81, 0x80, 0x01, 0x86, 0x00, 0x01, 0x98, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x33, 0x00,
  0x00, 0xC6, 0x00, 0x01, 0x86, 0x00, 0x06, 0x06, 0x00, 0x18, 0x06, 0x00,
  0x60, 0x0E, 0x00, 0xC0, 0x0C, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x30,
  0x00, 0x1C, 0xE0, 0x00, 0x1B, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x03, 0x60,
  0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30,
  0x00, 0x0C, 0x18, 0x00, 0x18, 0x18, 0x00, 0x18, 0x08, 0x00, 0x30, 0x0C,
  0x00, 0x30, 0x0C, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x03,
  0x00, 0xC0, 0x03, 0x00, 0xC0, 0x03, 0x00, 0x80, 0x01, 0x81, 0x80, 0x01,
  0x81, 0x80, 0x00, 0xC3, 0x00, 0x00, 0xC3, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x64, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x0F, 0x00,
  0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x0F, 0xFF,
  0x00, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3F,
  0xF0, 0x03, 0xFF, 0x00, 0xF0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x0F, 0xFF, 0x00, 0xFF, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0xC7, 0xF8, 0x00, 0x31, 0x87, 0x00, 0x08, 0xC0,
  0xE0, 0x06, 0x60, 0x1C, 0x01, 0x98, 0x03, 0x80, 0x44, 0x00, 0x70, 0x33,
  0x00, 0x0E, 0x18, 0xC0, 0x01, 0xFC, 0x30, 0x00, 0x1E, 0x00,
};

const GFXglyph IBMPlexMono_ExtraLight53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 32, 0, -1 },
  { 1, 4, 37, 32, 14, -37 },
  { 20, 10, 14, 32, 11, -39 },
  { 38, 30, 37, 32, 1, -37 },
  { 177, 25, 49, 32, 3, -43 },
  { 331, 29, 39, 32, 1, -38 },
  { 473, 27, 39, 32, 2, -38 },
  { 605, 2, 14, 32, 15, -39 },
  { 609, 13, 47, 32, 12, -40 },
  { 686, 13, 47, 32, 7, -40 },
  { 763, 27, 26, 32, 2, -29 },
  { 851, 26, 26, 32, 3, -29 },
  { 936, 6, 14, 32, 12, -5 },
  { 947, 14, 2, 32, 9, -17 },
  { 951, 4, 4, 32, 14, -4 },
  { 953, 21, 47, 32, 5, -40 },
  { 1077, 24, 39, 32, 4, -38 },
  { 1194, 25, 37, 32, 4, -37 },
  { 1310, 24, 38, 32, 4, -38 },
  { 1424, 23, 39, 32, 3, -38 },
  { 1537, 27, 37, 32, 2, -37 },
  { 1662, 23, 38, 32, 4, -37 },
  { 1772, 23, 38, 32, 4, -37 },
  { 1882, 23, 37, 32, 4, -37 },
  { 1989, 24, 39, 32, 4, -38 },
  { 2106, 24, 38, 32, 4, -38 },
  { 2220, 4, 28, 32, 14, -28 },
  { 2234, 6, 37, 32, 12, -28 },
  { 2262, 23, 29, 32, 4, -31 },
  { 2346, 26, 12, 32, 3, -22 },
  { 2385, 23, 29, 32, 4, -31 },
  { 2469, 22, 38, 32, 5, -38 },
  { 2574, 22, 44, 32, 5, -38 },
  { 2695, 27, 37, 32, 2, -37 },
  { 2820, 23, 37, 32, 5, -37 },
  { 2927, 24, 39, 32, 4, -38 },
  { 3044, 22, 37, 32, 6, -37 },
  { 3146, 21, 37, 32, 6, -37 },
  { 3244, 22, 37, 32, 6, -37 },
  { 3346, 23, 39, 32, 4, -38 },
  { 3459, 22, 37, 32, 5, -37 },
  { 3561, 22, 37, 32, 5, -37 },
  { 3663, 20, 38, 32, 5, -37 },
  { 3758, 24, 37, 32, 5, -37 },
  { 3869, 21, 37, 32, 7, -37 },
  { 3967, 24, 37, 32, 4, -37 },
  { 4078, 22, 37, 32, 5, -37 },
  { 4180, 24, 39, 32, 4, -38 },
  { 4297, 22, 37, 32, 6, -37 },
  { 4399, 24, 46, 32, 4, -38 },
  { 4537, 22, 37, 32, 6, -37 },
  { 4639, 25, 39, 32, 3, -38 },
  { 4761, 28, 37, 32, 2, -37 },
  { 4891, 22, 38, 32, 5, -37 },
  { 4996, 26, 37, 32, 3, -37 },
  { 5117, 26, 37, 32, 3, -37 },
  { 5238, 28, 37, 32, 2, -37 },
  { 5368, 29, 37, 32, 1, -37 },
  { 5503, 26, 37, 32, 3, -37 },
  { 5624, 13, 47, 32, 14, -40 },
  { 5701, 21, 47, 32, 5, -40 },
  { 5825, 13, 47, 32, 5, -40 },
  { 5902, 25, 20, 32, 3, -37 },
  { 5965, 26, 2, 32, 3, 6 },
  { 5972, 8, 9, 32, 10, -40 },
  { 5981, 24, 29, 32, 4, -28 },
  { 6068, 22, 40, 32, 6, -39 },
  { 6178, 21, 29, 32, 6, -28 },
  { 6255, 22, 40, 32, 4, -39 },
  { 6365, 22, 29, 32, 5, -28 },
  { 6445, 24, 39, 32, 4, -39 },
  { 6562, 25, 41, 32, 4, -30 },
  { 6691, 20, 39, 32, 6, -39 },
  { 6789, 23, 40, 32, 6, -40 },
  { 6904, 19, 51, 32, 5, -40 },
  { 7026, 23, 39, 32, 7, -39 },
  { 7139, 22, 39, 32, 5, -39 },
  { 7247, 24, 28, 32, 4, -28 },
  { 7331, 20, 28, 32, 6, -28 },
  { 7401, 23, 29, 32, 4, -28 },
  { 7485, 22, 39, 32, 6, -28 },
  { 7593, 22, 39, 32, 4, -28 },
  { 7701, 26, 27, 32, 4, -27 },
  { 7789, 24, 29, 32, 4, -28 },
  { 7876, 26, 37, 32, 2, -37 },
  { 7997, 19, 28, 32, 6, -27 },
  { 8064, 22, 27, 32, 5, -27 },
  { 8139, 28, 27, 32, 2, -27 },
  { 8234, 23, 27, 32, 4, -27 },
  { 8312, 24, 38, 32, 4, -27 },
  { 8426, 22, 27, 32, 5, -27 },
  { 8501, 20, 47, 32, 6, -40 },
  { 8619, 2, 47, 32, 15, -40 },
  { 8631, 20, 47, 32, 6, -40 },
  { 8749, 26, 10, 32, 3, -21 },
};

const GFXfont IBMPlexMono_ExtraLight53pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLight53pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLight53pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _IBMPLEXMONO_EXTRALIGHT53PT7B_H_
