#ifndef _IBMPLEXMONO_EXTRALIGHT18PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHT18PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLight.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLight18pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x88, 0xB6, 0xDA, 0x09, 0x02, 0x40, 0x90, 0x24, 0x71, 0xC4,
  0x81, 0x20, 0x48, 0xF3, 0xC4, 0x82, 0x20, 0x90, 0x24, 0x00, 0x08, 0x04,
  0x0F, 0x89, 0x28, 0x94, 0x42, 0x20, 0xD0, 0x1E, 0x04, 0x82, 0x41, 0x18,
  0x92, 0x48, 0xF8, 0x10, 0x08, 0x00, 0x38, 0x52, 0x28, 0x4A, 0x14, 0x49,
  0x0E, 0x00, 0x00, 0x0E, 0x14, 0x49, 0x12, 0x45, 0x11, 0x83, 0x80, 0x38,
  0x22, 0x10, 0x88, 0x04, 0x01, 0x01, 0xC7, 0x34, 0x8A, 0x43, 0x20, 0x90,
  0xA7, 0x98, 0xF8, 0x19, 0x10, 0x88, 0x42, 0x10, 0x84, 0x21, 0x04, 0x20,
  0x83, 0xC2, 0x08, 0x21, 0x08, 0x21, 0x08, 0x44, 0x21, 0x11, 0x18, 0x08,
  0x04, 0x02, 0x11, 0x37, 0xE0, 0xC0, 0x90, 0x44, 0x41, 0x00, 0x08, 0x04,
  0x02, 0x01, 0x0F, 0xF8, 0x40, 0x20, 0x10, 0x08, 0x00, 0x5A, 0x80, 0xF8,
  0x80, 0x02, 0x08, 0x10, 0x20, 0x81, 0x04, 0x08, 0x20, 0x40, 0x82, 0x04,
  0x10, 0x20, 0x40, 0x3C, 0x31, 0x10, 0x50, 0x28, 0x14, 0x06, 0x23, 0x01,
  0x81, 0x40, 0x90, 0x4C, 0x43, 0xC0, 0x08, 0x0C, 0x0A, 0x09, 0x08, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x07, 0xF8, 0x1C, 0x62, 0x81,
  0x01, 0x01, 0x01, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0xFF, 0x3C, 0x42,
  0x81, 0x01, 0x02, 0x3C, 0x06, 0x01, 0x01, 0x01, 0x81, 0x42, 0x3C, 0x02,
  0x03, 0x02, 0x82, 0x41, 0x21, 0x11, 0x09, 0x04, 0x82, 0x7F, 0xC0, 0x80,
  0x40, 0x20, 0x7F, 0x40, 0x40, 0x40, 0x40, 0x7E, 0x43, 0x01, 0x01, 0x01,
  0x81, 0x42, 0x3C, 0x0C, 0x10, 0x20, 0x20, 0x40, 0x5E, 0xE3, 0x81, 0x81,
  0x81, 0x81, 0x43, 0x3C, 0xFF, 0x81, 0x81, 0x82, 0x02, 0x04, 0x04, 0x08,
  0x08, 0x08, 0x10, 0x10, 0x20, 0x3E, 0x21, 0xA0, 0x50, 0x28, 0x12, 0x10,
  0xF0, 0xC6, 0x81, 0x40, 0x60, 0x48, 0x23, 0xE0, 0x7D, 0x0E, 0x0C, 0x18,
  0x30, 0x61, 0xBD, 0x02, 0x08, 0x20, 0x82, 0x00, 0x80, 0x80, 0x40, 0x01,
  0x6A, 0x02, 0x08, 0x61, 0x0C, 0x10, 0x18, 0x08, 0x0C, 0x04, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xF8, 0x80, 0x80, 0xC0, 0x40, 0x60, 0x43, 0x08, 0x61,
  0x00, 0x3C, 0x8E, 0x08, 0x10, 0x20, 0x86, 0x10, 0x20, 0x00, 0x00, 0x03,
  0x00, 0x38, 0x8A, 0x0C, 0x19, 0xF4, 0x68, 0xD1, 0xA3, 0x46, 0x7C, 0x08,
  0x08, 0x0F, 0x00, 0x08, 0x0C, 0x05, 0x04, 0x82, 0x41, 0x10, 0x88, 0x84,
  0x7F, 0x20, 0xA0, 0x50, 0x28, 0x08, 0xFD, 0x0A, 0x0C, 0x18, 0x30, 0xBF,
  0x41, 0x83, 0x06, 0x0C, 0x1F, 0xC0, 0x1E, 0x21, 0x41, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x41, 0x21, 0x1E, 0xF8, 0x84, 0x82, 0x82, 0x82,
  0x81, 0x81, 0x81, 0x82, 0x82, 0x82, 0x84, 0xF8, 0xFF, 0x02, 0x04, 0x08,
  0x10, 0x3F, 0xC0, 0x81, 0x02, 0x04, 0x0F, 0xE0, 0xFF, 0x02, 0x04, 0x08,
  0x10, 0x3F, 0xC0, 0x81, 0x02, 0x04, 0x08, 0x00, 0x1C, 0x62, 0x41, 0x80,
  0x80, 0x80, 0x80, 0x87, 0x81, 0x81, 0x41, 0x63, 0x3D, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x7F, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x20, 0xFE, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x8F, 0xE0, 0x7C, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x18, 0x61, 0x78, 0x83, 0x82, 0x84, 0x88, 0x90,
  0xA0, 0xD0, 0x88, 0x88, 0x84, 0x84, 0x82, 0x81, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x0F, 0xE0, 0xC1, 0xC3, 0xC3, 0xA3,
  0xA5, 0x95, 0x99, 0x89, 0x81, 0x81, 0x81, 0x81, 0x81, 0x83, 0x07, 0x0E,
  0x1A, 0x34, 0x64, 0xC9, 0x8B, 0x16, 0x1C, 0x38, 0x20, 0x3C, 0x31, 0x10,
  0x50, 0x28, 0x14, 0x06, 0x03, 0x01, 0x81, 0x40, 0x90, 0x4C, 0x43, 0xC0,
  0xFC, 0x82, 0x82, 0x81, 0x81, 0x82, 0x82, 0xFC, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x3C, 0x31, 0x10, 0x50, 0x28, 0x14, 0x06, 0x03, 0x01, 0x81, 0x40,
  0x90, 0x4C, 0x43, 0xC0, 0x40, 0x20, 0x1E, 0xFC, 0x82, 0x82, 0x81, 0x81,
  0x82, 0x82, 0xFC, 0x90, 0x88, 0x84, 0x84, 0x83, 0x3E, 0x20, 0xA0, 0x50,
  0x08, 0x03, 0x00, 0x78, 0x02, 0x01, 0x00, 0x60, 0x48, 0x23, 0xE0, 0xFF,
  0x84, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x37, 0xC0, 0x80, 0xC0, 0xA0, 0x48, 0x24, 0x12, 0x10, 0x88, 0x44, 0x24,
  0x0A, 0x05, 0x03, 0x00, 0x80, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x94, 0xCA,
  0x65, 0x2A, 0xA5, 0x52, 0xA8, 0xCC, 0x64, 0x10, 0x80, 0xA0, 0x90, 0x84,
  0x41, 0x40, 0xC0, 0x20, 0x28, 0x24, 0x11, 0x10, 0x90, 0x28, 0x08, 0xC0,
  0x50, 0x22, 0x08, 0x84, 0x11, 0x04, 0x80, 0xC0, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x00, 0xFF, 0x80, 0x80, 0x80, 0x40, 0x40, 0x40, 0x20,
  0x20, 0x20, 0x20, 0x10, 0x10, 0x0F, 0xF8, 0xF8, 0x88, 0x88, 0x88, 0x88,
  0x88, 0x88, 0x8F, 0x81, 0x02, 0x02, 0x04, 0x04, 0x08, 0x10, 0x10, 0x20,
  0x20, 0x40, 0x40, 0x81, 0x01, 0xF1, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11,
  0x1F, 0x08, 0x0A, 0x09, 0x04, 0x44, 0x24, 0x0A, 0x02, 0xFF, 0x80, 0xA4,
  0x3C, 0x61, 0x00, 0x80, 0x47, 0xE2, 0x12, 0x09, 0x0C, 0x79, 0x80, 0x81,
  0x02, 0x04, 0x0B, 0xD8, 0x60, 0xC1, 0x83, 0x06, 0x0E, 0x1B, 0xC0, 0x38,
  0x8A, 0x0C, 0x08, 0x10, 0x20, 0xA2, 0x38, 0x01, 0x01, 0x01, 0x01, 0x3D,
  0x43, 0x81, 0x81, 0x81, 0x81, 0x81, 0x43, 0x3D, 0x79, 0x0A, 0x0C, 0x1F,
  0xF0, 0x20, 0x41, 0x7C, 0x0F, 0x84, 0x02, 0x01, 0x0F, 0xF8, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x07, 0xF0, 0x07, 0x3C, 0x44, 0x82, 0x82,
  0x44, 0x78, 0x80, 0x80, 0x7E, 0x81, 0x81, 0x81, 0x7E, 0x81, 0x02, 0x04,
  0x0B, 0xD8, 0xA0, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x20, 0x18, 0x00, 0x00,
  0x00, 0xF0, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0xFF, 0x04, 0x00,
  0x00, 0xFC, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0xFC, 0x80,
  0x80, 0x80, 0x80, 0x83, 0x84, 0x88, 0x90, 0xF0, 0x88, 0x84, 0x82, 0x81,
  0xF0, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x8F, 0xE0,
  0xB7, 0x6C, 0xA2, 0x31, 0x18, 0x8C, 0x46, 0x23, 0x11, 0x88, 0x80, 0xBD,
  0x8A, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x82, 0x79, 0x0E, 0x0C, 0x18, 0x30,
  0x60, 0xC3, 0x78, 0xBD, 0x86, 0x0C, 0x18, 0x30, 0x60, 0xE1, 0xBD, 0x02,
  0x04, 0x08, 0x00, 0x3D, 0x43, 0x81, 0x81, 0x81, 0x81, 0x81, 0x43, 0x3D,
  0x01, 0x01, 0x01, 0x01, 0xF3, 0x8E, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0xFF, 0x00, 0x7D, 0x06, 0x04, 0x07, 0xC0, 0x40, 0xC1, 0x7C, 0x10,
  0x10, 0x10, 0x10, 0xFF, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x1F,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC3, 0x7A, 0x83, 0x06, 0x12, 0x24,
  0x49, 0x0A, 0x18, 0x10, 0x88, 0xCC, 0x66, 0x32, 0x9A, 0x55, 0x2A, 0x8C,
  0xC6, 0x43, 0x00, 0x41, 0x42, 0x24, 0x18, 0x08, 0x14, 0x24, 0x42, 0xC1,
  0x81, 0x41, 0x42, 0x42, 0x22, 0x24, 0x14, 0x18, 0x08, 0x08, 0x10, 0x10,
  0x60, 0xFE, 0x08, 0x10, 0x41, 0x04, 0x10, 0x40, 0xFE, 0x1E, 0x40, 0x81,
  0x01, 0x01, 0x02, 0x78, 0x18, 0x10, 0x40, 0x82, 0x04, 0x08, 0x0F, 0xFF,
  0xFF, 0xF0, 0x20, 0x40, 0x82, 0x04, 0x08, 0x0F, 0x30, 0x40, 0x80, 0x81,
  0x02, 0x04, 0x78, 0x70, 0xCC, 0x62, 0x50, 0xE0,
};

const GFXglyph IBMPlexMono_ExtraLight18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 1, 13, 11, 5, -13 },
  { 3, 3, 5, 11, 4, -13 },
  { 5, 10, 13, 11, 0, -13 },
  { 22, 9, 17, 11, 1, -15 },
  { 42, 10, 13, 11, 0, -13 },
  { 59, 9, 13, 11, 1, -13 },
  { 74, 1, 5, 11, 5, -13 },
  { 75, 5, 16, 11, 4, -14 },
  { 85, 5, 16, 11, 2, -14 },
  { 95, 9, 9, 11, 1, -10 },
  { 106, 9, 9, 11, 1, -10 },
  { 117, 2, 5, 11, 4, -2 },
  { 119, 5, 1, 11, 3, -6 },
  { 120, 1, 1, 11, 5, -1 },
  { 121, 7, 16, 11, 2, -14 },
  { 135, 9, 13, 11, 1, -13 },
  { 150, 9, 13, 11, 1, -13 },
  { 165, 8, 13, 11, 1, -13 },
  { 178, 8, 13, 11, 1, -13 },
  { 191, 9, 13, 11, 1, -13 },
  { 206, 8, 13, 11, 1, -13 },
  { 219, 8, 13, 11, 1, -13 },
  { 232, 8, 13, 11, 1, -13 },
  { 245, 9, 13, 11, 1, -13 },
  { 260, 7, 13, 11, 2, -13 },
  { 272, 1, 9, 11, 5, -9 },
  { 274, 2, 12, 11, 4, -9 },
  { 277, 7, 10, 11, 2, -10 },
  { 286, 9, 5, 11, 1, -8 },
  { 292, 7, 10, 11, 2, -10 },
  { 301, 7, 13, 11, 2, -13 },
  { 313, 7, 15, 11, 2, -13 },
  { 327, 9, 13, 11, 1, -13 },
  { 342, 7, 13, 11, 2, -13 },
  { 354, 8, 13, 11, 1, -13 },
  { 367, 8, 13, 11, 2, -13 },
  { 380, 7, 13, 11, 2, -13 },
  { 392, 7, 13, 11, 2, -13 },
  { 404, 8, 13, 11, 1, -13 },
  { 417, 7, 13, 11, 2, -13 },
  { 429, 7, 13, 11, 2, -13 },
  { 441, 6, 13, 11, 2, -13 },
  { 451, 8, 13, 11, 2, -13 },
  { 464, 7, 13, 11, 3, -13 },
  { 476, 8, 13, 11, 1, -13 },
  { 489, 7, 13, 11, 2, -13 },
  { 501, 9, 13, 11, 1, -13 },
  { 516, 8, 13, 11, 2, -13 },
  { 529, 9, 16, 11, 1, -13 },
  { 547, 8, 13, 11, 2, -13 },
  { 560, 9, 13, 11, 1, -13 },
  { 575, 9, 13, 11, 1, -13 },
  { 590, 7, 13, 11, 2, -13 },
  { 602, 9, 13, 11, 1, -13 },
  { 617, 9, 13, 11, 1, -13 },
  { 632, 9, 13, 11, 1, -13 },
  { 647, 10, 13, 11, 0, -13 },
  { 664, 9, 13, 11, 1, -13 },
  { 679, 4, 16, 11, 5, -14 },
  { 687, 7, 16, 11, 2, -14 },
  { 701, 4, 16, 11, 2, -14 },
  { 709, 9, 7, 11, 1, -13 },
  { 717, 9, 1, 11, 1, 2 },
  { 719, 2, 3, 11, 4, -14 },
  { 720, 9, 9, 11, 1, -9 },
  { 731, 7, 13, 11, 2, -13 },
  { 743, 7, 9, 11, 2, -9 },
  { 751, 8, 13, 11, 1, -13 },
  { 764, 7, 9, 11, 2, -9 },
  { 772, 9, 13, 11, 1, -13 },
  { 787, 8, 14, 11, 2, -10 },
  { 801, 7, 13, 11, 2, -13 },
  { 813, 8, 13, 11, 2, -13 },
  { 826, 6, 17, 11, 2, -13 },
  { 839, 8, 13, 11, 2, -13 },
  { 852, 7, 13, 11, 2, -13 },
  { 864, 9, 9, 11, 1, -9 },
  { 875, 7, 9, 11, 2, -9 },
  { 883, 7, 9, 11, 2, -9 },
  { 891, 7, 13, 11, 2, -9 },
  { 903, 8, 13, 11, 1, -9 },
  { 916, 9, 9, 11, 1, -9 },
  { 927, 7, 9, 11, 2, -9 },
  { 935, 8, 13, 11, 1, -13 },
  { 948, 7, 9, 11, 2, -9 },
  { 956, 7, 9, 11, 2, -9 },
  { 964, 9, 9, 11, 1, -9 },
  { 975, 8, 9, 11, 1, -9 },
  { 984, 8, 13, 11, 1, -9 },
  { 997, 7, 9, 11, 2, -9 },
  { 1005, 7, 16, 11, 2, -14 },
  { 1019, 1, 16, 11, 5, -14 },
  { 1021, 7, 16, 11, 2, -14 },
  { 1035, 9, 4, 11, 1, -7 },
};

const GFXfont IBMPlexMono_ExtraLight18pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLight18pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLight18pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _IBMPLEXMONO_EXTRALIGHT18PT7B_H_
