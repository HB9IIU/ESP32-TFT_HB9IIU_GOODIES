#ifndef _IBMPLEXMONO_EXTRALIGHT51PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHT51PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLight.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLight51pt7bBitmaps[] PROGMEM = {
  0x00, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x61,
  0x08, 0x42, 0x10, 0x84, 0x21, 0x00, 0x00, 0x00, 0x00, 0x77, 0xBE, 0xE0,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x18, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x60, 0x30, 0x00, 0x02,
  0x01, 0x00, 0x00, 0x30, 0x08, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x0C, 0x06,
  0x00, 0x00, 0x60, 0x30, 0x00, 0x02, 0x01, 0x80, 0x00, 0x10, 0x08, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x60, 0x30, 0x03, 0xFF,
  0x01, 0xFF, 0x9F, 0xF0, 0x0F, 0xFC, 0x00, 0x80, 0x40, 0x00, 0x0C, 0x06,
  0x00, 0x00, 0x60, 0x30, 0x00, 0x03, 0x01, 0x80, 0x00, 0x18, 0x0C, 0x00,
  0x00, 0x80, 0x40, 0x00, 0x0C, 0x02, 0x00, 0x00, 0x60, 0x30, 0x03, 0xFF,
  0x01, 0xFF, 0x9F, 0xF8, 0x0F, 0xFC, 0x00, 0xC0, 0x60, 0x00, 0x04, 0x02,
  0x00, 0x00, 0x60, 0x10, 0x00, 0x03, 0x01, 0x80, 0x00, 0x18, 0x0C, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x04, 0x03, 0x00, 0x00, 0x20, 0x10, 0x00, 0x03,
  0x01, 0x80, 0x00, 0x18, 0x0C, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F,
  0x08, 0x78, 0x1C, 0x08, 0x1C, 0x38, 0x08, 0x0E, 0x30, 0x08, 0x07, 0x60,
  0x08, 0x04, 0x60, 0x08, 0x00, 0x60, 0x08, 0x00, 0x60, 0x08, 0x00, 0x60,
  0x08, 0x00, 0x60, 0x08, 0x00, 0x30, 0x08, 0x00, 0x30, 0x08, 0x00, 0x38,
  0x08, 0x00, 0x1E, 0x08, 0x00, 0x0F, 0xC8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x09, 0xF8, 0x00, 0x08, 0x3C, 0x00, 0x08, 0x0E, 0x00,
  0x08, 0x06, 0x00, 0x08, 0x03, 0x00, 0x08, 0x03, 0x00, 0x08, 0x03, 0x00,
  0x08, 0x03, 0x00, 0x08, 0x03, 0x00, 0x08, 0x03, 0x00, 0x08, 0x03, 0x40,
  0x08, 0x03, 0xE0, 0x08, 0x06, 0x30, 0x08, 0x0E, 0x1C, 0x08, 0x1C, 0x0F,
  0x08, 0x78, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x07,
  0xE0, 0x00, 0x31, 0xFF, 0x00, 0x02, 0x38, 0x38, 0x00, 0x63, 0x00, 0xC0,
  0x04, 0x60, 0x0C, 0x00, 0xC6, 0x00, 0x60, 0x18, 0x40, 0x06, 0x01, 0x84,
  0x00, 0x60, 0x30, 0x40, 0x06, 0x02, 0x04, 0x00, 0x60, 0x60, 0x40, 0x06,
  0x0C, 0x06, 0x00, 0x60, 0xC0, 0x60, 0x0C, 0x18, 0x03, 0x00, 0xC1, 0x00,
  0x38, 0x38, 0x30, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x06, 0x1E, 0x1C, 0x00, 0xC1, 0x80, 0x60, 0x08, 0x30, 0x06, 0x01,
  0x83, 0x00, 0x30, 0x30, 0x20, 0x03, 0x03, 0x02, 0x00, 0x30, 0x60, 0x20,
  0x03, 0x04, 0x02, 0x00, 0x30, 0xC0, 0x20, 0x03, 0x08, 0x02, 0x00, 0x31,
  0x80, 0x30, 0x03, 0x30, 0x03, 0x00, 0x62, 0x00, 0x18, 0x06, 0x60, 0x01,
  0xC1, 0xC4, 0x00, 0x0F, 0xF8, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x78, 0x38, 0x00, 0x18, 0x03, 0x00, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x0C, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x01, 0xF0, 0x03, 0xF0, 0xEE, 0x00, 0xFC, 0x61,
  0xC0, 0x30, 0x30, 0x38, 0x0C, 0x18, 0x06, 0x03, 0x06, 0x00, 0xC0, 0xC3,
  0x00, 0x18, 0x20, 0xC0, 0x03, 0x08, 0x30, 0x00, 0x62, 0x0C, 0x00, 0x1D,
  0x83, 0x00, 0x03, 0xE0, 0xC0, 0x00, 0x70, 0x30, 0x00, 0x0C, 0x0C, 0x00,
  0x03, 0x81, 0x80, 0x01, 0xB0, 0x70, 0x00, 0xC6, 0x0E, 0x00, 0x60, 0xC1,
  0xE0, 0x70, 0x38, 0x3F, 0xF8, 0x07, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60, 0x0C,
  0x00, 0x80, 0x18, 0x01, 0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0x40,
  0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x40,
  0x04, 0x00, 0x60, 0x06, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01, 0x80, 0x08,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x07, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x01,
  0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x06, 0x00,
  0x20, 0x02, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06, 0x00,
  0x40, 0x0C, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x10, 0x03, 0x00, 0x60, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x18, 0x03, 0x00, 0x7F, 0xE0, 0xC0, 0xF8, 0x3F, 0x31, 0xF0, 0x01,
  0xFF, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x33, 0x80, 0x00, 0x18, 0x60, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x01,
  0x80, 0x01, 0x80, 0x60, 0x00, 0xE0, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x18,
  0x00, 0x30, 0x0C, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x1C, 0x71, 0xCE, 0x38, 0xC3, 0x0C, 0x61, 0x86, 0x10, 0xC0, 0xFF, 0xFF,
  0xFF, 0xF0, 0x77, 0xBE, 0xE0, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00,
  0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00,
  0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00,
  0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00,
  0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0x80, 0xE0, 0x0E, 0x00, 0x30,
  0x1C, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x06,
  0x30, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x02, 0x60, 0x00, 0x03,
  0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x1C, 0x03, 0xC0, 0x1C, 0x03, 0xC0, 0x1C, 0x03, 0xC0, 0x1C, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x40, 0x00, 0x03, 0x60, 0x00, 0x03,
  0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x02, 0x60, 0x00, 0x06,
  0x30, 0x00, 0x06, 0x30, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x0C,
  0x1C, 0x00, 0x18, 0x0E, 0x00, 0x30, 0x07, 0x80, 0xE0, 0x03, 0xFF, 0xC0,
  0x00, 0x7F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xEC, 0x00,
  0x01, 0xCC, 0x00, 0x03, 0x8C, 0x00, 0x07, 0x0C, 0x00, 0x1E, 0x0C, 0x00,
  0x3C, 0x0C, 0x00, 0x78, 0x0C, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0x80, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x7F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x38, 0x0F, 0x00,
  0xC0, 0x07, 0x03, 0x00, 0x07, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x06, 0x60,
  0x00, 0x0C, 0x40, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0xFE, 0x00, 0x0F, 0xFF, 0x00, 0xF0, 0x1E, 0x07, 0x00, 0x1C, 0x18, 0x00,
  0x38, 0xC0, 0x00, 0x62, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x01, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x34, 0x00, 0x00,
  0xF8, 0x00, 0x06, 0x70, 0x00, 0x38, 0xE0, 0x01, 0xC1, 0xF0, 0x1E, 0x01,
  0xFF, 0xF0, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0D, 0x00, 0x00, 0x02, 0x40, 0x00, 0x01, 0x90, 0x00, 0x00, 0xC4,
  0x00, 0x00, 0x21, 0x00, 0x00, 0x18, 0x40, 0x00, 0x0C, 0x10, 0x00, 0x06,
  0x04, 0x00, 0x01, 0x81, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x60, 0x10, 0x00,
  0x18, 0x04, 0x00, 0x0C, 0x01, 0x00, 0x06, 0x00, 0x40, 0x01, 0x00, 0x10,
  0x00, 0xC0, 0x04, 0x00, 0x60, 0x01, 0x00, 0x10, 0x00, 0x40, 0x0C, 0x00,
  0x10, 0x06, 0x00, 0x04, 0x01, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x40, 0x60,
  0x00, 0x10, 0x10, 0x00, 0x04, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x40, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x02, 0x0F, 0xE0, 0x08, 0xFF, 0xF0, 0x2F, 0x01,
  0xE0, 0xA0, 0x01, 0xC3, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x34, 0x00, 0x01, 0xB8, 0x00, 0x06, 0x70, 0x00, 0x30, 0xE0, 0x01, 0x81,
  0xE0, 0x1C, 0x01, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x0F,
  0xE0, 0x18, 0xFF, 0xF0, 0x67, 0x01, 0xE1, 0xB0, 0x01, 0xC7, 0x80, 0x03,
  0x94, 0x00, 0x06, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0x40, 0x00, 0x0D, 0x80, 0x00, 0x36, 0x00, 0x01, 0x8C, 0x00, 0x06,
  0x38, 0x00, 0x30, 0x70, 0x01, 0xC0, 0xF0, 0x1E, 0x01, 0xFF, 0xE0, 0x01,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x6C, 0x00, 0x03, 0x30, 0x00, 0x0C,
  0xC0, 0x00, 0x23, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x0F,
  0x80, 0xF0, 0x1E, 0x00, 0x38, 0x18, 0x00, 0x1C, 0x38, 0x00, 0x0C, 0x30,
  0x00, 0x06, 0x30, 0x00, 0x06, 0x30, 0x00, 0x06, 0x30, 0x00, 0x06, 0x30,
  0x00, 0x06, 0x30, 0x00, 0x06, 0x30, 0x00, 0x04, 0x18, 0x00, 0x0C, 0x18,
  0x00, 0x18, 0x0C, 0x00, 0x38, 0x07, 0x80, 0xF0, 0x01, 0xFF, 0xC0, 0x01,
  0xFF, 0xC0, 0x07, 0x00, 0xF0, 0x1C, 0x00, 0x18, 0x38, 0x00, 0x0C, 0x30,
  0x00, 0x06, 0x60, 0x00, 0x02, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0x40, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60,
  0x00, 0x03, 0x70, 0x00, 0x06, 0x38, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x0F,
  0x00, 0xF8, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x0F,
  0xFF, 0x00, 0x3C, 0x07, 0x80, 0xE0, 0x03, 0x83, 0x80, 0x03, 0x86, 0x00,
  0x03, 0x18, 0x00, 0x03, 0x30, 0x00, 0x06, 0x60, 0x00, 0x0D, 0x80, 0x00,
  0x0B, 0x00, 0x00, 0x16, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x6C, 0x00, 0x01,
  0xD8, 0x00, 0x03, 0xB0, 0x00, 0x06, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x78,
  0x70, 0x01, 0xB0, 0x78, 0x0E, 0x60, 0x7F, 0xF9, 0x80, 0x3F, 0x83, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x77, 0xBE, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0xF7, 0xDC, 0x1C, 0x78, 0xF8,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x0E, 0x1C, 0x70, 0xE1, 0x83, 0x06, 0x18,
  0x30, 0x60, 0x83, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x3F, 0xFC, 0x07, 0x80, 0xF0, 0x70, 0x01, 0xC3, 0x00, 0x06,
  0x30, 0x00, 0x1B, 0x00, 0x00, 0xD8, 0x00, 0x06, 0x40, 0x00, 0x10, 0x00,
  0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x3E,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x0F, 0xFE, 0x00, 0x70, 0x3C, 0x03, 0x00, 0x38, 0x18, 0x00, 0x70,
  0x60, 0x00, 0xC3, 0x00, 0x01, 0x8C, 0x00, 0x06, 0x20, 0x00, 0x19, 0x80,
  0x00, 0x26, 0x00, 0x00, 0x98, 0x03, 0xE2, 0x40, 0x3F, 0xCD, 0x01, 0xC1,
  0xB4, 0x0E, 0x01, 0xD0, 0x30, 0x07, 0xC0, 0x80, 0x0F, 0x02, 0x00, 0x3C,
  0x18, 0x00, 0xF0, 0x60, 0x03, 0xC1, 0x80, 0x0F, 0x06, 0x00, 0x3C, 0x18,
  0x00, 0xF0, 0x60, 0x03, 0xC1, 0x80, 0x0D, 0x02, 0x00, 0x34, 0x0C, 0x00,
  0xD0, 0x30, 0x07, 0x40, 0x60, 0x2D, 0x81, 0xFF, 0xB6, 0x01, 0xFC, 0xD8,
  0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0xFF, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xA0,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x13, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x03,
  0x18, 0x00, 0x00, 0x86, 0x00, 0x00, 0x61, 0x80, 0x00, 0x18, 0x30, 0x00,
  0x06, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x18,
  0x00, 0x18, 0x06, 0x00, 0x06, 0x00, 0xC0, 0x01, 0x80, 0x30, 0x00, 0xC0,
  0x0C, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x18, 0x01,
  0x80, 0x03, 0x00, 0x60, 0x00, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC,
  0x03, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x18, 0x18, 0x00,
  0x03, 0x0E, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x06, 0x30,
  0x00, 0x01, 0x98, 0x00, 0x00, 0x66, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x0C, 0x00, 0x3C, 0x30, 0x00, 0x38, 0xC0,
  0x00, 0x63, 0x00, 0x01, 0xCC, 0x00, 0x03, 0x30, 0x00, 0x0C, 0xC0, 0x00,
  0x33, 0x00, 0x00, 0xCC, 0x00, 0x03, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x33,
  0x00, 0x01, 0x8C, 0x00, 0x06, 0x30, 0x00, 0x30, 0xC0, 0x03, 0x83, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF8, 0x30, 0x00, 0x78, 0xC0, 0x00, 0x73, 0x00, 0x00,
  0xCC, 0x00, 0x01, 0xB0, 0x00, 0x06, 0xC0, 0x00, 0x0B, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0B, 0x00, 0x00, 0x6C, 0x00,
  0x01, 0xB0, 0x00, 0x0E, 0xC0, 0x00, 0x73, 0x00, 0x07, 0x8F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0x80, 0x1E, 0x03, 0x80,
  0x70, 0x01, 0x81, 0xC0, 0x01, 0x87, 0x00, 0x01, 0x8C, 0x00, 0x03, 0x18,
  0x00, 0x03, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0xCC, 0x00, 0x03, 0x1C, 0x00, 0x06, 0x1C,
  0x00, 0x18, 0x1C, 0x00, 0x60, 0x1E, 0x03, 0x80, 0x1F, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x0C, 0x00, 0x78, 0x30, 0x00,
  0x70, 0xC0, 0x00, 0x63, 0x00, 0x01, 0xCC, 0x00, 0x03, 0x30, 0x00, 0x06,
  0xC0, 0x00, 0x1B, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xB0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x2C, 0x00, 0x01, 0xB0, 0x00, 0x06, 0xC0, 0x00, 0x1B, 0x00, 0x00,
  0xCC, 0x00, 0x07, 0x30, 0x00, 0x18, 0xC0, 0x01, 0xC3, 0x00, 0x1E, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFE,
  0x00, 0xF0, 0x1E, 0x07, 0x00, 0x18, 0x18, 0x00, 0x30, 0xC0, 0x00, 0x63,
  0x00, 0x01, 0x98, 0x00, 0x03, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0x60, 0x00, 0x0D, 0x80, 0x00, 0x37, 0x00, 0x00, 0xCC, 0x00, 0x07, 0x18,
  0x00, 0x3C, 0x70, 0x01, 0xB0, 0xF0, 0x1C, 0xC0, 0xFF, 0xE3, 0x00, 0xFE,
  0x00, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x30,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xE3, 0xFF, 0xFC, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0xB0, 0x00,
  0x36, 0x00, 0x06, 0x60, 0x01, 0x8E, 0x00, 0x70, 0xF0, 0x3C, 0x0F, 0xFF,
  0x00, 0x3F, 0x00, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x66,
  0x00, 0x01, 0x8C, 0x00, 0x06, 0x18, 0x00, 0x18, 0x30, 0x00, 0x60, 0x60,
  0x01, 0xC0, 0xC0, 0x07, 0x01, 0x80, 0x0C, 0x03, 0x00, 0x30, 0x06, 0x00,
  0xC0, 0x0C, 0x03, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x30, 0x00, 0x60, 0xE0,
  0x00, 0xC3, 0xE0, 0x01, 0x86, 0xC0, 0x03, 0x18, 0xC0, 0x06, 0x61, 0xC0,
  0x0D, 0x81, 0x80, 0x1E, 0x01, 0x80, 0x38, 0x03, 0x80, 0x60, 0x03, 0x00,
  0xC0, 0x03, 0x01, 0x80, 0x07, 0x03, 0x00, 0x06, 0x06, 0x00, 0x06, 0x0C,
  0x00, 0x0C, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x18, 0xC0,
  0x00, 0x19, 0x80, 0x00, 0x3B, 0x00, 0x00, 0x36, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x0D, 0xD8, 0x00, 0x37, 0x60, 0x00, 0x9C, 0xC0, 0x06,
  0x73, 0x00, 0x19, 0xC4, 0x00, 0xC7, 0x18, 0x03, 0x1C, 0x60, 0x18, 0x70,
  0xC0, 0x61, 0xC3, 0x01, 0x07, 0x06, 0x0C, 0x1C, 0x18, 0x20, 0x70, 0x21,
  0x81, 0xC0, 0xC6, 0x07, 0x01, 0x30, 0x1C, 0x06, 0xC0, 0x70, 0x1E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xC0, 0x1C, 0x01, 0x00, 0x70, 0x08, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3D, 0x80, 0x01, 0xEC, 0x00, 0x0F,
  0x30, 0x00, 0x79, 0x80, 0x03, 0xC6, 0x00, 0x1E, 0x30, 0x00, 0xF0, 0xC0,
  0x07, 0x86, 0x00, 0x3C, 0x18, 0x01, 0xE0, 0xC0, 0x0F, 0x03, 0x00, 0x78,
  0x18, 0x03, 0xC0, 0x60, 0x1E, 0x03, 0x00, 0xF0, 0x0C, 0x07, 0x80, 0x60,
  0x3C, 0x01, 0x81, 0xE0, 0x0C, 0x0F, 0x00, 0x20, 0x78, 0x01, 0x83, 0xC0,
  0x04, 0x1E, 0x00, 0x30, 0xF0, 0x01, 0x87, 0x80, 0x06, 0x3C, 0x00, 0x31,
  0xE0, 0x00, 0xCF, 0x00, 0x06, 0x78, 0x00, 0x1B, 0xC0, 0x00, 0xDE, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x70, 0x00, 0x7F, 0x00, 0x01, 0xFF,
  0xC0, 0x07, 0x80, 0xE0, 0x0E, 0x00, 0x30, 0x1C, 0x00, 0x18, 0x18, 0x00,
  0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x30, 0x00, 0x06, 0x60, 0x00,
  0x06, 0x60, 0x00, 0x02, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00,
  0x03, 0x60, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0x40, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00,
  0x03, 0x60, 0x00, 0x02, 0x60, 0x00, 0x06, 0x30, 0x00, 0x06, 0x30, 0x00,
  0x06, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x1C, 0x00, 0x18, 0x0E, 0x00,
  0x30, 0x07, 0x80, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x0C, 0x00, 0x0F, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x1B,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x01, 0xB0, 0x00, 0x06, 0xC0, 0x00, 0x33, 0x00, 0x03, 0x8F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xC0, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0x80, 0xE0, 0x0E, 0x00,
  0x30, 0x1C, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00,
  0x06, 0x30, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x02, 0x60, 0x00,
  0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x40, 0x00, 0x03, 0x60, 0x00,
  0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x02, 0x60, 0x00,
  0x06, 0x30, 0x00, 0x06, 0x30, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x18, 0x00,
  0x0C, 0x1C, 0x00, 0x18, 0x0E, 0x00, 0x30, 0x07, 0x80, 0xE0, 0x03, 0xFF,
  0xC0, 0x00, 0x7F, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x0C, 0x00, 0x0F, 0x30, 0x00, 0x0C,
  0xC0, 0x00, 0x1B, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xB0, 0x00, 0x06, 0xC0, 0x00, 0x33,
  0x00, 0x03, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xC0, 0xC0, 0x30, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x03, 0x00, 0xC0, 0x06, 0x03, 0x00, 0x18,
  0x0C, 0x00, 0x30, 0x30, 0x00, 0xE0, 0xC0, 0x01, 0x83, 0x00, 0x03, 0x0C,
  0x00, 0x0C, 0x30, 0x00, 0x18, 0xC0, 0x00, 0x33, 0x00, 0x00, 0xCC, 0x00,
  0x01, 0xB0, 0x00, 0x07, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0x00,
  0xF8, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x0E, 0x30, 0x00, 0x07, 0x60, 0x00,
  0x04, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0x60, 0x00, 0x06, 0x30, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x0F, 0x00,
  0x78, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0x60, 0x00, 0x19, 0x80, 0x00, 0xCC, 0x00, 0x06, 0x70, 0x00, 0x61,
  0xC0, 0x07, 0x07, 0x00, 0xF0, 0x1F, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x0C,
  0x30, 0x00, 0x0C, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x03, 0x03, 0x00, 0x03,
  0x00, 0xC0, 0x01, 0x80, 0x60, 0x00, 0xC0, 0x30, 0x00, 0x40, 0x18, 0x00,
  0x60, 0x06, 0x00, 0x30, 0x03, 0x00, 0x10, 0x01, 0x80, 0x18, 0x00, 0x60,
  0x0C, 0x00, 0x30, 0x06, 0x00, 0x18, 0x06, 0x00, 0x06, 0x03, 0x00, 0x03,
  0x01, 0x80, 0x01, 0x81, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x30, 0x60, 0x00,
  0x18, 0x60, 0x00, 0x06, 0x30, 0x00, 0x03, 0x18, 0x00, 0x01, 0x98, 0x00,
  0x00, 0x4C, 0x00, 0x00, 0x36, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x16, 0x00, 0x00, 0x0B, 0x00,
  0x00, 0x05, 0x80, 0x00, 0x02, 0xC0, 0x00, 0x03, 0x20, 0x00, 0x01, 0x90,
  0x00, 0x00, 0xC8, 0x03, 0x80, 0x66, 0x01, 0xC0, 0x33, 0x00, 0xE0, 0x19,
  0x80, 0xD0, 0x0C, 0xC0, 0x6C, 0x06, 0x60, 0x26, 0x02, 0x30, 0x31, 0x01,
  0x18, 0x18, 0xC0, 0x8C, 0x0C, 0x60, 0xC2, 0x04, 0x30, 0x61, 0x06, 0x08,
  0x30, 0x83, 0x06, 0x18, 0x61, 0x03, 0x0C, 0x31, 0x81, 0x86, 0x18, 0xC0,
  0x43, 0x0C, 0x60, 0x31, 0x86, 0x20, 0x18, 0x83, 0x30, 0x04, 0x41, 0x98,
  0x03, 0x20, 0xC8, 0x01, 0xB0, 0x2C, 0x00, 0xD8, 0x16, 0x00, 0x2C, 0x0B,
  0x00, 0x1E, 0x07, 0x00, 0x0F, 0x03, 0x80, 0x03, 0x80, 0x60, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x63, 0x80, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x0C, 0x00,
  0x06, 0x03, 0x80, 0x03, 0x00, 0x60, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x30, 0x00, 0x60, 0x0C, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x1C, 0x60, 0x00, 0x03, 0x38, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x33, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x06, 0x0C, 0x00,
  0x03, 0x03, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x1C, 0x00, 0x38, 0x03,
  0x00, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x1C, 0x01, 0x80, 0x03, 0x00, 0xC0,
  0x00, 0x60, 0x60, 0x00, 0x18, 0x18, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x1B, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x06, 0x30, 0x00, 0x00, 0x63, 0x80, 0x00, 0x0C, 0x18, 0x00, 0x01, 0xC0,
  0xC0, 0x00, 0x18, 0x0C, 0x00, 0x03, 0x00, 0x60, 0x00, 0x30, 0x03, 0x00,
  0x06, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x0C, 0x00, 0x1C, 0x01, 0x80,
  0x00, 0xC0, 0x38, 0x00, 0x06, 0x03, 0x00, 0x00, 0x60, 0x60, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x01, 0x98, 0x00, 0x00, 0x0D, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0F, 0xFF, 0xFF, 0xFC,
  0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x08,
  0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x1C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x36, 0x00, 0x00, 0x66, 0x00, 0x00, 0x63,
  0x00, 0x00, 0xC1, 0x80, 0x01, 0x81, 0x80, 0x01, 0x80, 0xC0, 0x03, 0x00,
  0xC0, 0x03, 0x00, 0x60, 0x06, 0x00, 0x20, 0x04, 0x00, 0x30, 0x0C, 0x00,
  0x18, 0x18, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x20, 0x00,
  0x06, 0x60, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x40, 0x00, 0x02, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x41, 0xC1, 0x81, 0x81, 0x83, 0x03, 0x03,
  0x06, 0x03, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x78, 0x1E, 0x01, 0xC0, 0x0E,
  0x06, 0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x10, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF8, 0x1E, 0x00, 0x30, 0x70,
  0x00, 0x61, 0x80, 0x00, 0xC3, 0x00, 0x01, 0x86, 0x00, 0x03, 0x0C, 0x00,
  0x06, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x60, 0x00, 0x70, 0x60, 0x01,
  0x60, 0x70, 0x1C, 0x7C, 0x7F, 0xF0, 0xF8, 0x3F, 0x80, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x83, 0xF8, 0x0C, 0x7F, 0xF0, 0x67, 0x03, 0xC3, 0x60,
  0x07, 0x1C, 0x00, 0x1C, 0xE0, 0x00, 0x66, 0x00, 0x01, 0xB0, 0x00, 0x0D,
  0x80, 0x00, 0x6C, 0x00, 0x01, 0x60, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0B, 0x00, 0x00, 0xD8, 0x00, 0x06, 0xC0, 0x00,
  0x37, 0x00, 0x03, 0x38, 0x00, 0x39, 0xB0, 0x03, 0x8C, 0xE0, 0x78, 0x63,
  0xFF, 0x80, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xFC, 0x03, 0xC0,
  0xF0, 0x38, 0x01, 0xC1, 0x80, 0x03, 0x18, 0x00, 0x19, 0x80, 0x00, 0x4C,
  0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x08, 0xC0, 0x00, 0x63, 0x00, 0x06, 0x1C, 0x00, 0x60, 0x78,
  0x0E, 0x00, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x03, 0xF8, 0x30, 0x7F, 0xF1, 0x87, 0x81, 0xCC, 0x70, 0x03, 0x66, 0x00,
  0x0B, 0x70, 0x00, 0x3B, 0x00, 0x01, 0xD8, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x6C, 0x00, 0x03, 0x60, 0x00, 0x3B, 0x80, 0x01,
  0xCC, 0x00, 0x16, 0x38, 0x01, 0xB0, 0xF0, 0x39, 0x83, 0xFF, 0x8C, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0xF0, 0x1C, 0x07, 0x00,
  0x18, 0x18, 0x00, 0x30, 0xC0, 0x00, 0x62, 0x00, 0x01, 0x98, 0x00, 0x02,
  0x60, 0x00, 0x0D, 0x80, 0x00, 0x34, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x08,
  0xC0, 0x00, 0x33, 0x00, 0x01, 0x86, 0x00, 0x0C, 0x1C, 0x00, 0x70, 0x3C,
  0x07, 0x80, 0x3F, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x7F,
  0xFC, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x07, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0xFE, 0x40, 0x03, 0xFF, 0xC0, 0x07, 0x01, 0xC0,
  0x0C, 0x00, 0x60, 0x18, 0x00, 0x60, 0x18, 0x00, 0x30, 0x10, 0x00, 0x30,
  0x30, 0x00, 0x18, 0x30, 0x00, 0x18, 0x30, 0x00, 0x18, 0x30, 0x00, 0x18,
  0x10, 0x00, 0x30, 0x18, 0x00, 0x30, 0x18, 0x00, 0x70, 0x0C, 0x00, 0x60,
  0x07, 0x01, 0xC0, 0x03, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x1C, 0x00, 0x1E,
  0x30, 0x00, 0x06, 0x60, 0x00, 0x03, 0x40, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x60, 0x00, 0x06, 0x70, 0x00, 0x0E,
  0x3C, 0x00, 0x7C, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0xFC, 0x0C, 0x7F, 0xE1, 0x98, 0x0F, 0x34, 0x00, 0x67, 0x00, 0x06, 0xE0,
  0x00, 0xD8, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0x80, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xBF, 0xFF, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x67, 0xFF, 0xF9, 0xFF, 0xFC, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x72, 0x00, 0x03, 0x88, 0x00,
  0x1C, 0x20, 0x00, 0xC0, 0x80, 0x06, 0x02, 0x00, 0x30, 0x08, 0x01, 0x80,
  0x20, 0x1C, 0x00, 0x80, 0xE0, 0x02, 0x07, 0x00, 0x08, 0x38, 0x00, 0x21,
  0xB0, 0x00, 0x8C, 0xE0, 0x02, 0x61, 0x80, 0x0F, 0x03, 0x00, 0x38, 0x06,
  0x00, 0x80, 0x0C, 0x02, 0x00, 0x18, 0x08, 0x00, 0x70, 0x20, 0x00, 0xC0,
  0x80, 0x01, 0x82, 0x00, 0x03, 0x08, 0x00, 0x06, 0x20, 0x00, 0x1C, 0x80,
  0x00, 0x3A, 0x00, 0x00, 0x70, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0x81, 0xF1, 0x3F, 0x87, 0xFA, 0xC3, 0x98, 0x75, 0x01,
  0x20, 0x3C, 0x03, 0x80, 0x70, 0x06, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x18,
  0x03, 0x80, 0x30, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x1C, 0x01, 0x80,
  0x38, 0x03, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x18, 0x03,
  0x80, 0x30, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x38,
  0x03, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x18, 0x03, 0x80,
  0x30, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x18, 0x01, 0xF8, 0x18, 0xFF,
  0xC3, 0x30, 0x1E, 0x68, 0x00, 0xCE, 0x00, 0x0D, 0xC0, 0x01, 0xB0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0x80, 0x00, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0xF0, 0x1C, 0x07, 0x00, 0x18,
  0x18, 0x00, 0x30, 0xC0, 0x00, 0x66, 0x00, 0x01, 0x98, 0x00, 0x02, 0x60,
  0x00, 0x0D, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x34, 0x00, 0x00, 0xD8, 0x00, 0x03, 0x60, 0x00, 0x09, 0x80,
  0x00, 0x63, 0x00, 0x03, 0x86, 0x00, 0x0C, 0x1C, 0x00, 0x60, 0x3C, 0x07,
  0x00, 0x7F, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x06, 0x3F, 0xF8, 0x33,
  0x81, 0xE1, 0xB0, 0x03, 0x8E, 0x00, 0x0E, 0x70, 0x00, 0x33, 0x00, 0x00,
  0xD8, 0x00, 0x06, 0xC0, 0x00, 0x36, 0x00, 0x00, 0xB0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x05, 0x80, 0x00, 0x6C, 0x00,
  0x03, 0x60, 0x00, 0x1B, 0x80, 0x01, 0x9C, 0x00, 0x1C, 0xD8, 0x01, 0xC6,
  0x70, 0x3C, 0x31, 0xFF, 0xC1, 0x83, 0xF8, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x3F,
  0xF8, 0xC3, 0xC0, 0xE6, 0x38, 0x01, 0xB3, 0x00, 0x05, 0xB8, 0x00, 0x1D,
  0x80, 0x00, 0xEC, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x36, 0x00, 0x01, 0xB0, 0x00, 0x1D, 0xC0, 0x00, 0xE6, 0x00, 0x0B, 0x1C,
  0x00, 0xD8, 0x78, 0x1C, 0xC1, 0xFF, 0xC6, 0x03, 0xF8, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0xFF, 0xE0,
  0xFF, 0xFF, 0xE3, 0xFF, 0x00, 0x67, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFC, 0x01, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0xE0, 0x1E,
  0x06, 0x00, 0x0E, 0x30, 0x00, 0x1C, 0xC0, 0x00, 0x42, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00,
  0x00, 0x05, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xDC, 0x00, 0x03, 0x38, 0x00,
  0x38, 0x7C, 0x03, 0xC0, 0x7F, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x38, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x03,
  0xFF, 0xF0, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0xF0, 0x00, 0x36, 0x00, 0x15, 0xC0, 0x0D, 0x3C, 0x0E, 0x47, 0xFF,
  0x10, 0x7F, 0x00, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x36, 0x00, 0x01, 0x8C,
  0x00, 0x06, 0x30, 0x00, 0x18, 0xC0, 0x00, 0xC1, 0x80, 0x03, 0x06, 0x00,
  0x08, 0x08, 0x00, 0x60, 0x30, 0x01, 0x80, 0xC0, 0x04, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x06, 0x00, 0x30, 0x18, 0x00, 0xC0, 0x40, 0x01,
  0x03, 0x00, 0x06, 0x0C, 0x00, 0x18, 0x20, 0x00, 0x21, 0x80, 0x00, 0xC6,
  0x00, 0x03, 0x30, 0x00, 0x06, 0xC0, 0x00, 0x1A, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x28,
  0x01, 0x60, 0x0D, 0x00, 0x24, 0x01, 0xB0, 0x0C, 0x80, 0x26, 0x01, 0x98,
  0x0C, 0x40, 0x33, 0x01, 0x88, 0x04, 0x60, 0x31, 0x80, 0x84, 0x04, 0x30,
  0x30, 0x81, 0x82, 0x06, 0x18, 0x30, 0x40, 0xC3, 0x06, 0x0C, 0x10, 0x60,
  0x81, 0x82, 0x0C, 0x30, 0x10, 0x40, 0x86, 0x02, 0x18, 0x10, 0xC0, 0x63,
  0x03, 0x10, 0x0C, 0x60, 0x66, 0x00, 0x88, 0x0C, 0xC0, 0x11, 0x00, 0x98,
  0x03, 0x60, 0x12, 0x00, 0x6C, 0x03, 0xC0, 0x05, 0x80, 0x78, 0x00, 0xA0,
  0x0F, 0x00, 0x1C, 0x01, 0xC0, 0x03, 0x80, 0xE0, 0x00, 0x0C, 0xC0, 0x00,
  0x63, 0x00, 0x03, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x60, 0x18, 0x03, 0x00,
  0x60, 0x18, 0x00, 0xC0, 0xC0, 0x01, 0x83, 0x00, 0x03, 0x18, 0x00, 0x0E,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x06, 0xC0,
  0x00, 0x33, 0x00, 0x01, 0x86, 0x00, 0x06, 0x0C, 0x00, 0x30, 0x18, 0x01,
  0x80, 0x60, 0x0C, 0x00, 0xC0, 0x30, 0x01, 0x81, 0x80, 0x03, 0x0C, 0x00,
  0x0E, 0x60, 0x00, 0x1B, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x19, 0x80, 0x00, 0x33, 0x00, 0x00, 0xC3, 0x00, 0x01, 0x86, 0x00, 0x02,
  0x04, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x60, 0x18, 0x00, 0xC0,
  0x30, 0x01, 0x00, 0x30, 0x06, 0x00, 0x60, 0x08, 0x00, 0x40, 0x30, 0x00,
  0xC0, 0x60, 0x01, 0x81, 0x80, 0x01, 0x83, 0x00, 0x03, 0x04, 0x00, 0x02,
  0x18, 0x00, 0x06, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x1A,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x07,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00,
  0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x01, 0xC0, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x00, 0xE0, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00,
  0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00,
  0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x1F, 0xFE, 0x01,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x01,
  0xE0, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x04,
  0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x0F, 0xFE,
  0x01, 0xFF, 0xC0, 0x00, 0x0F, 0x80, 0x01, 0x8F, 0xE0, 0x00, 0x8E, 0x38,
  0x00, 0x46, 0x06, 0x00, 0x66, 0x01, 0x80, 0x33, 0x00, 0xE0, 0x11, 0x00,
  0x38, 0x19, 0x80, 0x0E, 0x18, 0xC0, 0x03, 0xF8, 0x40, 0x00, 0x78, 0x00,
};

const GFXglyph IBMPlexMono_ExtraLight51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 31, 0, -1 },
  { 1, 5, 36, 31, 13, -36 },
  { 24, 9, 13, 31, 11, -38 },
  { 39, 29, 36, 31, 1, -36 },
  { 170, 24, 47, 31, 3, -41 },
  { 311, 28, 37, 31, 1, -36 },
  { 441, 26, 37, 31, 2, -36 },
  { 562, 2, 13, 31, 14, -38 },
  { 566, 12, 46, 31, 12, -39 },
  { 635, 12, 46, 31, 7, -39 },
  { 704, 26, 25, 31, 2, -28 },
  { 786, 24, 26, 31, 3, -29 },
  { 864, 6, 13, 31, 11, -5 },
  { 874, 14, 2, 31, 8, -17 },
  { 878, 5, 4, 31, 13, -4 },
  { 881, 20, 46, 31, 5, -39 },
  { 996, 24, 37, 31, 3, -36 },
  { 1107, 24, 36, 31, 4, -36 },
  { 1215, 23, 36, 31, 4, -36 },
  { 1319, 22, 37, 31, 3, -36 },
  { 1421, 26, 36, 31, 2, -36 },
  { 1538, 22, 37, 31, 4, -36 },
  { 1640, 22, 37, 31, 4, -36 },
  { 1742, 22, 36, 31, 4, -36 },
  { 1841, 24, 37, 31, 3, -36 },
  { 1952, 23, 36, 31, 4, -36 },
  { 2056, 5, 27, 31, 13, -27 },
  { 2073, 7, 35, 31, 11, -27 },
  { 2104, 22, 28, 31, 4, -30 },
  { 2181, 24, 11, 31, 3, -21 },
  { 2214, 22, 28, 31, 4, -30 },
  { 2291, 21, 36, 31, 5, -36 },
  { 2386, 22, 41, 31, 4, -36 },
  { 2499, 26, 36, 31, 2, -36 },
  { 2616, 22, 36, 31, 5, -36 },
  { 2715, 23, 37, 31, 4, -36 },
  { 2822, 22, 36, 31, 5, -36 },
  { 2921, 21, 36, 31, 5, -36 },
  { 3016, 22, 36, 31, 5, -36 },
  { 3115, 22, 37, 31, 4, -36 },
  { 3217, 21, 36, 31, 5, -36 },
  { 3312, 21, 36, 31, 5, -36 },
  { 3407, 19, 37, 31, 5, -36 },
  { 3495, 23, 36, 31, 5, -36 },
  { 3599, 20, 36, 31, 7, -36 },
  { 3689, 22, 36, 31, 4, -36 },
  { 3788, 21, 36, 31, 5, -36 },
  { 3883, 24, 37, 31, 3, -36 },
  { 3994, 22, 36, 31, 5, -36 },
  { 4093, 24, 44, 31, 3, -36 },
  { 4225, 22, 36, 31, 5, -36 },
  { 4324, 24, 37, 31, 3, -36 },
  { 4435, 27, 36, 31, 2, -36 },
  { 4557, 21, 37, 31, 5, -36 },
  { 4655, 25, 36, 31, 3, -36 },
  { 4768, 25, 36, 31, 3, -36 },
  { 4881, 26, 36, 31, 2, -36 },
  { 4998, 28, 36, 31, 1, -36 },
  { 5124, 26, 36, 31, 2, -36 },
  { 5241, 13, 46, 31, 13, -39 },
  { 5316, 20, 46, 31, 5, -39 },
  { 5431, 13, 46, 31, 5, -39 },
  { 5506, 24, 20, 31, 3, -36 },
  { 5566, 25, 2, 31, 3, 6 },
  { 5573, 7, 9, 31, 10, -39 },
  { 5581, 23, 28, 31, 4, -27 },
  { 5662, 21, 39, 31, 6, -38 },
  { 5765, 21, 28, 31, 5, -27 },
  { 5839, 21, 39, 31, 4, -38 },
  { 5942, 22, 28, 31, 4, -27 },
  { 6019, 23, 38, 31, 4, -38 },
  { 6129, 24, 40, 31, 4, -29 },
  { 6249, 19, 38, 31, 6, -38 },
  { 6340, 21, 38, 31, 6, -38 },
  { 6440, 18, 48, 31, 5, -38 },
  { 6548, 22, 38, 31, 7, -38 },
  { 6653, 22, 38, 31, 4, -38 },
  { 6758, 23, 27, 31, 4, -27 },
  { 6836, 19, 27, 31, 6, -27 },
  { 6901, 22, 28, 31, 4, -27 },
  { 6978, 21, 37, 31, 6, -27 },
  { 7076, 21, 37, 31, 4, -27 },
  { 7174, 24, 26, 31, 4, -26 },
  { 7252, 22, 28, 31, 4, -27 },
  { 7329, 25, 36, 31, 2, -36 },
  { 7442, 18, 27, 31, 6, -26 },
  { 7503, 22, 26, 31, 4, -26 },
  { 7575, 27, 26, 31, 2, -26 },
  { 7663, 22, 26, 31, 4, -26 },
  { 7735, 23, 36, 31, 4, -26 },
  { 7839, 21, 26, 31, 5, -26 },
  { 7908, 19, 46, 31, 6, -39 },
  { 8018, 2, 46, 31, 14, -39 },
  { 8030, 19, 46, 31, 6, -39 },
  { 8140, 25, 10, 31, 3, -20 },
};

const GFXfont IBMPlexMono_ExtraLight51pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLight51pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLight51pt7bGlyphs,
  0x20, 0x7E, 66
};

#endif // _IBMPLEXMONO_EXTRALIGHT51PT7B_H_
