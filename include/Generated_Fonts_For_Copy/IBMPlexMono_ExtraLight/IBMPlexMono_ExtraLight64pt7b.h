#ifndef _IBMPLEXMONO_EXTRALIGHT64PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHT64PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLight.ttf
// Size: 64pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLight64pt7bBitmaps[] PROGMEM = {
  0x00, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0x41,
  0x04, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x79, 0xFF, 0xDF, 0x78, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0x00, 0x01, 0xC0,
  0x18, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x01, 0x80, 0x38, 0x00, 0x00,
  0x18, 0x03, 0x00, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x38, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x30, 0x07, 0x00, 0x00, 0x03, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00,
  0x70, 0x06, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0x60, 0x0E, 0x00,
  0x00, 0x06, 0x00, 0xC0, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x1F, 0xFE, 0x00,
  0xFF, 0xF0, 0x00, 0xE0, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x1C, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x18, 0x00,
  0x00, 0x1C, 0x01, 0x80, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x18, 0x03,
  0x80, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x30, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xCF, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0x30, 0x07, 0x00, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0x30, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0x70, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x1C, 0x00, 0x00, 0x0C,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x07, 0xE1, 0x8F, 0x80, 0x3C, 0x06, 0x07, 0x81, 0xC0, 0x18,
  0x07, 0x06, 0x00, 0x60, 0x0E, 0x38, 0x01, 0x80, 0x1C, 0xC0, 0x06, 0x00,
  0x47, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x60, 0x01, 0x80, 0x01,
  0x80, 0x06, 0x00, 0x06, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x70,
  0x01, 0x80, 0x00, 0xC0, 0x06, 0x00, 0x03, 0x80, 0x18, 0x00, 0x06, 0x00,
  0x60, 0x00, 0x1E, 0x01, 0x80, 0x00, 0x3C, 0x06, 0x00, 0x00, 0x7E, 0x18,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x18, 0xFC, 0x00, 0x00, 0x60, 0x78, 0x00, 0x01, 0x80, 0x70,
  0x00, 0x06, 0x00, 0xE0, 0x00, 0x18, 0x03, 0x80, 0x00, 0x60, 0x06, 0x00,
  0x01, 0x80, 0x1C, 0x00, 0x06, 0x00, 0x30, 0x00, 0x18, 0x00, 0xC0, 0x00,
  0x60, 0x03, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x06, 0x00, 0x30, 0x00, 0x18,
  0x00, 0xD0, 0x00, 0x60, 0x07, 0xE0, 0x01, 0x80, 0x19, 0xC0, 0x06, 0x00,
  0xE7, 0x80, 0x18, 0x03, 0x0F, 0x00, 0x60, 0x1C, 0x0F, 0x01, 0x81, 0xE0,
  0x1F, 0x86, 0x3E, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xE1, 0xFF, 0x80, 0x00, 0x18, 0x70, 0x38, 0x00, 0x06, 0x1C,
  0x03, 0x80, 0x00, 0xC7, 0x00, 0x38, 0x00, 0x30, 0xC0, 0x03, 0x00, 0x0E,
  0x38, 0x00, 0x70, 0x01, 0x86, 0x00, 0x06, 0x00, 0x60, 0xC0, 0x00, 0xC0,
  0x0C, 0x18, 0x00, 0x18, 0x03, 0x03, 0x00, 0x03, 0x00, 0x60, 0x60, 0x00,
  0x60, 0x18, 0x0C, 0x00, 0x0C, 0x06, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x38,
  0x00, 0x70, 0x30, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x70, 0x03, 0x81, 0x80,
  0x07, 0x00, 0xE0, 0x70, 0x00, 0x70, 0x38, 0x0C, 0x00, 0x07, 0xFE, 0x02,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0xE0, 0x78, 0x3C, 0x00, 0x18, 0x1C, 0x01,
  0x80, 0x06, 0x03, 0x00, 0x18, 0x00, 0xC0, 0xC0, 0x03, 0x80, 0x30, 0x18,
  0x00, 0x30, 0x0E, 0x03, 0x00, 0x06, 0x01, 0x80, 0x60, 0x00, 0xC0, 0x60,
  0x18, 0x00, 0x18, 0x0C, 0x03, 0x00, 0x03, 0x03, 0x00, 0x60, 0x00, 0x60,
  0x60, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0xC0, 0x01, 0x87, 0x00, 0x18, 0x00,
  0x30, 0xC0, 0x03, 0x00, 0x06, 0x30, 0x00, 0x60, 0x01, 0xC6, 0x00, 0x06,
  0x00, 0x31, 0x80, 0x00, 0xE0, 0x0C, 0x30, 0x00, 0x0F, 0x07, 0x8C, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x38, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x70, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x70, 0x00, 0xFE, 0x0E, 0x18, 0x00, 0x7F, 0x0E,
  0x0E, 0x00, 0x30, 0x0E, 0x03, 0x80, 0x18, 0x0E, 0x00, 0xE0, 0x0C, 0x06,
  0x00, 0x38, 0x06, 0x07, 0x00, 0x0E, 0x07, 0x03, 0x00, 0x03, 0x83, 0x01,
  0x80, 0x00, 0xC1, 0x80, 0xC0, 0x00, 0x30, 0xC0, 0xE0, 0x00, 0x1C, 0x60,
  0x70, 0x00, 0x07, 0x30, 0x38, 0x00, 0x01, 0xD8, 0x1C, 0x00, 0x00, 0x78,
  0x06, 0x00, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x05,
  0x80, 0xE0, 0x00, 0x06, 0x60, 0x38, 0x00, 0x06, 0x38, 0x0E, 0x00, 0x06,
  0x0E, 0x07, 0x80, 0x07, 0x03, 0x80, 0xF0, 0x1E, 0x00, 0xE0, 0x3F, 0xFE,
  0x00, 0x38, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0E,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x60, 0x01,
  0x80, 0x07, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00,
  0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x1C, 0xE0,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03,
  0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xE0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x01, 0x80, 0x03, 0xFC, 0x01, 0x80, 0x1F, 0x3F,
  0x81, 0x80, 0xFE, 0x07, 0xF1, 0x87, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0x60, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00,
  0x18, 0x1C, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00,
  0x60, 0x07, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x01, 0xC0, 0x01, 0x80, 0x03,
  0x80, 0x01, 0xC0, 0x03, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x60, 0x02,
  0x00, 0x00, 0x50, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x0F, 0x1E, 0x1E, 0x1E, 0x1C, 0x1C, 0x3C, 0x38, 0x38,
  0x38, 0x30, 0x70, 0x70, 0x60, 0x60, 0x60, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x79, 0xFF, 0xDF, 0x78, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1E, 0x01,
  0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x07, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x03,
  0x01, 0xC0, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x0E, 0x70,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x66, 0x00, 0x00, 0x01, 0x98, 0x00,
  0x00, 0x07, 0x60, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x1E, 0x00,
  0x3E, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0x80, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x60,
  0x00, 0x00, 0x1D, 0x80, 0x00, 0x00, 0x76, 0x00, 0x00, 0x01, 0xD8, 0x00,
  0x00, 0x07, 0x60, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x03, 0x8C, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x01,
  0xC1, 0x80, 0x00, 0x06, 0x07, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0xC0,
  0x1C, 0x00, 0x06, 0x00, 0x38, 0x00, 0x78, 0x00, 0x7C, 0x07, 0x80, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x1E, 0x60, 0x00, 0x00, 0xF1,
  0x80, 0x00, 0x07, 0x86, 0x00, 0x00, 0x3C, 0x18, 0x00, 0x01, 0xC0, 0x60,
  0x00, 0x0E, 0x01, 0x80, 0x00, 0x70, 0x06, 0x00, 0x07, 0x80, 0x18, 0x00,
  0x3C, 0x00, 0x60, 0x00, 0x60, 0x01, 0x80, 0x01, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xFF, 0xC0, 0x01, 0xF0, 0x0F, 0x00, 0x1C, 0x00, 0x1C, 0x01, 0xC0,
  0x00, 0x70, 0x1C, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x06, 0x0E, 0x00, 0x00,
  0x38, 0x60, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x06, 0x10, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x03,
  0xC0, 0x3E, 0x00, 0xF0, 0x00, 0xF0, 0x1C, 0x00, 0x03, 0x81, 0xC0, 0x00,
  0x18, 0x38, 0x00, 0x01, 0xC1, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x0C,
  0x70, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x38, 0x1E, 0x00, 0x07, 0x00, 0xFC,
  0x03, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0D,
  0x80, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x39, 0x80, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x01, 0x81, 0x80, 0x00, 0x03, 0x81, 0x80, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x06, 0x01, 0x80, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x1C, 0x01,
  0x80, 0x00, 0x18, 0x01, 0x80, 0x00, 0x30, 0x01, 0x80, 0x00, 0x70, 0x01,
  0x80, 0x00, 0x60, 0x01, 0x80, 0x00, 0xC0, 0x01, 0x80, 0x01, 0xC0, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x01, 0x80, 0x07, 0x00, 0x01,
  0x80, 0x06, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x01,
  0x80, 0x18, 0x00, 0x01, 0x80, 0x30, 0x00, 0x01, 0x80, 0x70, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x01, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x0F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFC, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x3F, 0xE0, 0x03, 0x0F, 0xFF, 0x80, 0x33, 0xC0, 0x3E, 0x03, 0x70,
  0x00, 0x70, 0x3C, 0x00, 0x03, 0x83, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x60, 0x00,
  0x00, 0xCE, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x01, 0x83, 0x80, 0x00, 0x38,
  0x1E, 0x00, 0x0F, 0x00, 0xFC, 0x03, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x1F, 0xE0, 0x03, 0x0F, 0xFF, 0x80,
  0x31, 0xC0, 0x3E, 0x07, 0x70, 0x00, 0xF0, 0x64, 0x00, 0x03, 0x86, 0x80,
  0x00, 0x1C, 0x78, 0x00, 0x00, 0xCF, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00,
  0x6E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0x60, 0x00, 0x00, 0x76, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x67,
  0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x0C, 0x18, 0x00,
  0x01, 0xC0, 0xC0, 0x00, 0x38, 0x0F, 0x00, 0x0F, 0x00, 0x3C, 0x03, 0xE0,
  0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x1C, 0xC0,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3E, 0x01, 0xF0, 0x01, 0xE0, 0x00, 0xF0,
  0x0E, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x03, 0x81, 0x80, 0x00, 0x07, 0x0E,
  0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x03, 0x8C, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x38, 0xC0, 0x00,
  0x00, 0xC3, 0x80, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00,
  0x60, 0x30, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0xE0,
  0x01, 0xE0, 0x1F, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0xF8, 0x03, 0xC0, 0x07, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x03, 0x81, 0x80,
  0x00, 0x07, 0x0C, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x19, 0x80, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0x60, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x00, 0x67, 0x00, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x70, 0x70, 0x00, 0x03, 0x80, 0xF0,
  0x00, 0x3C, 0x00, 0xF8, 0x03, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xE0, 0x3E,
  0x00, 0x70, 0x00, 0x70, 0x0E, 0x00, 0x03, 0x81, 0x80, 0x00, 0x1C, 0x38,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x07, 0x60, 0x00, 0x00, 0x36, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x03, 0x60, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x77, 0x00, 0x00, 0x07,
  0x38, 0x00, 0x00, 0xB1, 0x80, 0x00, 0x1F, 0x1E, 0x00, 0x03, 0x70, 0xF0,
  0x00, 0x66, 0x07, 0xE0, 0x3C, 0x60, 0x1F, 0xFF, 0x0E, 0x00, 0x3F, 0xC0,
  0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x79, 0xFF, 0xDF, 0x78, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xE7, 0xFF, 0x7D, 0xE0, 0x1E, 0x1F, 0x3F, 0x1F, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x1E,
  0x1E, 0x1E, 0x1C, 0x1C, 0x3C, 0x38, 0x38, 0x38, 0x30, 0x70, 0x70, 0x60,
  0x60, 0x60, 0xC0, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x7C, 0x07, 0xC0, 0x38, 0x00, 0x38, 0x1C,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x19, 0x80, 0x00, 0x06,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0x80, 0xF0, 0x01,
  0xC0, 0x07, 0x00, 0x60, 0x00, 0x70, 0x1C, 0x00, 0x07, 0x03, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x0E, 0x18, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x03, 0x98, 0x00, 0x00, 0x33, 0x00, 0x00, 0x06, 0xC0, 0x03, 0xF0,
  0xD8, 0x01, 0xFF, 0x9B, 0x00, 0x78, 0x3B, 0x60, 0x1C, 0x01, 0x6C, 0x03,
  0x00, 0x1D, 0x80, 0xC0, 0x03, 0xB0, 0x18, 0x00, 0x36, 0x03, 0x00, 0x06,
  0xC0, 0xE0, 0x00, 0xD8, 0x18, 0x00, 0x1B, 0x03, 0x00, 0x03, 0xE0, 0x60,
  0x00, 0x7C, 0x0C, 0x00, 0x0F, 0x81, 0x80, 0x01, 0xF0, 0x30, 0x00, 0x36,
  0x06, 0x00, 0x06, 0xC0, 0xC0, 0x00, 0xD8, 0x18, 0x00, 0x1B, 0x01, 0x80,
  0x03, 0x60, 0x30, 0x00, 0x6C, 0x06, 0x00, 0x0D, 0x80, 0xE0, 0x03, 0xB0,
  0x0C, 0x00, 0xB6, 0x01, 0xE0, 0x36, 0xC0, 0x1F, 0xBC, 0xD8, 0x00, 0xFF,
  0x19, 0x80, 0x03, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x60,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x06, 0x30,
  0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x0C, 0x18,
  0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x18, 0x0C,
  0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x30, 0x06,
  0x00, 0x00, 0x70, 0x06, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x60, 0x03,
  0x00, 0x00, 0xE0, 0x03, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0xC0, 0x01,
  0x80, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x00,
  0xC0, 0x03, 0x80, 0x00, 0xC0, 0x03, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00,
  0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x06, 0x00, 0x00,
  0x70, 0x0E, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00,
  0x38, 0x1C, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00,
  0x1C, 0x38, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00,
  0x0E, 0x70, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0x03, 0x00, 0x00, 0xF0, 0x60, 0x00, 0x07, 0x0C, 0x00,
  0x00, 0x71, 0x80, 0x00, 0x06, 0x30, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x0C,
  0xC0, 0x00, 0x01, 0x98, 0x00, 0x00, 0x33, 0x00, 0x00, 0x06, 0x60, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x19, 0x80, 0x00, 0x03, 0x30, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x03, 0x98, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x1C, 0x60, 0x00, 0x07, 0x0C, 0x00, 0x03, 0xC1, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFE, 0x06, 0x00, 0x00, 0xF0, 0xC0, 0x00, 0x07, 0x18, 0x00, 0x00,
  0x33, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x0E,
  0xC0, 0x00, 0x01, 0x98, 0x00, 0x00, 0xF3, 0x00, 0x00, 0x7C, 0x7F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFF, 0xC0,
  0x01, 0xF0, 0x1F, 0x00, 0x38, 0x00, 0x38, 0x07, 0x00, 0x01, 0xC0, 0xE0,
  0x00, 0x0E, 0x1C, 0x00, 0x00, 0x61, 0x80, 0x00, 0x07, 0x38, 0x00, 0x00,
  0x33, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x33, 0x80, 0x00, 0x03, 0x18, 0x00, 0x00, 0x71, 0xC0, 0x00,
  0x06, 0x0E, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x1C, 0x03, 0x80, 0x03, 0x80,
  0x1F, 0x01, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFC, 0x03, 0x00, 0x07, 0xC0, 0x60, 0x00, 0x1E, 0x0C,
  0x00, 0x01, 0xC1, 0x80, 0x00, 0x1C, 0x30, 0x00, 0x01, 0xC6, 0x00, 0x00,
  0x18, 0xC0, 0x00, 0x03, 0x98, 0x00, 0x00, 0x33, 0x00, 0x00, 0x07, 0x60,
  0x00, 0x00, 0xEC, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x01, 0xB0, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0xD8, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x39, 0x80, 0x00, 0x06, 0x30, 0x00, 0x01, 0xC6, 0x00, 0x00,
  0x70, 0xC0, 0x00, 0x1C, 0x18, 0x00, 0x07, 0x83, 0x00, 0x07, 0xC0, 0x7F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7C, 0x07, 0xC0, 0x07,
  0x80, 0x07, 0x00, 0x70, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x70, 0x30, 0x00,
  0x01, 0x83, 0x80, 0x00, 0x0E, 0x18, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x01,
  0xCC, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x07, 0xFF, 0xD8, 0x00,
  0x3F, 0xFE, 0xC0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0x1B,
  0x80, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x73, 0x80,
  0x00, 0x03, 0x8C, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x01, 0xE1, 0x80, 0x00,
  0x0B, 0x0E, 0x00, 0x00, 0xD8, 0x38, 0x00, 0x0C, 0xC0, 0xF0, 0x00, 0xC6,
  0x03, 0xE0, 0x3C, 0x30, 0x07, 0xFF, 0xC1, 0x80, 0x0F, 0xF0, 0x00, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x06, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x0E, 0x70, 0x00,
  0x1C, 0x38, 0x00, 0x1C, 0x3C, 0x00, 0x78, 0x1F, 0x01, 0xF0, 0x07, 0xFF,
  0xC0, 0x01, 0xFF, 0x00, 0xC0, 0x00, 0x00, 0x76, 0x00, 0x00, 0x07, 0x30,
  0x00, 0x00, 0x71, 0x80, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x70, 0x60, 0x00,
  0x03, 0x03, 0x00, 0x00, 0x38, 0x18, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x38,
  0x06, 0x00, 0x03, 0x80, 0x30, 0x00, 0x38, 0x01, 0x80, 0x03, 0x80, 0x0C,
  0x00, 0x38, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x1C, 0x00, 0x18, 0x01,
  0xC0, 0x00, 0xC0, 0x1C, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x30, 0x1C, 0x00,
  0x01, 0x81, 0xE0, 0x00, 0x0C, 0x1F, 0x80, 0x00, 0x60, 0xDC, 0x00, 0x03,
  0x0C, 0x70, 0x00, 0x18, 0xE1, 0xC0, 0x00, 0xCE, 0x0E, 0x00, 0x06, 0xE0,
  0x38, 0x00, 0x3E, 0x00, 0xE0, 0x01, 0xE0, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x60, 0x00, 0x60, 0x03, 0x00, 0x03, 0x80, 0x18, 0x00, 0x0E, 0x00,
  0xC0, 0x00, 0x30, 0x06, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x07, 0x01, 0x80,
  0x00, 0x18, 0x0C, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x03, 0x83, 0x00, 0x00,
  0x0C, 0x18, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x0E,
  0x30, 0x00, 0x00, 0x39, 0x80, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x07, 0x80,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFD, 0x80, 0x00, 0x0F, 0xD8,
  0x00, 0x01, 0xFD, 0xC0, 0x00, 0x1B, 0xCC, 0x00, 0x03, 0xBC, 0xE0, 0x00,
  0x33, 0xC6, 0x00, 0x07, 0x3C, 0x70, 0x00, 0x63, 0xC3, 0x00, 0x06, 0x3C,
  0x30, 0x00, 0xC3, 0xC1, 0x80, 0x0C, 0x3C, 0x18, 0x01, 0xC3, 0xC1, 0xC0,
  0x18, 0x3C, 0x0C, 0x03, 0x83, 0xC0, 0xE0, 0x30, 0x3C, 0x06, 0x03, 0x03,
  0xC0, 0x60, 0x60, 0x3C, 0x03, 0x06, 0x03, 0xC0, 0x30, 0xC0, 0x3C, 0x03,
  0x8C, 0x03, 0xC0, 0x19, 0xC0, 0x3C, 0x01, 0xD8, 0x03, 0xC0, 0x0D, 0x80,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0x60, 0x03, 0xC0,
  0x02, 0x00, 0x3C, 0x00, 0x40, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x30, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0x60, 0x00, 0x03,
  0xDC, 0x00, 0x00, 0xF3, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x0F, 0x18, 0x00,
  0x03, 0xC7, 0x00, 0x00, 0xF0, 0xC0, 0x00, 0x3C, 0x38, 0x00, 0x0F, 0x06,
  0x00, 0x03, 0xC1, 0xC0, 0x00, 0xF0, 0x30, 0x00, 0x3C, 0x0C, 0x00, 0x0F,
  0x01, 0x80, 0x03, 0xC0, 0x60, 0x00, 0xF0, 0x0C, 0x00, 0x3C, 0x03, 0x00,
  0x0F, 0x00, 0xE0, 0x03, 0xC0, 0x18, 0x00, 0xF0, 0x07, 0x00, 0x3C, 0x00,
  0xC0, 0x0F, 0x00, 0x38, 0x03, 0xC0, 0x06, 0x00, 0xF0, 0x01, 0xC0, 0x3C,
  0x00, 0x30, 0x0F, 0x00, 0x0E, 0x03, 0xC0, 0x01, 0x80, 0xF0, 0x00, 0x70,
  0x3C, 0x00, 0x0C, 0x0F, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x60, 0xF0, 0x00,
  0x1C, 0x3C, 0x00, 0x03, 0x0F, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x18, 0xF0,
  0x00, 0x07, 0x3C, 0x00, 0x00, 0xCF, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x06,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1E, 0x01,
  0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x07, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x03,
  0x01, 0xC0, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x0E, 0x70,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x66, 0x00, 0x00, 0x01, 0x98, 0x00,
  0x00, 0x07, 0x60, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x60,
  0x00, 0x00, 0x1D, 0x80, 0x00, 0x00, 0x76, 0x00, 0x00, 0x01, 0xD8, 0x00,
  0x00, 0x07, 0x60, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x03, 0x8C, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x01,
  0xC1, 0x80, 0x00, 0x06, 0x07, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0xC0,
  0x1C, 0x00, 0x06, 0x00, 0x38, 0x00, 0x78, 0x00, 0x7C, 0x07, 0x80, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0x83, 0x00, 0x00, 0x78, 0x60, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x39,
  0x80, 0x00, 0x03, 0x30, 0x00, 0x00, 0x76, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x07, 0x60,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x39, 0x80, 0x00, 0x0E, 0x30, 0x00, 0x07,
  0x87, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1E,
  0x01, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x07, 0x00, 0x01, 0xC0, 0x38, 0x00,
  0x03, 0x01, 0xC0, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x0E,
  0x70, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x66, 0x00, 0x00, 0x01, 0x98,
  0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0x60, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x00, 0x76, 0x00, 0x00, 0x01, 0xD8,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x00, 0x67, 0x00,
  0x00, 0x03, 0x8C, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x30, 0xE0, 0x00,
  0x01, 0xC1, 0x80, 0x00, 0x06, 0x07, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00,
  0xC0, 0x1C, 0x00, 0x06, 0x00, 0x38, 0x00, 0x78, 0x00, 0x7C, 0x07, 0x80,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x83, 0x00, 0x00, 0x78,
  0x60, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x39, 0x80, 0x00, 0x03, 0x30, 0x00,
  0x00, 0x76, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xD8,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0x39, 0x80, 0x00, 0x0E, 0x30, 0x00, 0x07, 0x87, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xE0, 0x18, 0x01, 0x80, 0x03, 0x00, 0x38, 0x00, 0x60, 0x03, 0x80,
  0x0C, 0x00, 0x30, 0x01, 0x80, 0x07, 0x00, 0x30, 0x00, 0x70, 0x06, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0xE0, 0x18, 0x00, 0x0C, 0x03, 0x00, 0x01, 0xC0,
  0x60, 0x00, 0x1C, 0x0C, 0x00, 0x01, 0x81, 0x80, 0x00, 0x38, 0x30, 0x00,
  0x03, 0x86, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x07, 0x18, 0x00, 0x00, 0x73,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x0E, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xC0, 0x00,
  0x78, 0x1C, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0x04, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1D, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0x9C, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x03, 0x80,
  0xF0, 0x00, 0x1E, 0x01, 0xF8, 0x03, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x03,
  0x60, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x67, 0x00, 0x00, 0x18, 0xC0, 0x00,
  0x0E, 0x38, 0x00, 0x03, 0x06, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0xE0, 0x3E,
  0x00, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x60, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00,
  0x06, 0x30, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00,
  0x0C, 0x18, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00,
  0x18, 0x0C, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00,
  0x30, 0x06, 0x00, 0x00, 0x70, 0x06, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00,
  0x60, 0x07, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00,
  0xC0, 0x03, 0x80, 0x00, 0xC0, 0x01, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0x80, 0x01, 0xC0, 0x01, 0x80, 0x00, 0xC0, 0x03, 0x80, 0x00, 0xC0, 0x03,
  0x00, 0x00, 0xE0, 0x03, 0x00, 0x00, 0x60, 0x07, 0x00, 0x00, 0x60, 0x06,
  0x00, 0x00, 0x70, 0x06, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x30, 0x0C,
  0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x18, 0x18,
  0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x0C, 0x38,
  0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x06, 0x70,
  0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x60, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00,
  0x03, 0x60, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00,
  0x06, 0x60, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00,
  0x06, 0x60, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00,
  0x06, 0x30, 0x01, 0xC0, 0x06, 0x30, 0x03, 0xC0, 0x06, 0x30, 0x03, 0xC0,
  0x06, 0x30, 0x03, 0xE0, 0x0E, 0x30, 0x03, 0x60, 0x0C, 0x30, 0x06, 0x60,
  0x0C, 0x30, 0x06, 0x60, 0x0C, 0x30, 0x06, 0x30, 0x0C, 0x30, 0x06, 0x30,
  0x0C, 0x38, 0x0C, 0x30, 0x0C, 0x18, 0x0C, 0x30, 0x0C, 0x18, 0x0C, 0x18,
  0x0C, 0x18, 0x1C, 0x18, 0x0C, 0x18, 0x18, 0x18, 0x0C, 0x18, 0x18, 0x1C,
  0x1C, 0x18, 0x18, 0x0C, 0x18, 0x18, 0x30, 0x0C, 0x18, 0x18, 0x30, 0x0C,
  0x18, 0x18, 0x30, 0x06, 0x18, 0x18, 0x70, 0x06, 0x18, 0x1C, 0x60, 0x06,
  0x18, 0x0C, 0x60, 0x07, 0x18, 0x0C, 0x60, 0x03, 0x18, 0x0C, 0xE0, 0x03,
  0x18, 0x0C, 0xC0, 0x03, 0x18, 0x0C, 0xC0, 0x03, 0xB8, 0x0C, 0xC0, 0x01,
  0xB0, 0x0D, 0x80, 0x01, 0xB0, 0x0D, 0x80, 0x01, 0xB0, 0x0D, 0x80, 0x00,
  0xF0, 0x0F, 0x80, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00,
  0x07, 0x38, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0x01, 0x80, 0x70, 0x00, 0x01, 0x80, 0x18, 0x00,
  0x01, 0xC0, 0x0E, 0x00, 0x00, 0xC0, 0x03, 0x80, 0x00, 0xE0, 0x00, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x06,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x30, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00,
  0x70, 0x38, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00,
  0x03, 0x9C, 0x00, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0x60, 0x00, 0x00, 0x03, 0x38, 0x00, 0x00, 0x03, 0x8E, 0x00,
  0x00, 0x03, 0x83, 0x00, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x01, 0xC0, 0x70,
  0x00, 0x01, 0xC0, 0x18, 0x00, 0x00, 0xC0, 0x0E, 0x00, 0x00, 0xE0, 0x03,
  0x80, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x18, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x03, 0x80, 0x38, 0x00,
  0x00, 0xC0, 0x38, 0x00, 0x00, 0x70, 0x18, 0x00, 0x00, 0x1C, 0x1C, 0x00,
  0x00, 0x06, 0x1C, 0x00, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x00, 0x39,
  0xC0, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00,
  0x70, 0x38, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x03, 0x80, 0x70, 0x00,
  0x00, 0x60, 0x07, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x0E,
  0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x01, 0x80, 0x00, 0x18, 0x00, 0x70, 0x00, 0x03, 0x80, 0x0C,
  0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x18, 0x00, 0x00, 0x06, 0x07, 0x00, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00,
  0x0E, 0x30, 0x00, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x00, 0x1D, 0x80, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0x38, 0x00,
  0x00, 0x1C, 0x60, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x03, 0x83, 0x00, 0x00,
  0x0C, 0x0E, 0x00, 0x00, 0x60, 0x18, 0x00, 0x03, 0x80, 0x30, 0x00, 0x0C,
  0x00, 0xE0, 0x00, 0x70, 0x01, 0x80, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x70, 0x00, 0x18, 0x01, 0x80, 0x00, 0x70, 0x0E, 0x00, 0x00,
  0xC0, 0x30, 0x00, 0x03, 0x81, 0x80, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x0C,
  0x30, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x66, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x40, 0xE0, 0x60, 0x70, 0x38, 0x18, 0x0C, 0x0E, 0x06,
  0x03, 0x01, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xE0, 0x3E,
  0x00, 0x38, 0x00, 0x78, 0x03, 0x80, 0x00, 0xC0, 0x18, 0x00, 0x07, 0x01,
  0x80, 0x00, 0x18, 0x04, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xC0, 0x00, 0xC0, 0x70,
  0x00, 0x06, 0x07, 0x00, 0x00, 0x30, 0x70, 0x00, 0x01, 0x83, 0x80, 0x00,
  0x0C, 0x18, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x03, 0x06, 0x00, 0x00, 0x18,
  0x30, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x05, 0x81, 0xC0, 0x00, 0x6C, 0x07, 0x00, 0x06, 0x60, 0x1E, 0x01,
  0xE3, 0xF8, 0x7F, 0xFE, 0x0F, 0xC0, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x3F, 0xC0, 0x0C, 0x3F, 0xFE, 0x03, 0x1C, 0x07,
  0xC0, 0xCC, 0x00, 0x38, 0x36, 0x00, 0x07, 0x0F, 0x00, 0x00, 0xE3, 0x80,
  0x00, 0x18, 0xC0, 0x00, 0x07, 0x30, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x3B,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x1B, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x07, 0x38, 0x00,
  0x01, 0x8F, 0x00, 0x00, 0xE3, 0x60, 0x00, 0x70, 0xCC, 0x00, 0x38, 0x31,
  0xC0, 0x3C, 0x0C, 0x3F, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0xF8, 0x01, 0xF0, 0x1E, 0x01, 0xC0, 0x03, 0xC1, 0xC0, 0x00,
  0x60, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x02, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x33, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x18, 0x70, 0x00, 0x1C, 0x1C, 0x00,
  0x3C, 0x07, 0xC0, 0x78, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x1F, 0xE0, 0x30, 0x1F, 0xFE, 0x0C,
  0x1F, 0x01, 0xE3, 0x0F, 0x00, 0x1C, 0xC7, 0x00, 0x01, 0xB1, 0x80, 0x00,
  0x2C, 0xE0, 0x00, 0x0F, 0x70, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x76, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xD8,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x07, 0x70, 0x00, 0x01,
  0xCE, 0x00, 0x00, 0xF1, 0x80, 0x00, 0x2C, 0x70, 0x00, 0x1B, 0x0F, 0x00,
  0x1C, 0xC1, 0xF0, 0x1E, 0x30, 0x1F, 0xFE, 0x0C, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xE0, 0x3C, 0x00, 0x70, 0x00,
  0xE0, 0x0E, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x18, 0x18, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0x0C, 0x30, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x06, 0x70, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x76, 0x00, 0x00, 0x03,
  0x60, 0x00, 0x00, 0x36, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x63, 0x80, 0x00,
  0x06, 0x18, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x80,
  0x70, 0x00, 0x70, 0x03, 0xE0, 0x3E, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x3F, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x7F, 0x18, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1E, 0x03, 0xE0,
  0x00, 0x70, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x07, 0x00, 0x01, 0x80,
  0x0C, 0x00, 0x01, 0x80, 0x38, 0x00, 0x03, 0x00, 0x70, 0x00, 0x07, 0x00,
  0xC0, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x38, 0x06,
  0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x01, 0xC0, 0x18,
  0x00, 0x03, 0x00, 0x30, 0x00, 0x06, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x70, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0x03, 0x86, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x07,
  0x30, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x00, 0x1B,
  0x80, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x01, 0x86,
  0x00, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x3C, 0x0F, 0x80, 0x03, 0xE0, 0x07,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x1F, 0xE0, 0x30,
  0xFF, 0xF0, 0x63, 0x80, 0xF8, 0xCC, 0x00, 0x79, 0xA0, 0x00, 0x33, 0x80,
  0x00, 0x77, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x31, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x80, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xCE,
  0x00, 0x00, 0x38, 0xE0, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xC0, 0xE0, 0x00,
  0x38, 0x0E, 0x00, 0x07, 0x00, 0xE0, 0x00, 0xE0, 0x0E, 0x00, 0x1C, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x00, 0xE0, 0x1E, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0xE1, 0xF8, 0x00,
  0x0E, 0x39, 0xC0, 0x00, 0xE7, 0x0E, 0x00, 0x0E, 0xC0, 0x70, 0x00, 0xF8,
  0x07, 0x00, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x0E, 0x00, 0x0E,
  0x00, 0xE0, 0x00, 0x70, 0x0E, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x38, 0x0E,
  0x00, 0x01, 0xC0, 0xE0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x70, 0xE0, 0x00,
  0x03, 0x0E, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x0E,
  0xE0, 0x00, 0x00, 0x70, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xF0, 0x0F, 0xC3, 0x9F,
  0xF0, 0x7F, 0xCE, 0xC1, 0xE3, 0x07, 0xBE, 0x01, 0x98, 0x0E, 0xF0, 0x07,
  0x40, 0x1B, 0x80, 0x0E, 0x00, 0x7E, 0x00, 0x38, 0x00, 0xF8, 0x00, 0xC0,
  0x03, 0xE0, 0x03, 0x00, 0x0F, 0x80, 0x0C, 0x00, 0x3E, 0x00, 0x30, 0x00,
  0xF8, 0x00, 0xC0, 0x03, 0xE0, 0x03, 0x00, 0x0F, 0x80, 0x0C, 0x00, 0x3E,
  0x00, 0x30, 0x00, 0xF8, 0x00, 0xC0, 0x03, 0xE0, 0x03, 0x00, 0x0F, 0x80,
  0x0C, 0x00, 0x3E, 0x00, 0x30, 0x00, 0xF8, 0x00, 0xC0, 0x03, 0xE0, 0x03,
  0x00, 0x0F, 0x80, 0x0C, 0x00, 0x3E, 0x00, 0x30, 0x00, 0xF8, 0x00, 0xC0,
  0x03, 0xE0, 0x03, 0x00, 0x0F, 0x80, 0x0C, 0x00, 0x3E, 0x00, 0x30, 0x00,
  0xF8, 0x00, 0xC0, 0x03, 0xE0, 0x03, 0x00, 0x0F, 0x80, 0x0C, 0x00, 0x3E,
  0x00, 0x30, 0x00, 0xF8, 0x00, 0xC0, 0x03, 0xE0, 0x03, 0x00, 0x0F, 0x80,
  0x0C, 0x00, 0x30, 0x00, 0xFF, 0x01, 0x87, 0xFF, 0x83, 0x1C, 0x07, 0xC6,
  0x60, 0x03, 0xCD, 0x00, 0x01, 0x9C, 0x00, 0x03, 0xB8, 0x00, 0x03, 0x60,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0C, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFF, 0x80,
  0x03, 0xC0, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x0E, 0x00, 0x07, 0x01, 0xC0,
  0x00, 0x38, 0x18, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x66, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0x76, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x07, 0x60, 0x00,
  0x00, 0x76, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x67, 0x00, 0x00, 0x06,
  0x30, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x0C, 0x18, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x38, 0x0E, 0x00, 0x03, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xE0, 0x3C,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x30,
  0xFF, 0xF8, 0x0C, 0x70, 0x1F, 0x03, 0x30, 0x00, 0xE0, 0xD8, 0x00, 0x1C,
  0x3C, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x63, 0x00, 0x00, 0x1C, 0xC0, 0x00,
  0x03, 0x30, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x06, 0xC0,
  0x00, 0x01, 0xB0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x1B, 0x00,
  0x00, 0x06, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x33,
  0x00, 0x00, 0x1C, 0xE0, 0x00, 0x06, 0x3C, 0x00, 0x03, 0x8D, 0x80, 0x01,
  0xC3, 0x30, 0x00, 0xE0, 0xC7, 0x00, 0xF0, 0x30, 0xFF, 0xF8, 0x0C, 0x0F,
  0xF0, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xF8, 0x30,
  0x7C, 0x07, 0x8C, 0x3C, 0x00, 0x73, 0x1C, 0x00, 0x06, 0xC6, 0x00, 0x00,
  0xB3, 0x80, 0x00, 0x3D, 0xC0, 0x00, 0x07, 0x60, 0x00, 0x01, 0xD8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0x60,
  0x00, 0x00, 0xD8, 0x00, 0x00, 0x36, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x07,
  0x38, 0x00, 0x03, 0xC6, 0x00, 0x00, 0xB1, 0xC0, 0x00, 0x6C, 0x3C, 0x00,
  0x73, 0x07, 0xC0, 0x78, 0xC0, 0x7F, 0xF8, 0x30, 0x07, 0xF8, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFC, 0x00, 0x63,
  0xC0, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x01, 0x90, 0x00, 0x00, 0x03, 0x40,
  0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xC0, 0x3F, 0x00, 0xE0, 0x00, 0x78,
  0x1C, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x43, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x34, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x06, 0x3C, 0x00, 0x00, 0xE0, 0xF0,
  0x00, 0x3C, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0x80, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0x60, 0x00, 0x07, 0x60, 0x00, 0x07, 0x70, 0x00, 0x0F, 0x38,
  0x00, 0x17, 0x1C, 0x00, 0x37, 0x0F, 0x01, 0xE7, 0x07, 0xFF, 0xC7, 0x01,
  0xFE, 0x00, 0xE0, 0x00, 0x00, 0x76, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x0C, 0x18,
  0x00, 0x01, 0x81, 0xC0, 0x00, 0x18, 0x0C, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x30, 0x0E, 0x00, 0x03, 0x00, 0x60, 0x00, 0x70, 0x06, 0x00, 0x06, 0x00,
  0x30, 0x00, 0x60, 0x03, 0x00, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x01, 0x80,
  0x0C, 0x00, 0x18, 0x01, 0x80, 0x01, 0xC0, 0x18, 0x00, 0x0C, 0x03, 0x80,
  0x00, 0xC0, 0x30, 0x00, 0x06, 0x03, 0x00, 0x00, 0x60, 0x70, 0x00, 0x06,
  0x06, 0x00, 0x00, 0x30, 0x60, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x38, 0xC0,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0x19, 0x80, 0x00, 0x01, 0xD8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00,
  0xE0, 0x00, 0xD8, 0x00, 0x78, 0x00, 0x36, 0x00, 0x1E, 0x00, 0x0D, 0x80,
  0x06, 0xC0, 0x06, 0x60, 0x01, 0xB0, 0x01, 0x98, 0x00, 0xCC, 0x00, 0x67,
  0x00, 0x33, 0x00, 0x18, 0xC0, 0x0C, 0x60, 0x06, 0x30, 0x03, 0x18, 0x01,
  0x8C, 0x01, 0x86, 0x00, 0xC3, 0x00, 0x61, 0x80, 0x30, 0xC0, 0x18, 0x30,
  0x0C, 0x18, 0x06, 0x0C, 0x03, 0x06, 0x03, 0x03, 0x00, 0xC1, 0x80, 0xC0,
  0xC0, 0x20, 0x60, 0x30, 0x18, 0x18, 0x18, 0x0C, 0x06, 0x06, 0x06, 0x06,
  0x01, 0x81, 0x80, 0xC1, 0x80, 0x60, 0x60, 0x30, 0x60, 0x0C, 0x18, 0x0C,
  0x18, 0x03, 0x0C, 0x03, 0x0C, 0x00, 0xC3, 0x00, 0xC3, 0x00, 0x30, 0xC0,
  0x18, 0xC0, 0x06, 0x30, 0x06, 0x30, 0x01, 0x8C, 0x01, 0x98, 0x00, 0x63,
  0x00, 0x66, 0x00, 0x19, 0x80, 0x19, 0x80, 0x02, 0x60, 0x06, 0x60, 0x00,
  0xD8, 0x00, 0xF0, 0x00, 0x36, 0x00, 0x3C, 0x00, 0x0D, 0x80, 0x0F, 0x00,
  0x01, 0xC0, 0x03, 0xC0, 0x00, 0x70, 0x00, 0xF0, 0x00, 0x00, 0x73, 0x00,
  0x00, 0x0E, 0x38, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x18, 0x0E, 0x00, 0x03,
  0x80, 0x60, 0x00, 0x70, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x01,
  0xC0, 0x18, 0x00, 0x0C, 0x03, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x07, 0x06,
  0x00, 0x00, 0x38, 0xC0, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1D,
  0x80, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x06, 0x06, 0x00,
  0x00, 0xE0, 0x30, 0x00, 0x1C, 0x03, 0x80, 0x01, 0x80, 0x1C, 0x00, 0x38,
  0x00, 0xE0, 0x07, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x70, 0x0C, 0x00, 0x03,
  0x81, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x0E, 0xE0,
  0x00, 0x00, 0x70, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0x98, 0x00,
  0x00, 0x1C, 0xE0, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x0E, 0x18, 0x00, 0x00,
  0x60, 0x60, 0x00, 0x03, 0x03, 0x00, 0x00, 0x30, 0x1C, 0x00, 0x01, 0x80,
  0x60, 0x00, 0x1C, 0x03, 0x80, 0x00, 0xC0, 0x0C, 0x00, 0x06, 0x00, 0x60,
  0x00, 0x60, 0x03, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x01,
  0x80, 0x01, 0x80, 0x1C, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x70, 0x06, 0x00,
  0x01, 0x80, 0x70, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x30, 0x38, 0x00, 0x01,
  0x81, 0x80, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x01, 0xC6,
  0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x3C, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x3E, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x06, 0x1F, 0xE0, 0x00,
  0x0C, 0x70, 0xE0, 0x00, 0x31, 0xC0, 0xE0, 0x00, 0x63, 0x00, 0xE0, 0x00,
  0xCC, 0x00, 0xE0, 0x03, 0x98, 0x00, 0xE0, 0x06, 0x30, 0x00, 0xE0, 0x1C,
  0xC0, 0x00, 0xE0, 0x31, 0x80, 0x00, 0xF1, 0xC3, 0x00, 0x00, 0xFF, 0x06,
  0x00, 0x00, 0x7C, 0x00,
};

const GFXglyph IBMPlexMono_ExtraLight64pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 38, 0, -1 },
  { 1, 6, 45, 38, 16, -45 },
  { 35, 11, 16, 38, 14, -47 },
  { 57, 36, 45, 38, 1, -45 },
  { 260, 30, 58, 38, 4, -51 },
  { 478, 35, 46, 38, 2, -45 },
  { 680, 33, 46, 38, 2, -45 },
  { 870, 2, 16, 38, 18, -47 },
  { 874, 15, 58, 38, 15, -49 },
  { 983, 16, 58, 38, 8, -49 },
  { 1099, 32, 32, 38, 3, -35 },
  { 1227, 30, 32, 38, 4, -36 },
  { 1347, 8, 17, 38, 14, -6 },
  { 1364, 17, 2, 38, 11, -20 },
  { 1369, 6, 5, 38, 16, -5 },
  { 1373, 26, 58, 38, 6, -49 },
  { 1562, 30, 46, 38, 4, -45 },
  { 1735, 30, 45, 38, 5, -45 },
  { 1904, 29, 45, 38, 5, -45 },
  { 2068, 28, 46, 38, 4, -45 },
  { 2229, 32, 45, 38, 3, -45 },
  { 2409, 28, 46, 38, 5, -45 },
  { 2570, 28, 46, 38, 5, -45 },
  { 2731, 28, 45, 38, 5, -45 },
  { 2889, 30, 46, 38, 4, -45 },
  { 3062, 28, 45, 38, 5, -45 },
  { 3220, 6, 34, 38, 16, -34 },
  { 3246, 8, 45, 38, 14, -34 },
  { 3291, 28, 35, 38, 5, -37 },
  { 3414, 30, 13, 38, 4, -26 },
  { 3463, 28, 35, 38, 5, -37 },
  { 3586, 26, 45, 38, 6, -45 },
  { 3733, 27, 52, 38, 5, -45 },
  { 3909, 32, 45, 38, 3, -45 },
  { 4089, 27, 45, 38, 6, -45 },
  { 4241, 28, 46, 38, 5, -45 },
  { 4402, 27, 45, 38, 7, -45 },
  { 4554, 26, 45, 38, 7, -45 },
  { 4701, 26, 45, 38, 7, -45 },
  { 4848, 29, 46, 38, 4, -45 },
  { 5015, 26, 45, 38, 6, -45 },
  { 5162, 27, 45, 38, 6, -45 },
  { 5314, 24, 46, 38, 6, -45 },
  { 5452, 29, 45, 38, 7, -45 },
  { 5616, 25, 45, 38, 9, -45 },
  { 5757, 28, 45, 38, 5, -45 },
  { 5915, 26, 45, 38, 6, -45 },
  { 6062, 30, 46, 38, 4, -45 },
  { 6235, 27, 45, 38, 7, -45 },
  { 6387, 30, 54, 38, 4, -45 },
  { 6590, 27, 45, 38, 7, -45 },
  { 6742, 30, 46, 38, 4, -45 },
  { 6915, 34, 45, 38, 2, -45 },
  { 7107, 26, 46, 38, 6, -45 },
  { 7257, 32, 45, 38, 3, -45 },
  { 7437, 32, 45, 38, 3, -45 },
  { 7617, 33, 45, 38, 3, -45 },
  { 7803, 35, 45, 38, 2, -45 },
  { 8000, 32, 45, 38, 3, -45 },
  { 8180, 16, 58, 38, 16, -49 },
  { 8296, 26, 58, 38, 6, -49 },
  { 8485, 16, 58, 38, 6, -49 },
  { 8601, 30, 25, 38, 4, -45 },
  { 8695, 31, 2, 38, 4, 7 },
  { 8703, 8, 11, 38, 13, -49 },
  { 8714, 29, 35, 38, 5, -34 },
  { 8841, 26, 48, 38, 8, -47 },
  { 8997, 25, 35, 38, 7, -34 },
  { 9107, 26, 48, 38, 5, -47 },
  { 9263, 28, 35, 38, 5, -34 },
  { 9386, 29, 47, 38, 5, -47 },
  { 9557, 31, 50, 38, 5, -36 },
  { 9751, 23, 47, 38, 8, -47 },
  { 9887, 27, 47, 38, 7, -47 },
  { 10046, 23, 60, 38, 6, -47 },
  { 10219, 28, 47, 38, 8, -47 },
  { 10384, 27, 47, 38, 6, -47 },
  { 10543, 30, 34, 38, 4, -34 },
  { 10671, 23, 34, 38, 8, -34 },
  { 10769, 28, 35, 38, 5, -34 },
  { 10892, 26, 47, 38, 8, -34 },
  { 11045, 26, 47, 38, 5, -34 },
  { 11198, 31, 33, 38, 5, -33 },
  { 11326, 28, 35, 38, 5, -34 },
  { 11449, 31, 45, 38, 2, -45 },
  { 11624, 24, 34, 38, 7, -33 },
  { 11726, 28, 33, 38, 5, -33 },
  { 11842, 34, 33, 38, 2, -33 },
  { 11983, 28, 33, 38, 5, -33 },
  { 12099, 29, 46, 38, 5, -33 },
  { 12266, 26, 33, 38, 6, -33 },
  { 12374, 24, 58, 38, 7, -49 },
  { 12548, 2, 58, 38, 18, -49 },
  { 12563, 24, 58, 38, 7, -49 },
  { 12737, 31, 12, 38, 4, -25 },
};

const GFXfont IBMPlexMono_ExtraLight64pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLight64pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLight64pt7bGlyphs,
  0x20, 0x7E, 83
};

#endif // _IBMPLEXMONO_EXTRALIGHT64PT7B_H_
