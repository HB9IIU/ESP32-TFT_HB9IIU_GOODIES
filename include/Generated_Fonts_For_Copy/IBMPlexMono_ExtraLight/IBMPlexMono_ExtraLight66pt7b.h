#ifndef _IBMPLEXMONO_EXTRALIGHT66PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHT66PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLight.ttf
// Size: 66pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLight66pt7bBitmaps[] PROGMEM = {
  0x00, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC2,
  0x08, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xEF, 0xFF, 0xFD, 0xE0,
  0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07,
  0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07,
  0xC0, 0x70, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x06, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x06, 0x00, 0x00, 0x03, 0x80, 0x30, 0x00, 0x00, 0x18, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x00,
  0x30, 0x07, 0x00, 0x00, 0x03, 0x80, 0x30, 0x00, 0x00, 0x18, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x30, 0x00, 0x00, 0x1C, 0x01, 0x80, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x30, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x38, 0x00, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x00,
  0xE0, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0x30, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x38, 0x00, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x18, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF3, 0xFF, 0xE0, 0x0F,
  0xFF, 0x80, 0x07, 0x00, 0x60, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x18, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x60, 0x00, 0x00, 0x38, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00,
  0x03, 0x00, 0x70, 0x00, 0x00, 0x38, 0x03, 0x00, 0x00, 0x01, 0x80, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xC3,
  0x0F, 0x80, 0x1C, 0x06, 0x03, 0xC0, 0x70, 0x0C, 0x03, 0xC1, 0xC0, 0x18,
  0x01, 0xC7, 0x00, 0x30, 0x01, 0xCC, 0x00, 0x60, 0x02, 0x18, 0x00, 0xC0,
  0x00, 0x70, 0x01, 0x80, 0x00, 0xE0, 0x03, 0x00, 0x01, 0xC0, 0x06, 0x00,
  0x03, 0x80, 0x0C, 0x00, 0x07, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x60, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x38, 0x01, 0x80, 0x00,
  0x38, 0x03, 0x00, 0x00, 0x38, 0x06, 0x00, 0x00, 0x3C, 0x0C, 0x00, 0x00,
  0x3F, 0x18, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0x87, 0xC0, 0x00, 0x03, 0x01, 0xE0, 0x00,
  0x06, 0x01, 0xE0, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x18, 0x01, 0xC0, 0x00,
  0x30, 0x01, 0x80, 0x00, 0x60, 0x03, 0x80, 0x00, 0xC0, 0x03, 0x00, 0x01,
  0x80, 0x06, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x60, 0x00, 0x30, 0x01, 0xD0, 0x00, 0x60,
  0x03, 0xF0, 0x00, 0xC0, 0x06, 0x70, 0x01, 0x80, 0x1C, 0x70, 0x03, 0x00,
  0x70, 0x78, 0x06, 0x01, 0xC0, 0x78, 0x0C, 0x07, 0x00, 0x7E, 0x18, 0x7C,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0x1E, 0x0F, 0x00,
  0x00, 0x63, 0x80, 0x38, 0x00, 0x0C, 0x70, 0x01, 0x80, 0x00, 0xC6, 0x00,
  0x1C, 0x00, 0x18, 0x60, 0x00, 0xC0, 0x03, 0x8C, 0x00, 0x0C, 0x00, 0x30,
  0xC0, 0x00, 0xC0, 0x07, 0x0C, 0x00, 0x0E, 0x00, 0x60, 0xC0, 0x00, 0xE0,
  0x0C, 0x0C, 0x00, 0x0E, 0x00, 0xC0, 0xC0, 0x00, 0xE0, 0x18, 0x0C, 0x00,
  0x0E, 0x03, 0x80, 0xC0, 0x00, 0xC0, 0x30, 0x06, 0x00, 0x0C, 0x06, 0x00,
  0x60, 0x01, 0xC0, 0x60, 0x07, 0x00, 0x18, 0x0C, 0x00, 0x38, 0x03, 0x80,
  0xC0, 0x01, 0xE0, 0xF0, 0x18, 0x00, 0x0F, 0xFE, 0x03, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0x80, 0x7F, 0xF0, 0x00, 0x38, 0x0F, 0x07, 0x80, 0x03,
  0x01, 0xC0, 0x1C, 0x00, 0x60, 0x38, 0x00, 0xC0, 0x06, 0x03, 0x00, 0x0E,
  0x00, 0xC0, 0x70, 0x00, 0x60, 0x0C, 0x06, 0x00, 0x06, 0x01, 0x80, 0x60,
  0x00, 0x60, 0x38, 0x06, 0x00, 0x06, 0x03, 0x00, 0x60, 0x00, 0x70, 0x60,
  0x06, 0x00, 0x07, 0x06, 0x00, 0x60, 0x00, 0x70, 0xC0, 0x06, 0x00, 0x06,
  0x1C, 0x00, 0x60, 0x00, 0x61, 0x80, 0x07, 0x00, 0x06, 0x38, 0x00, 0x30,
  0x00, 0xE3, 0x00, 0x03, 0x80, 0x0C, 0x60, 0x00, 0x1C, 0x01, 0xC6, 0x00,
  0x00, 0xF0, 0x78, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x78, 0x0F, 0x00,
  0x00, 0x70, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0x70, 0x00, 0x7F, 0x0E, 0x1C, 0x00, 0x3F, 0x8E, 0x07, 0x00, 0x18, 0x0E,
  0x01, 0xC0, 0x0C, 0x06, 0x00, 0x60, 0x06, 0x07, 0x00, 0x38, 0x07, 0x03,
  0x00, 0x0E, 0x03, 0x83, 0x80, 0x03, 0x81, 0x81, 0x80, 0x00, 0xE0, 0xC0,
  0xC0, 0x00, 0x38, 0x60, 0x60, 0x00, 0x0C, 0x30, 0x30, 0x00, 0x03, 0x18,
  0x18, 0x00, 0x01, 0xCC, 0x0C, 0x00, 0x00, 0x7C, 0x06, 0x00, 0x00, 0x1E,
  0x03, 0x00, 0x00, 0x07, 0x01, 0x80, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x03,
  0x70, 0x30, 0x00, 0x01, 0x18, 0x1C, 0x00, 0x01, 0x86, 0x07, 0x00, 0x01,
  0x83, 0x81, 0xE0, 0x03, 0x80, 0xE0, 0x7C, 0x07, 0x80, 0x38, 0x1F, 0xFF,
  0x00, 0x0E, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xE0, 0x01,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C,
  0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06,
  0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0xF0, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x70, 0x00,
  0x60, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x03, 0x00, 0x02, 0xF8, 0x00,
  0xC0, 0x07, 0x9F, 0xC0, 0x30, 0x0F, 0xF0, 0xFE, 0x0C, 0x1F, 0xC0, 0x07,
  0xF3, 0x3F, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0x30, 0x00,
  0x00, 0x03, 0x8E, 0x00, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x00, 0x70, 0x38,
  0x00, 0x00, 0x38, 0x06, 0x00, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x06, 0x00, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x1E, 0x3C, 0x78, 0xE3, 0xC7, 0x8E, 0x1C, 0x38, 0xE1, 0xC3, 0x86, 0x1C,
  0x38, 0x60, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7B, 0xFF, 0xFF, 0x78,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xC0, 0x7C, 0x00,
  0x1E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x1C, 0x03,
  0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x38, 0x70,
  0x00, 0x00, 0x30, 0xE0, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0xE3, 0x00,
  0x00, 0x00, 0xCE, 0x00, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x03, 0x30, 0x00,
  0x00, 0x07, 0x60, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x1D, 0x80, 0x00,
  0x00, 0x3B, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x70,
  0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0,
  0x07, 0xC0, 0x07, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x03,
  0xB0, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x19,
  0xC0, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x63, 0x00, 0x00, 0x01, 0xC7,
  0x00, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x1C, 0x1C,
  0x00, 0x00, 0x30, 0x1C, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x03, 0x80, 0x38,
  0x00, 0x0E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x07, 0x1C,
  0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x03, 0xC0, 0xE0,
  0x00, 0x0F, 0x01, 0xC0, 0x00, 0x3C, 0x03, 0x80, 0x00, 0xF0, 0x07, 0x00,
  0x03, 0x80, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x08, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x7C, 0x03, 0xE0, 0x03, 0xC0, 0x01, 0xC0, 0x1E, 0x00, 0x03, 0x80,
  0x60, 0x00, 0x07, 0x03, 0x80, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x38, 0x70,
  0x00, 0x00, 0xE1, 0x80, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xF8, 0x0F,
  0xC0, 0x0E, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0xE0,
  0xE0, 0x00, 0x03, 0x86, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x77, 0x80, 0x00, 0x07, 0x1E, 0x00,
  0x00, 0x38, 0x78, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x78, 0x03, 0xE0, 0x0F,
  0x80, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x3B,
  0x00, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x03,
  0x8C, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00,
  0x38, 0x30, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00,
  0x03, 0x80, 0xC0, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x60, 0x0C, 0x00,
  0x00, 0x38, 0x03, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x30,
  0x00, 0x03, 0x80, 0x0C, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x60, 0x00,
  0xC0, 0x00, 0x38, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x38, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x06,
  0x00, 0x00, 0x30, 0x03, 0x80, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x03, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x30, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x3F, 0xE0,
  0x01, 0x8F, 0xFF, 0xC0, 0x1C, 0xF0, 0x0F, 0x80, 0xCC, 0x00, 0x1E, 0x06,
  0xC0, 0x00, 0x38, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xCC, 0x00, 0x00,
  0x0C, 0xF0, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x06, 0x0F, 0x00, 0x00, 0x70,
  0x3C, 0x00, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x07, 0xF8, 0x00,
  0x60, 0xFF, 0xF8, 0x03, 0x1E, 0x03, 0xF0, 0x19, 0x80, 0x03, 0xC1, 0xD8,
  0x00, 0x07, 0x0D, 0x80, 0x00, 0x1C, 0x78, 0x00, 0x00, 0xE3, 0x80, 0x00,
  0x03, 0x9C, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x0E, 0xC0, 0x00,
  0x00, 0x76, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0x0E, 0x18, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x06, 0x03,
  0x80, 0x00, 0x70, 0x0E, 0x00, 0x0F, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0x60, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x1C, 0xC0,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x07, 0xC0, 0x3E, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x0E,
  0x01, 0xC0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x1C,
  0x38, 0x00, 0x00, 0x18, 0x70, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x00, 0x71,
  0xC0, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x03, 0x0E,
  0x00, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x38, 0x38,
  0x00, 0x00, 0x60, 0x38, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x07, 0x00, 0x38,
  0x00, 0x3C, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x01, 0xE0, 0x0F, 0x80, 0x0E, 0x00, 0x03, 0xC0, 0x38, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x01, 0x86, 0x00, 0x00,
  0x03, 0x9C, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00,
  0x0E, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x03,
  0xB8, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x38,
  0x70, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x03, 0x80, 0x78, 0x00, 0x1E, 0x00,
  0x7C, 0x01, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xC0, 0x3E, 0x00, 0xF0, 0x00,
  0xF0, 0x1C, 0x00, 0x03, 0x83, 0x80, 0x00, 0x1C, 0x30, 0x00, 0x00, 0xC7,
  0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x06, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00,
  0x77, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0xB3, 0x80, 0x00, 0x1F, 0x1C,
  0x00, 0x03, 0x60, 0xF0, 0x00, 0xE6, 0x07, 0xC0, 0x3C, 0x60, 0x1F, 0xFF,
  0x0E, 0x00, 0x7F, 0xC0, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7B, 0xFF, 0xFF, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xBF, 0xFF, 0xF7, 0x80, 0x1E,
  0x3F, 0x3F, 0x3F, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1E, 0x1E, 0x1E, 0x1C, 0x3C, 0x3C, 0x38, 0x38,
  0x38, 0x70, 0x70, 0x70, 0x60, 0xE0, 0xE0, 0xC0, 0xC0, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xFF, 0x00,
  0x1F, 0x00, 0xF8, 0x07, 0x80, 0x07, 0x81, 0xC0, 0x00, 0x38, 0x70, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x73, 0x80, 0x00, 0x06, 0x60, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1C, 0x80, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xFE, 0x00, 0x0F, 0x81, 0xF0, 0x03, 0x80, 0x07, 0x00, 0xE0, 0x00,
  0x70, 0x38, 0x00, 0x07, 0x06, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x0E, 0x30,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x00,
  0x76, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0xD8, 0x00, 0x7E, 0x1E, 0x00,
  0x3F, 0xE3, 0xC0, 0x0E, 0x06, 0x78, 0x03, 0x80, 0x2F, 0x00, 0xE0, 0x03,
  0xE0, 0x18, 0x00, 0x7C, 0x07, 0x00, 0x07, 0x80, 0xC0, 0x00, 0xF0, 0x18,
  0x00, 0x1E, 0x03, 0x00, 0x03, 0xC0, 0x60, 0x00, 0x78, 0x0C, 0x00, 0x0F,
  0x01, 0x80, 0x01, 0xE0, 0x30, 0x00, 0x3C, 0x06, 0x00, 0x07, 0x80, 0xC0,
  0x00, 0xF0, 0x18, 0x00, 0x1E, 0x03, 0x00, 0x03, 0xC0, 0x60, 0x00, 0x78,
  0x0C, 0x00, 0x0F, 0x01, 0xC0, 0x01, 0xE0, 0x18, 0x00, 0x7C, 0x03, 0x00,
  0x0F, 0x80, 0x70, 0x02, 0xF0, 0x07, 0x00, 0xDF, 0x00, 0x7C, 0xF3, 0x60,
  0x07, 0xFC, 0x6C, 0x00, 0x08, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x0D, 0xC0, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x01, 0xCC, 0x00,
  0x00, 0x00, 0x63, 0x80, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x0E, 0x18,
  0x00, 0x00, 0x03, 0x07, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x70,
  0x30, 0x00, 0x00, 0x18, 0x0E, 0x00, 0x00, 0x06, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x60, 0x00, 0x00, 0xC0, 0x1C, 0x00, 0x00, 0x30, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x30, 0x00, 0x01, 0x80, 0x0E, 0x00,
  0x00, 0xE0, 0x01, 0x80, 0x00, 0x38, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x38, 0x00, 0x18, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x03, 0x00,
  0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x18,
  0x00, 0x00, 0xE0, 0x06, 0x00, 0x00, 0x18, 0x03, 0x80, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x00, 0x30, 0x1C, 0x00, 0x00, 0x0C,
  0x06, 0x00, 0x00, 0x03, 0x81, 0x80, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x00,
  0x18, 0x30, 0x00, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x00, 0xC7, 0x00, 0x00,
  0x00, 0x31, 0x80, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x01, 0xB8, 0x00,
  0x00, 0x00, 0x70, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0xE0, 0x00,
  0x3E, 0x0E, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x38,
  0xE0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0xCE, 0x00,
  0x00, 0x0C, 0xE0, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00,
  0xCE, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x0C, 0xE0,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x03, 0x8E, 0x00, 0x00,
  0x30, 0xE0, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0xC0, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xC0, 0xE0, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x38, 0xE0, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x06, 0xE0,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x03, 0xCE, 0x00, 0x00,
  0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x07,
  0x80, 0x00, 0xE0, 0x38, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x07, 0x07, 0x00,
  0x00, 0x0E, 0x18, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x00, 0x73, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x86, 0x00,
  0x00, 0x07, 0x1C, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0xC0, 0xE0, 0x00,
  0x07, 0x01, 0xC0, 0x00, 0x38, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x3E,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFE, 0x00, 0xC0, 0x00, 0xF8, 0x0C, 0x00, 0x01, 0xC0, 0xC0, 0x00,
  0x0E, 0x0C, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x0E, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0xEC, 0x00,
  0x00, 0x0C, 0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x07, 0x0C, 0x00, 0x00, 0xE0, 0xC0,
  0x00, 0x1C, 0x0C, 0x00, 0x0F, 0x80, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7C, 0x07, 0xC0,
  0x07, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x31, 0x80, 0x00,
  0x01, 0xDC, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x37,
  0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x07, 0x18, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x02, 0xC3, 0x80, 0x00,
  0x36, 0x0E, 0x00, 0x03, 0x30, 0x38, 0x00, 0x71, 0x80, 0xF8, 0x0F, 0x0C,
  0x03, 0xFF, 0xF0, 0x60, 0x03, 0xFC, 0x00, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1B, 0x80,
  0x00, 0x0D, 0xC0, 0x00, 0x0E, 0x60, 0x00, 0x06, 0x38, 0x00, 0x07, 0x0E,
  0x00, 0x07, 0x03, 0x80, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0x3F, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0xC0, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x01, 0xCC, 0x00,
  0x00, 0x0E, 0x30, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x03, 0x83, 0x00, 0x00,
  0x0E, 0x0C, 0x00, 0x00, 0x70, 0x30, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x1C,
  0x03, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x07, 0x00, 0x30, 0x00, 0x38, 0x00,
  0xC0, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x30,
  0x01, 0xC0, 0x00, 0xC0, 0x0E, 0x00, 0x03, 0x00, 0x70, 0x00, 0x0C, 0x03,
  0x80, 0x00, 0x30, 0x1C, 0x00, 0x00, 0xC0, 0xF8, 0x00, 0x03, 0x07, 0x70,
  0x00, 0x0C, 0x19, 0xC0, 0x00, 0x30, 0xC3, 0x80, 0x00, 0xC7, 0x07, 0x00,
  0x03, 0x38, 0x1C, 0x00, 0x0D, 0xC0, 0x38, 0x00, 0x3E, 0x00, 0x70, 0x00,
  0xF0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x0C, 0x00, 0x06, 0x00, 0x30,
  0x00, 0x1C, 0x00, 0xC0, 0x00, 0x38, 0x03, 0x00, 0x00, 0x60, 0x0C, 0x00,
  0x01, 0xC0, 0x30, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x06, 0x03, 0x00, 0x00,
  0x1C, 0x0C, 0x00, 0x00, 0x38, 0x30, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x01,
  0xC3, 0x00, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x1C,
  0xC0, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0D, 0xF6, 0x00, 0x00, 0x6F,
  0xB8, 0x00, 0x06, 0x7C, 0xC0, 0x00, 0x33, 0xE6, 0x00, 0x03, 0x1F, 0x18,
  0x00, 0x18, 0xF8, 0xC0, 0x01, 0x87, 0xC7, 0x00, 0x0C, 0x3E, 0x18, 0x00,
  0xE1, 0xF0, 0xE0, 0x06, 0x0F, 0x83, 0x00, 0x70, 0x7C, 0x1C, 0x03, 0x03,
  0xE0, 0x60, 0x18, 0x1F, 0x03, 0x81, 0x80, 0xF8, 0x0C, 0x0C, 0x07, 0xC0,
  0x60, 0xC0, 0x3E, 0x01, 0x86, 0x01, 0xF0, 0x0C, 0x70, 0x0F, 0x80, 0x73,
  0x00, 0x7C, 0x01, 0xB8, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00,
  0xF8, 0x01, 0xC0, 0x07, 0xC0, 0x06, 0x00, 0x3E, 0x00, 0x20, 0x01, 0xF0,
  0x01, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0C, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xEC,
  0x00, 0x00, 0x3D, 0xC0, 0x00, 0x07, 0x98, 0x00, 0x00, 0xF3, 0x80, 0x00,
  0x1E, 0x30, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x78, 0x60, 0x00, 0x0F, 0x0E,
  0x00, 0x01, 0xE0, 0xC0, 0x00, 0x3C, 0x1C, 0x00, 0x07, 0x81, 0x80, 0x00,
  0xF0, 0x38, 0x00, 0x1E, 0x03, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x78, 0x06,
  0x00, 0x0F, 0x00, 0xE0, 0x01, 0xE0, 0x0C, 0x00, 0x3C, 0x01, 0xC0, 0x07,
  0x80, 0x18, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x30, 0x03, 0xC0, 0x07,
  0x00, 0x78, 0x00, 0x60, 0x0F, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0xC0, 0x3C,
  0x00, 0x1C, 0x07, 0x80, 0x01, 0x80, 0xF0, 0x00, 0x38, 0x1E, 0x00, 0x03,
  0x03, 0xC0, 0x00, 0x70, 0x78, 0x00, 0x06, 0x0F, 0x00, 0x00, 0xE1, 0xE0,
  0x00, 0x0C, 0x3C, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x18, 0xF0, 0x00, 0x03,
  0x9E, 0x00, 0x00, 0x33, 0xC0, 0x00, 0x07, 0x78, 0x00, 0x00, 0x6F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xC0, 0x7C,
  0x00, 0x1E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x1C,
  0x03, 0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x38,
  0x70, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0xE3,
  0x00, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x03, 0x30,
  0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x1D, 0x80,
  0x00, 0x00, 0x3B, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x01, 0xD8, 0x00, 0x00,
  0x03, 0xB0, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00,
  0x19, 0xC0, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x63, 0x00, 0x00, 0x01,
  0xC7, 0x00, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x1C,
  0x1C, 0x00, 0x00, 0x30, 0x1C, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x03, 0x80,
  0x38, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x3E, 0x01, 0xE0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xE0, 0xC0, 0x00, 0x0F, 0x0C, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x01,
  0xCC, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x06, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0xEC, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x38,
  0xC0, 0x00, 0x0F, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xC0, 0x7C, 0x00,
  0x1E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x1C, 0x03,
  0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x38, 0x70,
  0x00, 0x00, 0x30, 0xE0, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0xE3, 0x00,
  0x00, 0x00, 0xCE, 0x00, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x03, 0x30, 0x00,
  0x00, 0x07, 0x60, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x1D, 0x80, 0x00,
  0x00, 0x3B, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x03,
  0xB0, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x19,
  0xC0, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x63, 0x00, 0x00, 0x01, 0xC7,
  0x00, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x1C, 0x1C,
  0x00, 0x00, 0x30, 0x1C, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x03, 0x80, 0x38,
  0x00, 0x0E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0,
  0xC0, 0x00, 0x0F, 0x0C, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x01, 0xCC, 0x00,
  0x00, 0x0C, 0xC0, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0xEC,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x38, 0xC0, 0x00,
  0x0F, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x0C, 0x00, 0xE0, 0x00,
  0xC0, 0x07, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x80, 0x0C, 0x00,
  0x1C, 0x00, 0xC0, 0x01, 0xC0, 0x0C, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x60,
  0x0C, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x38, 0x0C, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x1C, 0x0C, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x0E, 0x0C, 0x00, 0x00,
  0x70, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x01, 0xCC,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x07, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0x80, 0x3F, 0x00, 0x78, 0x00,
  0x0F, 0x80, 0xE0, 0x00, 0x07, 0x83, 0x80, 0x00, 0x07, 0x8E, 0x00, 0x00,
  0x07, 0x18, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0xA0, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00,
  0x1C, 0xE0, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x03,
  0x80, 0xF0, 0x00, 0x1E, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x01,
  0xB0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x01, 0xDC, 0x00,
  0x00, 0x33, 0x80, 0x00, 0x06, 0x30, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x30,
  0x70, 0x00, 0x0E, 0x07, 0x00, 0x03, 0x80, 0x78, 0x03, 0xE0, 0x07, 0xFF,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00,
  0x01, 0xDC, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x00, 0x71, 0xC0, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x18, 0x30, 0x00,
  0x00, 0x1C, 0x1C, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x06, 0x03, 0x00,
  0x00, 0x07, 0x01, 0xC0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x01, 0x80, 0x30,
  0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x60, 0x03,
  0x00, 0x00, 0x30, 0x01, 0xC0, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x03, 0x80, 0x00, 0xE0, 0x01, 0x80,
  0x00, 0x30, 0x00, 0xC0, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x60,
  0x00, 0x07, 0x00, 0x30, 0x00, 0x01, 0x80, 0x38, 0x00, 0x00, 0xE0, 0x18,
  0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x18, 0x0E, 0x00, 0x00, 0x0E, 0x07,
  0x00, 0x00, 0x07, 0x03, 0x00, 0x00, 0x01, 0x83, 0x80, 0x00, 0x00, 0xE1,
  0xC0, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x00, 0x0C,
  0x70, 0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x00,
  0xDC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x00, 0xD8,
  0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x1B,
  0x00, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0x03, 0x38, 0x00, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00,
  0x18, 0xC0, 0x07, 0x00, 0x0C, 0x60, 0x03, 0xC0, 0x06, 0x30, 0x01, 0xE0,
  0x07, 0x18, 0x01, 0xF0, 0x03, 0x8C, 0x00, 0xDC, 0x01, 0x86, 0x00, 0x66,
  0x00, 0xC3, 0x80, 0x33, 0x00, 0x61, 0xC0, 0x31, 0x80, 0x30, 0x60, 0x18,
  0xE0, 0x18, 0x30, 0x0C, 0x30, 0x0C, 0x18, 0x0E, 0x18, 0x06, 0x0C, 0x06,
  0x0E, 0x03, 0x06, 0x03, 0x03, 0x01, 0x83, 0x01, 0x81, 0x81, 0xC1, 0x81,
  0x80, 0xC0, 0xE0, 0xC0, 0xC0, 0x70, 0x60, 0x60, 0x60, 0x18, 0x30, 0x38,
  0x70, 0x0C, 0x18, 0x1C, 0x30, 0x06, 0x0C, 0x06, 0x18, 0x01, 0x86, 0x03,
  0x0C, 0x00, 0xC3, 0x01, 0x8E, 0x00, 0x61, 0x80, 0xC6, 0x00, 0x38, 0xC0,
  0x63, 0x00, 0x0C, 0x60, 0x33, 0x80, 0x06, 0x70, 0x19, 0x80, 0x03, 0x30,
  0x0C, 0xC0, 0x00, 0xD8, 0x07, 0x60, 0x00, 0x6C, 0x03, 0xF0, 0x00, 0x36,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x00, 0x70, 0x70, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x0C, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x70, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0xC0, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00,
  0x03, 0x80, 0x07, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x1C, 0x00, 0xC0,
  0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x1C, 0x0C,
  0x00, 0x00, 0x03, 0x87, 0x00, 0x00, 0x00, 0x63, 0x80, 0x00, 0x00, 0x1C,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x00, 0x63, 0x80, 0x00, 0x00, 0x38, 0x70, 0x00,
  0x00, 0x0C, 0x0C, 0x00, 0x00, 0x06, 0x03, 0x80, 0x00, 0x03, 0x80, 0x70,
  0x00, 0x00, 0xC0, 0x1C, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x70, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80,
  0x00, 0x70, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x03, 0x80, 0x38,
  0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x03, 0x83,
  0x80, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x03,
  0xB8, 0x00, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x00, 0x76, 0x00, 0x00,
  0x00, 0x0E, 0x70, 0x00, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x00, 0x1C, 0x18,
  0x00, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x30, 0x00,
  0x01, 0xC0, 0x03, 0x80, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0xE0,
  0x00, 0x03, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x01, 0x80, 0x00, 0x01, 0xC0,
  0x38, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x00,
  0x07, 0x0E, 0x00, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x00, 0x03, 0x9C, 0x00,
  0x00, 0x00, 0x1B, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x00, 0x73,
  0x00, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x03, 0x86, 0x00, 0x00, 0x06, 0x0E,
  0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0xC0, 0x1C,
  0x00, 0x03, 0x80, 0x18, 0x00, 0x06, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x70, 0x03, 0x80, 0x00, 0x60,
  0x06, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x01, 0xC0,
  0xC0, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x01, 0x86, 0x00, 0x00, 0x03, 0x9C,
  0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x06, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x60, 0x70, 0x1C, 0x07, 0x01,
  0x80, 0x60, 0x38, 0x0C, 0x03, 0x01, 0xC0, 0x40, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x78, 0x07, 0x80, 0x03, 0x80, 0x07, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0xE0, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x30, 0x18, 0x00,
  0x00, 0xC0, 0x20, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80,
  0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xC0, 0x00, 0x60, 0x3C,
  0x00, 0x01, 0x81, 0xC0, 0x00, 0x06, 0x06, 0x00, 0x00, 0x18, 0x38, 0x00,
  0x00, 0x60, 0xE0, 0x00, 0x01, 0x83, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00,
  0x18, 0x30, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x0E,
  0x06, 0x00, 0x00, 0x58, 0x1C, 0x00, 0x03, 0x60, 0x38, 0x00, 0x39, 0x80,
  0x7C, 0x03, 0xC7, 0xF0, 0xFF, 0xFC, 0x0F, 0xC0, 0x7F, 0xC0, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x1F,
  0xE0, 0x06, 0x0F, 0xFF, 0x00, 0xC7, 0x80, 0xF8, 0x19, 0xC0, 0x07, 0x83,
  0x60, 0x00, 0x38, 0x68, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x31, 0xC0, 0x00,
  0x07, 0x30, 0x00, 0x00, 0x66, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x01, 0xD8,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x0E, 0xC0, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x33, 0x80, 0x00, 0x0E,
  0x70, 0x00, 0x01, 0x8D, 0x00, 0x00, 0x71, 0xB0, 0x00, 0x1C, 0x33, 0x00,
  0x0F, 0x06, 0x3C, 0x07, 0xC0, 0xC1, 0xFF, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x3C, 0x03, 0xC0, 0x1C, 0x00,
  0x38, 0x0E, 0x00, 0x07, 0x07, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x1C, 0xC0,
  0x00, 0x03, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x02, 0x30, 0x00, 0x00, 0xCE, 0x00,
  0x00, 0x71, 0xC0, 0x00, 0x18, 0x38, 0x00, 0x0E, 0x07, 0x00, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x0F, 0xF0, 0x38,
  0x0F, 0xFF, 0x87, 0x03, 0xE0, 0x38, 0xE1, 0xE0, 0x01, 0x9C, 0x38, 0x00,
  0x0B, 0x8E, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x1E, 0x60, 0x00, 0x01, 0xDC,
  0x00, 0x00, 0x3B, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0xEC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x07,
  0x60, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x03, 0x9C, 0x00,
  0x00, 0xF1, 0xC0, 0x00, 0x1E, 0x1C, 0x00, 0x05, 0xC3, 0xC0, 0x03, 0xB8,
  0x1E, 0x01, 0xC7, 0x01, 0xFF, 0xF0, 0xE0, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xC0, 0x3C, 0x00, 0x70, 0x00, 0xE0,
  0x0C, 0x00, 0x07, 0x01, 0x80, 0x00, 0x38, 0x38, 0x00, 0x01, 0xC3, 0x00,
  0x00, 0x0C, 0x70, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00,
  0x6E, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x47, 0x00, 0x00, 0x06,
  0x30, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x0C, 0x1C, 0x00, 0x01, 0xC0, 0xE0,
  0x00, 0x38, 0x07, 0x00, 0x0F, 0x00, 0x3C, 0x03, 0xE0, 0x01, 0xFF, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x1F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0x18, 0x00, 0x07, 0xFF, 0xB0, 0x00,
  0x3C, 0x03, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x01, 0x80, 0x06,
  0x00, 0x01, 0x80, 0x1C, 0x00, 0x03, 0x80, 0x30, 0x00, 0x03, 0x00, 0xE0,
  0x00, 0x06, 0x01, 0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x1C, 0x07, 0x00,
  0x00, 0x38, 0x0E, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0xE0, 0x38, 0x00,
  0x01, 0xC0, 0x30, 0x00, 0x03, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x60, 0x00,
  0x18, 0x00, 0xE0, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0xF0, 0x0F,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x70, 0x00, 0x0F, 0x83, 0x80, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x03, 0x18,
  0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x0D, 0x80,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0xEC, 0x00,
  0x00, 0x01, 0xDC, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x1C, 0x1C, 0x00,
  0x00, 0x70, 0x1F, 0x00, 0x07, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x7F, 0x80, 0xC3,
  0xFF, 0xE0, 0xC7, 0x80, 0xF8, 0xCC, 0x00, 0x38, 0xD8, 0x00, 0x1C, 0xD0,
  0x00, 0x0E, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x70,
  0xC0, 0x00, 0x1C, 0x0C, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x70, 0x0C, 0x00,
  0x0E, 0x00, 0xC0, 0x01, 0xC0, 0x0C, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00,
  0x0C, 0x01, 0xE0, 0x00, 0xC0, 0x38, 0x00, 0x0C, 0x07, 0x00, 0x00, 0xC0,
  0xF0, 0x00, 0x0C, 0x1F, 0x00, 0x00, 0xC3, 0xB8, 0x00, 0x0C, 0x71, 0xC0,
  0x00, 0xCC, 0x0E, 0x00, 0x0F, 0x80, 0x70, 0x00, 0xF0, 0x07, 0x00, 0x0E,
  0x00, 0x38, 0x00, 0xC0, 0x01, 0xC0, 0x0C, 0x00, 0x0E, 0x00, 0xC0, 0x00,
  0x70, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x38, 0x0C, 0x00, 0x01, 0xC0,
  0xC0, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x03, 0x8C, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00,
  0x70, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xF0, 0x0F, 0xC3, 0x3F, 0xE0, 0xFF,
  0xCD, 0xC1, 0xC7, 0x07, 0xB4, 0x03, 0x90, 0x0E, 0xE0, 0x06, 0x80, 0x1B,
  0x80, 0x1A, 0x00, 0x7C, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xC0, 0x03, 0xC0,
  0x03, 0x00, 0x0F, 0x00, 0x0C, 0x00, 0x3C, 0x00, 0x30, 0x00, 0xF0, 0x00,
  0xC0, 0x03, 0xC0, 0x03, 0x00, 0x0F, 0x00, 0x0C, 0x00, 0x3C, 0x00, 0x30,
  0x00, 0xF0, 0x00, 0xC0, 0x03, 0xC0, 0x03, 0x00, 0x0F, 0x00, 0x0C, 0x00,
  0x3C, 0x00, 0x30, 0x00, 0xF0, 0x00, 0xC0, 0x03, 0xC0, 0x03, 0x00, 0x0F,
  0x00, 0x0C, 0x00, 0x3C, 0x00, 0x30, 0x00, 0xF0, 0x00, 0xC0, 0x03, 0xC0,
  0x03, 0x00, 0x0F, 0x00, 0x0C, 0x00, 0x3C, 0x00, 0x30, 0x00, 0xF0, 0x00,
  0xC0, 0x03, 0xC0, 0x03, 0x00, 0x0F, 0x00, 0x0C, 0x00, 0x3C, 0x00, 0x30,
  0x00, 0xF0, 0x00, 0xC0, 0x03, 0xC0, 0x03, 0x00, 0x0F, 0x00, 0x0C, 0x00,
  0x3C, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x7F, 0x80, 0xC3, 0xFF, 0xE0, 0xC7,
  0x80, 0xF8, 0xCC, 0x00, 0x38, 0xD8, 0x00, 0x1C, 0xD0, 0x00, 0x0E, 0xE0,
  0x00, 0x06, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xC0, 0x7C,
  0x00, 0xF0, 0x00, 0xE0, 0x1C, 0x00, 0x07, 0x01, 0x80, 0x00, 0x38, 0x38,
  0x00, 0x01, 0xC7, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0xE6, 0x00, 0x00,
  0x06, 0xE0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x1C, 0x18,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0x70, 0x0F, 0x00, 0x0E, 0x00, 0x7C, 0x03,
  0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x18,
  0x3F, 0xFC, 0x03, 0x1E, 0x03, 0xE0, 0x67, 0x00, 0x1E, 0x0D, 0x80, 0x00,
  0xE1, 0xA0, 0x00, 0x0E, 0x38, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x1C, 0xC0,
  0x00, 0x01, 0x98, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xB0, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x3B,
  0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x39, 0xC0, 0x00,
  0x06, 0x34, 0x00, 0x01, 0xC6, 0xC0, 0x00, 0x70, 0xCC, 0x00, 0x3C, 0x18,
  0xF0, 0x1F, 0x03, 0x07, 0xFF, 0x80, 0x60, 0x3F, 0xC0, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xFE, 0x1C, 0x0F, 0x80, 0xE3,
  0x87, 0x80, 0x06, 0x70, 0xE0, 0x00, 0x2E, 0x38, 0x00, 0x03, 0xCE, 0x00,
  0x00, 0x79, 0x80, 0x00, 0x07, 0x70, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x1D,
  0x80, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0x60,
  0x00, 0x00, 0xEC, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x03, 0xB8, 0x00, 0x00,
  0x73, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x78, 0x70,
  0x00, 0x17, 0x0F, 0x00, 0x0E, 0xE0, 0x78, 0x07, 0x1C, 0x07, 0xFF, 0xC3,
  0x80, 0x1F, 0xE0, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0x00, 0x0C, 0x78, 0x00, 0x00, 0x0C, 0xE0, 0x00,
  0x00, 0x0D, 0x80, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0x80, 0x3E, 0x01, 0xE0,
  0x00, 0x78, 0x18, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x0E, 0x30, 0x00, 0x00,
  0x47, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00,
  0x63, 0x80, 0x00, 0x0E, 0x1E, 0x00, 0x03, 0xC0, 0x7C, 0x01, 0xF0, 0x01,
  0xFF, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xFC, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xB0, 0x00,
  0x01, 0xD8, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x77, 0x00, 0x00, 0x79, 0x80,
  0x00, 0x3C, 0xE0, 0x00, 0x2E, 0x3C, 0x00, 0x77, 0x0F, 0x80, 0xF3, 0x83,
  0xFF, 0xE1, 0xC0, 0x3F, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x06, 0x60, 0x00, 0x00, 0x66, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x0C, 0x30, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x18, 0x18, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x70,
  0x0E, 0x00, 0x06, 0x00, 0x60, 0x00, 0x60, 0x06, 0x00, 0x0E, 0x00, 0x70,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x01, 0x80, 0x18,
  0x00, 0x18, 0x03, 0x80, 0x01, 0xC0, 0x30, 0x00, 0x0C, 0x03, 0x00, 0x00,
  0xC0, 0x70, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x60, 0x60, 0x00, 0x06, 0x0C,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x39, 0x80, 0x00,
  0x01, 0x98, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x6C, 0x00, 0x1E,
  0x00, 0x0D, 0x80, 0x03, 0xC0, 0x01, 0xB0, 0x00, 0xD8, 0x00, 0x36, 0x00,
  0x19, 0x00, 0x0C, 0xC0, 0x03, 0x30, 0x01, 0x8C, 0x00, 0x66, 0x00, 0x31,
  0x80, 0x18, 0xC0, 0x06, 0x30, 0x03, 0x08, 0x00, 0xC6, 0x00, 0x61, 0x80,
  0x38, 0xC0, 0x0C, 0x30, 0x06, 0x1C, 0x03, 0x06, 0x00, 0xC1, 0x80, 0x60,
  0xC0, 0x18, 0x30, 0x0C, 0x0C, 0x03, 0x06, 0x01, 0x81, 0x80, 0x60, 0xC0,
  0x60, 0x30, 0x18, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x81, 0x80, 0x60, 0x60,
  0x30, 0x30, 0x0C, 0x0C, 0x06, 0x04, 0x01, 0x81, 0x80, 0xC1, 0x80, 0x30,
  0x30, 0x18, 0x30, 0x03, 0x0C, 0x03, 0x06, 0x00, 0x61, 0x80, 0x30, 0x80,
  0x0C, 0x30, 0x06, 0x30, 0x01, 0x86, 0x00, 0xC6, 0x00, 0x18, 0xC0, 0x18,
  0xC0, 0x03, 0x30, 0x03, 0x10, 0x00, 0x66, 0x00, 0x36, 0x00, 0x0C, 0xC0,
  0x06, 0xC0, 0x00, 0xD8, 0x00, 0xD8, 0x00, 0x1B, 0x00, 0x1A, 0x00, 0x03,
  0x60, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x07, 0x00, 0x70, 0x00,
  0x00, 0x39, 0xC0, 0x00, 0x03, 0x86, 0x00, 0x00, 0x38, 0x38, 0x00, 0x01,
  0x80, 0xE0, 0x00, 0x1C, 0x03, 0x80, 0x01, 0xC0, 0x0C, 0x00, 0x1C, 0x00,
  0x70, 0x00, 0xC0, 0x01, 0xC0, 0x0C, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x18,
  0x0E, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x03, 0x86, 0x00, 0x00, 0x0E, 0x70,
  0x00, 0x00, 0x37, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x01,
  0x8E, 0x00, 0x00, 0x18, 0x38, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x1C, 0x07,
  0x00, 0x00, 0xC0, 0x1C, 0x00, 0x0C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x0E, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x38, 0x06, 0x00, 0x00, 0xE0, 0x70,
  0x00, 0x03, 0x87, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0x77, 0x80, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x03, 0x9C, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x01,
  0x81, 0x80, 0x00, 0x06, 0x07, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0xC0,
  0x30, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x18, 0x01, 0x80, 0x00, 0xE0, 0x07,
  0x00, 0x03, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0x80, 0x01, 0x80, 0x0E, 0x00, 0x07, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0xC0, 0x00, 0x30, 0x06, 0x00, 0x00, 0x60, 0x18, 0x00, 0x01, 0x80, 0xE0,
  0x00, 0x07, 0x03, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x38, 0x60, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x07, 0x30, 0x00, 0x00,
  0x0D, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF,
  0xC0, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0xC0, 0x0F, 0xFF, 0x80,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC,
  0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x03, 0x0F,
  0xF8, 0x00, 0x03, 0x1C, 0x3C, 0x00, 0x06, 0x38, 0x0E, 0x00, 0x06, 0x30,
  0x07, 0x00, 0x06, 0x70, 0x03, 0x80, 0x0E, 0x60, 0x01, 0xC0, 0x0C, 0x60,
  0x00, 0xE0, 0x1C, 0xC0, 0x00, 0x70, 0x18, 0xC0, 0x00, 0x38, 0x70, 0xC0,
  0x00, 0x1F, 0xE0, 0xC0, 0x00, 0x07, 0xC0,
};

const GFXglyph IBMPlexMono_ExtraLight66pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 40, 0, -1 },
  { 1, 6, 46, 40, 17, -46 },
  { 36, 12, 17, 40, 14, -49 },
  { 62, 37, 46, 40, 1, -46 },
  { 275, 31, 62, 40, 4, -54 },
  { 516, 36, 48, 40, 2, -47 },
  { 732, 33, 48, 40, 3, -47 },
  { 930, 2, 17, 40, 19, -49 },
  { 935, 16, 59, 40, 15, -50 },
  { 1053, 16, 59, 40, 8, -50 },
  { 1171, 34, 33, 40, 3, -36 },
  { 1312, 32, 32, 40, 4, -36 },
  { 1440, 7, 17, 40, 15, -6 },
  { 1455, 18, 2, 40, 11, -21 },
  { 1460, 6, 5, 40, 17, -5 },
  { 1464, 26, 59, 40, 7, -50 },
  { 1656, 31, 48, 40, 4, -47 },
  { 1842, 31, 46, 40, 5, -46 },
  { 2021, 30, 47, 40, 5, -47 },
  { 2198, 29, 48, 40, 4, -47 },
  { 2372, 34, 46, 40, 3, -46 },
  { 2568, 29, 47, 40, 5, -46 },
  { 2739, 29, 47, 40, 5, -46 },
  { 2910, 29, 46, 40, 5, -46 },
  { 3077, 31, 48, 40, 4, -47 },
  { 3263, 28, 47, 40, 6, -47 },
  { 3428, 6, 35, 40, 17, -35 },
  { 3455, 8, 46, 40, 15, -35 },
  { 3501, 28, 36, 40, 6, -38 },
  { 3627, 32, 14, 40, 4, -27 },
  { 3683, 28, 36, 40, 6, -38 },
  { 3809, 27, 47, 40, 6, -47 },
  { 3968, 27, 54, 40, 6, -47 },
  { 4151, 34, 46, 40, 3, -46 },
  { 4347, 28, 46, 40, 6, -46 },
  { 4508, 30, 48, 40, 5, -47 },
  { 4688, 28, 46, 40, 7, -46 },
  { 4849, 27, 46, 40, 7, -46 },
  { 5005, 27, 46, 40, 7, -46 },
  { 5161, 29, 48, 40, 5, -47 },
  { 5335, 27, 46, 40, 6, -46 },
  { 5491, 28, 46, 40, 6, -46 },
  { 5652, 25, 47, 40, 6, -46 },
  { 5799, 30, 46, 40, 7, -46 },
  { 5972, 26, 46, 40, 9, -46 },
  { 6122, 29, 46, 40, 5, -46 },
  { 6289, 27, 46, 40, 6, -46 },
  { 6445, 31, 48, 40, 4, -47 },
  { 6631, 28, 46, 40, 7, -46 },
  { 6792, 31, 57, 40, 4, -47 },
  { 7013, 28, 46, 40, 7, -46 },
  { 7174, 31, 48, 40, 4, -47 },
  { 7360, 35, 46, 40, 2, -46 },
  { 7562, 27, 47, 40, 6, -46 },
  { 7721, 33, 46, 40, 3, -46 },
  { 7911, 33, 46, 40, 3, -46 },
  { 8101, 34, 46, 40, 3, -46 },
  { 8297, 36, 46, 40, 2, -46 },
  { 8504, 33, 46, 40, 3, -46 },
  { 8694, 16, 59, 40, 17, -50 },
  { 8812, 26, 59, 40, 7, -50 },
  { 9004, 17, 59, 40, 6, -50 },
  { 9130, 31, 25, 40, 4, -46 },
  { 9227, 32, 2, 40, 4, 8 },
  { 9235, 9, 11, 40, 13, -50 },
  { 9248, 30, 36, 40, 5, -35 },
  { 9383, 27, 50, 40, 8, -49 },
  { 9552, 26, 36, 40, 7, -35 },
  { 9669, 27, 50, 40, 5, -49 },
  { 9838, 28, 36, 40, 6, -35 },
  { 9964, 30, 49, 40, 5, -49 },
  { 10148, 31, 51, 40, 6, -37 },
  { 10346, 24, 49, 40, 8, -49 },
  { 10493, 28, 50, 40, 8, -50 },
  { 10668, 24, 63, 40, 6, -50 },
  { 10857, 28, 49, 40, 9, -49 },
  { 11029, 28, 49, 40, 6, -49 },
  { 11201, 30, 35, 40, 5, -35 },
  { 11333, 24, 35, 40, 8, -35 },
  { 11438, 28, 36, 40, 6, -35 },
  { 11564, 27, 48, 40, 8, -35 },
  { 11726, 27, 48, 40, 5, -35 },
  { 11888, 32, 34, 40, 5, -34 },
  { 12024, 28, 36, 40, 6, -35 },
  { 12150, 33, 46, 40, 2, -46 },
  { 12340, 25, 35, 40, 7, -34 },
  { 12450, 28, 34, 40, 6, -34 },
  { 12569, 35, 34, 40, 2, -34 },
  { 12718, 29, 34, 40, 5, -34 },
  { 12842, 30, 47, 40, 5, -34 },
  { 13019, 27, 34, 40, 6, -34 },
  { 13134, 25, 59, 40, 7, -50 },
  { 13319, 2, 59, 40, 19, -50 },
  { 13334, 25, 59, 40, 7, -50 },
  { 13519, 32, 12, 40, 4, -26 },
};

const GFXfont IBMPlexMono_ExtraLight66pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLight66pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLight66pt7bGlyphs,
  0x20, 0x7E, 86
};

#endif // _IBMPLEXMONO_EXTRALIGHT66PT7B_H_
