#ifndef _IBMPLEXMONO_EXTRALIGHT48PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHT48PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLight.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLight48pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x62, 0x22, 0x22, 0x22, 0x22,
  0x22, 0x00, 0x00, 0x00, 0x7F, 0xF7, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x30, 0x00, 0x18, 0x08, 0x00,
  0x03, 0x01, 0x00, 0x00, 0x40, 0x60, 0x00, 0x08, 0x0C, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x60, 0x20, 0x00, 0x0C, 0x04, 0x00, 0x01, 0x80, 0x80, 0x00,
  0x20, 0x30, 0x00, 0x04, 0x06, 0x00, 0x01, 0x80, 0xC0, 0x1F, 0xF0, 0x1F,
  0xF3, 0xFE, 0x03, 0xFE, 0x00, 0xC0, 0xC0, 0x00, 0x10, 0x18, 0x00, 0x02,
  0x03, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x18, 0x08, 0x00, 0x03, 0x01, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x08, 0x0C, 0x01, 0xFF, 0x01, 0xFF, 0x3F, 0xE0,
  0x3F, 0xE0, 0x0C, 0x04, 0x00, 0x01, 0x80, 0x80, 0x00, 0x30, 0x30, 0x00,
  0x04, 0x06, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x30, 0x18, 0x00, 0x06, 0x02,
  0x00, 0x00, 0xC0, 0x40, 0x00, 0x10, 0x18, 0x00, 0x02, 0x03, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xF0, 0x0F,
  0x08, 0xF0, 0x38, 0x10, 0x38, 0x60, 0x20, 0x39, 0x80, 0x40, 0x33, 0x00,
  0x80, 0x06, 0x01, 0x00, 0x0C, 0x02, 0x00, 0x18, 0x04, 0x00, 0x30, 0x08,
  0x00, 0x60, 0x10, 0x00, 0xE0, 0x20, 0x00, 0xC0, 0x40, 0x00, 0xE0, 0x80,
  0x00, 0xF9, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x09, 0xF0,
  0x00, 0x10, 0x70, 0x00, 0x20, 0x30, 0x00, 0x40, 0x30, 0x00, 0x80, 0x60,
  0x01, 0x00, 0x40, 0x02, 0x00, 0xC0, 0x04, 0x01, 0x80, 0x08, 0x03, 0x00,
  0x10, 0x04, 0x80, 0x20, 0x1B, 0x80, 0x40, 0x33, 0x80, 0x80, 0xC3, 0x81,
  0x03, 0x83, 0xE2, 0x1E, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0x10,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x63, 0xFE, 0x00, 0x18, 0xE0, 0xE0, 0x06, 0x30,
  0x0C, 0x00, 0xC6, 0x00, 0xC0, 0x30, 0x80, 0x18, 0x04, 0x10, 0x03, 0x01,
  0x86, 0x00, 0x60, 0x20, 0xC0, 0x0C, 0x0C, 0x08, 0x01, 0x83, 0x01, 0x00,
  0x30, 0x40, 0x30, 0x06, 0x18, 0x06, 0x01, 0x82, 0x00, 0x70, 0x70, 0xC0,
  0x07, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x0C, 0x38, 0x38,
  0x03, 0x06, 0x03, 0x00, 0x61, 0x80, 0x30, 0x18, 0x30, 0x06, 0x02, 0x04,
  0x00, 0x40, 0xC0, 0x80, 0x08, 0x10, 0x10, 0x01, 0x06, 0x02, 0x00, 0x21,
  0x80, 0x40, 0x04, 0x20, 0x0C, 0x01, 0x8C, 0x01, 0x80, 0x31, 0x00, 0x18,
  0x0C, 0x60, 0x03, 0x83, 0x88, 0x00, 0x3F, 0xE2, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x07, 0x07, 0x00, 0x0C, 0x01, 0x80,
  0x0C, 0x00, 0xC0, 0x18, 0x00, 0x40, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x07, 0x80, 0x1F, 0x0C, 0xC0, 0x1F, 0x18, 0x60, 0x10, 0x30, 0x70, 0x10,
  0x60, 0x38, 0x10, 0x40, 0x1C, 0x10, 0xC0, 0x0C, 0x30, 0xC0, 0x06, 0x30,
  0xC0, 0x03, 0x30, 0xC0, 0x01, 0xB0, 0xC0, 0x00, 0xE0, 0xC0, 0x00, 0x60,
  0xC0, 0x00, 0x70, 0xC0, 0x00, 0xF8, 0x60, 0x01, 0x98, 0x70, 0x03, 0x0C,
  0x3C, 0x0F, 0x06, 0x1F, 0xFC, 0x03, 0x07, 0xF0, 0x00, 0xFF, 0xF0, 0x00,
  0x70, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x18,
  0x01, 0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x04, 0x00, 0x40, 0x06, 0x00, 0x60, 0x02, 0x00, 0x30,
  0x01, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x70, 0xE0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00,
  0x60, 0x03, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x40,
  0x06, 0x00, 0x60, 0x02, 0x00, 0x20, 0x02, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x60,
  0x06, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x10, 0x03, 0x00,
  0x60, 0x04, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xE0, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x40, 0x08,
  0x01, 0x7C, 0x04, 0x07, 0xC7, 0xC2, 0x1F, 0x00, 0x7D, 0x7C, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0xC4, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x60, 0x18, 0x00,
  0x30, 0x06, 0x00, 0x30, 0x01, 0x80, 0x30, 0x00, 0x60, 0x08, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x39, 0xCC, 0x67,
  0x31, 0x8C, 0xC6, 0x31, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xF7, 0x00,
  0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00,
  0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0x00,
  0x3C, 0x07, 0x00, 0x60, 0x07, 0x01, 0x80, 0x03, 0x06, 0x00, 0x06, 0x0C,
  0x00, 0x06, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x19, 0x80,
  0x00, 0x32, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xD8, 0x00, 0x00, 0xB0, 0x00,
  0x01, 0x60, 0x00, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xE0,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x58, 0x00, 0x00, 0xB0, 0x00, 0x03,
  0x20, 0x00, 0x06, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x33,
  0x00, 0x00, 0xC3, 0x00, 0x01, 0x86, 0x00, 0x06, 0x06, 0x00, 0x0C, 0x06,
  0x00, 0x70, 0x0F, 0x01, 0xC0, 0x07, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xE0, 0x00, 0x1D, 0x80, 0x00, 0xE6, 0x00, 0x07, 0x18,
  0x00, 0x38, 0x60, 0x01, 0xC1, 0x80, 0x0E, 0x06, 0x00, 0xF0, 0x18, 0x03,
  0x80, 0x60, 0x08, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF0, 0x01, 0xFC, 0x00,
  0x3F, 0xF8, 0x07, 0x81, 0xE0, 0x70, 0x03, 0x83, 0x00, 0x0E, 0x30, 0x00,
  0x33, 0x00, 0x01, 0x98, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xFC, 0x03, 0x80, 0xF0, 0x30,
  0x01, 0xC3, 0x00, 0x06, 0x30, 0x00, 0x18, 0x80, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x34, 0x00, 0x03, 0x60, 0x00, 0x19, 0x80, 0x01,
  0x87, 0x00, 0x1C, 0x1E, 0x03, 0xC0, 0x7F, 0xFC, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x26, 0x00, 0x00, 0x33, 0x00, 0x00, 0x31, 0x80, 0x00, 0x10, 0xC0,
  0x00, 0x18, 0x60, 0x00, 0x18, 0x30, 0x00, 0x08, 0x18, 0x00, 0x08, 0x0C,
  0x00, 0x0C, 0x06, 0x00, 0x04, 0x03, 0x00, 0x04, 0x01, 0x80, 0x06, 0x00,
  0xC0, 0x06, 0x00, 0x60, 0x02, 0x00, 0x30, 0x03, 0x00, 0x18, 0x03, 0x00,
  0x0C, 0x01, 0x00, 0x06, 0x01, 0x80, 0x03, 0x01, 0x80, 0x01, 0x80, 0x80,
  0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x3F, 0xFF,
  0xE1, 0xFF, 0xFF, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0xFE, 0x01, 0x9F,
  0xFC, 0x0D, 0xC0, 0x78, 0x78, 0x00, 0xE3, 0x80, 0x03, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x68,
  0x00, 0x03, 0x60, 0x00, 0x31, 0x80, 0x01, 0x86, 0x00, 0x18, 0x1E, 0x03,
  0x80, 0x7F, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x87, 0xF0, 0x0C, 0xFF, 0xE0,
  0x4E, 0x03, 0xC6, 0xC0, 0x07, 0x3C, 0x00, 0x19, 0xC0, 0x00, 0x6C, 0x00,
  0x03, 0x60, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x24, 0x00, 0x03, 0x30, 0x00,
  0x18, 0xC0, 0x01, 0x87, 0x00, 0x18, 0x1E, 0x03, 0xC0, 0x3F, 0xF8, 0x00,
  0x7F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x05, 0x00, 0x00,
  0x68, 0x00, 0x03, 0x40, 0x00, 0x32, 0x00, 0x01, 0x90, 0x00, 0x08, 0x80,
  0x00, 0xC4, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00,
  0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x0F,
  0xFF, 0x80, 0x3C, 0x07, 0x80, 0xE0, 0x03, 0x83, 0x80, 0x03, 0x06, 0x00,
  0x03, 0x0C, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x08, 0xC0, 0x00,
  0x11, 0x80, 0x00, 0x61, 0x80, 0x00, 0xC3, 0x00, 0x01, 0x83, 0x00, 0x06,
  0x07, 0x00, 0x18, 0x07, 0x80, 0xE0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00,
  0x3C, 0x07, 0x80, 0xC0, 0x01, 0x83, 0x00, 0x01, 0x8C, 0x00, 0x01, 0x98,
  0x00, 0x03, 0x60, 0x00, 0x02, 0xC0, 0x00, 0x05, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x66, 0x00, 0x00, 0xCC, 0x00, 0x01, 0x8C, 0x00,
  0x06, 0x1C, 0x00, 0x1C, 0x1F, 0x01, 0xF0, 0x0F, 0xFF, 0x80, 0x07, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x07, 0x80, 0xF0, 0x70, 0x01, 0xC3,
  0x00, 0x06, 0x30, 0x00, 0x19, 0x80, 0x00, 0xD8, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0D, 0x80, 0x00, 0xEC, 0x00, 0x07, 0x30, 0x00, 0x79, 0xC0, 0x06,
  0x87, 0x80, 0xEC, 0x1F, 0xFE, 0x60, 0x1F, 0xC2, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x7F, 0xF7, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF7, 0x3B, 0xDE, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE7, 0x31,
  0x9C, 0xC6, 0x33, 0x18, 0xC4, 0x00, 0x00, 0x00, 0x08, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x04, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x01, 0xFF,
  0xC0, 0x70, 0x1E, 0x18, 0x00, 0xE6, 0x00, 0x0D, 0x80, 0x01, 0xF0, 0x00,
  0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E,
  0x00, 0x1F, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x1E, 0x00,
  0x03, 0xE0, 0x00, 0x38, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0x03,
  0x81, 0xC0, 0x1C, 0x18, 0x00, 0xE3, 0x00, 0x06, 0x20, 0x00, 0x26, 0x00,
  0x03, 0x60, 0x00, 0x36, 0x00, 0x03, 0x40, 0x1F, 0x34, 0x07, 0xFB, 0xC0,
  0xE0, 0xFC, 0x0C, 0x07, 0xC1, 0x80, 0x3C, 0x18, 0x03, 0xC1, 0x00, 0x3C,
  0x10, 0x03, 0xC1, 0x00, 0x3C, 0x10, 0x03, 0xC1, 0x00, 0x3C, 0x10, 0x03,
  0xC1, 0x00, 0x3C, 0x18, 0x03, 0xC1, 0x80, 0x3C, 0x18, 0x03, 0xC0, 0xC0,
  0x74, 0x07, 0xFB, 0x40, 0x3F, 0x34, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0D, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x02, 0x60, 0x00, 0x03,
  0x10, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x86, 0x00, 0x00, 0xC1, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x20, 0x60, 0x00, 0x10, 0x10, 0x00, 0x18, 0x0C, 0x00,
  0x0C, 0x06, 0x00, 0x04, 0x01, 0x00, 0x06, 0x00, 0xC0, 0x03, 0x00, 0x60,
  0x01, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x40, 0x01,
  0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x10, 0x00, 0x30, 0x18, 0x00,
  0x08, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x03, 0x06, 0x00, 0x00, 0x83, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x31, 0x80, 0x00, 0x08, 0xC0, 0x00, 0x06, 0x60,
  0x00, 0x03, 0x60, 0x00, 0x00, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x80,
  0x07, 0x88, 0x00, 0x18, 0x80, 0x00, 0xC8, 0x00, 0x0C, 0x80, 0x00, 0x48,
  0x00, 0x06, 0x80, 0x00, 0x68, 0x00, 0x06, 0x80, 0x00, 0x68, 0x00, 0x04,
  0x80, 0x00, 0xC8, 0x00, 0x0C, 0x80, 0x01, 0x88, 0x00, 0x70, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF0, 0x80, 0x03, 0xC8, 0x00, 0x0C, 0x80, 0x00, 0x68, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x06, 0x80, 0x00, 0xE8,
  0x00, 0x3C, 0xFF, 0xFF, 0x8F, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xFC,
  0x03, 0xC0, 0x70, 0x38, 0x01, 0xC1, 0x80, 0x03, 0x18, 0x00, 0x19, 0xC0,
  0x00, 0x6C, 0x00, 0x03, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x36, 0x00, 0x01, 0x98,
  0x00, 0x18, 0x60, 0x00, 0xC3, 0x80, 0x0C, 0x0F, 0x01, 0xC0, 0x1F, 0xFC,
  0x00, 0x3F, 0x80, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x30, 0x03, 0xC1, 0x80,
  0x07, 0x0C, 0x00, 0x1C, 0x60, 0x00, 0x63, 0x00, 0x01, 0x98, 0x00, 0x0C,
  0xC0, 0x00, 0x36, 0x00, 0x01, 0xB0, 0x00, 0x0D, 0x80, 0x00, 0x6C, 0x00,
  0x03, 0x60, 0x00, 0x0B, 0x00, 0x00, 0x58, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x2C, 0x00, 0x01, 0x60, 0x00,
  0x1B, 0x00, 0x00, 0xD8, 0x00, 0x06, 0xC0, 0x00, 0x36, 0x00, 0x01, 0xB0,
  0x00, 0x19, 0x80, 0x00, 0xCC, 0x00, 0x0C, 0x60, 0x00, 0xE3, 0x00, 0x0E,
  0x18, 0x01, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x78, 0x1C, 0x03, 0x80, 0x18, 0x1C, 0x00,
  0x30, 0x60, 0x00, 0x63, 0x00, 0x01, 0x8C, 0x00, 0x02, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x0D, 0x00, 0x00, 0x34,
  0x00, 0x00, 0xD8, 0x00, 0x03, 0x60, 0x00, 0x0D, 0x80, 0x00, 0x36, 0x00,
  0x00, 0xCC, 0x00, 0x03, 0x30, 0x00, 0x1C, 0xE0, 0x00, 0x71, 0x80, 0x02,
  0xC3, 0x80, 0x1B, 0x07, 0x81, 0xCC, 0x0F, 0xFE, 0x30, 0x0F, 0xE0, 0x00,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xC7, 0xFF, 0xF0, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x03, 0xC0, 0x00, 0xD8, 0x00, 0x36, 0x00, 0x18, 0xC0, 0x0E, 0x1C, 0x0F,
  0x03, 0xFF, 0x80, 0x3F, 0x00, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0xCC, 0x00,
  0x06, 0x30, 0x00, 0x30, 0xC0, 0x01, 0xC3, 0x00, 0x06, 0x0C, 0x00, 0x30,
  0x30, 0x01, 0x80, 0xC0, 0x0C, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x30,
  0x18, 0x00, 0xC0, 0xE0, 0x03, 0x03, 0x00, 0x0C, 0x18, 0x00, 0x30, 0xF0,
  0x00, 0xC6, 0xC0, 0x03, 0x31, 0x80, 0x0D, 0x87, 0x00, 0x3C, 0x0C, 0x00,
  0xF0, 0x18, 0x03, 0x80, 0x70, 0x0C, 0x00, 0xC0, 0x30, 0x01, 0x80, 0xC0,
  0x07, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x60, 0xC0, 0x00,
  0xC3, 0x00, 0x01, 0x8C, 0x00, 0x06, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x1B,
  0x00, 0x00, 0x70, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFD, 0x00, 0x05, 0xEC, 0x00, 0x6F,
  0x60, 0x03, 0x79, 0x80, 0x33, 0xCC, 0x01, 0x9E, 0x20, 0x18, 0xF1, 0x80,
  0xC7, 0x84, 0x04, 0x3C, 0x30, 0x61, 0xE1, 0x82, 0x0F, 0x06, 0x30, 0x78,
  0x31, 0x83, 0xC0, 0x98, 0x1E, 0x06, 0xC0, 0xF0, 0x14, 0x07, 0x80, 0xE0,
  0x3C, 0x02, 0x01, 0xE0, 0x10, 0x0F, 0x01, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xD8, 0x00, 0x1B,
  0x00, 0x03, 0x30, 0x00, 0x66, 0x00, 0x0C, 0x60, 0x01, 0x8C, 0x00, 0x30,
  0xC0, 0x06, 0x18, 0x00, 0xC1, 0x80, 0x18, 0x30, 0x03, 0x03, 0x00, 0x60,
  0x60, 0x0C, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x0C, 0x06, 0x01, 0x80, 0xC0,
  0x18, 0x18, 0x03, 0x03, 0x00, 0x30, 0x60, 0x06, 0x0C, 0x00, 0x61, 0x80,
  0x0C, 0x30, 0x00, 0x86, 0x00, 0x18, 0xC0, 0x01, 0x18, 0x00, 0x33, 0x00,
  0x02, 0x60, 0x00, 0x6C, 0x00, 0x05, 0x80, 0x00, 0xF0, 0x00, 0x0C, 0x00,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x3C, 0x07, 0x00, 0x60, 0x07, 0x01, 0x80,
  0x03, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x60, 0x00,
  0x0C, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x32, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0xD8, 0x00, 0x00, 0xB0, 0x00, 0x01, 0x60, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x58,
  0x00, 0x00, 0xB0, 0x00, 0x03, 0x20, 0x00, 0x06, 0x60, 0x00, 0x0C, 0xC0,
  0x00, 0x19, 0x80, 0x00, 0x33, 0x00, 0x00, 0xC3, 0x00, 0x01, 0x86, 0x00,
  0x06, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x70, 0x0F, 0x01, 0xC0, 0x07, 0xFF,
  0x00, 0x03, 0xF8, 0x00, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0xC0, 0x01, 0xCC,
  0x00, 0x0E, 0xC0, 0x00, 0x6C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x6C, 0x00, 0x0E, 0xC0, 0x01, 0xCF, 0xFF,
  0xF8, 0xFF, 0xFE, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x1C,
  0x07, 0x00, 0x60, 0x07, 0x01, 0x80, 0x03, 0x06, 0x00, 0x06, 0x0C, 0x00,
  0x06, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x19, 0x80, 0x00,
  0x32, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xD8, 0x00, 0x00, 0xB0, 0x00, 0x01,
  0x60, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x58, 0x00, 0x00, 0xB0, 0x00, 0x03, 0x20,
  0x00, 0x06, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x33, 0x00,
  0x00, 0xC3, 0x00, 0x01, 0x86, 0x00, 0x06, 0x06, 0x00, 0x0C, 0x06, 0x00,
  0x70, 0x0F, 0x01, 0xC0, 0x07, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0xC0,
  0x01, 0xCC, 0x00, 0x0E, 0xC0, 0x00, 0x6C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x6C, 0x00, 0x0E, 0xC0, 0x01,
  0xCF, 0xFF, 0xF8, 0xFF, 0xFE, 0x0C, 0x06, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x18, 0x0C, 0x00, 0xC0, 0xC0, 0x0C, 0x0C, 0x00, 0x60, 0xC0,
  0x03, 0x0C, 0x00, 0x30, 0xC0, 0x01, 0x8C, 0x00, 0x18, 0xC0, 0x00, 0xCC,
  0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x03, 0x01, 0xFF, 0x00, 0x1F, 0xFF,
  0x01, 0xE0, 0x1E, 0x0E, 0x00, 0x0E, 0x30, 0x00, 0x19, 0x80, 0x00, 0x36,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x40, 0x00, 0x0F, 0x80, 0x00, 0x37, 0x00, 0x01, 0x8E, 0x00, 0x0E, 0x1F,
  0x01, 0xF0, 0x1F, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0x98, 0x00, 0x33, 0x80, 0x0C, 0x3C,
  0x07, 0x83, 0xFF, 0xE0, 0x1F, 0xE0, 0x00, 0xC0, 0x00, 0x03, 0x60, 0x00,
  0x03, 0x60, 0x00, 0x03, 0x20, 0x00, 0x06, 0x30, 0x00, 0x06, 0x30, 0x00,
  0x06, 0x30, 0x00, 0x04, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x18, 0x00,
  0x08, 0x0C, 0x00, 0x18, 0x0C, 0x00, 0x18, 0x0C, 0x00, 0x10, 0x06, 0x00,
  0x30, 0x06, 0x00, 0x30, 0x06, 0x00, 0x20, 0x02, 0x00, 0x60, 0x03, 0x00,
  0x60, 0x03, 0x00, 0x60, 0x01, 0x00, 0xC0, 0x01, 0x80, 0xC0, 0x01, 0x80,
  0xC0, 0x00, 0x80, 0x80, 0x00, 0xC1, 0x80, 0x00, 0xC1, 0x80, 0x00, 0x41,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x63, 0x00, 0x00, 0x62, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x34, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x05, 0x80, 0x00, 0x0B, 0x00, 0xE0, 0x12, 0x01, 0xC0, 0x24,
  0x02, 0x80, 0x48, 0x0D, 0x01, 0x90, 0x1B, 0x03, 0x30, 0x26, 0x06, 0x60,
  0x44, 0x0C, 0xC1, 0x8C, 0x19, 0x83, 0x18, 0x33, 0x04, 0x30, 0x66, 0x08,
  0x20, 0x8C, 0x30, 0x61, 0x08, 0x60, 0xC2, 0x10, 0x80, 0x84, 0x23, 0x01,
  0x18, 0x46, 0x03, 0x30, 0xC8, 0x06, 0x61, 0x90, 0x04, 0xC3, 0x60, 0x0D,
  0x86, 0xC0, 0x1B, 0x0D, 0x00, 0x36, 0x1E, 0x00, 0x28, 0x3C, 0x00, 0x70,
  0x38, 0x00, 0xE0, 0x60, 0x00, 0x03, 0x18, 0x00, 0x03, 0x0C, 0x00, 0x01,
  0x83, 0x00, 0x01, 0x81, 0xC0, 0x01, 0x80, 0x60, 0x00, 0xC0, 0x18, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x03, 0x00, 0x60, 0x00, 0xC0, 0x60, 0x00, 0x60,
  0x20, 0x00, 0x18, 0x30, 0x00, 0x06, 0x30, 0x00, 0x03, 0x18, 0x00, 0x00,
  0xD8, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x04, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x06, 0x0C, 0x00,
  0x03, 0x06, 0x00, 0x03, 0x01, 0x80, 0x03, 0x00, 0x60, 0x01, 0x80, 0x30,
  0x01, 0x80, 0x0C, 0x01, 0x80, 0x07, 0x00, 0xC0, 0x01, 0x80, 0xC0, 0x00,
  0x60, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x03, 0x60, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x06,
  0x18, 0x00, 0x01, 0x81, 0x80, 0x00, 0x30, 0x18, 0x00, 0x0C, 0x03, 0x00,
  0x01, 0x80, 0x30, 0x00, 0x60, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0xC0, 0x10, 0x00, 0x0C, 0x06, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x18, 0x30, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x33, 0x00, 0x00,
  0x03, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x7F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0F, 0xFF, 0xFF,
  0xF0, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00,
  0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00,
  0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x40,
  0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x20,
  0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x10,
  0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x3F, 0xFF, 0xFF,
  0xF0, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xB0, 0x00, 0x06, 0x20,
  0x00, 0x0C, 0x60, 0x00, 0x30, 0x60, 0x00, 0x40, 0xC0, 0x01, 0x80, 0xC0,
  0x06, 0x00, 0x80, 0x0C, 0x01, 0x80, 0x30, 0x01, 0x80, 0x40, 0x03, 0x01,
  0x80, 0x03, 0x02, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x30, 0x00, 0x04, 0x60,
  0x00, 0x0D, 0x80, 0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x61,
  0xC0, 0xC0, 0xC1, 0x81, 0x81, 0x81, 0x03, 0xF8, 0x00, 0x3F, 0xF8, 0x03,
  0xC0, 0xF0, 0x1C, 0x00, 0xE0, 0x60, 0x01, 0x83, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x07, 0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0x80, 0x0C, 0x38,
  0x00, 0x30, 0xC0, 0x00, 0xC3, 0x00, 0x03, 0x08, 0x00, 0x0C, 0x20, 0x00,
  0x30, 0x80, 0x00, 0xC3, 0x00, 0x07, 0x0E, 0x00, 0x2C, 0x1E, 0x03, 0x3F,
  0x3F, 0xF8, 0x7C, 0x3F, 0x80, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x41, 0xFC, 0x08, 0xFF,
  0xE1, 0x38, 0x1E, 0x2C, 0x00, 0xE5, 0x00, 0x0C, 0xC0, 0x00, 0xD8, 0x00,
  0x1A, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x36, 0x00, 0x06, 0xA0, 0x01,
  0x96, 0x00, 0x72, 0x70, 0x3C, 0x47, 0xFF, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0xFF, 0xE0, 0x78, 0x1E, 0x0C, 0x00, 0xE3, 0x00, 0x0C, 0xC0, 0x00,
  0xD8, 0x00, 0x12, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x16, 0x00, 0x06,
  0x60, 0x01, 0x86, 0x00, 0x70, 0xF0, 0x3C, 0x07, 0xFE, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x81, 0xFC, 0x30, 0xFF, 0xE6, 0x3C, 0x0E, 0xCE, 0x00, 0x7B,
  0x80, 0x07, 0x60, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1B, 0x00, 0x03, 0x70, 0x00, 0xE7, 0x00, 0x3C, 0x78, 0x1D, 0x87,
  0xFF, 0x30, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0x80, 0xE0,
  0x30, 0x01, 0x83, 0x00, 0x06, 0x10, 0x00, 0x11, 0x80, 0x00, 0xC8, 0x00,
  0x02, 0x40, 0x00, 0x16, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x23, 0x00, 0x03, 0x18,
  0x00, 0x30, 0x60, 0x03, 0x81, 0xE0, 0x78, 0x07, 0xFF, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x0F, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x02,
  0x00, 0x0F, 0xE4, 0x00, 0x7F, 0xF8, 0x01, 0xC0, 0x78, 0x07, 0x00, 0x30,
  0x0C, 0x00, 0x30, 0x30, 0x00, 0x60, 0x60, 0x00, 0xC0, 0xC0, 0x01, 0x81,
  0x80, 0x03, 0x03, 0x00, 0x06, 0x06, 0x00, 0x0C, 0x0E, 0x00, 0x10, 0x0E,
  0x00, 0x60, 0x0E, 0x03, 0x80, 0x0F, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x60,
  0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x20, 0x00, 0xE1, 0x80, 0x00,
  0xE4, 0x00, 0x00, 0xC8, 0x00, 0x00, 0xB0, 0x00, 0x01, 0x60, 0x00, 0x02,
  0xC0, 0x00, 0x0D, 0xC0, 0x00, 0x19, 0xC0, 0x00, 0xE1, 0xE0, 0x07, 0x81,
  0xFF, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x7E, 0x08, 0xFF, 0xC4, 0xE0, 0x72,
  0xC0, 0x0D, 0x40, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00,
  0x70, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07,
  0x00, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xEF,
  0xFF, 0xF0, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x6F, 0xFF, 0xE7, 0xFF, 0xF0,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0xEC, 0x00, 0x0C, 0x60, 0x00,
  0xC3, 0x00, 0x0C, 0x18, 0x00, 0xC0, 0xC0, 0x1C, 0x06, 0x01, 0xC0, 0x30,
  0x18, 0x01, 0x81, 0x80, 0x0C, 0x18, 0x00, 0x61, 0xC0, 0x03, 0x1B, 0x00,
  0x19, 0x8C, 0x00, 0xF8, 0x30, 0x07, 0x01, 0xC0, 0x30, 0x06, 0x01, 0x80,
  0x18, 0x0C, 0x00, 0x60, 0x60, 0x01, 0x83, 0x00, 0x06, 0x18, 0x00, 0x30,
  0xC0, 0x00, 0xC6, 0x00, 0x03, 0x30, 0x00, 0x0D, 0x80, 0x00, 0x30, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC7, 0x81,
  0xF1, 0xBF, 0xC7, 0xF3, 0x61, 0x98, 0x77, 0x01, 0xC0, 0x6C, 0x03, 0x80,
  0x58, 0x06, 0x00, 0xB0, 0x04, 0x01, 0xE0, 0x08, 0x03, 0xC0, 0x10, 0x07,
  0x80, 0x20, 0x0F, 0x00, 0x40, 0x1E, 0x00, 0x80, 0x3C, 0x01, 0x00, 0x78,
  0x02, 0x00, 0xF0, 0x04, 0x01, 0xE0, 0x08, 0x03, 0xC0, 0x10, 0x07, 0x80,
  0x20, 0x0F, 0x00, 0x40, 0x1E, 0x00, 0x80, 0x3C, 0x01, 0x00, 0x78, 0x02,
  0x00, 0xF0, 0x04, 0x01, 0xE0, 0x08, 0x03, 0xC0, 0x10, 0x06, 0x83, 0xF0,
  0x47, 0xFE, 0x27, 0x03, 0x96, 0x00, 0x6A, 0x00, 0x3E, 0x00, 0x0F, 0x00,
  0x07, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0x80, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0x81, 0xE0,
  0x30, 0x01, 0x83, 0x00, 0x06, 0x30, 0x00, 0x31, 0x80, 0x00, 0xC8, 0x00,
  0x06, 0xC0, 0x00, 0x16, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0x90, 0x00, 0x0C, 0xC0, 0x00, 0x66, 0x00, 0x06, 0x18,
  0x00, 0x30, 0x60, 0x03, 0x01, 0xC0, 0x70, 0x07, 0xFF, 0x00, 0x0F, 0xE0,
  0x00, 0x83, 0xF8, 0x11, 0xFF, 0xC2, 0x70, 0x3C, 0x58, 0x01, 0xCA, 0x00,
  0x19, 0x80, 0x01, 0xB0, 0x00, 0x34, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00,
  0x6C, 0x00, 0x0D, 0x40, 0x03, 0x2C, 0x00, 0xE4, 0xE0, 0x78, 0x8F, 0xFE,
  0x10, 0x7F, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x61, 0xFF, 0xCC, 0x78, 0x1D, 0x9C, 0x00, 0xF7, 0x00,
  0x0E, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x36, 0x00, 0x06, 0xE0, 0x01, 0xCE, 0x00, 0x78, 0xF0, 0x3B, 0x0F, 0xFE,
  0x60, 0x7F, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0xFF, 0xC1, 0xFF, 0xFF, 0x8F, 0xFC, 0x03, 0x30, 0x00, 0x06, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF0, 0x03, 0xFC, 0x00, 0x7F, 0xFC, 0x07, 0x80, 0xF0, 0x60, 0x00, 0xC3,
  0x00, 0x03, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x34, 0x00, 0x01, 0xF0, 0x00, 0x18, 0xE0,
  0x01, 0xC3, 0xC0, 0x3C, 0x0F, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFC,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0D, 0x00, 0x03, 0x60, 0x00, 0xD8,
  0x00, 0x73, 0x00, 0x2C, 0xF0, 0x3B, 0x1F, 0xFC, 0xC0, 0xFC, 0x00, 0xC0,
  0x00, 0x1A, 0x00, 0x01, 0x98, 0x00, 0x0C, 0xC0, 0x00, 0x43, 0x00, 0x06,
  0x18, 0x00, 0x30, 0x40, 0x01, 0x03, 0x00, 0x18, 0x18, 0x00, 0xC0, 0x40,
  0x04, 0x03, 0x00, 0x60, 0x18, 0x02, 0x00, 0x40, 0x30, 0x03, 0x01, 0x80,
  0x18, 0x08, 0x00, 0x60, 0xC0, 0x03, 0x06, 0x00, 0x08, 0x20, 0x00, 0x63,
  0x00, 0x03, 0x10, 0x00, 0x08, 0x80, 0x00, 0x6C, 0x00, 0x03, 0x40, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xF0,
  0x05, 0x00, 0x78, 0x06, 0x80, 0x24, 0x03, 0x60, 0x12, 0x01, 0x30, 0x09,
  0x00, 0x88, 0x0C, 0xC0, 0x44, 0x06, 0x60, 0x63, 0x03, 0x30, 0x21, 0x81,
  0x08, 0x10, 0x40, 0x84, 0x08, 0x20, 0x42, 0x0C, 0x18, 0x61, 0x84, 0x0C,
  0x30, 0xC2, 0x02, 0x10, 0x61, 0x01, 0x08, 0x11, 0x80, 0x84, 0x08, 0x80,
  0x62, 0x04, 0x40, 0x13, 0x03, 0x20, 0x09, 0x81, 0xB0, 0x04, 0x80, 0x50,
  0x03, 0x40, 0x28, 0x00, 0xA0, 0x14, 0x00, 0x50, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x00, 0x3B, 0x00, 0x01, 0x8C, 0x00, 0x18, 0x30, 0x01, 0x81, 0xC0,
  0x18, 0x06, 0x00, 0xC0, 0x18, 0x0C, 0x00, 0x60, 0xC0, 0x03, 0x0C, 0x00,
  0x0C, 0x60, 0x00, 0x36, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x38,
  0x00, 0x03, 0x60, 0x00, 0x31, 0x80, 0x03, 0x0C, 0x00, 0x18, 0x30, 0x01,
  0x80, 0xC0, 0x18, 0x03, 0x01, 0x80, 0x18, 0x0C, 0x00, 0x60, 0xC0, 0x01,
  0x8C, 0x00, 0x06, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xD0,
  0x00, 0x0C, 0xC0, 0x00, 0x66, 0x00, 0x02, 0x18, 0x00, 0x30, 0xC0, 0x01,
  0x82, 0x00, 0x18, 0x18, 0x00, 0xC0, 0xC0, 0x04, 0x03, 0x00, 0x60, 0x18,
  0x02, 0x00, 0x40, 0x30, 0x03, 0x01, 0x80, 0x08, 0x08, 0x00, 0x60, 0xC0,
  0x03, 0x04, 0x00, 0x08, 0x60, 0x00, 0x63, 0x00, 0x01, 0x10, 0x00, 0x0D,
  0x80, 0x00, 0x68, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0xC0, 0xFF,
  0xC0, 0x3F, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x7F,
  0xF0, 0x0F, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xE0, 0x3F,
  0xF8, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x07, 0x80, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x1E,
  0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0x0F, 0x00,
  0x02, 0x3F, 0x80, 0x0C, 0xC3, 0x80, 0x1B, 0x03, 0x80, 0x26, 0x03, 0x80,
  0xD8, 0x03, 0x81, 0xB0, 0x03, 0x86, 0x40, 0x03, 0xF8, 0x80, 0x01, 0xE0,
};

const GFXglyph IBMPlexMono_ExtraLight48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 29, 0, -1 },
  { 1, 4, 34, 29, 12, -34 },
  { 18, 9, 12, 29, 10, -36 },
  { 32, 27, 34, 29, 1, -34 },
  { 147, 23, 45, 29, 3, -39 },
  { 277, 27, 35, 29, 1, -34 },
  { 396, 24, 35, 29, 2, -34 },
  { 501, 1, 12, 29, 14, -36 },
  { 503, 12, 43, 29, 11, -36 },
  { 568, 12, 43, 29, 6, -36 },
  { 633, 25, 24, 29, 2, -26 },
  { 708, 23, 24, 29, 3, -27 },
  { 777, 5, 12, 29, 11, -4 },
  { 785, 13, 2, 29, 8, -16 },
  { 789, 4, 4, 29, 12, -4 },
  { 791, 19, 43, 29, 5, -36 },
  { 894, 23, 35, 29, 3, -34 },
  { 995, 22, 34, 29, 4, -34 },
  { 1089, 21, 34, 29, 4, -34 },
  { 1179, 21, 35, 29, 3, -34 },
  { 1271, 25, 34, 29, 2, -34 },
  { 1378, 21, 35, 29, 4, -34 },
  { 1470, 21, 35, 29, 4, -34 },
  { 1562, 21, 34, 29, 4, -34 },
  { 1652, 23, 35, 29, 3, -34 },
  { 1753, 21, 34, 29, 4, -34 },
  { 1843, 4, 26, 29, 12, -26 },
  { 1856, 5, 34, 29, 11, -26 },
  { 1878, 21, 26, 29, 4, -28 },
  { 1947, 23, 11, 29, 3, -20 },
  { 1979, 21, 26, 29, 4, -28 },
  { 2048, 19, 34, 29, 5, -34 },
  { 2129, 20, 39, 29, 4, -34 },
  { 2227, 25, 34, 29, 2, -34 },
  { 2334, 20, 34, 29, 5, -34 },
  { 2419, 21, 35, 29, 4, -34 },
  { 2511, 21, 34, 29, 5, -34 },
  { 2601, 20, 34, 29, 5, -34 },
  { 2686, 20, 34, 29, 5, -34 },
  { 2771, 22, 35, 29, 3, -34 },
  { 2868, 19, 34, 29, 5, -34 },
  { 2949, 20, 34, 29, 4, -34 },
  { 3034, 18, 35, 29, 4, -34 },
  { 3113, 22, 34, 29, 5, -34 },
  { 3207, 18, 34, 29, 7, -34 },
  { 3284, 21, 34, 29, 4, -34 },
  { 3374, 19, 34, 29, 5, -34 },
  { 3455, 23, 35, 29, 3, -34 },
  { 3556, 20, 34, 29, 5, -34 },
  { 3641, 23, 42, 29, 3, -34 },
  { 3762, 20, 34, 29, 5, -34 },
  { 3847, 22, 35, 29, 3, -34 },
  { 3944, 25, 34, 29, 2, -34 },
  { 4051, 19, 35, 29, 5, -34 },
  { 4135, 24, 34, 29, 2, -34 },
  { 4237, 23, 34, 29, 3, -34 },
  { 4335, 25, 34, 29, 2, -34 },
  { 4442, 27, 34, 29, 1, -34 },
  { 4557, 25, 34, 29, 2, -34 },
  { 4664, 12, 43, 29, 12, -36 },
  { 4729, 19, 43, 29, 5, -36 },
  { 4832, 12, 43, 29, 5, -36 },
  { 4897, 23, 18, 29, 3, -34 },
  { 4949, 23, 2, 29, 3, 5 },
  { 4955, 7, 8, 29, 9, -37 },
  { 4962, 22, 26, 29, 4, -25 },
  { 5034, 19, 37, 29, 6, -36 },
  { 5122, 19, 26, 29, 5, -25 },
  { 5184, 19, 37, 29, 4, -36 },
  { 5272, 21, 26, 29, 4, -25 },
  { 5341, 22, 36, 29, 4, -36 },
  { 5440, 23, 38, 29, 4, -28 },
  { 5550, 17, 36, 29, 6, -36 },
  { 5627, 21, 36, 29, 5, -36 },
  { 5722, 17, 46, 29, 5, -36 },
  { 5820, 21, 36, 29, 6, -36 },
  { 5915, 21, 36, 29, 4, -36 },
  { 6010, 23, 25, 29, 3, -25 },
  { 6082, 17, 25, 29, 6, -25 },
  { 6136, 21, 26, 29, 4, -25 },
  { 6205, 19, 35, 29, 6, -25 },
  { 6289, 19, 35, 29, 4, -25 },
  { 6373, 23, 25, 29, 4, -25 },
  { 6445, 21, 26, 29, 4, -25 },
  { 6514, 23, 34, 29, 2, -34 },
  { 6612, 18, 26, 29, 5, -25 },
  { 6671, 21, 25, 29, 4, -25 },
  { 6737, 25, 25, 29, 2, -25 },
  { 6816, 21, 25, 29, 4, -25 },
  { 6882, 21, 35, 29, 4, -25 },
  { 6974, 19, 25, 29, 5, -25 },
  { 7034, 18, 43, 29, 5, -36 },
  { 7131, 1, 43, 29, 14, -36 },
  { 7137, 18, 43, 29, 5, -36 },
  { 7234, 23, 9, 29, 3, -19 },
};

const GFXfont IBMPlexMono_ExtraLight48pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLight48pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLight48pt7bGlyphs,
  0x20, 0x7E, 62
};

#endif // _IBMPLEXMONO_EXTRALIGHT48PT7B_H_
