#ifndef _IBMPLEXMONO_EXTRALIGHT25PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHT25PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLight.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLight25pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x92, 0x49, 0x20, 0x07, 0xE0, 0x8C, 0x63, 0x18, 0xC4,
  0x04, 0x20, 0x11, 0x00, 0x44, 0x01, 0x10, 0x08, 0x43, 0xE1, 0xF0, 0x88,
  0x02, 0x20, 0x08, 0x80, 0x22, 0x01, 0x08, 0x3C, 0x3E, 0x10, 0x80, 0x44,
  0x01, 0x10, 0x08, 0x40, 0x21, 0x00, 0x04, 0x00, 0x80, 0x10, 0x0F, 0x86,
  0x4D, 0x08, 0x61, 0x04, 0x20, 0x84, 0x08, 0x81, 0xD0, 0x07, 0xC0, 0x44,
  0x08, 0x41, 0x08, 0x21, 0x84, 0x30, 0x85, 0x93, 0x0F, 0xC0, 0x40, 0x08,
  0x01, 0x00, 0x78, 0x0E, 0x20, 0xA0, 0x85, 0x04, 0x48, 0x22, 0x41, 0x23,
  0x11, 0x0F, 0x10, 0x00, 0x00, 0x47, 0x84, 0x46, 0x24, 0x12, 0x20, 0x91,
  0x05, 0x08, 0x30, 0x23, 0x80, 0xF0, 0x0F, 0x01, 0x8C, 0x08, 0x20, 0x40,
  0x82, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x28, 0x3A, 0x21, 0x20, 0x89,
  0x02, 0x88, 0x0C, 0x40, 0x22, 0x02, 0x8C, 0x24, 0x3E, 0x18, 0xFC, 0x0C,
  0x42, 0x08, 0x41, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x41,
  0x02, 0x08, 0x10, 0x30, 0xC0, 0x81, 0x04, 0x08, 0x20, 0x41, 0x04, 0x10,
  0x41, 0x04, 0x10, 0x41, 0x08, 0x21, 0x04, 0x23, 0x00, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x08, 0x20, 0xB9, 0x38, 0x3E, 0x00, 0xA0, 0x05, 0x00,
  0x44, 0x04, 0x10, 0x40, 0x40, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x3F, 0xF8, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x6B,
  0x49, 0x00, 0xFE, 0xFC, 0x00, 0x80, 0x40, 0x40, 0x20, 0x10, 0x10, 0x08,
  0x08, 0x04, 0x02, 0x02, 0x01, 0x01, 0x00, 0x80, 0x80, 0x40, 0x20, 0x20,
  0x10, 0x10, 0x08, 0x04, 0x00, 0x1F, 0x04, 0x11, 0x01, 0x40, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x21, 0x84, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x50, 0x11, 0x04, 0x1F, 0x00, 0x06, 0x01, 0xA0, 0x32, 0x06, 0x20, 0xC2,
  0x08, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0xFF, 0xF0, 0x1F, 0x04, 0x11, 0x01, 0x40,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0xFF, 0xE0, 0x1F, 0x18, 0x24, 0x06, 0x01,
  0x00, 0x40, 0x10, 0x18, 0x78, 0x01, 0x80, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x18, 0x05, 0x86, 0x3F, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x50, 0x04, 0x80,
  0x44, 0x02, 0x20, 0x21, 0x02, 0x08, 0x10, 0x41, 0x02, 0x10, 0x11, 0x00,
  0x8F, 0xFF, 0x80, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x7F, 0xC8, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x17, 0xC3, 0x06, 0x40, 0x40, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0xA0, 0x13, 0x04, 0x1F, 0x00, 0x03, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0xC0, 0x10, 0x02, 0xF8, 0xA0, 0xD8, 0x0A, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x50, 0x11, 0x06, 0x1F, 0x00, 0xFF, 0xF0, 0x06,
  0x01, 0x40, 0x28, 0x08, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x08,
  0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x10, 0x00, 0x1F, 0x0C, 0x19,
  0x01, 0x40, 0x18, 0x03, 0x00, 0x50, 0x11, 0x04, 0x1F, 0x0C, 0x1A, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0B, 0x06, 0x1F, 0x00, 0x1F, 0x0C, 0x19,
  0x01, 0x40, 0x18, 0x03, 0x00, 0x60, 0x0A, 0x03, 0x60, 0xA3, 0xEC, 0x01,
  0x00, 0x60, 0x08, 0x02, 0x00, 0xC0, 0x20, 0x18, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0xFC, 0x00, 0x00, 0x00, 0x35, 0xA4, 0x80, 0x00, 0x20, 0x18,
  0x04, 0x03, 0x00, 0x80, 0x60, 0x30, 0x06, 0x00, 0x20, 0x03, 0x00, 0x18,
  0x00, 0x80, 0x0C, 0x00, 0x40, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFE,
  0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x20, 0x03, 0x00, 0x18, 0x03, 0x00,
  0x80, 0x60, 0x30, 0x08, 0x06, 0x01, 0x00, 0x00, 0x1F, 0x04, 0x19, 0x01,
  0x40, 0x20, 0x06, 0x00, 0x80, 0x10, 0x04, 0x07, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x1F, 0x04, 0x11, 0x01,
  0x20, 0x28, 0x05, 0x0F, 0xA3, 0x2C, 0x43, 0x90, 0x32, 0x06, 0x40, 0xC8,
  0x18, 0x83, 0x10, 0xE1, 0xEC, 0x00, 0x40, 0x08, 0x00, 0xC0, 0x0F, 0xE0,
  0x02, 0x00, 0x28, 0x01, 0x40, 0x0A, 0x00, 0x88, 0x04, 0x40, 0x22, 0x02,
  0x08, 0x10, 0x40, 0x82, 0x08, 0x08, 0x7F, 0xC2, 0x02, 0x20, 0x09, 0x00,
  0x48, 0x02, 0x80, 0x08, 0xFF, 0x10, 0x12, 0x01, 0x40, 0x28, 0x05, 0x00,
  0xA0, 0x14, 0x04, 0xFF, 0x10, 0x1A, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x02, 0xFF, 0x80, 0x1F, 0x06, 0x19, 0x01, 0x20, 0x18, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x00, 0x80, 0x50,
  0x11, 0x86, 0x1F, 0x00, 0xFE, 0x20, 0x48, 0x0A, 0x03, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x38, 0x0A, 0x04,
  0xFE, 0x00, 0xFF, 0xE0, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0xFF, 0xE0, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0xFF, 0xC0,
  0xFF, 0xE0, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0xFF, 0xA0,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x00, 0x1F, 0x04,
  0x11, 0x01, 0x60, 0x18, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x7E,
  0x00, 0xC0, 0x18, 0x03, 0x80, 0x50, 0x19, 0x05, 0x1F, 0x20, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0xFF, 0xF0, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20, 0xFF, 0xE0,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0xFF, 0xE0, 0x3F, 0xC0,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x60, 0x14, 0x09, 0x86, 0x1E, 0x00, 0x80, 0x70, 0x12, 0x06,
  0x41, 0x88, 0x21, 0x08, 0x22, 0x04, 0x80, 0xA8, 0x18, 0x82, 0x18, 0x41,
  0x08, 0x11, 0x03, 0x20, 0x24, 0x02, 0x80, 0x60, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0xFF, 0xC0, 0xC0, 0x38, 0x0F, 0x02, 0xD0, 0x5A,
  0x13, 0x22, 0x64, 0x4C, 0x51, 0x8A, 0x30, 0x86, 0x10, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x20, 0xC0, 0x38, 0x06, 0x80, 0xD0, 0x19,
  0x03, 0x20, 0x62, 0x0C, 0x41, 0x84, 0x30, 0xC6, 0x08, 0xC0, 0x98, 0x13,
  0x01, 0x60, 0x2C, 0x03, 0x80, 0x60, 0x1F, 0x04, 0x11, 0x01, 0x40, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x50, 0x11, 0x04, 0x1F, 0x00, 0xFF, 0x20, 0x28, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0xBF, 0xC8, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x00, 0x1F, 0x04, 0x11, 0x01, 0x40, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x50,
  0x11, 0x04, 0x1F, 0x00, 0x80, 0x10, 0x02, 0x00, 0x7C, 0xFF, 0x20, 0x28,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0xBF, 0xC8, 0x42, 0x10,
  0x82, 0x20, 0x48, 0x12, 0x02, 0x80, 0x40, 0x1F, 0x0C, 0x1A, 0x00, 0xC0,
  0x08, 0x01, 0x00, 0x10, 0x03, 0x80, 0x0F, 0x80, 0x18, 0x00, 0x80, 0x10,
  0x03, 0x00, 0x60, 0x0B, 0x06, 0x1F, 0x80, 0xFF, 0xF8, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x02, 0x80, 0x90, 0x13, 0x06, 0x1F, 0x00, 0x80,
  0x0A, 0x00, 0x90, 0x04, 0x80, 0x22, 0x02, 0x10, 0x10, 0x80, 0x82, 0x08,
  0x10, 0x40, 0x82, 0x02, 0x20, 0x11, 0x00, 0x88, 0x02, 0x80, 0x14, 0x00,
  0xA0, 0x02, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x05, 0x00, 0x24, 0x01, 0x21,
  0x09, 0x18, 0x48, 0xA2, 0x45, 0x12, 0x28, 0x92, 0x24, 0x91, 0x24, 0x89,
  0x28, 0x50, 0xC1, 0x86, 0x0C, 0x30, 0x60, 0xC0, 0x1A, 0x00, 0x88, 0x08,
  0x20, 0x81, 0x04, 0x04, 0x40, 0x14, 0x00, 0xA0, 0x02, 0x00, 0x28, 0x01,
  0x60, 0x11, 0x01, 0x04, 0x10, 0x30, 0x80, 0x88, 0x02, 0x80, 0x08, 0x80,
  0x0A, 0x00, 0x90, 0x04, 0x40, 0x41, 0x04, 0x08, 0x20, 0x22, 0x01, 0x90,
  0x05, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x7F, 0xF0, 0x00, 0x80, 0x08, 0x00, 0x80, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x60, 0x02, 0x00, 0x20, 0x02, 0x00, 0x30, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x08, 0x00, 0xFF, 0xF8, 0xFF, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x1F, 0xC0, 0x80, 0x40, 0x20, 0x08, 0x04, 0x01, 0x00, 0x80, 0x40,
  0x10, 0x08, 0x02, 0x01, 0x00, 0x40, 0x20, 0x10, 0x04, 0x02, 0x00, 0x80,
  0x40, 0x20, 0x08, 0x04, 0xFE, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x3F, 0xC0,
  0x04, 0x01, 0x40, 0x48, 0x08, 0x82, 0x08, 0x41, 0x10, 0x12, 0x02, 0x80,
  0x30, 0x04, 0xFF, 0xF8, 0x88, 0x90, 0x3E, 0x08, 0x32, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x0F, 0xE6, 0x04, 0x80, 0x90, 0x12, 0x02, 0x60, 0xC3, 0xE6,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x09, 0xE3, 0x86, 0x80, 0xA0,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0xB8, 0x69, 0xE0,
  0x1E, 0x18, 0x6C, 0x0A, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x2C, 0x0D, 0x86, 0x1E, 0x00, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x11, 0xE5, 0x87, 0x40, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x40, 0x58, 0x71, 0xE4, 0x1F, 0x04, 0x11, 0x01, 0x20, 0x28, 0x03,
  0x00, 0x7F, 0xFC, 0x00, 0x80, 0x10, 0x01, 0x00, 0x90, 0x61, 0xF0, 0x07,
  0xE0, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x3F, 0xF8, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x83,
  0xFF, 0x80, 0x00, 0xF1, 0xF8, 0x20, 0x84, 0x04, 0x40, 0x44, 0x04, 0x40,
  0x44, 0x04, 0x20, 0x83, 0xF0, 0x60, 0x04, 0x00, 0x40, 0x07, 0xFC, 0xC0,
  0x28, 0x01, 0x80, 0x14, 0x06, 0x3F, 0x80, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x79, 0xC2, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x20, 0x0C, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x0F, 0xFC, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0xFF, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x14, 0x04, 0x83, 0x10, 0xC2, 0x20, 0x4C,
  0x0A, 0x41, 0x84, 0x20, 0x84, 0x08, 0x80, 0x90, 0x0A, 0x00, 0x80, 0xFC,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x83,
  0xFF, 0x80, 0xB9, 0xD9, 0x46, 0x10, 0xC2, 0x18, 0x43, 0x08, 0x61, 0x0C,
  0x21, 0x84, 0x30, 0x86, 0x10, 0xC2, 0x18, 0x42, 0x9E, 0x70, 0xA0, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x08, 0x1F,
  0x04, 0x11, 0x01, 0x40, 0x28, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x09, 0x01, 0x10, 0x41, 0xF0, 0x9E, 0x38, 0x68, 0x0A, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0B, 0x86, 0x9E, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x00, 0x1E, 0x58, 0x74, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x14, 0x05, 0x87, 0x1E, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0xF9, 0xF0, 0xA0, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0xFF, 0xE0, 0x1F,
  0x0C, 0x19, 0x01, 0xA0, 0x04, 0x00, 0xE0, 0x07, 0xE0, 0x02, 0x00, 0x20,
  0x06, 0x00, 0xB0, 0x21, 0xF8, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0xFF,
  0xF0, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x07, 0xF0, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x28, 0x33, 0xE8, 0x80, 0x28,
  0x09, 0x01, 0x20, 0x22, 0x08, 0x41, 0x08, 0x40, 0x88, 0x11, 0x01, 0x40,
  0x28, 0x05, 0x00, 0x40, 0x82, 0x0C, 0x30, 0x61, 0x43, 0x0A, 0x24, 0x51,
  0x24, 0x89, 0x22, 0x49, 0x12, 0x48, 0x92, 0x85, 0x0C, 0x18, 0x60, 0xC3,
  0x06, 0x00, 0xC0, 0x68, 0x08, 0x82, 0x08, 0x81, 0xA0, 0x14, 0x01, 0x00,
  0x50, 0x11, 0x02, 0x20, 0x82, 0x20, 0x28, 0x06, 0x80, 0x30, 0x09, 0x01,
  0x20, 0x22, 0x08, 0x41, 0x08, 0x40, 0x88, 0x11, 0x01, 0x40, 0x28, 0x02,
  0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x10, 0x1E, 0x00, 0x7F, 0xC0, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x00, 0x80,
  0x20, 0x0F, 0xFE, 0x0F, 0x88, 0x04, 0x02, 0x01, 0x00, 0x40, 0x10, 0x08,
  0x04, 0x02, 0x3E, 0x03, 0x80, 0x40, 0x20, 0x10, 0x10, 0x08, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x7C, 0xFF, 0xFF, 0xFC, 0xF8, 0x02, 0x01, 0x00, 0x80,
  0x80, 0x40, 0x40, 0x40, 0x20, 0x08, 0x03, 0xE3, 0x81, 0x01, 0x00, 0x40,
  0x10, 0x08, 0x04, 0x01, 0x00, 0x80, 0x47, 0xC0, 0x38, 0x0B, 0x20, 0x90,
  0x85, 0x02, 0x68, 0x0E, 0x00,
};

const GFXglyph IBMPlexMono_ExtraLight25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 3, 17, 15, 6, -17 },
  { 8, 5, 6, 15, 5, -19 },
  { 12, 14, 17, 15, 1, -17 },
  { 42, 11, 23, 15, 2, -20 },
  { 74, 13, 17, 15, 1, -17 },
  { 102, 13, 17, 15, 1, -17 },
  { 130, 1, 6, 15, 7, -19 },
  { 131, 6, 22, 15, 6, -19 },
  { 148, 6, 22, 15, 3, -19 },
  { 165, 13, 12, 15, 1, -14 },
  { 185, 11, 13, 15, 2, -14 },
  { 203, 3, 6, 15, 6, -2 },
  { 206, 7, 1, 15, 4, -8 },
  { 207, 3, 2, 15, 6, -2 },
  { 208, 9, 22, 15, 3, -19 },
  { 233, 11, 17, 15, 2, -17 },
  { 257, 12, 17, 15, 2, -17 },
  { 283, 11, 17, 15, 2, -17 },
  { 307, 10, 17, 15, 2, -17 },
  { 329, 13, 17, 15, 1, -17 },
  { 357, 11, 17, 15, 2, -17 },
  { 381, 11, 17, 15, 2, -17 },
  { 405, 11, 17, 15, 2, -17 },
  { 429, 11, 17, 15, 2, -17 },
  { 453, 11, 17, 15, 2, -17 },
  { 477, 3, 13, 15, 6, -13 },
  { 482, 3, 17, 15, 6, -13 },
  { 489, 11, 14, 15, 2, -15 },
  { 509, 11, 5, 15, 2, -10 },
  { 516, 11, 14, 15, 2, -15 },
  { 536, 11, 17, 15, 2, -17 },
  { 560, 11, 20, 15, 2, -17 },
  { 588, 13, 17, 15, 1, -17 },
  { 616, 11, 17, 15, 2, -17 },
  { 640, 11, 17, 15, 2, -17 },
  { 664, 10, 17, 15, 3, -17 },
  { 686, 10, 17, 15, 3, -17 },
  { 708, 10, 17, 15, 3, -17 },
  { 730, 11, 17, 15, 2, -17 },
  { 754, 11, 17, 15, 2, -17 },
  { 778, 11, 17, 15, 2, -17 },
  { 802, 10, 17, 15, 2, -17 },
  { 824, 11, 17, 15, 3, -17 },
  { 848, 10, 17, 15, 3, -17 },
  { 870, 11, 17, 15, 2, -17 },
  { 894, 11, 17, 15, 2, -17 },
  { 918, 11, 17, 15, 2, -17 },
  { 942, 10, 17, 15, 3, -17 },
  { 964, 11, 21, 15, 2, -17 },
  { 993, 10, 17, 15, 3, -17 },
  { 1015, 11, 17, 15, 2, -17 },
  { 1039, 13, 17, 15, 1, -17 },
  { 1067, 11, 17, 15, 2, -17 },
  { 1091, 13, 17, 15, 1, -17 },
  { 1119, 13, 17, 15, 1, -17 },
  { 1147, 13, 17, 15, 1, -17 },
  { 1175, 13, 17, 15, 1, -17 },
  { 1203, 13, 17, 15, 1, -17 },
  { 1231, 7, 22, 15, 6, -19 },
  { 1251, 9, 22, 15, 3, -19 },
  { 1276, 7, 22, 15, 2, -19 },
  { 1296, 11, 10, 15, 2, -17 },
  { 1310, 13, 1, 15, 1, 3 },
  { 1312, 3, 4, 15, 5, -19 },
  { 1314, 11, 13, 15, 2, -13 },
  { 1332, 10, 19, 15, 3, -19 },
  { 1356, 10, 13, 15, 3, -13 },
  { 1373, 10, 19, 15, 2, -19 },
  { 1397, 11, 13, 15, 2, -13 },
  { 1415, 11, 19, 15, 2, -19 },
  { 1442, 12, 19, 15, 2, -14 },
  { 1471, 9, 19, 15, 3, -19 },
  { 1493, 10, 19, 15, 3, -19 },
  { 1517, 9, 24, 15, 2, -19 },
  { 1544, 11, 19, 15, 3, -19 },
  { 1571, 11, 19, 15, 2, -19 },
  { 1598, 11, 13, 15, 2, -13 },
  { 1616, 9, 13, 15, 3, -13 },
  { 1631, 11, 13, 15, 2, -13 },
  { 1649, 10, 18, 15, 3, -13 },
  { 1672, 10, 18, 15, 2, -13 },
  { 1695, 12, 13, 15, 2, -13 },
  { 1715, 11, 13, 15, 2, -13 },
  { 1733, 12, 17, 15, 1, -17 },
  { 1759, 9, 13, 15, 3, -13 },
  { 1774, 11, 13, 15, 2, -13 },
  { 1792, 13, 13, 15, 1, -13 },
  { 1814, 11, 13, 15, 2, -13 },
  { 1832, 11, 18, 15, 2, -13 },
  { 1857, 11, 13, 15, 2, -13 },
  { 1875, 9, 22, 15, 3, -19 },
  { 1900, 1, 22, 15, 7, -19 },
  { 1903, 9, 22, 15, 3, -19 },
  { 1928, 13, 5, 15, 1, -10 },
};

const GFXfont IBMPlexMono_ExtraLight25pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLight25pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLight25pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _IBMPLEXMONO_EXTRALIGHT25PT7B_H_
